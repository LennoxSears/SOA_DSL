+    dela_nld5_lvt_10hv_dwmos       = (nom_dela_nld5_lvt_10hv_dwmos+(sig_dela_nld5_lvt_10hv_dwmos*nsig_dela_nld5_lvt_10hv_dwmos)+(nsmm_dela_nld5_lvt_10hv_dwox*smm_dela_nld5_lvt_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld5_lvt_10hv_vtw         = (nom_dela_nld5_lvt_10hv_vtw+(sig_dela_nld5_lvt_10hv_vtw*nsig_dela_nld5_lvt_10hv_vtw))
+    delr_nld5_lvt_10hv_vsat        = (nom_delr_nld5_lvt_10hv_vsat*(1+sig_delr_nld5_lvt_10hv_vsat*nsig_delr_nld5_lvt_10hv_vsat))
+    delr_nld5_lvt_10hv_nsub        = (nld5_lvt_10hv_fac_nsub_sti_final*(1+nsmm_delr_nld5_lvt_10hv_nsub*smm_delr_nld5_lvt_10hv_nsub(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_ub          = (nom_delr_nld5_lvt_10hv_ub*(1+sig_delr_nld5_lvt_10hv_ub*nsig_delr_nld5_lvt_10hv_ub))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.01*1e-10*delr_nld5_lvt_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.4)
+    lchtcad                        = (0.343)
+    lacc                           = (0.058)
+    lch                            = (0.343)
+    lsovl                          = (0.025)
+    ld                             = (0.405)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.20)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    d_cfr                          = (4.6556e-17)
+    lfr                            = (0.090191174)
+    dw_mos                         = (0)
+    dw_res                         = (-0.333834)
+    lcheff                         = (0.343)
+    numbernplus                    = (int_round((w-1.66)/0.84+2))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(1.8)/(w**1.0))*(1-fem))
+    w_cap                          = (w)
+    xnsd                           = (ld+lacc)
+    ynsd                           = (w)
+    ansd                           = (xnsd*ynsd*ngeff)
+    pnsd                           = ((2*xnsd+ynsd)*ngeff)
+    rsda                           = (1.69544e+07/ansd)
+    rsdp                           = 0.08*(3352.71/pnsd)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = ((2*xiso)+(lcell*ngeff))
+    ysub                           = (w+2*yiso)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lchdrawn*0.585*ng)
+    area_accum                     = ((lacc+0.15824)*w*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = (24)
+    nb_ct_ply_d                    = (int_round(w/(0.18+0.24)+0.2))
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*w-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*w-lfr_ct_ply_s)
+    lm1s                           = (0.6*2*n_src)
+    lm1d                           = (0.6*2*n_drn)
+    ng_dmy                         = (2*sti_dummy)
+    area_accum_dmy                 = ((lacc+0.15824)*w*ng_dmy)
+    lfring_dmy                     = (w*ng_dmy)
+    lfr_ct_ply_d_dmy               = (nb_ct_ply_d*0.18*ng_dmy)
+    lfr_m1_ply_d_dmy               = (ng_dmy*w-lfr_ct_ply_d_dmy)
+    n_drn_dmy                      = (ng_dmy/2)
+    lm1d_dmy                       = (0.6*2*n_drn_dmy)
+    sdotmult                       = (1)
+    sdotmult2                      = (1)
+    lm                             = (ld+0)
+    nd                             = (1.05175e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.21681/delr_nld5_lvt_10hv_res)*(1+(0*deltee)+(0*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.0079934)
+    aphi_tnom                      = (aphi_junc_nld5_lvt_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld5_lvt_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld5_lvt_d_body)
+    pphi_tnom                      = (pphi_junc_nld5_lvt_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld5_lvt_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld5_lvt_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_lvt_10hv_tox)
+ nch      = 0.5*(3.10e16*delr_nld5_lvt_10hv_nsub)
+ nsub     = 15*(4.75e16*delr_nld5_lvt_10hv_nsub)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((2.4e-08+0.5e-6*dela_nld5_lvt_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = (0)
+ vfb      = (-0.944+dela_nld5_lvt_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nld5_lvt_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nld5_lvt_10hv-relimo_ratio1_b_hci_nld5_lvt_10hv))
+ a0       = (4.5*delr_a0_relimo)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (390*delr_nld5_lvt_10hv_uch*delr_u0_relimo)
+ ua       = (-2.02e-09)
+ ub       = (1.352e-18*delr_nld5_lvt_10hv_ub)
+ vsat     = (150400*1.14*delr_nld5_lvt_10hv_vsat)
+ wvsat    = (50000*1.6)
+ drout    = (0.56)
+ pclm     = (0.3)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1e-2)
+ delta    = (0.0785775)
+ rdsw     = (28.15*delr_nld5_lvt_10hv_res*delr_rdsw_relimo)
+ wr       = (1.00)
+ prwg     = (2)
+ prt      = (24.9511)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1.0)
+ moin     = (10)
+ cgsl     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0)
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0+80*dela_nld5_lvt_10hv_vtw)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = 1.3*(2.4)
+ voff     = (-0.18)
+ beta0    = (50)
+ kt1      = (-0.5)
+ ua1      = (-2.6e-10)
+ wua1     = (-1.9e-10)
+ ub1      = (1.1e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.5)
+ dlc      = (0.140e-6)
+ dwc      = (2e-7)
+ at       = (6000*0)
+ wat      = (-8000*0)
+ noia     = (1.0e21)
+ noib     = (5e4*8.0)
+ noic     = (0.0)
+ em       = (4.1e7)
+ af       = (1)
+ ef       = (1)
+ kf       = (0)

model nmcapmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_lvt_10hv_tox)
+ nch      = (1.10e15)
+ nsub     = (4.75e16)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-1.26807e-07)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((6.44544e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((7.45381e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-10.5045+6.5/w)*(1+-0.0035677*(temp-27)+4.19128e-06*(temp-27)*(temp-27)))
+ vfb      = (0.30)
+ a0       = (1.37362)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (708.188)
+ ua       = (1.20e-10)
+ ub       = (1.28673e-20)
+ vsat     = (459379)
+ drout    = (0.56)
+ pclm     = (0.37)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.0785775)
+ rdsw     = (8.09082)
+ wr       = (1.00)
+ prwg     = (2.85)
+ prt      = (24.9511)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1)
+ moin     = (10)
+ cgsl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = (2.4)
+ voff     = (-0.24)
+ beta0    = (50)
+ kt1      = (-0.30)
+ ua1      = (1.31648e-10)
+ ub1      = (-9.04058e-20)
+ uc1      = (-5.6e-11)
+ ute      = (-1.25783)
+ dlc      = (0.0835e-6)
+ dwc      = (0)
+ at       = (33000)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld5_lvt_d_body)*1e5)*1.0e12)
+ n             = (ajnd_junc_nld5_lvt_d_body)
+ cj            = ((((acj0_junc_nld5_lvt_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (aphi_temp)
+ mj            = (aexm_junc_nld5_lvt_d_body)
+ xti           = 2.5*(axti_junc_nld5_lvt_d_body)
+ bv            = (8+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld5_lvt_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld5_lvt_d_body)
+ gap2          = (abetaeg_junc_nld5_lvt_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld5_lvt_d_body/sDOTmult)*1e5)*1.0e12)
+ n             = (pjnd_junc_nld5_lvt_d_body)
+ cj            = ((((pcj0_junc_nld5_lvt_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (pphi_temp)
+ mj            = (pexm_junc_nld5_lvt_d_body)
+ xti           = 2.5*(pxti_junc_nld5_lvt_d_body)
+ bv            = (8+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld5_lvt_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld5_lvt_d_body)
+ gap2          = (pbetaeg_junc_nld5_lvt_d_body)

if (ng_dmy>=2) {
mpowermos_dmy (intd_dmy s s s) nmosmodel l=lcheff w=(w_mos) m=(ng_dmy) ad=(1e-18) pd=(1e-18)
cgd_frg_dmy (s d) capacitor c=(d_cfr*lfring_dmy*sdotmult)
cgd_m1_dmy (s d) capacitor c=(lfr_m1_ply_d_dmy*cfr_nld5_lvt_d_ply_met*sdotmult+lfr_ct_ply_d_dmy*cfr_nld5_lvt_d_ply_m1ct*sdotmult+lm1d_dmy*3.06679e-16*sdotmult)
capmos1_dmy (d s) capacitor c=(cox_accum*area_accum_dmy*sdotmult2*1e-12/2.5)
resdrift_dmy (d intd_dmy) resistor r=(lm/(0.70*w_res*xj*ng_dmy*qq*uu*nd))
}
mpowermos (intd intg s s) nmosmodel l=lcheff w=(w_mos) m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=(w_cap) m=(ng)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_frg (intg s) capacitor c=(cox*(lsovl+lfr)*lfring*sDOTmult2)
cgd_frg (intg d) capacitor c=(d_cfr*lfring*sDOTmult)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply_s*cfr_nld5_lvt_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld5_lvt_s_ply_m1ct*sDOTmult+lm1s*3.06679e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld5_lvt_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld5_lvt_d_ply_m1ct*sDOTmult+lm1d*3.06679e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.36)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd)
dsd_a (s intdx) dbody_area area=(ansd)
dsd_p (s intdx) dbody_perim area=(pnsd)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (d intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/2.5)
resdrift (d intd) resistor r=(lm/(0.70*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld5_lvt_10hv_dfrt
ends



//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld30b_10hv (d g s sub)
parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
+    fem                            = 0
+    soa                            = 1
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld30b_vthratio     = 1.0
+    presto_nld30b_ronratio     = 0.01/0.74

parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.35)
//
+    dw_mos                         = (0)
+    numbernplus                    = ((2+(w>=2.375)+(w>=3.18)+(w>=3.975)+(w>=4.775)+(w>=5.58)+(w>=6.38)+(w>=7.18)+(w>=7.98)+(w>=8.775)+(w>=9.58)+(w>=10.38)+(w>=11.175)+(w>=11.98)+(w>=12.775)+(w>=13.58)+(w>=14.38)+(w>=15.175)+(w>=15.98)+(w>=16.775)*(1+int_round((w-16.775)/0.8)))*(1-fem)+fem*int_round(w/0.8+1e-6))
+    w_um                           = (numbernplus*0.4+dw_mos*(1-fem))
+    l_um                           = (l)
+    wdrift                         = (w)
+    ldrift                         = (1.15)
+    ldr1                           = (0.65)
+    lacts                          = (0.375)
+    lactd                          = (0.69)
+    wg2nhv                         = (1.35)
+    aplyfld_d                      = (((ldr1+ldrift+lactd*0.5)*2*wg2nhv-(0.6*2+1.39)*1.2)*(1-fem)+0.2*wdrift)*ng
+    aplyfld_d_dmy                  = (((ldr1+ldrift+lactd*0.5)*2*wg2nhv-(0.6*2+1.39)*1.2)*(1-fem)+0.2*wdrift)*ng_dmy
+    aplyfld_s                      = ((ldr1+ldrift+lactd*0.5+0.35)*2*1.72-(ldr1+ldrift+lactd*0.5)*2*wg2nhv)*ng*(1-fem)
+    as_xdr                         = (lacts*w_um)
+    ps_xdr                         = ((2*(lacts+0.4))*numbernplus)
+    ad_xdr                         = ((ldr1+ldrift*0.5)*(w+2*wg2nhv*(1-fem)))
+    pd_xdr                         = ((2*((ldr1+ldrift*0.5)*(1-fem)+(w+2*wg2nhv*(1-fem)))))
+    ad2_xdr                        = ((lactd+ldrift)*0.5*(w+2*wg2nhv*(1-fem)))
+    pd2_xdr                        = ((lactd+ldrift))
+    as_i                           = (as_xdr)
+    ps_i                           = (ps_xdr)
+    ad_i                           = (ad_xdr)
+    pd_i                           = (pd_xdr)
+    ad2_i                          = (ad2_xdr)
+    pd2_i                          = (pd2_xdr)
+    lg2dt                          = (1.485)
+    wg2dt                          = (2.23*(1-fem))
+    lg2g_d                         = ((ldr1+ldrift+lactd*0.5)*2)
+    lg2g_s                         = (0.42)
+    lg2w                           = (l)
+    xnbl_xdr                       = (lg2dt*nse+lg2w*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (2*wg2dt+w)
+    anbl_xdr                       = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_nld30b_sphv_10hv+tc2_ecrit_nld30b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    wfact_ecrit                    = (1+ecritw_nld30b_sphv_10hv/w*(1-fem))
+    w_heat=w
+    l_heat=(lg2w*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld30b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld30b_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff
+    nsmm_delr_gox_nld30b_sphv_10hv  = 0
+    nsmm_dela_dw_nld30b_sphv_10hv   = tmp_nsmm_dela_dw_nld30b_sphv_10hv
+    nsmm_dela_vfb_nld30b_sphv_10hv  = tmp_nsmm_dela_vfb_nld30b_sphv_10hv
+    nsmm_delr_mobref_nld30b_sphv_10hv = 0
+    nsmm_delr_rshl_nld30b_sphv_10hv = 0
+    nsmm_delr_nsub_nld30b_sphv_10hv = tmp_nsmm_delr_nsub_nld30b_sphv_10hv

//+    delr_tox_nld30b_sphv_10hv      = (nom_delr_tox_nld30b_sphv_10hv*(1.0+nsig_delr_tox_nld30b_sphv_10hv*sig_delr_tox_nld30b_sphv_10hv+nsmm_delr_gox_nld30b_sphv_10hv*smm_delr_gox_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_tox_nld30b_sphv_10hv      = (nom_delr_tox_nld30b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld30b_sphv_10hv+nsmm_delr_gox_nld30b_sphv_10hv*smm_delr_gox_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld30b_sphv_10hv       = (nom_dela_dw_nld30b_sphv_10hv+nsig_dela_dw_nld30b_sphv_10hv*sig_dela_dw_nld30b_sphv_10hv+nsmm_dela_dw_nld30b_sphv_10hv*smm_dela_dw_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld30b_sphv_10hv       = (nom_dela_xw_nld30b_sphv_10hv+nsig_dela_xw_nld30b_sphv_10hv*sig_dela_xw_nld30b_sphv_10hv)
+    dela_vfb_nld30b_sphv_10hv      = (nom_dela_vfb_nld30b_sphv_10hv+nsig_dela_vfb_nld30b_sphv_10hv*sig_dela_vfb_nld30b_sphv_10hv+nsmm_dela_vfb_nld30b_sphv_10hv*smm_dela_vfb_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_nld30b_sphv_10hv     = (nom_dela_vtwl_nld30b_sphv_10hv+nsig_dela_vtwl_nld30b_sphv_10hv*sig_dela_vtwl_nld30b_sphv_10hv)
+    delr_mobref_nld30b_sphv_10hv   = (nom_delr_mobref_nld30b_sphv_10hv*(1.0+nsig_delr_mobref_nld30b_sphv_10hv*sig_delr_mobref_nld30b_sphv_10hv+nsmm_delr_mobref_nld30b_sphv_10hv*smm_delr_mobref_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_nld30b_sphv_10hv     = (nom_delr_rshl_nld30b_sphv_10hv*(1.0+nsig_delr_rshl_nld30b_sphv_10hv*sig_delr_rshl_nld30b_sphv_10hv)+nsmm_delr_rshl_nld30b_sphv_10hv*smm_delr_rshl_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_nld30b_sphv_10hv     = (1+nsmm_delr_nsub_nld30b_sphv_10hv*smm_delr_nsub_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
//+    cj0_junc_nld30b_d_body         = ((nom_delr_cj0_junc_nld30b_d_body*(1+nsig_delr_cj0_junc_nld30b_d_body*sig_delr_cj0_junc_nld30b_d_body)))
//+    js_junc_nld30b_d_body          = ((nom_delr_js_junc_nld30b_d_body*(1+nsig_delr_js_junc_nld30b_d_body*sig_delr_js_junc_nld30b_d_body)))
+    delr_cj_nld30b_sphv_10hv = (nom_delr_cj_nld30b_sphv_10hv*(1+sig_delr_cj_nld30b_sphv_10hv*nsig_delr_cj_nld30b_sphv_10hv))
+    delr_is_nld30b_sphv_10hv = (nom_delr_is_nld30b_sphv_10hv*exp(sig_delr_is_nld30b_sphv_10hv*nsig_delr_is_nld30b_sphv_10hv))
+    delr_is2_nld30b_sphv_10hv = (nom_delr_is2_nld30b_sphv_10hv*exp(sig_delr_is2_nld30b_sphv_10hv*nsig_delr_is2_nld30b_sphv_10hv))
+    delr_ir_nld30b_sphv_10hv = (nom_delr_ir_nld30b_sphv_10hv*exp(sig_delr_ir_nld30b_sphv_10hv*nsig_delr_ir_nld30b_sphv_10hv))


//+    cpp_ply_fld                    = (nom_cpp_ply_fld)
//+    nom_cpp_ply_fld                = (0.092229166666667e-15)
//+    cpp_ply_sdt                    = (nom_cpp_ply_sdt)
//+    nom_cpp_ply_sdt                = (2.6460229885057e-15)

+    lfr_ct_ply_s                   = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d                   = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d                   = ((w+2*0.555*(1-fem))*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555*(1-fem))*ng-lfr_ct_ply_s)

// for dummy
+    lfr_ct_ply_d_dmy                   = (ng_dmy*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d_dmy                   = ((w+2*0.555*(1-fem))*ng_dmy-lfr_ct_ply_d_dmy)

//**parameters for multi ng
+ fac_r_ng_rshldd= (1-(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.01)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+0.8*(1-fem))-2/(2+0.8))*0.04*1.5*2*(w/(w+0.8)))
+ fac_a_ng_uo= (1+(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.016*2.5)


//+    cfr_nld30b_d_ply_m1ct       = (4.90e-17)

//+    cfr_nld30b_s_ply_m1ct       = (1.59e-16)

//+    cfr_nld30b_s_ply_met        = (7.65e-17)

//+    cfr_nld30b_d_ply_met        = (4.17e-17)

+    lfring                         = (w*ng)
+    lch_drawn                      = (0.35)
+    lch                            = (0.32)
+    lacc_drawn                     = (0.7)
+    lacc                           = (0.669)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    lflap                          = (0.25)

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))


+ swdrlin  = (2)  
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8)

if (ng_dmy>=2) {

cgd_fld_d_dmy (s d) capacitor c=(cpp_ply_fld*aplyfld_d_dmy)

cgd_m1_dmy (s d) capacitor c=((lfr_m1_ply_d_dmy*cfr_nld30b_d_ply_met+lfr_ct_ply_d_dmy*cfr_nld30b_d_ply_m1ct))

mpowermos_dmy  (d s s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
}

model sphvt_simkit sphvt
+ type     =(n)
+ vdscale  = (vdscale_nld30b_sphv_10hv*(1-0.06*(1-fem)/w))
+ ctgo     = (0.1)
+ stcto    = (0.2)
+ stvdscale= (-0.27)
+ strthao  = (0.8)
+ tr       = (27)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec    = (1)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ xvsat = (xvsat_nld30b_sphv_10hv*(1+xvsatw_nld30b_sphv_10hv/w*(1-fem)))
+ qmc      = (qmc_nld30b_sphv_10hv)
+ lvaro    = (lvaro_nld30b_sphv_10hv)
+ lvarl    = (lvarl_nld30b_sphv_10hv)
+ lvarw    = (lvarw_nld30b_sphv_10hv*(1-fem))
+ lap      = (lap_nld30b_sphv_10hv)
+ wvaro    = (wvaro_nld30b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld30b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld30b_sphv_10hv*(1-fem))
+ wot      = ((wot_nld30b_sphv_10hv+0.5e-6*dela_dw_nld30b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld30b_sphv_10hv)
+ dwq      = (dwq_nld30b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld30b_sphv_10hv+fac_a_ng_vfbo+dela_vfb_nld30b_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld30b_vthratio)
+ vfbl     = (vfbl_nld30b_sphv_10hv)
+ vfbw     = (vfbw_nld30b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld30b_sphv_10hv+dela_vtwl_nld30b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld30b_sphv_10hv)
+ stvfbl   = (stvfbl_nld30b_sphv_10hv)
+ stvfbw   = (stvfbw_nld30b_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld30b_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ epsroxo  = (epsroxo_nld30b_sphv_10hv)
+ nsubo    = (nsubo_nld30b_sphv_10hv*delr_nsub_nld30b_sphv_10hv)
+ nsubw    = (nsubw_nld30b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld30b_sphv_10hv)
+ npck     = (npck_nld30b_sphv_10hv)
+ npckw    = (npckw_nld30b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld30b_sphv_10hv)
+ lpck     = (lpck_nld30b_sphv_10hv)
+ lpckw    = (lpckw_nld30b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld30b_sphv_10hv)
+ fol2     = (fol2_nld30b_sphv_10hv)
+ facneffaco = (facneffaco_nld30b_sphv_10hv)
+ facneffacl = (facneffacl_nld30b_sphv_10hv)
+ facneffacw = (facneffacw_nld30b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld30b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld30b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld30b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld30b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld30b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld30b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld30b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld30b_sphv_10hv)
+ vnsubo   = (vnsubo_nld30b_sphv_10hv)
+ nslpo    = (nslpo_nld30b_sphv_10hv)
+ dnsubo   = (dnsubo_nld30b_sphv_10hv)
+ dphibo   = (dphibo_nld30b_sphv_10hv)
+ dphibl   = (dphibl_nld30b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld30b_sphv_10hv)
+ dphibw   = (dphibw_nld30b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld30b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld30b_sphv_10hv)
+ delvtacl = (delvtacl_nld30b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld30b_sphv_10hv)
+ delvtacw = (delvtacw_nld30b_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld30b_sphv_10hv)*(1-fem)
+ npo      = (npo_nld30b_sphv_10hv)
+ npl      = (npl_nld30b_sphv_10hv)
+ cto      = (cto_nld30b_sphv_10hv)
+ ctl      = (ctl_nld30b_sphv_10hv)
+ ctlexp   = (ctlexp_nld30b_sphv_10hv)
+ ctw      = (ctw_nld30b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld30b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ toxovdo  = (toxovdo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ lov      = (lov_nld30b_sphv_10hv)
+ dlovd    = (dlovd_nld30b_sphv_10hv)
+ novo     = (novo_nld30b_sphv_10hv)
+ novdo    = (novdo_nld30b_sphv_10hv)
+ cfl      = (cfl_nld30b_sphv_10hv)
+ cflexp   = (cflexp_nld30b_sphv_10hv)
+ cfw      = (cfw_nld30b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld30b_sphv_10hv)
+ uo       = (uo_nld30b_sphv_10hv*fac_a_ng_uo*delr_mobref_nld30b_sphv_10hv*delr_u0_relimo)*w_um/wdrift
+ fbet1    = (fbet1_nld30b_sphv_10hv)
+ fbet1w   = (fbet1w_nld30b_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld30b_sphv_10hv)
+ lp1w     = (lp1w_nld30b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld30b_sphv_10hv)
+ lp2      = (lp2_nld30b_sphv_10hv)
+ betw1    = (betw1_nld30b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld30b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld30b_sphv_10hv)
+ stbeto   = (stbeto_nld30b_sphv_10hv)
+ stbetl   = (stbetl_nld30b_sphv_10hv)
+ stbetw   = (stbetw_nld30b_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld30b_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld30b_sphv_10hv)
+ muew     = (muew_nld30b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld30b_sphv_10hv)
+ themuo   = (themuo_nld30b_sphv_10hv)
+ stthemuo = (stthemuo_nld30b_sphv_10hv)
+ cso      = (cso_nld30b_sphv_10hv)
+ csl      = (csl_nld30b_sphv_10hv)
+ cslexp   = (cslexp_nld30b_sphv_10hv)
+ csw      = (csw_nld30b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld30b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld30b_sphv_10hv)
+ xcoro    = (xcoro_nld30b_sphv_10hv)
+ xcorl    = (xcorl_nld30b_sphv_10hv)
+ xcorw    = (xcorw_nld30b_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld30b_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld30b_sphv_10hv)
+ fetao    = (fetao_nld30b_sphv_10hv)
+ rsw1     = (rsw1_nld30b_sphv_10hv)
+ rsw2     = (rsw2_nld30b_sphv_10hv)*(1-fem)
+ strso    = (strso_nld30b_sphv_10hv)
+ rsbo     = (rsbo_nld30b_sphv_10hv)
+ rsgo     = (rsgo_nld30b_sphv_10hv)
+ thesato  = (thesato_nld30b_sphv_10hv)
+ thesatl  = (thesatl_nld30b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld30b_sphv_10hv)
+ thesatw  = (thesatw_nld30b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld30b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld30b_sphv_10hv)
+ stthesatl = (stthesatl_nld30b_sphv_10hv)
+ stthesatw = (stthesatw_nld30b_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld30b_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld30b_sphv_10hv)
+ thesatgo = (thesatgo_nld30b_sphv_10hv)
+ thesatgl = (thesatgl_nld30b_sphv_10hv)
+ thesatgw = (thesatgw_nld30b_sphv_10hv*(1-fem))
+ axo      = (axo_nld30b_sphv_10hv)
+ axl      = (axl_nld30b_sphv_10hv)
+ alpl     = (alpl_nld30b_sphv_10hv)
+ alplexp  = (alplexp_nld30b_sphv_10hv)
+ alpw     = (alpw_nld30b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld30b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld30b_sphv_10hv)
+ alp1l2   = (alp1l2_nld30b_sphv_10hv)
+ alp1w    = (alp1w_nld30b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld30b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld30b_sphv_10hv)
+ alp2l2   = (alp2l2_nld30b_sphv_10hv)
+ alp2w    = (alp2w_nld30b_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld30b_sphv_10hv)
+ a1o      = (a1o_nld30b_sphv_10hv)
+ a1l      = (a1l_nld30b_sphv_10hv)
+ a1w      = (a1w_nld30b_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld30b_sphv_10hv)
+ sta2o    = (sta2o_nld30b_sphv_10hv)
+ a3o      = (a3o_nld30b_sphv_10hv)
+ a3l      = (a3l_nld30b_sphv_10hv)
+ a3w      = (a3w_nld30b_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld30b_sphv_10hv)
+ a4l      = (a4l_nld30b_sphv_10hv)
+ a4w      = (a4w_nld30b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld30b_sphv_10hv)
+ iginvlw  = (iginvlw_nld30b_sphv_10hv)
+ igovw    = (igovw_nld30b_sphv_10hv)
+ igovdw   = (igovdw_nld30b_sphv_10hv)
+ stigo    = (stigo_nld30b_sphv_10hv)
+ gc2o     = (gc2o_nld30b_sphv_10hv)
+ gc3o     = (gc3o_nld30b_sphv_10hv)
+ chibo    = (chibo_nld30b_sphv_10hv)
+ agidlw   = (agidlw_nld30b_sphv_10hv)
+ agidldw  = (agidldw_nld30b_sphv_10hv)
+ bgidlo   = (bgidlo_nld30b_sphv_10hv)
+ bgidldo  = (bgidldo_nld30b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld30b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld30b_sphv_10hv)
+ cgidlo   = (cgidlo_nld30b_sphv_10hv)
+ cgidldo  = (cgidldo_nld30b_sphv_10hv)
+ cgbovl   = (cgbovl_nld30b_sphv_10hv)
+ cfrw     = (cfrw_nld30b_sphv_10hv)
+ cfrdw    = (cfrdw_nld30b_sphv_10hv)
+ fnto     = (fnto_nld30b_sphv_10hv)
+ nfalw    = (nfalw_nld30b_sphv_10hv)
+ nfblw    = (nfblw_nld30b_sphv_10hv)
+ nfclw    = (nfclw_nld30b_sphv_10hv)
+ efo      = (efo_nld30b_sphv_10hv)
+ lintnoi  = (lintnoi_nld30b_sphv_10hv)
+ alpnoi   = (alpnoi_nld30b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld30b_sphv_10hv)
+ kvthowel = (kvthowel_nld30b_sphv_10hv)
+ kvthowew = (kvthowew_nld30b_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld30b_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld30b_sphv_10hv)
+ kuowel   = (kuowel_nld30b_sphv_10hv)
+ kuowew   = (kuowew_nld30b_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld30b_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld30b_sphv_10hv)
+ rsh      = (rsh_nld30b_sphv_10hv)
+ rbulko   = (rbulko_nld30b_sphv_10hv)
+ rwello   = (rwello_nld30b_sphv_10hv)
+ rjunso   = (rjunso_nld30b_sphv_10hv/(w_um+dwrjunso_nld30b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld30b_sphv_10hv/(wdrift+dwrjundo_nld30b_sphv_10hv*(1-fem)))
+ rint     = (rint_nld30b_sphv_10hv)
+ rvpoly   = (rvpoly_nld30b_sphv_10hv)
+ rshg     = (rshg_nld30b_sphv_10hv)
+ dlsil    = (dlsil_nld30b_sphv_10hv)
+ saref    = (saref_nld30b_sphv_10hv)
+ sbref    = (sbref_nld30b_sphv_10hv)
+ wlod     = (wlod_nld30b_sphv_10hv)
+ kuo      = (kuo_nld30b_sphv_10hv)
+ kvsat    = (kvsat_nld30b_sphv_10hv)
+ tkuo     = (tkuo_nld30b_sphv_10hv)
+ lkuo     = (lkuo_nld30b_sphv_10hv)
+ wkuo     = (wkuo_nld30b_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld30b_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld30b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld30b_sphv_10hv)
+ kvtho    = (kvtho_nld30b_sphv_10hv)
+ lkvtho   = (lkvtho_nld30b_sphv_10hv)
+ wkvtho   = (wkvtho_nld30b_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld30b_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld30b_sphv_10hv)
+ wlodvth  = (wlodvth_nld30b_sphv_10hv)
+ stetao   = (stetao_nld30b_sphv_10hv)
+ lodetao  = (lodetao_nld30b_sphv_10hv)
+ scref    = (scref_nld30b_sphv_10hv)
+ web      = (web_nld30b_sphv_10hv)
+ wec      = (wec_nld30b_sphv_10hv)
+ adr1o    = (adr1o_nld30b_sphv_10hv)
+ adr1l    = (adr1l_nld30b_sphv_10hv)
+ adr1w    = (adr1w_nld30b_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld30b_sphv_10hv)
+ stadr2o  = (stadr2o_nld30b_sphv_10hv)
+ adr3o    = (adr3o_nld30b_sphv_10hv)
+ adr3l    = (adr3l_nld30b_sphv_10hv)
+ adr3w    = (adr3w_nld30b_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld30b_sphv_10hv)
+ adr4l    = (adr4l_nld30b_sphv_10hv)
+ adr4w    = (adr4w_nld30b_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld30b_sphv_10hv)
+ adr5l    = (adr5l_nld30b_sphv_10hv)
+ adr5w    = (adr5w_nld30b_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld30b_sphv_10hv)
+ bidr1l   = (bidr1l_nld30b_sphv_10hv)
+ bidr1w   = (bidr1w_nld30b_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld30b_sphv_10hv)
+ bidr2w   = (bidr2w_nld30b_sphv_10hv)*(1-fem)
//+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld30b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld30b_sphv_10hv*fac_r_ng_rshldd*delr_rshl_nld30b_sphv_10hv*delr_rdsw_relimo)*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld30b_ronratio))
+ xw       = ((xw_nld30b_sphv_10hv+0.5e-6*dela_xw_nld30b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld30b_sphv_10hv*(1-fem))
+ xl       = (xl_nld30b_sphv_10hv)
+ xlw      = (xlw_nld30b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld30b_sphv_10hv)
+ nst      = (nst_nld30b_sphv_10hv)
+ ats      = (ats_nld30b_sphv_10hv)
+ dfinf    = (dfinf_nld30b_sphv_10hv)
+ dfw      = (dfw_nld30b_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld30b_sphv_10hv)
+ dflw     = (dflw_nld30b_sphv_10hv*(1-fem))
+ dp       = (dp_nld30b_sphv_10hv)
+ ecrit    = (ecrit_nld30b_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ ecorn    = (ecorn_nld30b_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ du       = (du_nld30b_sphv_10hv)
+ tc1      = (tc1_nld30b_sphv_10hv)
+ tc2      = (tc2_nld30b_sphv_10hv)
+ tc1l     = (tc1l_nld30b_sphv_10hv)
+ tc2l     = (tc2l_nld30b_sphv_10hv)
+ tc1w     = (tc1w_nld30b_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld30b_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld30b_sphv_10hv)
+ theacc2  = (theacc2_nld30b_sphv_10hv)
+ aacc     = (aacc_nld30b_sphv_10hv)
+ rva      = (rva_nld30b_sphv_10hv)*(1+2.5/w*(1-fem))
+ dta      = (dta_nld30b_sphv_10hv)
+ trj      = (trj_nld30b_sphv_10hv)
+ cjarea   = (cjarea_nld30b_sphv_10hv)*delr_cj_nld30b_sphv_10hv
+ cjlsti   = (cjlsti_nld30b_sphv_10hv)*djunc*delr_cj_nld30b_sphv_10hv
+ cjlgat   = (cjlgat_nld30b_sphv_10hv)*djunc*delr_cj_nld30b_sphv_10hv
+ vbiarea  = (vbiarea_nld30b_sphv_10hv)
+ vbisti   = (vbisti_nld30b_sphv_10hv)
+ vbigat   = (vbigat_nld30b_sphv_10hv)
+ parea    = (parea_nld30b_sphv_10hv)
+ psti     = (psti_nld30b_sphv_10hv)
+ pgat     = (pgat_nld30b_sphv_10hv)
+ is1area  = (is1area_nld30b_sphv_10hv)
+ ttarea   = (ttarea_nld30b_sphv_10hv)
+ is2area  = (is2area_nld30b_sphv_10hv)
+ irarea   = (irarea_nld30b_sphv_10hv)
+ stis1area = (stis1area_nld30b_sphv_10hv)
+ stis2area = (stis2area_nld30b_sphv_10hv)
+ stirarea = (stirarea_nld30b_sphv_10hv)
+ n1area   = (n1area_nld30b_sphv_10hv)
+ n2area   = (n2area_nld30b_sphv_10hv)
+ nrarea   = (nrarea_nld30b_sphv_10hv)
+ is1lsti  = (is1lsti_nld30b_sphv_10hv)
+ ttlsti   = (ttlsti_nld30b_sphv_10hv)
+ is2lsti  = (is2lsti_nld30b_sphv_10hv)
+ irlsti   = (irlsti_nld30b_sphv_10hv)
+ stis1sti = (stis1sti_nld30b_sphv_10hv)
+ stis2sti = (stis2sti_nld30b_sphv_10hv)
+ stirsti  = (stirsti_nld30b_sphv_10hv)
+ n1sti    = (n1sti_nld30b_sphv_10hv)
+ n2sti    = (n2sti_nld30b_sphv_10hv)
+ nrsti    = (nrsti_nld30b_sphv_10hv)
+ is1lgat  = (is1lgat_nld30b_sphv_10hv)
+ ttlgat   = (ttlgat_nld30b_sphv_10hv)
+ is2lgat  = (is2lgat_nld30b_sphv_10hv)
+ irlgat   = (irlgat_nld30b_sphv_10hv)
+ stis1gat = (stis1gat_nld30b_sphv_10hv)
+ stis2gat = (stis2gat_nld30b_sphv_10hv)
+ stirgat  = (stirgat_nld30b_sphv_10hv)
+ n1gat    = (n1gat_nld30b_sphv_10hv)
+ n2gat    = (n2gat_nld30b_sphv_10hv)
+ nrgat    = (nrgat_nld30b_sphv_10hv)
+ cjaread  = (cjaread_nld30b_sphv_10hv*delr_cj_nld30b_sphv_10hv)
+ cjlstid  = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ cjlgatd  = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ vbiaread = (vbiaread_nld30b_sphv_10hv)
+ vbistid  = (vbistid_nld30b_sphv_10hv)
+ vbigatd  = (vbigatd_nld30b_sphv_10hv)
+ paread   = (paread_nld30b_sphv_10hv)
+ pstid    = (pstid_nld30b_sphv_10hv)
+ pgatd    = (pgatd_nld30b_sphv_10hv)
+ is1aread = (is1aread_nld30b_sphv_10hv*delr_is_nld30b_sphv_10hv)
+ ttaread  = (ttaread_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread = (is2aread_nld30b_sphv_10hv*delr_is2_nld30b_sphv_10hv)
+ iraread  = (iraread_nld30b_sphv_10hv*delr_ir_nld30b_sphv_10hv)
+ stis1aread = (stis1aread_nld30b_sphv_10hv)
+ stis2aread = (stis2aread_nld30b_sphv_10hv)
+ stiraread = (stiraread_nld30b_sphv_10hv)
+ n1aread  = (n1aread_nld30b_sphv_10hv)
+ n2aread  = (n2aread_nld30b_sphv_10hv)
+ nraread  = (nraread_nld30b_sphv_10hv)
+ is1lstid = (is1aread_nld30b_sphv_10hv*djunc*delr_is_nld30b_sphv_10hv*0)
+ ttlstid  = (ttlstid_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid = (is2aread_nld30b_sphv_10hv*djunc*delr_is2_nld30b_sphv_10hv)
+ irlstid  = (irlstid_nld30b_sphv_10hv*djunc*delr_ir_nld30b_sphv_10hv)
+ stis1stid = (stis1stid_nld30b_sphv_10hv)
+ stis2stid = (stis2stid_nld30b_sphv_10hv)
+ stirstid = (stirstid_nld30b_sphv_10hv)
+ n1stid   = (n1stid_nld30b_sphv_10hv)
+ n2stid   = (n2stid_nld30b_sphv_10hv)
+ nrstid   = (nrstid_nld30b_sphv_10hv)
+ is1lgatd = (is1aread_nld30b_sphv_10hv*djunc*delr_is_nld30b_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lgatd = (is2aread_nld30b_sphv_10hv*djunc*delr_is2_nld30b_sphv_10hv)
+ irlgatd  = (irlgatd_nld30b_sphv_10hv*djunc*delr_ir_nld30b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld30b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld30b_sphv_10hv)
+ stirgatd = (stirgatd_nld30b_sphv_10hv)
+ n1gatd   = (n1gatd_nld30b_sphv_10hv)
+ n2gatd   = (n2gatd_nld30b_sphv_10hv)
+ nrgatd   = (nrgatd_nld30b_sphv_10hv)
+ cjaread2 = (cjaread_nld30b_sphv_10hv*delr_cj_nld30b_sphv_10hv)
+ cjlstid2 = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld30b_sphv_10hv)
+ vbistid2 = (vbistid2_nld30b_sphv_10hv)
+ paread2  = (paread2_nld30b_sphv_10hv)
+ pstid2   = (pstid2_nld30b_sphv_10hv)
+ is1aread2 = (is1aread_nld30b_sphv_10hv)*delr_is_nld30b_sphv_10hv
+ ttaread2 = (ttaread2_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread2 = (is2aread_nld30b_sphv_10hv)*delr_is2_nld30b_sphv_10hv
+ iraread2 = (iraread2_nld30b_sphv_10hv)*delr_ir_nld30b_sphv_10hv
+ stis1aread2 = (stis1aread_nld30b_sphv_10hv)
+ stis2aread2 = (stis2aread_nld30b_sphv_10hv)
+ stiraread2 = (stiraread2_nld30b_sphv_10hv)
+ n1aread2 = (n1aread2_nld30b_sphv_10hv)
+ n2aread2 = (n2aread2_nld30b_sphv_10hv)
+ nraread2 = (nraread2_nld30b_sphv_10hv)
+ is1lstid2 = (is1aread_nld30b_sphv_10hv*djunc*0)
+ ttlstid2 = (ttlstid2_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid2 = (is2aread_nld30b_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_nld30b_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld30b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld30b_sphv_10hv)
+ stirstid2 = (stirstid2_nld30b_sphv_10hv)
+ n1stid2  = (n1stid2_nld30b_sphv_10hv)
+ n2stid2  = (n2stid2_nld30b_sphv_10hv)
+ nrstid2  = (nrstid2_nld30b_sphv_10hv)

+ eais1area = (eais1area_nld30b_sphv_10hv)
+ eais2area = (eais2area_nld30b_sphv_10hv)
+ eairarea = (eairarea_nld30b_sphv_10hv)
+ eais1sti = (eais1sti_nld30b_sphv_10hv)
+ eais2sti = (eais2sti_nld30b_sphv_10hv)
+ eairsti = (eairsti_nld30b_sphv_10hv)
+ eais1gat = (eais1gat_nld30b_sphv_10hv)
+ eais2gat = (eais2gat_nld30b_sphv_10hv)
+ eairgat = (eairgat_nld30b_sphv_10hv)

+ eais1aread = (eais1aread_nld30b_sphv_10hv)
+ eais2aread = (eais2aread_nld30b_sphv_10hv)
+ eairaread = (eairaread_nld30b_sphv_10hv)
+ eais1stid = (eais1stid_nld30b_sphv_10hv)
+ eais2stid = (eais2stid_nld30b_sphv_10hv)
+ eairstid = (eairstid_nld30b_sphv_10hv)
+ eais1gatd = (eais1gatd_nld30b_sphv_10hv)
+ eais2gatd = (eais2gatd_nld30b_sphv_10hv)
+ eairgatd = (eairgatd_nld30b_sphv_10hv)

+ eais1aread2 = (eais1aread2_nld30b_sphv_10hv)
+ eais2aread2 = (eais2aread2_nld30b_sphv_10hv)
+ eairaread2 = (eairaread2_nld30b_sphv_10hv)
+ eais1stid2 = (eais1stid2_nld30b_sphv_10hv)
+ eais2stid2 = (eais2stid2_nld30b_sphv_10hv)
+ eairstid2 = (eairstid2_nld30b_sphv_10hv)

+ ikfarea               = ikfarea_nld30b_sphv_10hv
+ ikflsti               = ikfarea_nld30b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld30b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld30b_sphv_10hv
+ stikfsti              = stikfarea_nld30b_sphv_10hv
+ stikfgat              = stikfarea_nld30b_sphv_10hv
+ ikfaread              = ikfaread_nld30b_sphv_10hv*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflstid              = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflgatd              = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikfaread2             = ikfaread_nld30b_sphv_10hv*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflstid2             = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ stikfaread             = stikfaread_nld30b_sphv_10hv
+ stikfstid             = stikfaread_nld30b_sphv_10hv
+ stikfgatd             = stikfaread_nld30b_sphv_10hv
+ stikfaread2            = stikfaread_nld30b_sphv_10hv
+ stikfstid2            = stikfaread_nld30b_sphv_10hv

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt    = (1e12)
+ tnom    = (27)
+ is           = (1e-30)
+ n           = (1.0)
+ cj          = (1e-30)
+ pta        = (0)
+ tlevc     = (2)
+ tlev       = (2)
+ bv         = (41.5+bvdss_shift)
+ ibv         = (1e-5/1e-12)


xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
//cgs_frg_s (intg s) capacitor c=(cpp_ply_sdt*(lovlap+lfrs)*lfring)
//cgd_frg_d (intg d) capacitor c=(cpp_ply_sdt*(lfrd)*lfring)
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld30b_s_ply_met+lfr_ct_ply_s*cfr_nld30b_s_ply_m1ct))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld30b_d_ply_met+lfr_ct_ply_d*cfr_nld30b_d_ply_m1ct))
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
dbodyBV (s rd)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rd d)   resistor r=0.01

rgate (g intg) resistor r=(rply*((w+2*1.495*(1-fem))/((lch+lacc+lflap)*3*ng)))

include "./smos10hv_ade_dfrt.scs" section=nld30b_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = 1
+    selfheat                       = 1
+    fscale			    = 1
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_sphv_10hv
+    nsmm_dela_vfb_nld45b_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_sphv_10hv
+    nsmm_dela_vtw_nld45b_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_sphv_10hv
+    nsmm_delr_mobref_nld45b_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_sphv_10hv
+    nsmm_delr_rsh_nld45b_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_sphv_10hv
+    nsmm_delr_vdscale_nld45b_sphv_10hv = tmp_nsmm_delr_vdscale_nld45b_sphv_10hv
+    nsmm_delr_nsub_nld45b_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_vthratio     = 1.0/1.075
+    presto_nld45b_ronratio     = 0.01/0.58
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.4)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.2)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.5)
+    ldr1 			    = (0.6)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.255)
+    wd2g			    = (0.75)*(1-fem)
+    wg1			    = (0.7)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.4)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lch                            = (0.352)
+    lacc                           = (0.594)
+    lflap                          = (0.55)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.42)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w)+0.5*pi4models*(wd2g+wg1)*(wd2g+wg1))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_sphv_10hv+tc2_ecrit_nld45b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1.2)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-5e-4))

+    delr_tox_nld45b_sphv_10hv      = (nom_delr_tox_nld45b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_sphv_10hv+nsmm_delr_gox_nld45b_sphv_10hv*smm_delr_gox_nld45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_xw_nld45b_sphv_10hv       = (nom_dela_xw_nld45b_sphv_10hv+nsig_dela_xw_nld45b_sphv_10hv*sig_dela_xw_nld45b_sphv_10hv+nsmm_dela_xw_nld45b_sphv_10hv*smm_dela_xw_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_nld45b_sphv_10hv      = (nom_dela_vfb_nld45b_sphv_10hv+nsig_dela_vfb_nld45b_sphv_10hv*sig_dela_vfb_nld45b_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_sphv_10hv*smm_dela_vfb_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtw_nld45b_sphv_10hv     = (nom_dela_vtw_nld45b_sphv_10hv+nsig_dela_vtw_nld45b_sphv_10hv*sig_dela_vtw_nld45b_sphv_10hv+nsmm_dela_vtw_nld45b_sphv_10hv*smm_dela_vtw_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_mobref_nld45b_sphv_10hv   = (nom_delr_mobref_nld45b_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_sphv_10hv*sig_delr_mobref_nld45b_sphv_10hv+nsmm_delr_mobref_nld45b_sphv_10hv*smm_delr_mobref_nld45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rsh_nld45b_sphv_10hv     = (nom_delr_rsh_nld45b_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_sphv_10hv*sig_delr_rsh_nld45b_sphv_10hv)+nsmm_delr_rsh_nld45b_sphv_10hv*smm_delr_rsh_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_vdscale_nld45b_sphv_10hv     = (nom_delr_vdscale_nld45b_sphv_10hv*(1.0+nsig_delr_vdscale_nld45b_sphv_10hv*sig_delr_vdscale_nld45b_sphv_10hv)+nsmm_delr_vdscale_nld45b_sphv_10hv*smm_delr_vdscale_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_nld45b_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_sphv_10hv*smm_delr_nsub_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_cj_nld45b_sphv_10hv        = ((nom_delr_cj_nld45b_sphv_10hv*(1+nsig_delr_cj_nld45b_sphv_10hv*sig_delr_cj_nld45b_sphv_10hv)))
+    delr_is_nld45b_sphv_10hv = (nom_delr_is_nld45b_sphv_10hv*exp(sig_delr_is_nld45b_sphv_10hv*nsig_delr_is_nld45b_sphv_10hv))
+    delr_is2_nld45b_sphv_10hv = (nom_delr_is2_nld45b_sphv_10hv*exp(sig_delr_is2_nld45b_sphv_10hv*nsig_delr_is2_nld45b_sphv_10hv))
+    delr_ir_nld45b_sphv_10hv = (nom_delr_ir_nld45b_sphv_10hv*exp(sig_delr_ir_nld45b_sphv_10hv*nsig_delr_ir_nld45b_sphv_10hv))
// bin parameters
+    dwvdscale =(dwvdscale_nld45b_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(0)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ uo_ng_del =	      (weff/(weff+2))*(0.15)
+ uo_ng_fac =	      (ngeff/(ngeff+uo_ng_del))/(2/(2+uo_ng_del))
+ dvth_ng=weff/(weff+0.25)*(0.03)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ rshldd_ng_del =   (weff/(weff+2))*(0.12)
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(rshldd_ng_del)*(1-fem)
//simple model
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.85)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}


// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (57+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rply*((w+2*3.425*(1-fem))/((lch+lacc+lflap)*3*ng)))
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+     dphibo=(dphibo_nld45b_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_pspmoscap_10hv+dela_vfb_nld45b_sphv_10hv)
+     nsubo=(nsubo_nld45b_sphv_10hv)
+     nsubw=(nsubw_nld45b_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =amoscap/l*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_mosb_10hv)
+ wdrift     =(w_nld45b_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_mosb_10hv)+(stdelvto_nld45b_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)
+ factuo     =(factuo_nld45b_mosb_10hv)*(1+(stfactuo_nld45b_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))


model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=(vdscale_nld45b_sphv_10hv)*(1+dwvdscale/w+dwvdscalew/(w*w))*(((temp+273.5)/(tnom+273.5))**(stvdscale1_nld45b_sphv_10hv))*(delr_vdscale_nld45b_sphv_10hv)
+ stvdscale=(stvdscale_nld45b_sphv_10hv)
+ ctgo=(ctgo_nld45b_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (1)
+ swexp    = (1)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_sphv_10hv)
+ qmc      = (qmc_nld45b_sphv_10hv)
+ lvaro    = (lvaro_nld45b_sphv_10hv)
+ lvarl    = (lvarl_nld45b_sphv_10hv)
+ lvarw    = (lvarw_nld45b_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_sphv_10hv)
+ wvaro    = (wvaro_nld45b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_sphv_10hv+0.5e-6*dela_dw_nld45b_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_sphv_10hv)
+ dwq      = (dwq_nld45b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_sphv_10hv+dela_vfb_nld45b_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_sphv_10hv+dela_vtw_nld45b_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_sphv_10hv)
+ nsubo    = (nsubo_nld45b_sphv_10hv*delr_nsub_nld45b_sphv_10hv)
+ nsubw    = (nsubw_nld45b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_sphv_10hv)
+ npck     = (npck_nld45b_sphv_10hv)
+ npckw    = (npckw_nld45b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_sphv_10hv)
+ lpck     = (lpck_nld45b_sphv_10hv)
+ lpckw    = (lpckw_nld45b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_sphv_10hv)
+ fol2     = (fol2_nld45b_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_sphv_10hv)
+ nslpo    = (nslpo_nld45b_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_sphv_10hv)
+ dphibo   = (dphibo_nld45b_sphv_10hv)
+ dphibl   = (dphibl_nld45b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_sphv_10hv)
+ dphibw   = (dphibw_nld45b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_sphv_10hv)
+ npl      = (npl_nld45b_sphv_10hv)
+ cto      = (cto_nld45b_sphv_10hv)
+ ctl      = (ctl_nld45b_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_sphv_10hv)
+ ctw      = (ctw_nld45b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ lov      = (lov_nld45b_sphv_10hv)
+ dlovd    = (dlovd_nld45b_sphv_10hv)
+ novo     = (novo_nld45b_sphv_10hv)
+ novdo    = (novdo_nld45b_sphv_10hv)
+ cfl      = (cfl_nld45b_sphv_10hv)
+ cflexp   = (cflexp_nld45b_sphv_10hv)
+ cfw      = (cfw_nld45b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_sphv_10hv)
+ uo       = (uo_nld45b_sphv_10hv*delr_mobref_nld45b_sphv_10hv*delr_u0_relimo)*(weff/w)*(uo_ng_fac)
+ fbet1    = (fbet1_nld45b_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_sphv_10hv)
+ lp1w     = (lp1w_nld45b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_sphv_10hv)
+ lp2      = (lp2_nld45b_sphv_10hv)
+ betw1    = (betw1_nld45b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_sphv_10hv)
+ stbeto   = (stbeto_nld45b_sphv_10hv)
+ stbetl   = (stbetl_nld45b_sphv_10hv)
+ stbetw   = (stbetw_nld45b_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_sphv_10hv)
+ muew     = (muew_nld45b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_sphv_10hv)
+ themuo   = (themuo_nld45b_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_sphv_10hv)
+ cso      = (cso_nld45b_sphv_10hv)
+ csl      = (csl_nld45b_sphv_10hv)
+ cslexp   = (cslexp_nld45b_sphv_10hv)
+ csw      = (csw_nld45b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_sphv_10hv)
+ xcoro    = (xcoro_nld45b_sphv_10hv)
+ xcorl    = (xcorl_nld45b_sphv_10hv)
+ xcorw    = (xcorw_nld45b_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_sphv_10hv)
+ fetao    = (fetao_nld45b_sphv_10hv)
+ rsw1     = (rsw1_nld45b_sphv_10hv)
+ rsw2     = (rsw2_nld45b_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_sphv_10hv)
+ rsbo     = (rsbo_nld45b_sphv_10hv)
+ rsgo     = (rsgo_nld45b_sphv_10hv)
+ thesato  = (thesato_nld45b_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_sphv_10hv)
+ thesatw  = (thesatw_nld45b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_sphv_10hv)
+ axl      = (axl_nld45b_sphv_10hv)
+ alpl     = (alpl_nld45b_sphv_10hv)
+ alplexp  = (alplexp_nld45b_sphv_10hv)
+ alpw     = (alpw_nld45b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_sphv_10hv)
+ alp1w    = (alp1w_nld45b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_sphv_10hv)
+ alp2w    = (alp2w_nld45b_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_sphv_10hv)
+ a1o      = (a1o_nld45b_sphv_10hv)
+ a1l      = (a1l_nld45b_sphv_10hv)
+ a1w      = (a1w_nld45b_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_sphv_10hv)
+ sta2o    = (sta2o_nld45b_sphv_10hv)
+ a3o      = (a3o_nld45b_sphv_10hv)
+ a3l      = (a3l_nld45b_sphv_10hv)
+ a3w      = (a3w_nld45b_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_sphv_10hv)
+ a4l      = (a4l_nld45b_sphv_10hv)
+ a4w      = (a4w_nld45b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_sphv_10hv)
+ igovw    = (igovw_nld45b_sphv_10hv)
+ igovdw   = (igovdw_nld45b_sphv_10hv)
+ stigo    = (stigo_nld45b_sphv_10hv)
+ gc2o     = (gc2o_nld45b_sphv_10hv)
+ gc3o     = (gc3o_nld45b_sphv_10hv)
+ chibo    = (chibo_nld45b_sphv_10hv)
+ agidlw   = (agidlw_nld45b_sphv_10hv)
+ agidldw  = (agidldw_nld45b_sphv_10hv)
+ bgidlo   = (bgidlo_nld45b_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_sphv_10hv)
+ cfrw     = (cfrw_nld45b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_sphv_10hv)
+ nfalw    = (nfalw_nld45b_sphv_10hv)
+ nfblw    = (nfblw_nld45b_sphv_10hv)
+ nfclw    = (nfclw_nld45b_sphv_10hv)
+ efo      = (efo_nld45b_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_sphv_10hv)
+ kuowel   = (kuowel_nld45b_sphv_10hv)
+ kuowew   = (kuowew_nld45b_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_sphv_10hv)
+ rsh      = (rsh_nld45b_sphv_10hv)
+ rbulko   = (rbulko_nld45b_sphv_10hv)
+ rwello   = (rwello_nld45b_sphv_10hv)
+ rjunso   = (rjunso_nld45b_sphv_10hv/(weff+dwrjunso_nld45b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_sphv_10hv/(weff+dwrjundo_nld45b_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_sphv_10hv)
+ rshg     = (rshg_nld45b_sphv_10hv)
+ dlsil    = (dlsil_nld45b_sphv_10hv)
+ saref    = (saref_nld45b_sphv_10hv)
+ sbref    = (sbref_nld45b_sphv_10hv)
+ wlod     = (wlod_nld45b_sphv_10hv)
+ kuo      = (kuo_nld45b_sphv_10hv)
+ kvsat    = (kvsat_nld45b_sphv_10hv)
+ tkuo     = (tkuo_nld45b_sphv_10hv)
+ lkuo     = (lkuo_nld45b_sphv_10hv)
+ wkuo     = (wkuo_nld45b_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_sphv_10hv)
+ kvtho    = (kvtho_nld45b_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_sphv_10hv)
+ stetao   = (stetao_nld45b_sphv_10hv)
+ lodetao  = (lodetao_nld45b_sphv_10hv)
+ scref    = (scref_nld45b_sphv_10hv)
+ web      = (web_nld45b_sphv_10hv)
+ wec      = (wec_nld45b_sphv_10hv)
+ adr1o    = (adr1o_nld45b_sphv_10hv)
+ adr1l    = (adr1l_nld45b_sphv_10hv)
+ adr1w    = ((adr1w_nld45b_sphv_10hv)/exp(w))*(1-fem)
+ adr2o    = (adr2o_nld45b_sphv_10hv)*((temp+273.5)/(tnom+273.5))**(stadr2o1_nld45b_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_sphv_10hv)
+ adr3o    = (adr3o_nld45b_sphv_10hv)
+ adr3l    = (adr3l_nld45b_sphv_10hv)
+ adr3w    = (adr3w_nld45b_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_sphv_10hv)
+ adr4l    = (adr4l_nld45b_sphv_10hv)
+ adr4w    = (adr4w_nld45b_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_sphv_10hv)
+ adr5l    = (adr5l_nld45b_sphv_10hv)
+ adr5w    = (adr5w_nld45b_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_sphv_10hv)
+ strthao   = (strthao_nld45b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
//+ rshldd   = (rshldd_nld45b_sphv_10hv*(1+(ng/(ng+6)-2/(2+6))*0.08*(1-fem))*delr_rsh_nld45b_sphv_10hv*delr_rdsw_relimo)
+ rshldd   = ((rshldd_nld45b_sphv_10hv*delr_rsh_nld45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_ronratio))*fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_sphv_10hv+(1e-6)*dela_xw_nld45b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_sphv_10hv)
+ xlw      = (xlw_nld45b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_sphv_10hv)
+ nst      = (nst_nld45b_sphv_10hv)
+ ats      = (ats_nld45b_sphv_10hv)
+ dfinf    = (dfinf_nld45b_sphv_10hv)
+ dfw      = (dfw_nld45b_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_sphv_10hv)
+ dflw     = (dflw_nld45b_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_sphv_10hv)
+ ecrit    = (ecrit_nld45b_sphv_10hv*tfact_ecrit)*(1+dwecrit/w+dwecritw/(w*w))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_sphv_10hv*tfact_ecrit)*(1+dwecrit/w+dwecritw/(w*w))*(ecrit_ng_fac)
+ du       = (du_nld45b_sphv_10hv)
+ tc1      = (tc1_nld45b_sphv_10hv)
+ tc2      = (tc2_nld45b_sphv_10hv)
+ tc1l     = (tc1l_nld45b_sphv_10hv)
+ tc2l     = (tc2l_nld45b_sphv_10hv)
+ tc1w     = (tc1w_nld45b_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_sphv_10hv)
+ theacc2  = (theacc2_nld45b_sphv_10hv)
+ aacc     = (aacc_nld45b_sphv_10hv)
+ rva      = (rva_nld45b_sphv_10hv)
+ dta      = (dta_nld45b_sphv_10hv)
+ trj      = (trj_nld45b_sphv_10hv)
+ cjarea   = (cjarea_nld45b_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_sphv_10hv)
+ vbisti   = (vbisti_nld45b_sphv_10hv)
+ vbigat   = (vbigat_nld45b_sphv_10hv)
+ parea    = (parea_nld45b_sphv_10hv)
+ psti     = (psti_nld45b_sphv_10hv)
+ pgat     = (pgat_nld45b_sphv_10hv)
+ is1area  = (is1area_nld45b_sphv_10hv)
+ ttarea   = (ttarea_nld45b_sphv_10hv)
+ is2area  = (is2area_nld45b_sphv_10hv)
+ irarea   = (irarea_nld45b_sphv_10hv)
+ stis1area = (stis1area_nld45b_sphv_10hv)
+ stis2area = (stis2area_nld45b_sphv_10hv)
+ stirarea = (stirarea_nld45b_sphv_10hv)
+ n1area   = (n1area_nld45b_sphv_10hv)
+ n2area   = (n2area_nld45b_sphv_10hv)
+ nrarea   = (nrarea_nld45b_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_sphv_10hv)
+ irlsti   = (irlsti_nld45b_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_sphv_10hv)
+ stirsti  = (stirsti_nld45b_sphv_10hv)
+ n1sti    = (n1sti_nld45b_sphv_10hv)
+ n2sti    = (n2sti_nld45b_sphv_10hv)
+ nrsti    = (nrsti_nld45b_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_sphv_10hv)
+ irlgat   = (irlgat_nld45b_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_sphv_10hv)
+ stirgat  = (stirgat_nld45b_sphv_10hv)
+ n1gat    = (n1gat_nld45b_sphv_10hv)
+ n2gat    = (n2gat_nld45b_sphv_10hv)
+ nrgat    = (nrgat_nld45b_sphv_10hv)
+ cjaread  = (cjaread_nld45b_sphv_10hv*delr_cj_nld45b_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_sphv_10hv)
+ vbistid  = (vbistid_nld45b_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_sphv_10hv)
+ paread   = (paread_nld45b_sphv_10hv)
+ pstid    = (pstid_nld45b_sphv_10hv)
+ pgatd    = (pgatd_nld45b_sphv_10hv)
+ is1aread = (is1aread_nld45b_sphv_10hv*delr_is_nld45b_sphv_10hv)
+ ttaread  = (ttaread_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2aread = (is2aread_nld45b_sphv_10hv*delr_is2_nld45b_sphv_10hv)
+ iraread  = (iraread_nld45b_sphv_10hv*delr_ir_nld45b_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_sphv_10hv)
+ stiraread = (stiraread_nld45b_sphv_10hv)
+ n1aread  = (n1aread_nld45b_sphv_10hv)
+ n2aread  = (n2aread_nld45b_sphv_10hv)
+ nraread  = (nraread_nld45b_sphv_10hv)
+ is1lstid = (is1aread_nld45b_sphv_10hv*djunc*delr_is_nld45b_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lstid = (is2aread_nld45b_sphv_10hv*djunc*delr_is2_nld45b_sphv_10hv)
+ irlstid  = (iraread_nld45b_sphv_10hv*djunc*delr_ir_nld45b_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_sphv_10hv)
+ stirstid = (stirstid_nld45b_sphv_10hv)
+ n1stid   = (n1stid_nld45b_sphv_10hv)
+ n2stid   = (n2stid_nld45b_sphv_10hv)
+ nrstid   = (nrstid_nld45b_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_sphv_10hv*djunc*delr_is_nld45b_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lgatd = (is2aread_nld45b_sphv_10hv*djunc*delr_is2_nld45b_sphv_10hv)
+ irlgatd  = (iraread_nld45b_sphv_10hv*djunc*delr_ir_nld45b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_sphv_10hv*delr_cj_nld45b_sphv_10hv)
+ cjlstid2 = (0*cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_sphv_10hv)
+ paread2  = (paread2_nld45b_sphv_10hv)
+ pstid2   = (pstid2_nld45b_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2aread2 = (is2aread_nld45b_sphv_10hv)
+ iraread2 = (iraread2_nld45b_sphv_10hv*delr_ir_nld45b_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_sphv_10hv)
+ nraread2 = (nraread2_nld45b_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lstid2 = (is2aread_nld45b_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_sphv_10hv*djunc)
+ stis1stid2 = (stis1stid2_nld45b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_sphv_10hv)
+ eais1area		= eais1area_nld45b_sphv_10hv
+ eais2area		= eais2area_nld45b_sphv_10hv
+ eairarea		= eairarea_nld45b_sphv_10hv
+ eais1sti		= eais1sti_nld45b_sphv_10hv
+ eais2sti		= eais2sti_nld45b_sphv_10hv
+ eairsti	  = eairsti_nld45b_sphv_10hv
+ eais1gat		= eais1gat_nld45b_sphv_10hv
+ eais2gat		= eais2gat_nld45b_sphv_10hv
+ eairgat	  = eairgat_nld45b_sphv_10hv
+ eais1aread		= eais1aread_nld45b_sphv_10hv
+ eais2aread		= eais2aread_nld45b_sphv_10hv
+ eairaread		= eairaread_nld45b_sphv_10hv
+ eais1stid		= eais1stid_nld45b_sphv_10hv
+ eais2stid		= eais2stid_nld45b_sphv_10hv
+ eairstid		= eairstid_nld45b_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_sphv_10hv
+ eairgatd		= eairgatd_nld45b_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_sphv_10hv
+ eairaread2		= eairaread2_nld45b_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_sphv_10hv
+ eairstid2		= eairstid2_nld45b_sphv_10hv
+ ikfarea               = ikfarea_nld45b_sphv_10hv
+ ikflsti               = ikfarea_nld45b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_sphv_10hv
+ stikfsti              = stikfarea_nld45b_sphv_10hv
+ stikfgat              = stikfarea_nld45b_sphv_10hv
+ ikfaread              = ikfaread_nld45b_sphv_10hv*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_sphv_10hv*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_sphv_10hv
+ stikfstid             = stikfaread_nld45b_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_sphv_10hv



include "./smos10hv_ade_dfrt.scs" section=nld45b_10hv_dfrt
ends


//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld65b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    sti_dummy                      = 0


//*support mismatch
//*******************************************************************************************************
+ tc_vth_mm                      = (1+(temp-27)*(-2.5e-3))
+ nsmm_delr_gox_nld65b_sphv_10hv = tmp_nsmm_delr_gox_nld65b_sphv_10hv
+ nsmm_delr_uch_nld65b_sphv_10hv  = tmp_nsmm_delr_uch_nld65b_sphv_10hv
+ nsmm_delr_res_nld65b_sphv_10hv  = tmp_nsmm_delr_res_nld65b_sphv_10hv
+ nsmm_dela_vfb_nld65b_sphv_10hv  = tmp_nsmm_dela_vfb_nld65b_sphv_10hv
+ nsmm_dela_vtw_nld65b_sphv_10hv  = tmp_nsmm_dela_vtw_nld65b_sphv_10hv
+ nsmm_delr_nsub_nld65b_sphv_10hv = tmp_nsmm_delr_nsub_nld65b_sphv_10hv
+ nsmm_dela_dxw_nld65b_sphv_10hv = tmp_nsmm_dela_dxw_nld65b_sphv_10hv

//*relimo model
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld65b_vthratio     = 1.0
+    presto_nld65b_ronratio     = 0.01/1.25

//**parameters for multi ng
+ fac_ng_rshldd=(1+(ngeff/(ngeff-0.3*(1-fem))-2/(2-0.3))*(0.1))
+ fac_ng_vfbo= ((ngeff/(ngeff+0.6*(1-fem))-2/(2+0.6))*(0.14))
+ fac_ng_thesato= (1+(ngeff/(ngeff+0.1*(1-fem))-2/(2+0.1))*(0))

//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+ delr_tox_nld65b_sphv_10hv=(nom_delr_tox_nld65b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld65b_sphv_10hv+nsmm_delr_gox_nld65b_sphv_10hv*smm_delr_gox_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_uch_nld65b_sphv_10hv = (nom_delr_uch_nld65b_sphv_10hv*(1+sig_delr_uch_nld65b_sphv_10hv*nsig_delr_uch_nld65b_sphv_10hv+nsmm_delr_uch_nld65b_sphv_10hv*smm_delr_uch_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_nld65b_sphv_10hv = (nom_delr_res_nld65b_sphv_10hv*(1+sig_delr_res_nld65b_sphv_10hv*nsig_delr_res_nld65b_sphv_10hv+nsmm_delr_res_nld65b_sphv_10hv*smm_delr_res_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_nld65b_sphv_10hv = (nom_dela_vfb_nld65b_sphv_10hv+(sig_dela_vfb_nld65b_sphv_10hv*nsig_dela_vfb_nld65b_sphv_10hv)+tc_vth_mm*nsmm_dela_vfb_nld65b_sphv_10hv*smm_dela_vfb_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_nld65b_sphv_10hv = (nom_dela_vtw_nld65b_sphv_10hv+(sig_dela_vtw_nld65b_sphv_10hv*nsig_dela_vtw_nld65b_sphv_10hv)+nsmm_dela_vtw_nld65b_sphv_10hv*smm_dela_vtw_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_xw_nld65b_sphv_10hv = (nom_dela_xw_nld65b_sphv_10hv+(sig_dela_xw_nld65b_sphv_10hv*nsig_dela_xw_nld65b_sphv_10hv)+(nsmm_dela_dxw_nld65b_sphv_10hv*smm_dela_dxw_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_nsub_nld65b_sphv_10hv = (1+nsmm_delr_nsub_nld65b_sphv_10hv*smm_delr_nsub_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_thesatw_nld65b_sphv_10hv = (nom_dela_thesatw_nld65b_sphv_10hv+(sig_dela_thesatw_nld65b_sphv_10hv*nsig_dela_thesatw_nld65b_sphv_10hv))
+ delr_cj_nld65b_sphv_10hv = (nom_delr_cj_nld65b_sphv_10hv*(1+sig_delr_cj_nld65b_sphv_10hv*nsig_delr_cj_nld65b_sphv_10hv))
+ delr_is_nld65b_sphv_10hv = (nom_delr_is_nld65b_sphv_10hv*exp(sig_delr_is_nld65b_sphv_10hv*nsig_delr_is_nld65b_sphv_10hv))
+ delr_is2_nld65b_sphv_10hv = (nom_delr_is2_nld65b_sphv_10hv*exp(sig_delr_is2_nld65b_sphv_10hv*nsig_delr_is2_nld65b_sphv_10hv))
+ delr_ir_nld65b_sphv_10hv = (nom_delr_ir_nld65b_sphv_10hv*exp(sig_delr_ir_nld65b_sphv_10hv*nsig_delr_ir_nld65b_sphv_10hv))
//****************************************************************************************************
// *will remove in final assemble
//****************************************************************************************************
//+    cpp_ply_fld		    = (0.092229166666667e-15)
//+    cpp_ply_sdt		    = (2.6460229885057e-15)
//+    cpp_m1_sd 		            = (0.054083183333333e-15)
//

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))


+    fscale			    = (1)
+    nde			    = (0)
+    nse			    = (2)
+    ns 		    = ((ng+nse)/2)
+    nd 		    = (ng/2)
+    ndi			    = (nd-nde)
+    nsi			    = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv		    = (3.9)
+    l                              = (0.55)
+    numbernplus		    = (int_round((w-0.09*(1-fem))/0.84))
+    weff		    = (numbernplus*0.42*fscale)
+    ldrift_dr  	    = (2.75*fscale)
+    wdrift_dr  	    = (w*fscale)
+    ldr1		    = (0.6*fscale)
+    lacts			    = (0.375)
+    lactd			    = (0.69/2)
+    ldrift			    = (2.75)
+    wd2g		    = (1.3)*(1-fem)
+    wg1		    = (1.95)*(1-fem)
+    wg2		    = (1.85)*(1-fem)
+    wnc		    = (0.95)*(1-fem)
+    wgd			    = (0.6)*(1-fem)
+    wdcfply                        = (0.7)*(1-fem)

// for the moscap
+    rect_area  		    = (wd2g+wg1+wg2)*(l+ldr1+ldrift+lactd)*2
+    rect_cutout		    = (ldr1+ldrift+lactd)*(wd2g)*2
+    semi_cutout		    =  pi4models*(wdcfply+wgd+wg1)*(wdcfply+wgd+wg1)/2
+    amoscap			    = ((rect_area-rect_cutout-semi_cutout)*fscale*fscale)
// for the parastic cap
+    ld2g			    = 0.8
+    as_xdr			    = (lacts*(weff))
+    ps_xdr			    = (2*(lacts+(weff)))
+    ad_xdr			    = (((ldrift*2+ldr1*2+lactd*2)*(w+2*wd2g)+pi4models*(wg1+wdcfply+wgd)*(wg1+wdcfply+wgd))/2)
+    pd_xdr			    = (((2*pi4models*(wg1+wdcfply+wgd))+2*(w+2*wd2g))/2)
+    ad2_xdr			    = (((lactd*2+ldrift)*(w)+pi4models*wd2g*wd2g)/2)
+    as_dr			    = (as_xdr*fscale*fscale)
+    ps_dr			    = (ps_xdr*fscale)
+    ad_dr			    = ((ad_xdr-ad2_xdr)*fscale*fscale)
+    pd_dr			    = (pd_xdr*fscale)
+    ad2_dr			    = (ad2_xdr*fscale*fscale)
+    pd2_dr			    = (0)
+    la2dt			    = (1.485)
+    wa2dt			    = (1.11)*(1-fem)
+    lg2g_d			    = (2*(ldr1+ldrift+lactd))
+    lg2g_s			    = (0.78)
+    xnbl_xdr			    = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			    = (w+(wd2g+wg1+wg2+wa2dt)*2)
+    anbl_xdr			    = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			    = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			    = 2.0*1e-6
+    aplyfld_d  		    = (((ldrift_dr-ld2g-0.7)*(w+wd2g*2)+(pi4models*(wg1)*(wg1))/2)*ngeff*fscale*fscale)
+    aplyact_d  		    = ((ldr1*wd2g*2+pi4models*(wg1+wdcfply+wgd)*(wg1+wdcfply+wgd)/2-pi4models*(wg1+wdcfply)*(wg1+wdcfply)/2)*fscale*fscale)
+    ldr1_eff		            = (ldr1+1.0*aplyact_d/(w))
+    lacc			    = (0.6)
+    lch			    = (0.55)
+    lflap                          = (1.25)
+    aplyfld_d_rgate                = (aplyfld_d/ngeff)
+    rgateout			    = (rply*(w+2*5.375*(1-fem))/((lch+lacc)*3))
+    rgatein			    = (rply*aplyfld_d_rgate/((lflap)*(lflap)*3))
+    rgatetot			    = (rgatein*rgateout/(rgatein+rgateout))
+    tfact_ecrit		    = 1+(tc1_ecrit_nld65b_sphv_10hv+tc2_ecrit_nld65b_sphv_10hv*(temp-tnom))*(temp-tnom)
+    w_heat			    = w
+    l_heat			    = (lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=(((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld65b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld65b_sphv_10hv)*ngeff/she_fit)
+    cth_f=(((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8668)


+    xcoord			    = (0)
+    ycoord			    = (0)


if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift_dr wdrift=wdrift_dr ldr1=ldr1_eff mult=ng_dmy ad=ad_dr pd=pd_dr as=as_dr ps=ps_dr ad2=ad2_dr pd2=pd2_dr
}

model pspmoscap psp103t type=n
+     tr		 = 27
+     toxo=toxo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+     dphibo=dphibo_nld65b_sphv_10hv
+     vfbo=vfbo_nld65b_sphv_10hv+dela_vfb_nld65b_sphv_10hv+fac_ng_vfbo-0.85
+     nsubo=nsubo_nld65b_sphv_10hv
+     nsubw=nsubw_nld65b_sphv_10hv*(1-fem)*0
+     rtho=1e18
+     ctho=0


mmoscap (s intg s s dtemp) pspmoscap
+ l	     =0.64
+ w	     =amoscap/l*(1-fem)+fem*1e-3
+ mult       =ng

// BV diode model card:
model dbodydrainbv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (84+bvdss_shift)
+ ibv      = (1e-5/1e-12)



amost (d intg s s dtemp) sphvt_simkit
+ w	     =w
+ l	     =l
+ ldrift     =ldrift_dr
+ wdrift     =wdrift_dr
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad	     =ad_dr
+ pd	     =pd_dr
+ as	     =as_dr
+ ps	     =ps_dr
+ ad2	     =ad2_dr
+ pd2	     =pd2_dr

model sphvt_simkit sphvt
+ type         = n
+ vdscale      = 1.23
+ tr	       = 27
+ swgeo        = 1
+ swgedi       = 1
+ swigate      = 0
+ swimpact     = 1
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = 1
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 0
+ swnud        = 0
+ swptest      = 0
+ swdrlin      = swdrlin
+ xvsat	       = xvsat_nld65b_sphv_10hv
+ qmc	       = qmc_nld65b_sphv_10hv
+ lvaro    = lvaro_nld65b_sphv_10hv
+ lvarl    = lvarl_nld65b_sphv_10hv
+ lvarw    = (lvarw_nld65b_sphv_10hv*(1-fem))
+ lap		     = lap_nld65b_sphv_10hv
+ wvaro     = (wvaro_nld65b_sphv_10hv*(1-fem))
+ wvarl     = (wvarl_nld65b_sphv_10hv*(1-fem))
+ wvarw     = (wvarw_nld65b_sphv_10hv*(1-fem))
+ wot		     = (wot_nld65b_sphv_10hv*(1-fem))
+ dlq		     = dlq_nld65b_sphv_10hv
+ dwq		     = (dwq_nld65b_sphv_10hv*(1-fem))
+ vfbo     = vfbo_nld65b_sphv_10hv+dela_vfb_nld65b_sphv_10hv+fac_ng_vfbo+dela_vth_relimo+hvgsvthdegr*presto_nld65b_vthratio
+ vfbl     = vfbl_nld65b_sphv_10hv
+ vfbw     = (vfbw_nld65b_sphv_10hv+dela_vtw_nld65b_sphv_10hv*(1-fem))
+ vfblw     = (vfblw_nld65b_sphv_10hv*(1-fem))
+ stvfbo     = stvfbo_nld65b_sphv_10hv
+ stvfbl     = stvfbl_nld65b_sphv_10hv
+ stvfbw     = (stvfbw_nld65b_sphv_10hv*(1-fem))
+ stvfblw     = (stvfblw_nld65b_sphv_10hv*(1-fem))
+ toxo     = toxo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ epsroxo     = epsroxo_nld65b_sphv_10hv
+ nsubo     = nsubo_nld65b_sphv_10hv*delr_nsub_nld65b_sphv_10hv
+ nsubw     = (nsubw_nld65b_sphv_10hv*(1-fem))
+ wseg     = wseg_nld65b_sphv_10hv
+ npck     = npck_nld65b_sphv_10hv
+ npckw     = (npckw_nld65b_sphv_10hv*(1-fem))
+ wsegp     = wsegp_nld65b_sphv_10hv
+ lpck     = lpck_nld65b_sphv_10hv
+ lpckw     = (lpckw_nld65b_sphv_10hv*(1-fem))
+ fol1     = fol1_nld65b_sphv_10hv
+ fol2     = fol2_nld65b_sphv_10hv
+ facneffaco		   = facneffaco_nld65b_sphv_10hv
+ facneffacl		   = facneffacl_nld65b_sphv_10hv
+ facneffacw		   = (facneffacw_nld65b_sphv_10hv*(1-fem))
+ facneffaclw		    = (facneffaclw_nld65b_sphv_10hv*(1-fem))
+ gfacnudo		 = gfacnudo_nld65b_sphv_10hv
+ gfacnudl		 = gfacnudl_nld65b_sphv_10hv
+ gfacnudlexp		    = gfacnudlexp_nld65b_sphv_10hv
+ gfacnudw		 = (gfacnudw_nld65b_sphv_10hv*(1-fem))
+ gfacnudlw		  = (gfacnudlw_nld65b_sphv_10hv*(1-fem))
+ vsbnudo     = vsbnudo_nld65b_sphv_10hv
+ dvsbnudo		 = dvsbnudo_nld65b_sphv_10hv
+ vnsubo     = vnsubo_nld65b_sphv_10hv
+ nslpo     = nslpo_nld65b_sphv_10hv
+ dnsubo     = dnsubo_nld65b_sphv_10hv
+ dphibo     = dphibo_nld65b_sphv_10hv
+ dphibl     = dphibl_nld65b_sphv_10hv
+ dphiblexp		  = dphiblexp_nld65b_sphv_10hv
+ dphibw     = (dphibw_nld65b_sphv_10hv*(1-fem))
+ dphiblw     = (dphiblw_nld65b_sphv_10hv*(1-fem))
+ delvtaco		 = delvtaco_nld65b_sphv_10hv
+ delvtacl		 = delvtacl_nld65b_sphv_10hv
+ delvtaclexp		    = delvtaclexp_nld65b_sphv_10hv
+ delvtacw		 = delvtacw_nld65b_sphv_10hv*(1-fem)
+ delvtaclw		  = delvtaclw_nld65b_sphv_10hv*(1-fem)
+ npo		    = npo_nld65b_sphv_10hv
+ npl		    = npl_nld65b_sphv_10hv
+ cto		    = cto_nld65b_sphv_10hv
+ ctl		    = ctl_nld65b_sphv_10hv
+ ctlexp     = ctlexp_nld65b_sphv_10hv
+ ctw		    = (ctw_nld65b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld65b_sphv_10hv*(1-fem))
+ toxovo     = toxovo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ toxovdo    = toxovdo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ lov		    = lov_nld65b_sphv_10hv
+ dlovd     = dlovd_nld65b_sphv_10hv
+ novo     = novo_nld65b_sphv_10hv
+ novdo     = novdo_nld65b_sphv_10hv
+ cfl		    = cfl_nld65b_sphv_10hv
+ cflexp     = cflexp_nld65b_sphv_10hv
+ cfw		    = (cfw_nld65b_sphv_10hv*(1-fem))
+ cfbo     = cfbo_nld65b_sphv_10hv
+ uo		   = uo_nld65b_sphv_10hv*(weff/w)*delr_uch_nld65b_sphv_10hv*delr_u0_relimo
+ fbet1     = fbet1_nld65b_sphv_10hv
+ fbet1w     = (fbet1w_nld65b_sphv_10hv*(1-fem))
+ lp1		    = lp1_nld65b_sphv_10hv
+ lp1w     = (lp1w_nld65b_sphv_10hv*(1-fem))
+ fbet2     = fbet2_nld65b_sphv_10hv
+ lp2		    = lp2_nld65b_sphv_10hv
+ betw1     = (betw1_nld65b_sphv_10hv*(1-fem))
+ betw2     = (betw2_nld65b_sphv_10hv*(1-fem))
+ wbet     = wbet_nld65b_sphv_10hv
+ stbeto     = stbeto_nld65b_sphv_10hv
+ stbetl     = stbetl_nld65b_sphv_10hv
+ stbetw     = (stbetw_nld65b_sphv_10hv*(1-fem))
+ stbetlw     = (stbetlw_nld65b_sphv_10hv*(1-fem))
+ mueo     = mueo_nld65b_sphv_10hv
+ muew     = (muew_nld65b_sphv_10hv*(1-fem))
+ stmueo     = stmueo_nld65b_sphv_10hv
+ themuo     = themuo_nld65b_sphv_10hv
+ stthemuo		 = stthemuo_nld65b_sphv_10hv
+ cso		    = cso_nld65b_sphv_10hv
+ csl		    = csl_nld65b_sphv_10hv
+ cslexp     = cslexp_nld65b_sphv_10hv
+ csw		    = (csw_nld65b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld65b_sphv_10hv*(1-fem))
+ stcso     = stcso_nld65b_sphv_10hv
+ xcoro     = xcoro_nld65b_sphv_10hv
+ xcorl     = xcorl_nld65b_sphv_10hv
+ xcorw     = (xcorw_nld65b_sphv_10hv*(1-fem))
+ xcorlw     = (xcorlw_nld65b_sphv_10hv*(1-fem))
+ stxcoro     = stxcoro_nld65b_sphv_10hv
+ fetao     = fetao_nld65b_sphv_10hv
+ rsw1     = rsw1_nld65b_sphv_10hv
+ rsw2     = rsw2_nld65b_sphv_10hv*(1-fem)
+ strso     = strso_nld65b_sphv_10hv
+ rsbo     = rsbo_nld65b_sphv_10hv
+ rsgo     = rsgo_nld65b_sphv_10hv
+ thesato     = (thesato_nld65b_sphv_10hv)*fac_ng_thesato
+ thesatl     = (thesatl_nld65b_sphv_10hv)
+ thesatlexp		 = thesatlexp_nld65b_sphv_10hv
+ thesatw     = ((thesatw_nld65b_sphv_10hv+dela_thesatw_nld65b_sphv_10hv)*(1-fem))
+ thesatlw	       = (thesatlw_nld65b_sphv_10hv*(1-fem))
+ stthesato		  = stthesato_nld65b_sphv_10hv
+ stthesatl		  = stthesatl_nld65b_sphv_10hv
+ stthesatw		  = (stthesatw_nld65b_sphv_10hv*(1-fem))
+ stthesatlw		   = (stthesatlw_nld65b_sphv_10hv*(1-fem))
+ thesatbo		 = thesatbo_nld65b_sphv_10hv
+ thesatgo		 = thesatgo_nld65b_sphv_10hv
+ thesatgl		 = thesatgl_nld65b_sphv_10hv
+ thesatgw		 = (thesatgw_nld65b_sphv_10hv*(1-fem))
+ axo		    = axo_nld65b_sphv_10hv
+ axl		    = axl_nld65b_sphv_10hv
+ alpl     = alpl_nld65b_sphv_10hv
+ alplexp     = alplexp_nld65b_sphv_10hv
+ alpw     = (alpw_nld65b_sphv_10hv*(1-fem))
+ alp1l1     = alp1l1_nld65b_sphv_10hv
+ alp1lexp		 = alp1lexp_nld65b_sphv_10hv
+ alp1l2     = alp1l2_nld65b_sphv_10hv
+ alp1w     = (alp1w_nld65b_sphv_10hv*(1-fem))
+ alp2l1     = alp2l1_nld65b_sphv_10hv
+ alp2lexp		 = alp2lexp_nld65b_sphv_10hv
+ alp2l2     = alp2l2_nld65b_sphv_10hv
+ alp2w     = (alp2w_nld65b_sphv_10hv*(1-fem))
+ vpo		    = vpo_nld65b_sphv_10hv
+ a1o		    = a1o_nld65b_sphv_10hv
+ a1l		    = a1l_nld65b_sphv_10hv
+ a1w		    = (a1w_nld65b_sphv_10hv*(1-fem))
+ a2o		    = a2o_nld65b_sphv_10hv
+ sta2o     = sta2o_nld65b_sphv_10hv
+ a3o		    = a3o_nld65b_sphv_10hv
+ a3l		    = a3l_nld65b_sphv_10hv
+ a3w		    = (a3w_nld65b_sphv_10hv*(1-fem))
+ a4o		    = a4o_nld65b_sphv_10hv
+ a4l		    = a4l_nld65b_sphv_10hv
+ a4w		    = (a4w_nld65b_sphv_10hv*(1-fem))
+ gcoo     = gcoo_nld65b_sphv_10hv
+ iginvlw     = iginvlw_nld65b_sphv_10hv
+ igovw     = igovw_nld65b_sphv_10hv
+ igovdw     = igovdw_nld65b_sphv_10hv
+ stigo     = stigo_nld65b_sphv_10hv
+ gc2o     = gc2o_nld65b_sphv_10hv
+ gc3o     = gc3o_nld65b_sphv_10hv
+ chibo     = chibo_nld65b_sphv_10hv
+ agidlw     = (agidlw_nld65b_sphv_10hv)
+ agidldw     = (agidldw_nld65b_sphv_10hv)
+ bgidlo     = bgidlo_nld65b_sphv_10hv
+ bgidldo     = bgidldo_nld65b_sphv_10hv
+ stbgidlo		 = stbgidlo_nld65b_sphv_10hv
+ stbgidldo		  = stbgidldo_nld65b_sphv_10hv
+ cgidlo     = cgidlo_nld65b_sphv_10hv
+ cgidldo     = cgidldo_nld65b_sphv_10hv
+ cgbovl     = cgbovl_nld65b_sphv_10hv
+ cfrw     = (cfrw_nld65b_sphv_10hv)*(1-fem)
+ cfrdw     = (cfrdw_nld65b_sphv_10hv*(1-fem))
+ fnto     = fnto_nld65b_sphv_10hv
+ nfalw     = nfalw_nld65b_sphv_10hv
+ nfblw     = nfblw_nld65b_sphv_10hv
+ nfclw     = nfclw_nld65b_sphv_10hv
+ efo		    = efo_nld65b_sphv_10hv
+ lintnoi     = lintnoi_nld65b_sphv_10hv
+ alpnoi     = alpnoi_nld65b_sphv_10hv
+ kvthoweo		 = kvthoweo_nld65b_sphv_10hv
+ kvthowel		 = kvthowel_nld65b_sphv_10hv
+ kvthowew		 = kvthowew_nld65b_sphv_10hv*(1-fem)
+ kvthowelw		  = kvthowelw_nld65b_sphv_10hv*(1-fem)
+ kuoweo     = kuoweo_nld65b_sphv_10hv
+ kuowel     = kuowel_nld65b_sphv_10hv
+ kuowew     = kuowew_nld65b_sphv_10hv*(1-fem)
+ kuowelw     = kuowelw_nld65b_sphv_10hv*(1-fem)
+ rgo		    = rgo_nld65b_sphv_10hv
+ rsh		    = rsh_nld65b_sphv_10hv
+ rbulko     = rbulko_nld65b_sphv_10hv
+ rwello     = rwello_nld65b_sphv_10hv
+ rjunso     = rjunso_nld65b_sphv_10hv/(w+dwrjunso_nld65b_sphv_10hv*(1-fem))
+ rjundo     = rjundo_nld65b_sphv_10hv/(w+dwrjundo_nld65b_sphv_10hv*(1-fem))
+ rint     = rint_nld65b_sphv_10hv
+ rvpoly     = rvpoly_nld65b_sphv_10hv
+ rshg     = rshg_nld65b_sphv_10hv
+ dlsil     = dlsil_nld65b_sphv_10hv
+ saref     = saref_nld65b_sphv_10hv
+ sbref     = sbref_nld65b_sphv_10hv
+ wlod     = wlod_nld65b_sphv_10hv
+ kuo		    = kuo_nld65b_sphv_10hv
+ kvsat     = kvsat_nld65b_sphv_10hv
+ tkuo     = tkuo_nld65b_sphv_10hv
+ lkuo     = lkuo_nld65b_sphv_10hv
+ wkuo     = wkuo_nld65b_sphv_10hv*(1-fem)
+ pkuo     = pkuo_nld65b_sphv_10hv*(1-fem)
+ llodkuo     = llodkuo_nld65b_sphv_10hv
+ wlodkuo     = wlodkuo_nld65b_sphv_10hv
+ kvtho     = kvtho_nld65b_sphv_10hv
+ lkvtho     = lkvtho_nld65b_sphv_10hv
+ wkvtho     = wkvtho_nld65b_sphv_10hv*(1-fem)
+ pkvtho     = pkvtho_nld65b_sphv_10hv*(1-fem)
+ llodvth     = llodvth_nld65b_sphv_10hv
+ wlodvth     = wlodvth_nld65b_sphv_10hv
+ stetao     = stetao_nld65b_sphv_10hv
+ lodetao     = lodetao_nld65b_sphv_10hv
+ scref     = scref_nld65b_sphv_10hv
+ web		    = web_nld65b_sphv_10hv
+ wec		    = wec_nld65b_sphv_10hv
+ adr1o     = adr1o_nld65b_sphv_10hv
+ adr1l     = adr1l_nld65b_sphv_10hv
+ adr1w     = adr1w_nld65b_sphv_10hv*(1-fem)
+ adr2o     = adr2o_nld65b_sphv_10hv
+ stadr2o     = stadr2o_nld65b_sphv_10hv
+ adr3o     = adr3o_nld65b_sphv_10hv
+ adr3l     = adr3l_nld65b_sphv_10hv
+ adr3w     = adr3w_nld65b_sphv_10hv*(1-fem)
+ adr4o     = adr4o_nld65b_sphv_10hv
+ adr4l     = adr4l_nld65b_sphv_10hv
+ adr4w     = adr4w_nld65b_sphv_10hv*(1-fem)
+ adr5o     = adr5o_nld65b_sphv_10hv
+ adr5l     = adr5l_nld65b_sphv_10hv
+ adr5w     = adr5w_nld65b_sphv_10hv*(1-fem)
+ bidr1o     = bidr1o_nld65b_sphv_10hv
+ bidr1l     = bidr1l_nld65b_sphv_10hv
+ bidr1w     = bidr1w_nld65b_sphv_10hv*(1-fem)
+ bidr2o     = bidr2o_nld65b_sphv_10hv
+ bidr2w     = bidr2w_nld65b_sphv_10hv*(1-fem)
+ rtho     = (selfheat*enable_selfheat>0)?rth_f:0.0
+ //rtho     = rth_f
+ rthl     = 0
+ rthw     = 0
+ rthlw     = 0
+ strtho     = strtho_nld65b_sphv_10hv
+ strthao     = strthao_nld65b_sphv_10hv
+ ctho     = cth_f
+ cthl     = 0
+ cthw     = 0
+ cthlw     = 0
+ rshldd     = (rshldd_nld65b_sphv_10hv*fac_ng_rshldd*delr_res_nld65b_sphv_10hv*delr_rdsw_relimo*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld65b_ronratio))
+ xw		   = ((xw_nld65b_sphv_10hv+1e-6*dela_xw_nld65b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld65b_sphv_10hv*(1-fem))
+ xl		   = xl_nld65b_sphv_10hv
+ xlw		    = (xlw_nld65b_sphv_10hv*(1-fem))
+ dxlsat     = dxlsat_nld65b_sphv_10hv
+ nst		    = nst_nld65b_sphv_10hv
+ ats		    = ats_nld65b_sphv_10hv
+ dfinf     = dfinf_nld65b_sphv_10hv
+ dfw		    = (dfw_nld65b_sphv_10hv*(1-fem))
+ dfl		    = dfl_nld65b_sphv_10hv
+ dflw     = (dflw_nld65b_sphv_10hv*(1-fem))
+ dp		   = dp_nld65b_sphv_10hv
+ ecrit     = ecrit_nld65b_sphv_10hv*tfact_ecrit
+ ecorn     = ecorn_nld65b_sphv_10hv*tfact_ecrit
+ du		   = du_nld65b_sphv_10hv
+ tc1		    = tc1_nld65b_sphv_10hv
+ tc2		    = tc2_nld65b_sphv_10hv
+ tc1l     = tc1l_nld65b_sphv_10hv
+ tc2l     = tc2l_nld65b_sphv_10hv
+ tc1w     = (tc1w_nld65b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld65b_sphv_10hv*(1-fem))
+ theacc     = theacc_nld65b_sphv_10hv
+ theacc2     = theacc2_nld65b_sphv_10hv
+ aacc        = aacc_nld65b_sphv_10hv
+ rva		    = rva_nld65b_sphv_10hv
+ dta		    = dta_nld65b_sphv_10hv
+ trj		    = trj_nld65b_sphv_10hv
+ cjarea     = cjarea_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlsti     = cjarea_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ cjlgat     = cjarea_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiarea     = vbiarea_nld65b_sphv_10hv
+ vbisti     = vbisti_nld65b_sphv_10hv
+ vbigat     = vbigat_nld65b_sphv_10hv
+ parea     = parea_nld65b_sphv_10hv
+ psti     = psti_nld65b_sphv_10hv
+ pgat     = pgat_nld65b_sphv_10hv
+ is1area     = is1area_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttarea     = ttarea_nld65b_sphv_10hv
+ is2area     = is2area_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ irarea     = irarea_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1area		  = stis1area_nld65b_sphv_10hv
+ stis2area		  = stis2area_nld65b_sphv_10hv
+ stirarea		 = stirarea_nld65b_sphv_10hv
+ n1area     = n1area_nld65b_sphv_10hv
+ n2area     = n2area_nld65b_sphv_10hv
+ nrarea     = nrarea_nld65b_sphv_10hv
+ is1lsti     = is1area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlsti     = ttlsti_nld65b_sphv_10hv
+ is2lsti     = is2area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ irlsti     = irarea_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1sti		 = stis1sti_nld65b_sphv_10hv
+ stis2sti		 = stis2sti_nld65b_sphv_10hv
+ stirsti     = stirsti_nld65b_sphv_10hv
+ n1sti     = n1sti_nld65b_sphv_10hv
+ n2sti     = n2sti_nld65b_sphv_10hv
+ nrsti     = nrsti_nld65b_sphv_10hv
+ is1lgat     = is1area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlgat     = ttlgat_nld65b_sphv_10hv
+ is2lgat     = is2area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ irlgat     = irarea_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1gat		 = stis1gat_nld65b_sphv_10hv
+ stis2gat		 = stis2gat_nld65b_sphv_10hv
+ stirgat     = stirgat_nld65b_sphv_10hv
+ n1gat     = n1gat_nld65b_sphv_10hv
+ n2gat     = n2gat_nld65b_sphv_10hv
+ nrgat     = nrgat_nld65b_sphv_10hv
+ cjaread     = cjaread_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlstid     = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ cjlgatd     = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiaread		 = vbiaread_nld65b_sphv_10hv
+ vbistid     = vbistid_nld65b_sphv_10hv
+ vbigatd     = vbigatd_nld65b_sphv_10hv
+ paread     = paread_nld65b_sphv_10hv
+ pstid     = pstid_nld65b_sphv_10hv
+ pgatd     = pgatd_nld65b_sphv_10hv
+ is1aread		 = is1aread_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttaread     = ttaread_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2aread		 = is2aread_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ iraread     = iraread_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1aread		   = stis1aread_nld65b_sphv_10hv
+ stis2aread		   = stis2aread_nld65b_sphv_10hv
+ stiraread		  = stiraread_nld65b_sphv_10hv
+ n1aread     = n1aread_nld65b_sphv_10hv
+ n2aread     = n2aread_nld65b_sphv_10hv
+ nraread     = nraread_nld65b_sphv_10hv
+ is1lstid		 = 0
+ ttlstid     = ttlstid_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lstid		 = 0
+ irlstid     = 0
+ stis1stid		  = stis1stid_nld65b_sphv_10hv
+ stis2stid		  = stis2stid_nld65b_sphv_10hv
+ stirstid		 = stirstid_nld65b_sphv_10hv
+ n1stid     = n1stid_nld65b_sphv_10hv
+ n2stid     = n2stid_nld65b_sphv_10hv
+ nrstid     = nrstid_nld65b_sphv_10hv
+ is1lgatd		 = is1aread_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlgatd     = ttlgatd_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lgatd		 = is2aread_nld65b_sphv_10hv*djunc*delr_is2_nld65b_sphv_10hv
+ irlgatd     = iraread_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1gatd		  = stis1gatd_nld65b_sphv_10hv
+ stis2gatd		  = stis2gatd_nld65b_sphv_10hv
+ stirgatd		 = stirgatd_nld65b_sphv_10hv
+ n1gatd     = n1gatd_nld65b_sphv_10hv
+ n2gatd     = n2gatd_nld65b_sphv_10hv
+ nrgatd     = nrgatd_nld65b_sphv_10hv
+ cjaread2		 = cjaread_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlstid2		 = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiaread2		  = vbiaread2_nld65b_sphv_10hv
+ vbistid2		 = vbistid2_nld65b_sphv_10hv
+ paread2     = paread2_nld65b_sphv_10hv
+ pstid2     = pstid2_nld65b_sphv_10hv
+ is1aread2		  = is1aread_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttaread2		 = ttaread2_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2aread2		  = is2aread_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ iraread2		 = iraread_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1aread2		    = stis1aread2_nld65b_sphv_10hv
+ stis2aread2		    = stis2aread2_nld65b_sphv_10hv
+ stiraread2		   = stiraread2_nld65b_sphv_10hv
+ n1aread2		 = n1aread2_nld65b_sphv_10hv
+ n2aread2		 = n2aread2_nld65b_sphv_10hv
+ nraread2		 = nraread2_nld65b_sphv_10hv
+ is1lstid2		  = 0
+ ttlstid2		 = ttlstid2_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lstid2		  = 0
+ irlstid2		 = 0
+ stis1stid2		   = stis1stid2_nld65b_sphv_10hv
+ stis2stid2		   = stis2stid2_nld65b_sphv_10hv
+ stirstid2		  = stirstid2_nld65b_sphv_10hv
+ n1stid2     = n1stid2_nld65b_sphv_10hv
+ n2stid2     = n2stid2_nld65b_sphv_10hv
+ nrstid2     = nrstid2_nld65b_sphv_10hv
+ eais1area		= eais1area_nld65b_sphv_10hv
+ eais2area		= eais2area_nld65b_sphv_10hv
+ eairarea		= eairarea_nld65b_sphv_10hv
+ eais1sti		= eais1sti_nld65b_sphv_10hv
+ eais2sti		= eais2sti_nld65b_sphv_10hv
+ eairsti	  = eairsti_nld65b_sphv_10hv
+ eais1gat		= eais1gat_nld65b_sphv_10hv
+ eais2gat		= eais2gat_nld65b_sphv_10hv
+ eairgat	  = eairgat_nld65b_sphv_10hv
+ eais1aread		= eais1aread_nld65b_sphv_10hv
+ eais2aread		= eais2aread_nld65b_sphv_10hv
+ eairaread		= eairaread_nld65b_sphv_10hv
+ eais1stid		= eais1stid_nld65b_sphv_10hv
+ eais2stid		= eais2stid_nld65b_sphv_10hv
+ eairstid		= eairstid_nld65b_sphv_10hv
+ eais1gatd		= eais1gatd_nld65b_sphv_10hv
+ eais2gatd		= eais2gatd_nld65b_sphv_10hv
+ eairgatd		= eairgatd_nld65b_sphv_10hv
+ eais1aread2		= eais1aread2_nld65b_sphv_10hv
+ eais2aread2		= eais2aread2_nld65b_sphv_10hv
+ eairaread2		= eairaread2_nld65b_sphv_10hv
+ eais1stid2		= eais1stid2_nld65b_sphv_10hv
+ eais2stid2		= eais2stid2_nld65b_sphv_10hv
+ eairstid2		= eairstid2_nld65b_sphv_10hv
+ ikfarea               = ikfarea_nld65b_sphv_10hv
+ ikflsti               = ikfarea_nld65b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld65b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld65b_sphv_10hv
+ stikfsti              = stikfarea_nld65b_sphv_10hv
+ stikfgat              = stikfarea_nld65b_sphv_10hv
+ ikfaread              = ikfaread_nld65b_sphv_10hv*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflstid              = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflgatd              = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikfaread2             = ikfaread_nld65b_sphv_10hv*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflstid2             = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ stikfaread             = stikfaread_nld65b_sphv_10hv
+ stikfstid             = stikfaread_nld65b_sphv_10hv
+ stikfgatd             = stikfaread_nld65b_sphv_10hv
+ stikfaread2            = stikfaread_nld65b_sphv_10hv
+ stikfstid2            = stikfaread_nld65b_sphv_10hv

// ****** ckt elements:
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
dbdbv	  (s d) dbodydrainbv area=(ad_xdr) m=(ng)
rgate     (g intg) resistor r=rgatetot m=ng
xdsub	  (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
//cgd_m1_d (intg d) capacitor c=(cpp_m1_sd*aplyfld_d)
//cgd_act_d (intg d) capacitor c=(cpp_ply_sdt*aplyact_d)

include "./smos10hv_ade_dfrt.scs" section=nld65b_10hv_dfrt
ends

subckt pld45b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    l                              = 0.05
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    selfheat                       = 1
+    mode_rthcth                    = 1

+    nsmm_delr_gox_pld45b_sphv_10hv  = tmp_nsmm_delr_gox_pld45b_sphv_10hv
+    nsmm_dela_dw_pld45b_sphv_10hv   = tmp_nsmm_dela_dw_pld45b_sphv_10hv
+    nsmm_dela_vfb_pld45b_sphv_10hv  = tmp_nsmm_dela_vfb_pld45b_sphv_10hv
+    nsmm_delr_uch_pld45b_sphv_10hv  = tmp_nsmm_delr_uch_pld45b_sphv_10hv
+    nsmm_delr_rshl_pld45b_sphv_10hv = tmp_nsmm_delr_rshl_pld45b_sphv_10hv
+    nsmm_delr_nsub_pld45b_sphv_10hv = tmp_nsmm_delr_nsub_pld45b_sphv_10hv

parameters
+ nde=(0)
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+    ng_dmy         = 2*sti_dummy
+    ngeff          = ng+ng_dmy
+    ndi_eff        = (ngeff/2)
+    nsi_eff        = ((ngeff-2)/2)

// check these values against layout
+    leff                           = (0.432)   // effective channel length from TCAD
+    rnhv_pld45b_10hv               = (1.360*(1-fem))   // radius of the inner nhv corner
+    w2nhv_pld45b_10hv              = (3.100*(1-fem))   // top edge of the active to the top edge of the inner nhv
+    lg2aa_s_pld45b_10hv            = (0.550)   // lateral dimension from the center of the LHS of the source/drain contact to the LHS of the POLY
+    lg2aa_d_pld45b_10hv            = (0.000)
+    lg2g_s_pld45b_10hv             = (1.100)   // use ng=4 on pcell to measure this variable
+    lg2g_d_pld45b_10hv             = (5.490)   // dimension from the inner LHS NHV to the inner RHS NHV
+    wg2aa_se_pld45b_10hv           = (0.000)
+    wg2aa_si_pld45b_10hv           = (0.000)
+    wg2aa_di_pld45b_10hv           = (6.200*(1-fem))   // 2 times of the dimension from the top edge of the active to the inner edge of the NHV
+    wg2trench_pld45b_10hv          = (8.200*(1-fem))   // 2 times of the dimension from the top edge of the active to the inner edge fo the DTI
+    wg2m1_pld45b_10hv              = (1.110*(1-fem))   // 2 times of the dimension from the top edge of the active to the edge fo the M1
+    trench2se_body_pld45b_10hv     = (0.000)
+    trench2se_nobody_pld45b_10hv   = (1.110)   // for devices w/o body, the dimension from external source to DTI
+    trench2de_pld45b_10hv          = (0.000)
+    s2s_inside_pld45b_10hv         = (0.000)   // shared active for sources
+    djunc                          = (2e-6)    // scale does not impact vertically, unit should be in meter
+    lactd                          = (0.690)   // lateral dimension of the drain active region
+    lpoly                          = (0.650)   // drawn poly dimension
+    ldr1                           = (lpoly-leff)   // first drift region or the RHS edge of the NHV to the RHS of the poly edge (i.e., the first part of the split gate)
+    ldr1drawn                      = (lpoly-l)   // drawn first drift region or the rhs edge of the NHV to the RHS of the poly edge (i.e., the first part of the split gate)
+    ldrift                         = (1.500)   // dirft region or the width of the STI or the RHS of the first active to the LHS of the second active
+    lgply2sti                      = (0.300)   // lateral dimension from RHS poly edge to the RHS of the active edge
+    wg2plye_pld45b_10hv            = (6.400*(1-fem))   // 2 times distance of channel top edge to poly top edge
+    lsebc                          = (0.2075)  // length of source edge to body center
+    lsti_g_pld45b_10hv             = (0.650)   // lateral dimension of the side hole in the split gate structure
+    lsti_d_pld45b_10hv             = (2.390)   // lateral dimension of the middle hole in the split gate structure
+    wae2plye_isti_g_pld45b_10hv    = (2.550*(1-fem))   // vertical dimension of the LHS hole in POLY subtract the width of the channcel or w
+    wae2plye_isti_d_pld45b_10hv    = (2.550*(1-fem))   // vertical dimension of the middle hole in POLY subtract the width of the channcel or w
+    lcc2aa_pld45b_10hv             = (0.165)   // lateral dimension from the center of the cont to the source/drain active edge
+    lpoly2m1_pld45b_10hv           = (1.025)   // lateral dimension from the edge of the poly to the edge of the m1 for parasitic cgs due to frindge cap between m1 and m2


//**** calculation for d/b junction:JD and JD2 ********
+    as                             = ((lg2aa_s_pld45b_10hv*(wg2aa_se_pld45b_10hv+w)*nse+lg2g_s_pld45b_10hv*(wg2aa_si_pld45b_10hv+w)*nsi)/ng)
+    ps                             = ((2*((lg2aa_s_pld45b_10hv+wg2aa_se_pld45b_10hv+w)*nse+(lg2g_s_pld45b_10hv+wg2aa_si_pld45b_10hv+w)*nsi))/ng)
+    ad2                            = (w+wg2aa_di_pld45b_10hv)*(ldrift/2+lactd/2)
+    pd2                            = (lactd+ldrift)
+    ad                             = (w+wg2aa_di_pld45b_10hv)*(ldr1+lgply2sti+ldrift/2)
+    pd                             = (2*(ldr1+lgply2sti+ldrift/2)+w+wg2aa_di_pld45b_10hv)
// L and W for trench box calculation wg2trench_pld45b_10hv should be 2*each side; length2 is the LHS edge of the active to the edge of active on the RHS
+    length1                        = (trench2se_nobody_pld45b_10hv*nse+trench2de_pld45b_10hv*nde)
+    length2                        = (l*ngeff+lcc2aa_pld45b_10hv*2+lg2aa_s_pld45b_10hv*nse+lg2g_s_pld45b_10hv*nsi_eff+lg2aa_d_pld45b_10hv*nde+lg2g_d_pld45b_10hv*ndi_eff)
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_pld45b_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
+    fac_c_lstid                    = (0.4)
+    fac_i_lstid                    = (0.0)
+    fac_tt                         = ((w+3.0*(1-fem))/w)

//**** parameters for bv diode  ********
+    dcbv_pld45b_10hv               = (59)

//**** parameters for rgate copied from pld45  ********
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.05)
+    laccdrawn                      = (1.0)
+    lflap                          = (0.85)

//**** multi-ng scaling ****
+    dela_vth_ng		    = (ngeff/(ngeff+0.05)-2/(2+0.05))*1.78*(1-fem)
+    delr_thesato_ng		    = (1+(ngeff/(ngeff+0.05)-2/(2+0.05))*2.0*(1-fem))
+    delr_rshldd_ng		    = (1+(ngeff/(ngeff+0.1)-2/(2+0.1))*0.10*(1-fem))
+    delr_u0_ng 		    = (1+(ngeff/(ngeff+0.1)-2/(2+0.1))*(-0.50)*(1-fem))

//**** geometry input for vfunctions: rthch_think_wafer()********
//**** vfunction:   (rth, cth)=rthcth_thin_wafer(weff, leff, rtc1, rtc2, ctc1, ctc2)
//**** description: calculate thermal resistance rth. inputs in micrometer. outputs in K/W.
//**** weff: effective width in micrometer for thermal injection.
//**** leff: effective length in micrometer for thermal injection.
+ w_heat_um	 =	w				// in unit of micrometer
+ l_heat_um	 =	(l*ng+lcc2aa_pld45b_10hv*2+lg2aa_s_pld45b_10hv*nse+lg2g_s_pld45b_10hv*nsi+lg2aa_d_pld45b_10hv*nde+lg2g_d_pld45b_10hv*ndi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat_um)*(l_heat_um)
+ aspr__1__=max((w_heat_um),(l_heat_um))/min((w_heat_um),(l_heat_um))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f          =      ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld45b_sphv_10hv)*ngeff
+ cth_f          =      ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

+ swshe = selfheat*enable_selfheat
+ rth_f_sw = (swshe>0)*rth_f
+ swdrlin  = (2)  
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8)
+ dw_ecrit = 0.250*(1-fem)

+ tfact_ecrit	=	1+(tc1_ecrit_pld45b_sphv_10hv+tc2_ecrit_pld45b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ tfact_rth_power = 0.0
+ tfact_rth=pow((temp+273.15)/(27+273.15),tfact_rth_power)

//**** calculation for poly over field parasitic cap: cgd_ply_fld ********

+ aply_fld_cgd=(0.5* lg2g_d_pld45b_10hv *(wg2aa_di_pld45b_10hv+w)-(wae2plye_isti_g_pld45b_10hv+w)*lsti_g_pld45b_10hv-0.5*(wae2plye_isti_d_pld45b_10hv+w )*lsti_d_pld45b_10hv-w*ldr1drawn-(2-0.5*pi4models)*rnhv_pld45b_10hv*rnhv_pld45b_10hv)*ng
+ pply_fld_cgd= 0
+ cgd_ply_fld=aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld

+ aply_fld_cgd_dmy=(0.5* lg2g_d_pld45b_10hv *(wg2aa_di_pld45b_10hv+w)-(wae2plye_isti_g_pld45b_10hv+w)*lsti_g_pld45b_10hv-0.5*(wae2plye_isti_d_pld45b_10hv+w )*lsti_d_pld45b_10hv-w*ldr1drawn-(2-0.5*pi4models)*rnhv_pld45b_10hv*rnhv_pld45b_10hv)*ng_dmy
+ pply_fld_cgd_dmy= 0
+ cgd_ply_fld_dmy=aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld


//**** calculation for poly over field parasitic cap: cgs_ply_fld ********
+ aply_fld_cgs=((wg2plye_pld45b_10hv*l)+(0.5*wg2plye_pld45b_10hv-0.5*wg2aa_di_pld45b_10hv)* lg2g_d_pld45b_10hv+2*(rnhv_pld45b_10hv*rnhv_pld45b_10hv*(1.0-0.25*pi4models)))*ng
+ pply_fld_cgs= (wg2plye_pld45b_10hv+lg2g_d_pld45b_10hv)*ng
+ cgs_ply_fld=aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld

//**** calculation for m1 to poly gate capacitance, unit is micron ********
+ cfr_ply_m1_s         = (w+wg2m1_pld45b_10hv)*nom_cfr_m1_ply*ng*(1-lpe)+lpe*1e-19

// metal par cap
+    cgs_pld45b_10hv_m2m1_par      = ((1-lpe)*((l+0.5*lg2g_d_pld45b_10hv-lpoly2m1_pld45b_10hv*2)*ng*cfr_m2_m1)+lpe*1e-20)

// mismatch
//*******************************************************************************************************

//*******************************************************************************************************
// casing
//*******************************************************************************************************
+    delr_tox_pld45b_sphv_10hv      = (nom_delr_tox_pld45b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld45b_sphv_10hv+nsmm_delr_gox_pld45b_sphv_10hv*smm_delr_gox_pld45b_sphv_10hv(leff,w,ng)))
+    dela_dw_pld45b_sphv_10hv       = (nom_dela_dw_pld45b_sphv_10hv+nsig_dela_dw_pld45b_sphv_10hv*sig_dela_dw_pld45b_sphv_10hv+nsmm_dela_dw_pld45b_sphv_10hv*smm_dela_dw_pld45b_sphv_10hv(leff,w,ng))
+    dela_vfb_pld45b_sphv_10hv      = (nom_dela_vfb_pld45b_sphv_10hv+nsig_dela_vfb_pld45b_sphv_10hv*sig_dela_vfb_pld45b_sphv_10hv+nsmm_dela_vfb_pld45b_sphv_10hv*smm_dela_vfb_pld45b_sphv_10hv(leff,w,ng))
+    dela_vtwl_pld45b_sphv_10hv     = (nom_dela_vtwl_pld45b_sphv_10hv+nsig_dela_vtwl_pld45b_sphv_10hv*sig_dela_vtwl_pld45b_sphv_10hv)
+    delr_uch_pld45b_sphv_10hv      = (nom_delr_uch_pld45b_sphv_10hv*(1.0+nsig_delr_uch_pld45b_sphv_10hv*sig_delr_uch_pld45b_sphv_10hv+nsmm_delr_uch_pld45b_sphv_10hv*smm_delr_uch_pld45b_sphv_10hv(leff,w,ng)))
+    delr_rshl_pld45b_sphv_10hv     = (nom_delr_rshl_pld45b_sphv_10hv*(1.0+nsig_delr_rshl_pld45b_sphv_10hv*sig_delr_rshl_pld45b_sphv_10hv)+nsmm_delr_rshl_pld45b_sphv_10hv*smm_delr_rshl_pld45b_sphv_10hv(leff,w,ng))
+    delr_nsub_pld45b_sphv_10hv     = (1+nsmm_delr_nsub_pld45b_sphv_10hv*smm_delr_nsub_pld45b_sphv_10hv(leff,w,ng))
+    delr_cj_pld45b_sphv_10hv       = (nom_delr_cj_pld45b_sphv_10hv*(1.0+nsig_delr_cj_pld45b_sphv_10hv*sig_delr_cj_pld45b_sphv_10hv))
+    delr_is_pld45b_sphv_10hv       = (nom_delr_is_pld45b_sphv_10hv*(1.0+nsig_delr_is_pld45b_sphv_10hv*sig_delr_is_pld45b_sphv_10hv))
+    delr_is2_pld45b_sphv_10hv      = (nom_delr_is2_pld45b_sphv_10hv*(1.0+nsig_delr_is2_pld45b_sphv_10hv*sig_delr_is2_pld45b_sphv_10hv))
+    delr_ir_pld45b_sphv_10hv 	    = (nom_delr_ir_pld45b_sphv_10hv*exp(nsig_delr_ir_pld45b_sphv_10hv*sig_delr_ir_pld45b_sphv_10hv))
+    dela_nwxw_pld45b_sphv_10hv     = (nom_dela_nwxw_pld45b_sphv_10hv+nsig_dela_nwxw_pld45b_sphv_10hv*sig_dela_nwxw_pld45b_sphv_10hv)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld45b_vthratio     = 1.0
+    presto_pld45b_ronratio     = 0.01

//*******************************************************************************************************
// to add one more parasitic poly to m2 Cgs cap (scale with ng)

+ fac_cgd_ply_fld = 0.9
+ delta_cgd_ply_fld = 1e-16
+ delta_cfr_ply_m1_s = 1e-16

cgs_fld (intg s) capacitor c=(cgs_ply_fld)
cgd_fld (intg d) capacitor c=(cgd_ply_fld*fac_cgd_ply_fld+delta_cgd_ply_fld*ng*w)

cgs_ply_m1_s (intg s) capacitor c=(cfr_ply_m1_s+delta_cfr_ply_m1_s*ng)

ccgs_pld45b_10hv_m2m1_par (intg s) capacitor c=cgs_pld45b_10hv_m2m1_par

xdsub (s sub) cdgoptub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=1

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swtcec   = (1)
+ swgedi   = (1)
+ qmc      = (qmc_pld45b_sphv_10hv)
+ lvaro    = (lvaro_pld45b_sphv_10hv)
+ lvarl    = (lvarl_pld45b_sphv_10hv)
+ lvarw    = (lvarw_pld45b_sphv_10hv*(1-fem))
+ lap      = (lap_pld45b_sphv_10hv)
+ wvaro    = (wvaro_pld45b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld45b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld45b_sphv_10hv*(1-fem))
+ wot      = ((wot_pld45b_sphv_10hv+0.5e-6*dela_dw_pld45b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_pld45b_sphv_10hv)
+ dwq      = (dwq_pld45b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld45b_sphv_10hv+dela_vfb_pld45b_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld45b_vthratio+dela_vth_ng)
+ vfbl     = (vfbl_pld45b_sphv_10hv)
+ vfbw     = (vfbw_pld45b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_pld45b_sphv_10hv+dela_vtwl_pld45b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_pld45b_sphv_10hv)
+ stvfbl   = (stvfbl_pld45b_sphv_10hv)
+ stvfbw   = (stvfbw_pld45b_sphv_10hv*(1-fem))
+ stvfblw  = (stvfblw_pld45b_sphv_10hv*(1-fem))
+ toxo     = (toxo_pld45b_sphv_10hv*delr_tox_pld45b_sphv_10hv)
+ epsroxo  = (epsroxo_pld45b_sphv_10hv)
+ nsubo    = (nsubo_pld45b_sphv_10hv*delr_nsub_pld45b_sphv_10hv)
+ nsubw    = (nsubw_pld45b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld45b_sphv_10hv)
+ npck     = (npck_pld45b_sphv_10hv)
+ npckw    = (npckw_pld45b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld45b_sphv_10hv)
+ lpck     = (lpck_pld45b_sphv_10hv)
+ lpckw    = (lpckw_pld45b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld45b_sphv_10hv)
+ fol2     = (fol2_pld45b_sphv_10hv)
+ facneffaco = (facneffaco_pld45b_sphv_10hv)
+ facneffacl = (facneffacl_pld45b_sphv_10hv)
+ facneffacw = (facneffacw_pld45b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld45b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld45b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld45b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld45b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld45b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld45b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld45b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld45b_sphv_10hv)
+ vnsubo   = (vnsubo_pld45b_sphv_10hv)
+ nslpo    = (nslpo_pld45b_sphv_10hv)
+ dnsubo   = (dnsubo_pld45b_sphv_10hv)
+ dphibo   = (dphibo_pld45b_sphv_10hv)
+ dphibl   = (dphibl_pld45b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld45b_sphv_10hv)
+ dphibw   = (dphibw_pld45b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld45b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld45b_sphv_10hv)
+ delvtacl = (delvtacl_pld45b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld45b_sphv_10hv)
+ delvtacw = (delvtacw_pld45b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_pld45b_sphv_10hv*(1-fem))
+ npo      = (npo_pld45b_sphv_10hv)
+ npl      = (npl_pld45b_sphv_10hv)
+ cto      = (cto_pld45b_sphv_10hv)
+ ctl      = (ctl_pld45b_sphv_10hv)
+ ctlexp   = (ctlexp_pld45b_sphv_10hv)
+ ctw      = (ctw_pld45b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld45b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld45b_sphv_10hv)
+ toxovdo  = (toxovdo_pld45b_sphv_10hv)
+ lov      = (lov_pld45b_sphv_10hv)
+ dlovd    = (dlovd_pld45b_sphv_10hv)
+ novo     = (novo_pld45b_sphv_10hv)
+ novdo    = (novdo_pld45b_sphv_10hv)
+ cfl      = (cfl_pld45b_sphv_10hv)
+ cflexp   = (cflexp_pld45b_sphv_10hv)
+ cfw      = (cfw_pld45b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld45b_sphv_10hv)
+ uo       = (uo_pld45b_sphv_10hv*delr_uch_pld45b_sphv_10hv*delr_u0_relimo*delr_u0_ng)
+ fbet1    = (fbet1_pld45b_sphv_10hv)
+ fbet1w   = (fbet1w_pld45b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld45b_sphv_10hv)
+ lp1w     = (lp1w_pld45b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld45b_sphv_10hv)
+ lp2      = (lp2_pld45b_sphv_10hv)
+ betw1    = (betw1_pld45b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld45b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld45b_sphv_10hv)
+ stbeto   = (stbeto_pld45b_sphv_10hv)
+ stbetl   = (stbetl_pld45b_sphv_10hv)
+ stbetw   = (stbetw_pld45b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_pld45b_sphv_10hv*(1-fem))
+ mueo     = (mueo_pld45b_sphv_10hv)
+ muew     = (muew_pld45b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld45b_sphv_10hv)
+ themuo   = (themuo_pld45b_sphv_10hv)
+ stthemuo = (stthemuo_pld45b_sphv_10hv)
+ cso      = (cso_pld45b_sphv_10hv)
+ csl      = (csl_pld45b_sphv_10hv)
+ cslexp   = (cslexp_pld45b_sphv_10hv)
+ csw      = (csw_pld45b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld45b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld45b_sphv_10hv)
+ xcoro    = (xcoro_pld45b_sphv_10hv)
+ xcorl    = (xcorl_pld45b_sphv_10hv)
+ xcorw    = (xcorw_pld45b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_pld45b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_pld45b_sphv_10hv)
+ fetao    = (fetao_pld45b_sphv_10hv)
+ rsw1     = (rsw1_pld45b_sphv_10hv)
+ rsw2     = (rsw2_pld45b_sphv_10hv*(1-fem))
+ strso    = (strso_pld45b_sphv_10hv)
+ rsbo     = (rsbo_pld45b_sphv_10hv)
+ rsgo     = (rsgo_pld45b_sphv_10hv)
+ thesato  = (thesato_pld45b_sphv_10hv*delr_thesato_ng)
+ thesatl  = (thesatl_pld45b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld45b_sphv_10hv)
+ thesatw  = (thesatw_pld45b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_pld45b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld45b_sphv_10hv)
+ stthesatl = (stthesatl_pld45b_sphv_10hv)
+ stthesatw = (stthesatw_pld45b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_pld45b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_pld45b_sphv_10hv)
+ thesatgo = (thesatgo_pld45b_sphv_10hv)
+ thesatgl = (thesatgl_pld45b_sphv_10hv)
+ thesatgw = (thesatgw_pld45b_sphv_10hv*(1-fem))
+ vdscale  = (vdscale_pld45b_sphv_10hv)
+ vdscaleb = (vdscaleb_pld45b_sphv_10hv)
+ stvdscale = (stvdscale_pld45b_sphv_10hv)
+ axo      = (axo_pld45b_sphv_10hv)
+ axl      = (axl_pld45b_sphv_10hv)
+ alpl     = (alpl_pld45b_sphv_10hv)
+ alplexp  = (alplexp_pld45b_sphv_10hv)
+ alpw     = (alpw_pld45b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld45b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld45b_sphv_10hv)
+ alp1l2   = (alp1l2_pld45b_sphv_10hv)
+ alp1w    = (alp1w_pld45b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld45b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld45b_sphv_10hv)
+ alp2l2   = (alp2l2_pld45b_sphv_10hv)
+ alp2w    = (alp2w_pld45b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld45b_sphv_10hv)
+ a1o      = (a1o_pld45b_sphv_10hv)
+ a1l      = (a1l_pld45b_sphv_10hv)
+ a1w      = (a1w_pld45b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld45b_sphv_10hv)
+ sta2o    = (sta2o_pld45b_sphv_10hv)
+ a3o      = (a3o_pld45b_sphv_10hv)
+ a3l      = (a3l_pld45b_sphv_10hv)
+ a3w      = (a3w_pld45b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld45b_sphv_10hv)
+ a4l      = (a4l_pld45b_sphv_10hv)
+ a4w      = (a4w_pld45b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld45b_sphv_10hv)
+ iginvlw  = (iginvlw_pld45b_sphv_10hv)
+ igovw    = (igovw_pld45b_sphv_10hv)
+ igovdw   = (igovdw_pld45b_sphv_10hv)
+ stigo    = (stigo_pld45b_sphv_10hv)
+ gc2o     = (gc2o_pld45b_sphv_10hv)
+ gc3o     = (gc3o_pld45b_sphv_10hv)
+ chibo    = (chibo_pld45b_sphv_10hv)
+ agidlw   = (agidlw_pld45b_sphv_10hv)
+ agidldw  = (agidldw_pld45b_sphv_10hv)
+ bgidlo   = (bgidlo_pld45b_sphv_10hv)
+ bgidldo  = (bgidldo_pld45b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld45b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld45b_sphv_10hv)
+ cgidlo   = (cgidlo_pld45b_sphv_10hv)
+ cgidldo  = (cgidldo_pld45b_sphv_10hv)
+ cgbovl   = (cgbovl_pld45b_sphv_10hv)
+ cfrw     = (cfrw_pld45b_sphv_10hv)
+ cfrdw    = (cfrdw_pld45b_sphv_10hv)
+ fnto     = (fnto_pld45b_sphv_10hv)
+ nfalw    = (nfalw_pld45b_sphv_10hv)
+ nfblw    = (nfblw_pld45b_sphv_10hv)
+ nfclw    = (nfclw_pld45b_sphv_10hv)
+ efo      = (efo_pld45b_sphv_10hv)
+ lintnoi  = (lintnoi_pld45b_sphv_10hv)
+ alpnoi   = (alpnoi_pld45b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld45b_sphv_10hv)
+ kvthowel = (kvthowel_pld45b_sphv_10hv)
+ kvthowew = (kvthowew_pld45b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_pld45b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_pld45b_sphv_10hv)
+ kuowel   = (kuowel_pld45b_sphv_10hv)
+ kuowew   = (kuowew_pld45b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_pld45b_sphv_10hv*(1-fem))
+ rgo      = (rgo_pld45b_sphv_10hv)
+ rsh      = (rsh_pld45b_sphv_10hv)
+ rbulko   = (rbulko_pld45b_sphv_10hv)
+ rwello   = (rwello_pld45b_sphv_10hv)
+ rjunso   = (rjunso_pld45b_sphv_10hv/(w+dwrjunso_pld45b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_pld45b_sphv_10hv/(w+dwrjundo_pld45b_sphv_10hv*(1-fem)))
+ rint     = (rint_pld45b_sphv_10hv)
+ rvpoly   = (rvpoly_pld45b_sphv_10hv)
+ rshg     = (rshg_pld45b_sphv_10hv)
+ dlsil    = (dlsil_pld45b_sphv_10hv)
+ saref    = (saref_pld45b_sphv_10hv)
+ sbref    = (sbref_pld45b_sphv_10hv)
+ wlod     = (wlod_pld45b_sphv_10hv*(1-fem))
+ kuo      = (kuo_pld45b_sphv_10hv)
+ kvsat    = (kvsat_pld45b_sphv_10hv)
+ tkuo     = (tkuo_pld45b_sphv_10hv)
+ lkuo     = (lkuo_pld45b_sphv_10hv)
+ wkuo     = (wkuo_pld45b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_pld45b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_pld45b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld45b_sphv_10hv)
+ kvtho    = (kvtho_pld45b_sphv_10hv)
+ lkvtho   = (lkvtho_pld45b_sphv_10hv)
+ wkvtho   = (wkvtho_pld45b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_pld45b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_pld45b_sphv_10hv)
+ wlodvth  = (wlodvth_pld45b_sphv_10hv)
+ stetao   = (stetao_pld45b_sphv_10hv)
+ lodetao  = (lodetao_pld45b_sphv_10hv)
+ scref    = (scref_pld45b_sphv_10hv)
+ web      = (web_pld45b_sphv_10hv)
+ wec      = (wec_pld45b_sphv_10hv)
+ adr1o    = (adr1o_pld45b_sphv_10hv)
+ adr1l    = (adr1l_pld45b_sphv_10hv)
+ adr1w    = (adr1w_pld45b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_pld45b_sphv_10hv)
+ stadr2o  = (stadr2o_pld45b_sphv_10hv)
+ adr3o    = (adr3o_pld45b_sphv_10hv)
+ adr3l    = (adr3l_pld45b_sphv_10hv)
+ adr3w    = (adr3w_pld45b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_pld45b_sphv_10hv)
+ adr4l    = (adr4l_pld45b_sphv_10hv)
+ adr4w    = (adr4w_pld45b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_pld45b_sphv_10hv)
+ adr5l    = (adr5l_pld45b_sphv_10hv)
+ adr5w    = (adr5w_pld45b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_pld45b_sphv_10hv)
+ bidr1l   = (bidr1l_pld45b_sphv_10hv)
+ bidr1w   = (bidr1w_pld45b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_pld45b_sphv_10hv)
+ bidr2w   = (bidr2w_pld45b_sphv_10hv*(1-fem))
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_pld45b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_pld45b_sphv_10hv*delr_rshldd_ng*delr_rshl_pld45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld45b_ronratio))*fac_rshldd)
+ xw       = (xw_pld45b_sphv_10hv*(1-fem))
+ nwxw     = ((nwxw_pld45b_sphv_10hv+1e-12*dela_nwxw_pld45b_sphv_10hv)*(1-fem))
+ xl       = (xl_pld45b_sphv_10hv)
+ xlw      = (xlw_pld45b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld45b_sphv_10hv)
+ nst      = (nst_pld45b_sphv_10hv)
+ ats      = (ats_pld45b_sphv_10hv)
+ dfinf    = (dfinf_pld45b_sphv_10hv)
+ dfw      = (dfw_pld45b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld45b_sphv_10hv)
+ dflw     = (dflw_pld45b_sphv_10hv*(1-fem))
+ dp       = (dp_pld45b_sphv_10hv)
+ ecrit    = (ecrit_pld45b_sphv_10hv*tfact_ecrit)*(w+dw_ecrit)/w
+ ecorn    = (ecorn_pld45b_sphv_10hv*tfact_ecrit)*(w+dw_ecrit)/w
+ du       = (du_pld45b_sphv_10hv)
+ tc1      = (tc1_pld45b_sphv_10hv)
+ tc2      = (tc2_pld45b_sphv_10hv)
+ tc1l     = (tc1l_pld45b_sphv_10hv)
+ tc2l     = (tc2l_pld45b_sphv_10hv)
+ tc1w     = (tc1w_pld45b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_pld45b_sphv_10hv*(1-fem))
+ theacc   = (theacc_pld45b_sphv_10hv)
+ theacc2  = (theacc2_pld45b_sphv_10hv)
+ aacc     = (aacc_pld45b_sphv_10hv)
+ rva      = (rva_pld45b_sphv_10hv)
+ dta      = (dta_pld45b_sphv_10hv)
+ trj      = (trj_pld45b_sphv_10hv)
+ cjarea   = (cjarea_pld45b_sphv_10hv)
+ cjlsti   = (cjlsti_pld45b_sphv_10hv)
+ cjlgat   = (cjlgat_pld45b_sphv_10hv)
+ vbiarea  = (vbiarea_pld45b_sphv_10hv)
+ vbisti   = (vbisti_pld45b_sphv_10hv)
+ vbigat   = (vbigat_pld45b_sphv_10hv)
+ parea    = (parea_pld45b_sphv_10hv)
+ psti     = (psti_pld45b_sphv_10hv)
+ pgat     = (pgat_pld45b_sphv_10hv)
+ is1area  = (is1area_pld45b_sphv_10hv)
+ ttarea   = (ttarea_pld45b_sphv_10hv)
+ is2area  = (is2area_pld45b_sphv_10hv)
+ irarea   = (irarea_pld45b_sphv_10hv)
+ stis1area = (stis1area_pld45b_sphv_10hv)
+ stis2area = (stis2area_pld45b_sphv_10hv)
+ stirarea = (stirarea_pld45b_sphv_10hv)
+ n1area   = (n1area_pld45b_sphv_10hv)
+ n2area   = (n2area_pld45b_sphv_10hv)
+ nrarea   = (nrarea_pld45b_sphv_10hv)
+ is1lsti  = (is1lsti_pld45b_sphv_10hv)
+ ttlsti   = (ttlsti_pld45b_sphv_10hv)
+ is2lsti  = (is2lsti_pld45b_sphv_10hv)
+ irlsti   = (irlsti_pld45b_sphv_10hv)
+ stis1sti = (stis1sti_pld45b_sphv_10hv)
+ stis2sti = (stis2sti_pld45b_sphv_10hv)
+ stirsti  = (stirsti_pld45b_sphv_10hv)
+ n1sti    = (n1sti_pld45b_sphv_10hv)
+ n2sti    = (n2sti_pld45b_sphv_10hv)
+ nrsti    = (nrsti_pld45b_sphv_10hv)
+ is1lgat  = (is1lgat_pld45b_sphv_10hv)
+ ttlgat   = (ttlgat_pld45b_sphv_10hv)
+ is2lgat  = (is2lgat_pld45b_sphv_10hv)
+ irlgat   = (irlgat_pld45b_sphv_10hv)
+ stis1gat = (stis1gat_pld45b_sphv_10hv)
+ stis2gat = (stis2gat_pld45b_sphv_10hv)
+ stirgat  = (stirgat_pld45b_sphv_10hv)
+ n1gat    = (n1gat_pld45b_sphv_10hv)
+ n2gat    = (n2gat_pld45b_sphv_10hv)
+ nrgat    = (nrgat_pld45b_sphv_10hv)
+ cjaread  = (cjaread_pld45b_sphv_10hv*delr_cj_pld45b_sphv_10hv)
+ cjlstid  = (cjaread_pld45b_sphv_10hv*djunc*delr_cj_pld45b_sphv_10hv*fac_c_lstid)
+ cjlgatd  = (cjaread_pld45b_sphv_10hv*djunc*delr_cj_pld45b_sphv_10hv)
+ vbiaread = (vbiaread_pld45b_sphv_10hv)
+ vbistid  = (vbistid_pld45b_sphv_10hv)
+ vbigatd  = (vbigatd_pld45b_sphv_10hv)
+ paread   = (paread_pld45b_sphv_10hv)
+ pstid    = (pstid_pld45b_sphv_10hv)
+ pgatd    = (pgatd_pld45b_sphv_10hv)
+ is1aread = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttaread  = (ttaread_pld45b_sphv_10hv*fac_tt)
+ is2aread = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ iraread  = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1aread = (stis1aread_pld45b_sphv_10hv)
+ stis2aread = (stis2aread_pld45b_sphv_10hv)
+ stiraread = (stiraread_pld45b_sphv_10hv)
+ n1aread  = (n1aread_pld45b_sphv_10hv)
+ n2aread  = (n2aread_pld45b_sphv_10hv)
+ nraread  = (nraread_pld45b_sphv_10hv)
+ is1lstid = (is1aread_pld45b_sphv_10hv*djunc*delr_is_pld45b_sphv_10hv*fac_i_lstid)
+ ttlstid  = (ttlstid_pld45b_sphv_10hv*fac_tt)
+ is2lstid = (is2aread_pld45b_sphv_10hv*djunc*delr_is2_pld45b_sphv_10hv*fac_i_lstid)
+ irlstid  = (iraread_pld45b_sphv_10hv*djunc*delr_ir_pld45b_sphv_10hv*fac_i_lstid)
+ stis1stid = (stis1stid_pld45b_sphv_10hv)
+ stis2stid = (stis2stid_pld45b_sphv_10hv)
+ stirstid = (stirstid_pld45b_sphv_10hv)
+ n1stid   = (n1stid_pld45b_sphv_10hv)
+ n2stid   = (n2stid_pld45b_sphv_10hv)
+ nrstid   = (nrstid_pld45b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttlgatd  = (ttlgatd_pld45b_sphv_10hv*fac_tt)
+ is2lgatd = (is2lgatd_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ irlgatd  = (irlgatd_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1gatd = (stis1gatd_pld45b_sphv_10hv)
+ stis2gatd = (stis2gatd_pld45b_sphv_10hv)
+ stirgatd = (stirgatd_pld45b_sphv_10hv)
+ n1gatd   = (n1gatd_pld45b_sphv_10hv)
+ n2gatd   = (n2gatd_pld45b_sphv_10hv)
+ nrgatd   = (nrgatd_pld45b_sphv_10hv)
+ cjaread2 = (cjaread_pld45b_sphv_10hv)
+ cjlstid2 = (cjaread_pld45b_sphv_10hv*djunc*fac_c_lstid)
+ vbiaread2 = (vbiaread2_pld45b_sphv_10hv)
+ vbistid2 = (vbistid2_pld45b_sphv_10hv)
+ paread2  = (paread2_pld45b_sphv_10hv)
+ pstid2   = (pstid2_pld45b_sphv_10hv)
+ is1aread2 = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttaread2 = (ttaread2_pld45b_sphv_10hv*fac_tt)
+ is2aread2 = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ iraread2 = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld45b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld45b_sphv_10hv)
+ stiraread2 = (stiraread2_pld45b_sphv_10hv)
+ n1aread2 = (n1aread2_pld45b_sphv_10hv)
+ n2aread2 = (n2aread2_pld45b_sphv_10hv)
+ nraread2 = (nraread2_pld45b_sphv_10hv)
+ is1lstid2 = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ ttlstid2 = (ttlstid2_pld45b_sphv_10hv*fac_tt)
+ is2lstid2 = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ irlstid2 = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ stis1stid2 = (stis1stid2_pld45b_sphv_10hv)
+ stis2stid2 = (stis2stid2_pld45b_sphv_10hv)
+ stirstid2 = (stirstid2_pld45b_sphv_10hv)
+ n1stid2  = (n1stid2_pld45b_sphv_10hv)
+ n2stid2  = (n2stid2_pld45b_sphv_10hv)
+ nrstid2  = (nrstid2_pld45b_sphv_10hv)
+ eais1area  = (eais1area_pld45b_sphv_10hv)
+ eais2area  = (eais2area_pld45b_sphv_10hv)
+ eairarea   = (eairarea_pld45b_sphv_10hv)
+ eais1sti   = (eais1sti_pld45b_sphv_10hv)
+ eais2sti   = (eais2sti_pld45b_sphv_10hv)
+ eairsti    = (eairsti_pld45b_sphv_10hv)
+ eais1gat   = (eais1gat_pld45b_sphv_10hv)
+ eais2gat   = (eais2gat_pld45b_sphv_10hv)
+ eairgat    = (eairgat_pld45b_sphv_10hv)
+ eais1aread = (eais1aread_pld45b_sphv_10hv)
+ eais2aread = (eais2aread_pld45b_sphv_10hv)
+ eairaread  = (eairaread_pld45b_sphv_10hv)
+ eais1stid  = (eais1stid_pld45b_sphv_10hv)
+ eais2stid  = (eais2stid_pld45b_sphv_10hv)
+ eairstid   = (eairstid_pld45b_sphv_10hv)
+ eais1gatd  = (eais1gatd_pld45b_sphv_10hv)
+ eais2gatd  = (eais2gatd_pld45b_sphv_10hv)
+ eairgatd    = (eairgat_pld45b_sphv_10hv)
+ eais1aread2 = (eais1aread_pld45b_sphv_10hv)
+ eais2aread2 = (eais2aread_pld45b_sphv_10hv)
+ eairaread2  = (eairaread_pld45b_sphv_10hv)
+ eais1stid2  = (eais1stid_pld45b_sphv_10hv)
+ eais2stid2  = (eais2stid_pld45b_sphv_10hv)
+ eairstid2   = (eairstid_pld45b_sphv_10hv)
+ ctgo        = (ctgo_pld45b_sphv_10hv)
+ xvsat       = (xvsat_pld45b_sphv_10hv)
+ ikfarea     = (ikfarea_pld45b_sphv_10hv)
+ ikflsti     = (ikfarea_pld45b_sphv_10hv*djunc)
+ ikflgat     = (ikfarea_pld45b_sphv_10hv*djunc)
+ stikfarea   = (stikfarea_pld45b_sphv_10hv)
+ stikfsti   = (stikfarea_pld45b_sphv_10hv)
+ stikfgat   = (stikfarea_pld45b_sphv_10hv)
+ ikfaread    = (ikfaread_pld45b_sphv_10hv*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflstid    = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflgatd    = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikfaread2   = (ikfaread_pld45b_sphv_10hv*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflstid2   = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ stikfaread  = (stikfaread_pld45b_sphv_10hv)
+ stikfstid  = (stikfaread_pld45b_sphv_10hv)
+ stikfgatd  = (stikfaread_pld45b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld45b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld45b_sphv_10hv)

model dbodybv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (dcbv_pld45b_10hv+bvdss_shift)
+ ibv      = (1e-5/1e-12)

mpowermos (d intg s s dtemp) sphvt_simkit w=w l=leff ldrift=ldrift wdrift=w ldr1=ldr1 mult=ng ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2
rgate (g intg) resistor r=(rply*((w+2*3.325)/((lchdrawn+laccdrawn+lflap)*3*ng)))
dbodybv (d rd) dbodybv area=((ad+ad2)*ngeff)
rlimit (rd s) resistor r=0.01

if (ng_dmy >= 2) {

cgd_fld_dmy (s d) capacitor c=(cgd_ply_fld_dmy*fac_cgd_ply_fld+delta_cgd_ply_fld*ng_dmy*w)
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=leff ldrift=ldrift wdrift=w ldr1=ldr1 mult=ng_dmy ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2

}



include "./smos10hv_ade_dfrt.scs" section=pld45b_10hv_dfrt
ends

subckt pld30b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy			    = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1

parameters
//* parameters to control self-heating model
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
//* switch for simple model
+    swdrlin  = (2)  
+    fac_rshldd                     = ((swdrlin==0)+(swdrlin==2)*0.848)
//* geometry parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2.0)
+    nd                             = (ng/2.0)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
//* dummy parameters
+    ng_dmy                         = (2*sti_dummy)
+    ng_eff                         = (ng+ng_dmy)
+    ndi_eff                        = (ng_eff/2)
+    nsi_eff                        = ((ng_eff-2)/2)
//* geometry parameters
+    l                              = (0.5)
+    lacts                          = (0.66)
+    lactd                          = (0.36)
+    ldr1                           = (0.25)
+    ldrift                         = (0.85)
+    lgply2act                      = (0.2)
+    lg2pepi_s                      = (1.77)
+    lg2pepi_d                      = (0)
+    lp2p_d                         = (2.96)
+    lp2p_s                         = (0.99)
+    wnwx                           = (1.4)
+    wdrift                         = (w)
+    wd2g                           = (0.6)
+    wd2pepi                        = (2.85)
+    wplyend                        = (1.5)
+    djunc                          = (2.5e-06)      // vertical, not scalable
//* junction
+    as                             = (lacts*w)
+    ps                             = ((lacts+w)*2)
+    ad                             = (((ldr1+lgply2act)+ldrift*0.5)*(w+2*wnwx*(1-fem)))
+    pd                             = ((2*((ldr1+lgply2act)+ldrift*0.5)+(w+2*wnwx*(1-fem))))
+    ad2                            = ((lactd+ldrift)*0.5*(w+2*wnwx*(1-fem)))
+    pd2                            = ((lactd+ldrift))
//* box cap
+    xiso                           = (lg2pepi_s*nse+lg2pepi_d*nde+l*ng_eff+lp2p_d*ndi_eff+lp2p_s*nsi_eff)
+    yiso                           = (w+2*wd2pepi*(1-fem))
+    aiso                           = (xiso*yiso)
+    piso                           = (2*(xiso+yiso))
//* parasitic cgd_ply_fld and cgs_ply_fld
+    ca_ply_fld                     = (cpp_ply_fld)
+    ahole_nhv_d                    = (lp2p_d*(w+2*wnwx*(1-fem)))
+    ahole_noply_d                  = ((w+2*wd2g*(1-fem))*(0.5+1.06+0.5))
+    aldr1_d                        = ((ldr1*w)*2)
+    aplyfld_d                      = ((ahole_nhv_d-ahole_noply_d-aldr1_d)/2.0)
+    aply_s                         = ((lp2p_d+2*l)*(w+2*wd2g*(1-fem)+2*wplyend*(1-fem)))
+    ach_s                          = ((l*w)*2)
+    aplyfld_s                      = ((aply_s-ahole_nhv_d-ach_s)/2.0*(1-fem)+1e-18*fem)
+    cgd_ply_fld                    = (ca_ply_fld*aplyfld_d)
+    cgs_ply_fld                    = (ca_ply_fld*aplyfld_s)
//* gate resistance, copy from pld30.
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rgate                          = ((rply*((w+2*1.875*(1-fem))/((l+ldr1)*3*ng))))
//* BV diode
+    dcbv_pld30b_sphv_10hv          = (40)
//* multi-ng
+    dela_vth_ng                    = (ng_eff/(ng_eff+1.2*(1-fem))-2/(2+1.2))*0.025
+    delr_thesato_ng                = (1+(ng_eff/(ng_eff+0.1*(1-fem))-2/(2+0.1))*4.5)
+    delr_thesatw_ng                = (1+(ng_eff/(ng_eff+0.1*(1-fem))-2/(2+0.1))*3)
//* self_heating
+    w_heat                         = w
+    l_heat                         = (l*ng+lp2p_d*ndi+lp2p_s*nsi+lacts*nse)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f                          = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld30b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld30b_sphv_10hv)*ng_eff
+    cth_f                          = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff
+    tfact_ecrit                    = (1+(tc1_ecrit_pld30b_sphv_10hv+tc2_ecrit_pld30b_sphv_10hv*delt)*delt)
//* reliability parameters
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld30b_vthratio     = 1.0
+    presto_pld30b_ronratio     = 0.01
//* mismatch
+    nsmm_dela_vfbo_pld30b_sphv_10hv   = tmp_nsmm_dela_vfbo_pld30b_sphv_10hv
+    nsmm_delr_uo_pld30b_sphv_10hv     = tmp_nsmm_delr_uo_pld30b_sphv_10hv
+    nsmm_delr_rshldd_pld30b_sphv_10hv = tmp_nsmm_delr_rshldd_pld30b_sphv_10hv
+    tc_rshldd_mm                      = (1+(temp-27)*(-1.3e-3))
+    tc_uo_mm                          = (1+(temp-27)*(5e-3))
//* casing
+    delr_tox_pld30b_sphv_10hv      = (nom_delr_tox_pld30b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld30b_sphv_10hv))
+    dela_vfbo_pld30b_sphv_10hv     = (nom_dela_vfbo_pld30b_sphv_10hv+nsig_dela_vfbo_pld30b_sphv_10hv*sig_dela_vfbo_pld30b_sphv_10hv+nsmm_dela_vfbo_pld30b_sphv_10hv*smm_dela_vfbo_pld30b_sphv_10hv(l,w,ng))
+    dela_vfbw_pld30b_sphv_10hv     = (nom_dela_vfbw_pld30b_sphv_10hv+nsig_dela_vfbw_pld30b_sphv_10hv*sig_dela_vfbw_pld30b_sphv_10hv)
+    delr_rshldd_pld30b_sphv_10hv   = (nom_delr_rshldd_pld30b_sphv_10hv*(1.0+nsig_delr_rshldd_pld30b_sphv_10hv*sig_delr_rshldd_pld30b_sphv_10hv)+tc_rshldd_mm*nsmm_delr_rshldd_pld30b_sphv_10hv*smm_delr_rshldd_pld30b_sphv_10hv(l,w,ng))
+    dela_nwxw_pld30b_sphv_10hv     = (nom_dela_nwxw_pld30b_sphv_10hv+nsig_dela_nwxw_pld30b_sphv_10hv*sig_dela_nwxw_pld30b_sphv_10hv)
+    dela_vdscale_pld30b_sphv_10hv  = (nom_dela_vdscale_pld30b_sphv_10hv+nsig_dela_vdscale_pld30b_sphv_10hv*sig_dela_vdscale_pld30b_sphv_10hv)
+    dela_vdscalew_pld30b_sphv_10hv = (nom_dela_vdscalew_pld30b_sphv_10hv+nsig_dela_vdscalew_pld30b_sphv_10hv*sig_dela_vdscalew_pld30b_sphv_10hv)
+    delr_uo_pld30b_sphv_10hv       = (1.0+tc_uo_mm*nsmm_delr_uo_pld30b_sphv_10hv*smm_delr_uo_pld30b_sphv_10hv(l,w,ng))
+    delr_cj_pld30b_sphv_10hv	    = (nom_delr_cj_pld30b_sphv_10hv*(1.0+nsig_delr_cj_pld30b_sphv_10hv*sig_delr_cj_pld30b_sphv_10hv))
+    delr_is_pld30b_sphv_10hv	    = (nom_delr_is_pld30b_sphv_10hv*exp(nsig_delr_is_pld30b_sphv_10hv*sig_delr_is_pld30b_sphv_10hv))
+    delr_is2_pld30b_sphv_10hv	    = (nom_delr_is2_pld30b_sphv_10hv*exp(nsig_delr_is2_pld30b_sphv_10hv*sig_delr_is2_pld30b_sphv_10hv))
+    delr_ir_pld30b_sphv_10hv	    = (nom_delr_ir_pld30b_sphv_10hv*exp(nsig_delr_ir_pld30b_sphv_10hv*sig_delr_ir_pld30b_sphv_10hv))

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ vdscale  = ((vdscale_pld30b_sphv_10hv+dela_vdscale_pld30b_sphv_10hv)+(vdscalew_pld30b_sphv_10hv+dela_vdscalew_pld30b_sphv_10hv)/w*(1-fem))
+ vdscaleb = (vdscaleb_pld30b_sphv_10hv)
+ stvdscale= (stvdscale_pld30b_sphv_10hv)
+ ctgo     = (0)
+ ctbo     = (0)
+ stcto    = (0)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swgedi   = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec   = (1)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ xvsat    = (xvsat_pld30b_sphv_10hv)
+ qmc      = (qmc_pld30b_sphv_10hv)
+ lvaro    = (lvaro_pld30b_sphv_10hv)
+ lvarl    = (lvarl_pld30b_sphv_10hv)
+ lvarw    = (lvarw_pld30b_sphv_10hv*(1-fem))
+ lap      = (lap_pld30b_sphv_10hv)
+ wvaro    = (wvaro_pld30b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld30b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld30b_sphv_10hv*(1-fem))
+ wot      = (wot_pld30b_sphv_10hv*(1-fem))
+ dlq      = (dlq_pld30b_sphv_10hv)
+ dwq      = (dwq_pld30b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld30b_sphv_10hv+dela_vfbo_pld30b_sphv_10hv+dela_vth_ng+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld30b_vthratio)
+ vfbl     = (vfbl_pld30b_sphv_10hv)
+ vfbw     = ((vfbw_pld30b_sphv_10hv+dela_vfbw_pld30b_sphv_10hv)*(1-fem))
+ vfblw    = (vfblw_pld30b_sphv_10hv*(1-fem))
+ stvfbo   = (stvfbo_pld30b_sphv_10hv)
+ stvfbl   = (stvfbl_pld30b_sphv_10hv)
+ stvfbw   = (stvfbw_pld30b_sphv_10hv*(1-fem))
+ stvfblw  = (stvfblw_pld30b_sphv_10hv*(1-fem))
+ toxo     = (toxo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ epsroxo  = (epsroxo_pld30b_sphv_10hv)
+ nsubo    = (nsubo_pld30b_sphv_10hv)
+ nsubw    = (nsubw_pld30b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld30b_sphv_10hv)
+ npck     = (npck_pld30b_sphv_10hv)
+ npckw    = (npckw_pld30b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld30b_sphv_10hv)
+ lpck     = (lpck_pld30b_sphv_10hv)
+ lpckw    = (lpckw_pld30b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld30b_sphv_10hv)
+ fol2     = (fol2_pld30b_sphv_10hv)
+ facneffaco = (facneffaco_pld30b_sphv_10hv)
+ facneffacl = (facneffacl_pld30b_sphv_10hv)
+ facneffacw = (facneffacw_pld30b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld30b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld30b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld30b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld30b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld30b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld30b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld30b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld30b_sphv_10hv)
+ vnsubo   = (vnsubo_pld30b_sphv_10hv)
+ nslpo    = (nslpo_pld30b_sphv_10hv)
+ dnsubo   = (dnsubo_pld30b_sphv_10hv)
+ dphibo   = (dphibo_pld30b_sphv_10hv)
+ dphibl   = (dphibl_pld30b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld30b_sphv_10hv)
+ dphibw   = (dphibw_pld30b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld30b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld30b_sphv_10hv)
+ delvtacl = (delvtacl_pld30b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld30b_sphv_10hv)
+ delvtacw = (delvtacw_pld30b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_pld30b_sphv_10hv*(1-fem))
+ npo      = (npo_pld30b_sphv_10hv)
+ npl      = (npl_pld30b_sphv_10hv)
+ cto      = (cto_pld30b_sphv_10hv)
+ ctl      = (ctl_pld30b_sphv_10hv)
+ ctlexp   = (ctlexp_pld30b_sphv_10hv)
+ ctw      = (ctw_pld30b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld30b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ toxovdo  = (toxovdo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ lov      = (lov_pld30b_sphv_10hv)
+ dlovd    = (dlovd_pld30b_sphv_10hv)
+ novo     = (novo_pld30b_sphv_10hv)
+ novdo    = (novdo_pld30b_sphv_10hv)
+ cfl      = (cfl_pld30b_sphv_10hv)
+ cflexp   = (cflexp_pld30b_sphv_10hv)
+ cfw      = (cfw_pld30b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld30b_sphv_10hv)
+ uo       = (uo_pld30b_sphv_10hv*delr_uo_pld30b_sphv_10hv*delr_u0_relimo)
+ fbet1    = (fbet1_pld30b_sphv_10hv)
+ fbet1w   = (fbet1w_pld30b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld30b_sphv_10hv)
+ lp1w     = (lp1w_pld30b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld30b_sphv_10hv)
+ lp2      = (lp2_pld30b_sphv_10hv)
+ betw1    = (betw1_pld30b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld30b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld30b_sphv_10hv)
+ stbeto   = (stbeto_pld30b_sphv_10hv)
+ stbetl   = (stbetl_pld30b_sphv_10hv)
+ stbetw   = (stbetw_pld30b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_pld30b_sphv_10hv*(1-fem))
+ mueo     = (mueo_pld30b_sphv_10hv)
+ muew     = (muew_pld30b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld30b_sphv_10hv)
+ themuo   = (themuo_pld30b_sphv_10hv)
+ stthemuo = (stthemuo_pld30b_sphv_10hv)
+ cso      = (cso_pld30b_sphv_10hv)
+ csl      = (csl_pld30b_sphv_10hv)
+ cslexp   = (cslexp_pld30b_sphv_10hv)
+ csw      = (csw_pld30b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld30b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld30b_sphv_10hv)
+ xcoro    = (xcoro_pld30b_sphv_10hv)
+ xcorl    = (xcorl_pld30b_sphv_10hv)
+ xcorw    = (xcorw_pld30b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_pld30b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_pld30b_sphv_10hv)
+ fetao    = (fetao_pld30b_sphv_10hv)
+ rsw1     = (rsw1_pld30b_sphv_10hv*(1-fem))
+ rsw2     = (rsw2_pld30b_sphv_10hv*(1-fem))
+ strso    = (strso_pld30b_sphv_10hv)
+ rsbo     = (rsbo_pld30b_sphv_10hv)
+ rsgo     = (rsgo_pld30b_sphv_10hv)
+ thesato  = (thesato_pld30b_sphv_10hv*delr_thesato_ng)
+ thesatl  = (thesatl_pld30b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld30b_sphv_10hv)
+ thesatw  = (thesatw_pld30b_sphv_10hv*delr_thesatw_ng*(1-fem))
+ thesatlw = (thesatlw_pld30b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld30b_sphv_10hv)
+ stthesatl = (stthesatl_pld30b_sphv_10hv)
+ stthesatw = (stthesatw_pld30b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_pld30b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_pld30b_sphv_10hv)
+ thesatgo = (thesatgo_pld30b_sphv_10hv)
+ thesatgl = (thesatgl_pld30b_sphv_10hv)
+ thesatgw = (thesatgw_pld30b_sphv_10hv*(1-fem))
+ axo      = (axo_pld30b_sphv_10hv)
+ axl      = (axl_pld30b_sphv_10hv)
+ alpl     = (alpl_pld30b_sphv_10hv)
+ alplexp  = (alplexp_pld30b_sphv_10hv)
+ alpw     = (alpw_pld30b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld30b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld30b_sphv_10hv)
+ alp1l2   = (alp1l2_pld30b_sphv_10hv)
+ alp1w    = (alp1w_pld30b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld30b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld30b_sphv_10hv)
+ alp2l2   = (alp2l2_pld30b_sphv_10hv)
+ alp2w    = (alp2w_pld30b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld30b_sphv_10hv)
+ a1o      = (a1o_pld30b_sphv_10hv)
+ a1l      = (a1l_pld30b_sphv_10hv)
+ a1w      = (a1w_pld30b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld30b_sphv_10hv)
+ sta2o    = (sta2o_pld30b_sphv_10hv)
+ a3o      = (a3o_pld30b_sphv_10hv)
+ a3l      = (a3l_pld30b_sphv_10hv)
+ a3w      = (a3w_pld30b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld30b_sphv_10hv)
+ a4l      = (a4l_pld30b_sphv_10hv)
+ a4w      = (a4w_pld30b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld30b_sphv_10hv)
+ iginvlw  = (iginvlw_pld30b_sphv_10hv)
+ igovw    = (igovw_pld30b_sphv_10hv)
+ igovdw   = (igovdw_pld30b_sphv_10hv)
+ stigo    = (stigo_pld30b_sphv_10hv)
+ gc2o     = (gc2o_pld30b_sphv_10hv)
+ gc3o     = (gc3o_pld30b_sphv_10hv)
+ chibo    = (chibo_pld30b_sphv_10hv)
+ agidlw   = (agidlw_pld30b_sphv_10hv)
+ agidldw  = (agidldw_pld30b_sphv_10hv)
+ bgidlo   = (bgidlo_pld30b_sphv_10hv)
+ bgidldo  = (bgidldo_pld30b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld30b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld30b_sphv_10hv)
+ cgidlo   = (cgidlo_pld30b_sphv_10hv)
+ cgidldo  = (cgidldo_pld30b_sphv_10hv)
+ cgbovl   = (cgbovl_pld30b_sphv_10hv)
+ cfrw     = (cfrw_pld30b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_pld30b_sphv_10hv*(1-fem))
+ fnto     = (fnto_pld30b_sphv_10hv)
+ nfalw    = (nfalw_pld30b_sphv_10hv)
+ nfblw    = (nfblw_pld30b_sphv_10hv)
+ nfclw    = (nfclw_pld30b_sphv_10hv)
+ efo      = (efo_pld30b_sphv_10hv)
+ lintnoi  = (lintnoi_pld30b_sphv_10hv)
+ alpnoi   = (alpnoi_pld30b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld30b_sphv_10hv)
+ kvthowel = (kvthowel_pld30b_sphv_10hv)
+ kvthowew = (kvthowew_pld30b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_pld30b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_pld30b_sphv_10hv)
+ kuowel   = (kuowel_pld30b_sphv_10hv)
+ kuowew   = (kuowew_pld30b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_pld30b_sphv_10hv*(1-fem))
+ rgo      = (rgo_pld30b_sphv_10hv)
+ rsh      = (rsh_pld30b_sphv_10hv)
+ rbulko   = (rbulko_pld30b_sphv_10hv)
+ rwello   = (rwello_pld30b_sphv_10hv)
+ rjunso   = (rjunso_pld30b_sphv_10hv)
+ rjundo   = ((rjundo_pld30b_sphv_10hv/(w+(1-fem)*dwrjundo_pld30b_sphv_10hv))*(1-0.0002*(temp-27)))
+ rint     = (rint_pld30b_sphv_10hv)
+ rvpoly   = (rvpoly_pld30b_sphv_10hv)
+ rshg     = (rshg_pld30b_sphv_10hv)
+ dlsil    = (dlsil_pld30b_sphv_10hv)
+ saref    = (saref_pld30b_sphv_10hv)
+ sbref    = (sbref_pld30b_sphv_10hv)
+ wlod     = (wlod_pld30b_sphv_10hv)
+ kuo      = (kuo_pld30b_sphv_10hv)
+ kvsat    = (kvsat_pld30b_sphv_10hv)
+ tkuo     = (tkuo_pld30b_sphv_10hv)
+ lkuo     = (lkuo_pld30b_sphv_10hv)
+ wkuo     = (wkuo_pld30b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_pld30b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_pld30b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld30b_sphv_10hv*(1-fem))
+ kvtho    = (kvtho_pld30b_sphv_10hv)
+ lkvtho   = (lkvtho_pld30b_sphv_10hv)
+ wkvtho   = (wkvtho_pld30b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_pld30b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_pld30b_sphv_10hv)
+ wlodvth  = (wlodvth_pld30b_sphv_10hv*(1-fem))
+ stetao   = (stetao_pld30b_sphv_10hv)
+ lodetao  = (lodetao_pld30b_sphv_10hv)
+ scref    = (scref_pld30b_sphv_10hv)
+ web      = (web_pld30b_sphv_10hv)
+ wec      = (wec_pld30b_sphv_10hv)
+ adr1o    = (adr1o_pld30b_sphv_10hv)
+ adr1l    = (adr1l_pld30b_sphv_10hv)
+ adr1w    = (adr1w_pld30b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_pld30b_sphv_10hv)
+ stadr2o  = (stadr2o_pld30b_sphv_10hv)
+ adr3o    = (adr3o_pld30b_sphv_10hv)
+ adr3l    = (adr3l_pld30b_sphv_10hv)
+ adr3w    = (adr3w_pld30b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_pld30b_sphv_10hv)
+ adr4l    = (adr4l_pld30b_sphv_10hv)
+ adr4w    = (adr4w_pld30b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_pld30b_sphv_10hv)
+ adr5l    = (adr5l_pld30b_sphv_10hv)
+ adr5w    = (adr5w_pld30b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_pld30b_sphv_10hv)
+ bidr1l   = (bidr1l_pld30b_sphv_10hv)
+ bidr1w   = (bidr1w_pld30b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_pld30b_sphv_10hv)
+ bidr2w   = (bidr2w_pld30b_sphv_10hv*(1-fem))
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0*(1-fem))
+ rthlw    = (0*(1-fem))
+ strtho   = (strtho_pld30b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0*(1-fem))
+ cthlw    = (0*(1-fem))
+ rshldd   = (rshldd_pld30b_sphv_10hv*delr_rshldd_pld30b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld30b_ronratio))*fac_rshldd
+ xw       = (xw_pld30b_sphv_10hv*(1-fem))
+ nwxw     = ((nwxw_pld30b_sphv_10hv+1.0e-12*dela_nwxw_pld30b_sphv_10hv)*(1-fem))
+ xl       = (xl_pld30b_sphv_10hv)
+ xlw      = (xlw_pld30b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld30b_sphv_10hv)
+ nst      = (nst_pld30b_sphv_10hv)
+ ats      = (ats_pld30b_sphv_10hv)
+ dfinf    = (dfinf_pld30b_sphv_10hv)
+ dfw      = (dfw_pld30b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld30b_sphv_10hv)
+ dflw     = (dflw_pld30b_sphv_10hv*(1-fem))
+ dp       = (dp_pld30b_sphv_10hv)
+ ecrit    = (ecrit_pld30b_sphv_10hv*tfact_ecrit)*(1+ecritw_pld30b_sphv_10hv/w*(1-fem))
+ ecorn    = (ecorn_pld30b_sphv_10hv*tfact_ecrit)*(1+ecritw_pld30b_sphv_10hv/w*(1-fem))
+ du       = (du_pld30b_sphv_10hv)
+ tc1      = (tc1_pld30b_sphv_10hv)
+ tc2      = (tc2_pld30b_sphv_10hv)
+ tc1l     = (tc1l_pld30b_sphv_10hv)
+ tc2l     = (tc2l_pld30b_sphv_10hv)
+ tc1w     = (tc1w_pld30b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_pld30b_sphv_10hv*(1-fem))
+ theacc   = (theacc_pld30b_sphv_10hv)
+ theacc2  = (theacc2_pld30b_sphv_10hv)
+ aacc     = (aacc_pld30b_sphv_10hv)
+ rva      = (rva_pld30b_sphv_10hv)
+ dta      = (dta_pld30b_sphv_10hv)
+ trj      = (trj_pld30b_sphv_10hv)
+ cjarea   = (cjarea_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlsti   = (cjlsti_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlgat   = (cjlgat_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiarea  = (vbiarea_pld30b_sphv_10hv)
+ vbisti   = (vbisti_pld30b_sphv_10hv)
+ vbigat   = (vbigat_pld30b_sphv_10hv)
+ parea    = (parea_pld30b_sphv_10hv)
+ psti     = (psti_pld30b_sphv_10hv)
+ pgat     = (pgat_pld30b_sphv_10hv)
+ is1area  = (is1area_pld30b_sphv_10hv)
+ ttarea   = (ttarea_pld30b_sphv_10hv)
+ is2area  = (is2area_pld30b_sphv_10hv)
+ irarea   = (irarea_pld30b_sphv_10hv)
+ stis1area = (stis1area_pld30b_sphv_10hv)
+ stis2area = (stis2area_pld30b_sphv_10hv)
+ stirarea = (stirarea_pld30b_sphv_10hv)
+ n1area   = (n1area_pld30b_sphv_10hv)
+ n2area   = (n2area_pld30b_sphv_10hv)
+ nrarea   = (nrarea_pld30b_sphv_10hv)
+ is1lsti  = (is1lsti_pld30b_sphv_10hv)
+ ttlsti   = (ttlsti_pld30b_sphv_10hv)
+ is2lsti  = (is2lsti_pld30b_sphv_10hv)
+ irlsti   = (irlsti_pld30b_sphv_10hv)
+ stis1sti = (stis1area_pld30b_sphv_10hv)
+ stis2sti = (stis2area_pld30b_sphv_10hv)
+ stirsti  = (stirarea_pld30b_sphv_10hv)
+ n1sti    = (n1sti_pld30b_sphv_10hv)
+ n2sti    = (n2sti_pld30b_sphv_10hv)
+ nrsti    = (nrsti_pld30b_sphv_10hv)
+ is1lgat  = (is1lgat_pld30b_sphv_10hv)
+ ttlgat   = (ttlgat_pld30b_sphv_10hv)
+ is2lgat  = (is2lgat_pld30b_sphv_10hv)
+ irlgat   = (irlgat_pld30b_sphv_10hv)
+ stis1gat = (stis1area_pld30b_sphv_10hv)
+ stis2gat = (stis2area_pld30b_sphv_10hv)
+ stirgat  = (stirarea_pld30b_sphv_10hv)
+ n1gat    = (n1gat_pld30b_sphv_10hv)
+ n2gat    = (n2gat_pld30b_sphv_10hv)
+ nrgat    = (nrgat_pld30b_sphv_10hv)
+ cjaread  = (cjaread_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlstid  = (cjlstid_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlgatd  = (cjlgatd_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiaread = (vbiaread_pld30b_sphv_10hv)
+ vbistid  = (vbistid_pld30b_sphv_10hv)
+ vbigatd  = (vbigatd_pld30b_sphv_10hv)
+ paread   = (paread_pld30b_sphv_10hv)
+ pstid    = (pstid_pld30b_sphv_10hv)
+ pgatd    = (pgatd_pld30b_sphv_10hv)
+ is1aread = (is1aread_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttaread  = (ttaread_pld30b_sphv_10hv)
+ is2aread = (is2aread_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ iraread  = (iraread_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1aread = (stis1aread_pld30b_sphv_10hv)
+ stis2aread = (stis2aread_pld30b_sphv_10hv)
+ stiraread = (stiraread_pld30b_sphv_10hv)
+ n1aread  = (n1aread_pld30b_sphv_10hv)
+ n2aread  = (n2aread_pld30b_sphv_10hv)
+ nraread  = (nraread_pld30b_sphv_10hv)
+ is1lstid = (is1lstid_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlstid  = (ttlstid_pld30b_sphv_10hv)
+ is2lstid = (is2lstid_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlstid  = (irlstid_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1stid = (stis1aread_pld30b_sphv_10hv)
+ stis2stid = (stis2aread_pld30b_sphv_10hv)
+ stirstid = (stiraread_pld30b_sphv_10hv)
+ n1stid   = (n1stid_pld30b_sphv_10hv)
+ n2stid   = (n2stid_pld30b_sphv_10hv)
+ nrstid   = (nrstid_pld30b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlgatd  = (ttlgatd_pld30b_sphv_10hv)
+ is2lgatd = (is2lgatd_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlgatd  = (irlgatd_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1gatd = (stis1aread_pld30b_sphv_10hv)
+ stis2gatd = (stis2aread_pld30b_sphv_10hv)
+ stirgatd = (stiraread_pld30b_sphv_10hv)
+ n1gatd   = (n1gatd_pld30b_sphv_10hv)
+ n2gatd   = (n2gatd_pld30b_sphv_10hv)
+ nrgatd   = (nrgatd_pld30b_sphv_10hv)
+ cjaread2 = (cjaread_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlstid2 = (cjlstid_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiaread2 = (vbiaread_pld30b_sphv_10hv)
+ vbistid2 = (vbistid_pld30b_sphv_10hv)
+ paread2  = (paread_pld30b_sphv_10hv)
+ pstid2   = (pstid_pld30b_sphv_10hv)
+ is1aread2 = (is1aread2_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttaread2 = (ttaread2_pld30b_sphv_10hv)
+ is2aread2 = (is2aread2_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ iraread2 = (iraread2_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld30b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld30b_sphv_10hv)
+ stiraread2 = (stiraread_pld30b_sphv_10hv)
+ n1aread2 = (n1aread2_pld30b_sphv_10hv)
+ n2aread2 = (n2aread2_pld30b_sphv_10hv)
+ nraread2 = (nraread2_pld30b_sphv_10hv)
+ is1lstid2 = (is1lstid2_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlstid2 = (ttlstid2_pld30b_sphv_10hv)
+ is2lstid2 = (is2lstid2_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlstid2 = (irlstid2_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1stid2 = (stis1aread_pld30b_sphv_10hv)
+ stis2stid2 = (stis2aread_pld30b_sphv_10hv)
+ stirstid2 = (stiraread_pld30b_sphv_10hv)
+ n1stid2  = (n1stid2_pld30b_sphv_10hv)
+ n2stid2  = (n2stid2_pld30b_sphv_10hv)
+ nrstid2  = (nrstid2_pld30b_sphv_10hv)
+ eais1area = (eais1area_pld30b_sphv_10hv)
+ eais2area = (eais2area_pld30b_sphv_10hv)
+ eairarea = (eairarea_pld30b_sphv_10hv)
+ eais1sti = (eais1sti_pld30b_sphv_10hv)
+ eais2sti = (eais2sti_pld30b_sphv_10hv)
+ eairsti = (eairsti_pld30b_sphv_10hv)
+ eais1gat = (eais1gat_pld30b_sphv_10hv)
+ eais2gat = (eais2gat_pld30b_sphv_10hv)
+ eairgat = (eairgat_pld30b_sphv_10hv)
+ eais1aread = (eais1aread_pld30b_sphv_10hv)
+ eais2aread = (eais2aread_pld30b_sphv_10hv)
+ eairaread = (eairaread_pld30b_sphv_10hv)
+ eais1stid = (eais1stid_pld30b_sphv_10hv)
+ eais2stid = (eais2stid_pld30b_sphv_10hv)
+ eairstid = (eairstid_pld30b_sphv_10hv)
+ eais1gatd = (eais1gatd_pld30b_sphv_10hv)
+ eais2gatd = (eais2gatd_pld30b_sphv_10hv)
+ eairgatd = (eairgatd_pld30b_sphv_10hv)
+ eais1aread2 = (eais1aread2_pld30b_sphv_10hv)
+ eais2aread2 = (eais2aread2_pld30b_sphv_10hv)
+ eairaread2 = (eairaread2_pld30b_sphv_10hv)
+ eais1stid2 = (eais1stid2_pld30b_sphv_10hv)
+ eais2stid2 = (eais2stid2_pld30b_sphv_10hv)
+ eairstid2 = (eairstid2_pld30b_sphv_10hv)
+ ikfarea = (ikfarea_pld30b_sphv_10hv)
+ ikflsti = (ikfarea_pld30b_sphv_10hv*djunc)
+ ikflgat = (ikfarea_pld30b_sphv_10hv*djunc)
+ stikfarea = (stikfarea_pld30b_sphv_10hv)
+ stikfsti = (stikfarea_pld30b_sphv_10hv)
+ stikfgat = (stikfarea_pld30b_sphv_10hv)
+ ikfaread = (ikfaread_pld30b_sphv_10hv*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflstid = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflgatd = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikfaread2 = (ikfaread_pld30b_sphv_10hv*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflstid2 = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ stikfaread = (stikfaread_pld30b_sphv_10hv)
+ stikfstid = (stikfaread_pld30b_sphv_10hv)
+ stikfgatd = (stikfaread_pld30b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld30b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld30b_sphv_10hv)

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax          = (1e12)
+ jmelt         = (1e12)
+ tnom          = (27)
+ is            = (1e-30)
+ n             = (1.0)
+ cj            = (1e-30)
+ pta           = (0)
+ tlevc         = (2)
+ tlev          = (2)
+ bv            = (dcbv_pld30b_sphv_10hv+bvdss_shift)
+ ibv           = (1e-5/1e-12)

mpowermos (d gi s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2
cgd (gi d) capacitor c=(cgd_ply_fld*1.3) m=ng
cgs (gi s) capacitor c=(cgs_ply_fld) m=ng
rg (g gi) resistor r=rgate
dbodyBV (d di) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (di s) resistor r=0.01
xdsub (s sub) cdgoptub_box_sub_10hv area=(aiso*(1-lpe)+1e-12) perim=(piso*(1-lpe)+1e-12) soa=1

if (ng_dmy>=2) {

cgd_dmy (s d) capacitor c=(cgd_ply_fld*1.3) m=ng_dmy
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2

}

include "./smos10hv_ade_dfrt.scs" section=pld30b_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld10_10hv (d g s sub)
parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    fem                            = 0
+    soa                            = 1
+    sti_dummy                      = 0


parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.25)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)

//
+    dw_mos                         = (0.03525*(1-fem))
+    numbernplus                    = (int_round(w/0.8))
+    w_um                           = (numbernplus*0.4+dw_mos*(1-fem))
+    l_um                           = (lch_drawn)

+    wdrift                         = (w)
+    wnwx                           = (0.6)
+    ldrift                         = (0.35)
+    ldr1                           = (lacc_drawn)
+    lacts                          = (0.375)
+    lactd                          = (0.57)
+    wg2nhv                         = (0.765*(1-fem))
+    aplyfld_d                      = (((ldr1)*2*wg2nhv)*ngeff)
+    aplyfld_s                      = (1e-15*ng)
+    as_xdr                         = (lacts*w_um)
+    ps_xdr                         = ((2*(lacts+0.4))*numbernplus)
+    ad_xdr                         = ((ldr1+ldrift+lactd*0.5)*(w+2*wnwx))
+    pd_xdr                         = ((2*((ldr1+ldrift+lactd*0.5)+(w+2*wnwx))))
//+    ad2_xdr                        = ((lactd+ldrift)*0.5*(w+2*wg2nhv*(1-fem)))
//+    pd2_xdr                        = ((lactd+ldrift))
+    as_i                           = (as_xdr)
+    ps_i                           = (ps_xdr)
+    ad_i                           = (ad_xdr)
+    pd_i                           = (pd_xdr)
//+    ad2_i                          = (ad2_xdr)
//+    pd2_i                          = (pd2_xdr)
+    lg2dt                          = (1.485)
+    wg2dt                          = (1.35*(1-fem))
+    lg2g_d                         = ((ldrift+lactd*0.5)*2)
+    lg2g_s                         = (0.42)
+    lg2w                           = (l_um)
+    xnbl_xdr                       = (lg2dt*nse+lg2w*ngeff+ldr1*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (2*wg2dt+w)
+    anbl_xdr                       = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_nld10_sphv_10hv+tc2_ecrit_nld10_sphv_10hv*(temp-tnom))*(temp-tnom))
+    wfact_ecrit                    = (1+ecritw_nld10_sphv_10hv/w*(1-fem))
+    w_heat=w
+    l_heat=(lg2w*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1.7)
+    rth_f=(((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld10_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld10_sphv_10hv)*ngeff/she_fit)
+    cth_f=(((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.82)

+    nsmm_delr_gox_nld10_sphv_10hv  = 0
+    nsmm_dela_dw_nld10_sphv_10hv   = tmp_nsmm_dela_dw_nld10_sphv_10hv
+    nsmm_dela_vfb_nld10_sphv_10hv  = tmp_nsmm_dela_vfb_nld10_sphv_10hv
+    nsmm_delr_mobref_nld10_sphv_10hv = 0
+    nsmm_delr_rshl_nld10_sphv_10hv = 0
+    nsmm_delr_nsub_nld10_sphv_10hv = tmp_nsmm_delr_nsub_nld10_sphv_10hv

+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld10_vthratio      = 1.0
+    presto_nld10_ronratio      = 0.01/1/9.8537

//**parameters for multi ng
+ fac_ng_rshldd=(1+(ngeff/(ngeff-1.0*(1-fem))-2/(2-1.0))*(0.2))
+ fac_ng_vfbo= ((ngeff/(ngeff+0.8*(1-fem))-2/(2+0.8))*(0.02))

//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
//+    delr_tox_nld10_sphv_10hv      = (nom_delr_tox_nld10_sphv_10hv*(1.0+nsig_delr_tox_nld10_sphv_10hv*sig_delr_tox_nld10_sphv_10hv+nsmm_delr_gox_nld10_sphv_10hv*smm_delr_gox_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_tox_nld10_sphv_10hv      = (nom_delr_tox_nld10_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld10_sphv_10hv+nsmm_delr_gox_nld10_sphv_10hv*smm_delr_gox_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld10_sphv_10hv       = (nom_dela_dw_nld10_sphv_10hv+nsig_dela_dw_nld10_sphv_10hv*sig_dela_dw_nld10_sphv_10hv+nsmm_dela_dw_nld10_sphv_10hv*smm_dela_dw_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld10_sphv_10hv       = (nom_dela_xw_nld10_sphv_10hv+nsig_dela_xw_nld10_sphv_10hv*sig_dela_xw_nld10_sphv_10hv)
+    dela_vfb_nld10_sphv_10hv      = (nom_dela_vfb_nld10_sphv_10hv+nsig_dela_vfb_nld10_sphv_10hv*sig_dela_vfb_nld10_sphv_10hv+nsmm_dela_vfb_nld10_sphv_10hv*smm_dela_vfb_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_nld10_sphv_10hv     = (nom_dela_vtwl_nld10_sphv_10hv+nsig_dela_vtwl_nld10_sphv_10hv*sig_dela_vtwl_nld10_sphv_10hv)
+    delr_mobref_nld10_sphv_10hv   = (nom_delr_mobref_nld10_sphv_10hv*(1.0+nsig_delr_mobref_nld10_sphv_10hv*sig_delr_mobref_nld10_sphv_10hv+nsmm_delr_mobref_nld10_sphv_10hv*smm_delr_mobref_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_nld10_sphv_10hv     = (nom_delr_rshl_nld10_sphv_10hv*(1.0+nsig_delr_rshl_nld10_sphv_10hv*sig_delr_rshl_nld10_sphv_10hv)+nsmm_delr_rshl_nld10_sphv_10hv*smm_delr_rshl_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_thesato_nld10_sphv_10hv     = (nom_delr_thesato_nld10_sphv_10hv*(1.0+nsig_delr_thesato_nld10_sphv_10hv*sig_delr_thesato_nld10_sphv_10hv))
+    delr_nsub_nld10_sphv_10hv     = (1+nsmm_delr_nsub_nld10_sphv_10hv*smm_delr_nsub_nld10_sphv_10hv(l,w)/sqrt(ng/2))
//+    cj0_junc_nld10_d_body         = ((nom_delr_cj0_junc_nld10_d_body*(1+nsig_delr_cj0_junc_nld10_d_body*sig_delr_cj0_junc_nld10_d_body)))
//+    js_junc_nld10_d_body          = ((nom_delr_js_junc_nld10_d_body*(1+nsig_delr_js_junc_nld10_d_body*sig_delr_js_junc_nld10_d_body)))
+    delr_cj_nld10_sphv_10hv = (nom_delr_cj_nld10_sphv_10hv*(1+sig_delr_cj_nld10_sphv_10hv*nsig_delr_cj_nld10_sphv_10hv))
+    delr_is_nld10_sphv_10hv = (nom_delr_is_nld10_sphv_10hv*exp(sig_delr_is_nld10_sphv_10hv*nsig_delr_is_nld10_sphv_10hv))
+    delr_is2_nld10_sphv_10hv = (nom_delr_is2_nld10_sphv_10hv*exp(sig_delr_is2_nld10_sphv_10hv*nsig_delr_is2_nld10_sphv_10hv))
+    delr_ir_nld10_sphv_10hv = (nom_delr_ir_nld10_sphv_10hv*exp(sig_delr_ir_nld10_sphv_10hv*nsig_delr_ir_nld10_sphv_10hv))


//+    cpp_ply_fld		    = (nom_cpp_ply_fld)
//+    nom_cpp_ply_fld		    = (0.092229166666667e-15)
//+    cpp_ply_sdt		    = (nom_cpp_ply_sdt)
//+    nom_cpp_ply_sdt		    = (2.6460229885057e-15)

+    lfr_ct_ply_s		    = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d		    = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d		    = ((w+0*0.06*(1-fem))*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s		    = ((w+0*0.06*(1-fem))*ng-lfr_ct_ply_s)


//+    cfr_nld10_d_ply_m1ct	= (4.36e-17)

//+    cfr_nld10_s_ply_m1ct	= (1.29e-16)

//+    cfr_nld10_s_ply_met	= (4.25e-17)

//+    cfr_nld10_d_ply_met	= (3.96e-17)

+    lfring                         = (w*ng)
+    lch_drawn                      = (0.55)
+    lch                            = (0.401)
+    lacc_drawn                     = (0.45)
+    lacc                           = (0.554)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    lflap                          = (0.25)

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))

if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr
}


model sphvt_simkit sphvt
+ type     =(n)
+ vdscale  = (vdscale_nld10_sphv_10hv*(1-0.06*(1-fem)/w))
+ ctgo     = (0.1)
+ stcto    = (0.2)
+ stvdscale= (-0.27)
+ strthao  = (0.8)
+ tr       = (27)
+ swgeo    = (1)
+ swgedi    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec    = (1)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = swdrlin
+ xvsat = (xvsat_nld10_sphv_10hv*(1+xvsatw_nld10_sphv_10hv/w*(1-fem)))
+ qmc      = (qmc_nld10_sphv_10hv)
+ lvaro    = (lvaro_nld10_sphv_10hv)
+ lvarl    = (lvarl_nld10_sphv_10hv)
+ lvarw    = (lvarw_nld10_sphv_10hv*(1-fem))
+ lap      = (lap_nld10_sphv_10hv)
+ wvaro    = (wvaro_nld10_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld10_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld10_sphv_10hv*(1-fem))
+ wot      = ((wot_nld10_sphv_10hv+0.5e-6*dela_dw_nld10_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld10_sphv_10hv)
+ dwq      = (dwq_nld10_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld10_sphv_10hv+fac_ng_vfbo+dela_vfb_nld10_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld10_vthratio)
+ vfbl     = (vfbl_nld10_sphv_10hv)
+ vfbw     = (vfbw_nld10_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld10_sphv_10hv+dela_vtwl_nld10_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld10_sphv_10hv)
+ stvfbl   = (stvfbl_nld10_sphv_10hv)
+ stvfbw   = (stvfbw_nld10_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld10_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ epsroxo  = (epsroxo_nld10_sphv_10hv)
+ nsubo    = (nsubo_nld10_sphv_10hv*delr_nsub_nld10_sphv_10hv)
+ nsubw    = (nsubw_nld10_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld10_sphv_10hv)
+ npck     = (npck_nld10_sphv_10hv)
+ npckw    = (npckw_nld10_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld10_sphv_10hv)
+ lpck     = (lpck_nld10_sphv_10hv)
+ lpckw    = (lpckw_nld10_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld10_sphv_10hv)
+ fol2     = (fol2_nld10_sphv_10hv)
+ facneffaco = (facneffaco_nld10_sphv_10hv)
+ facneffacl = (facneffacl_nld10_sphv_10hv)
+ facneffacw = (facneffacw_nld10_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld10_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld10_sphv_10hv)
+ gfacnudl = (gfacnudl_nld10_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld10_sphv_10hv)
+ gfacnudw = (gfacnudw_nld10_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld10_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld10_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld10_sphv_10hv)
+ vnsubo   = (vnsubo_nld10_sphv_10hv)
+ nslpo    = (nslpo_nld10_sphv_10hv)
+ dnsubo   = (dnsubo_nld10_sphv_10hv)
+ dphibo   = (dphibo_nld10_sphv_10hv)
+ dphibl   = (dphibl_nld10_sphv_10hv)
+ dphiblexp = (dphiblexp_nld10_sphv_10hv)
+ dphibw   = (dphibw_nld10_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld10_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld10_sphv_10hv)
+ delvtacl = (delvtacl_nld10_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld10_sphv_10hv)
+ delvtacw = (delvtacw_nld10_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld10_sphv_10hv)*(1-fem)
+ npo      = (npo_nld10_sphv_10hv)
+ npl      = (npl_nld10_sphv_10hv)
+ cto      = (cto_nld10_sphv_10hv)
+ ctl      = (ctl_nld10_sphv_10hv)
+ ctlexp   = (ctlexp_nld10_sphv_10hv)
+ ctw      = (ctw_nld10_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld10_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ toxovdo  = (toxovdo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ lov      = (lov_nld10_sphv_10hv)
+ dlovd    = (dlovd_nld10_sphv_10hv)
+ novo     = (novo_nld10_sphv_10hv)
+ novdo    = (novdo_nld10_sphv_10hv)
+ cfl      = (cfl_nld10_sphv_10hv)
+ cflexp   = (cflexp_nld10_sphv_10hv)
+ cfw      = (cfw_nld10_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld10_sphv_10hv)
+ uo       = (uo_nld10_sphv_10hv*delr_mobref_nld10_sphv_10hv*delr_u0_relimo)*w_um/wdrift
+ fbet1    = (fbet1_nld10_sphv_10hv)
+ fbet1w   = (fbet1w_nld10_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld10_sphv_10hv)
+ lp1w     = (lp1w_nld10_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld10_sphv_10hv)
+ lp2      = (lp2_nld10_sphv_10hv)
+ betw1    = (betw1_nld10_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld10_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld10_sphv_10hv)
+ stbeto   = (stbeto_nld10_sphv_10hv)
+ stbetl   = (stbetl_nld10_sphv_10hv)
+ stbetw   = (stbetw_nld10_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld10_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld10_sphv_10hv)
+ muew     = (muew_nld10_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld10_sphv_10hv)
+ themuo   = (themuo_nld10_sphv_10hv)
+ stthemuo = (stthemuo_nld10_sphv_10hv)
+ cso      = (cso_nld10_sphv_10hv)
+ csl      = (csl_nld10_sphv_10hv)
+ cslexp   = (cslexp_nld10_sphv_10hv)
+ csw      = (csw_nld10_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld10_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld10_sphv_10hv)
+ xcoro    = (xcoro_nld10_sphv_10hv)
+ xcorl    = (xcorl_nld10_sphv_10hv)
+ xcorw    = (xcorw_nld10_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld10_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld10_sphv_10hv)
+ fetao    = (fetao_nld10_sphv_10hv)
+ rsw1     = (rsw1_nld10_sphv_10hv)
+ rsw2     = (rsw2_nld10_sphv_10hv)*(1-fem)
+ strso    = (strso_nld10_sphv_10hv)
+ rsbo     = (rsbo_nld10_sphv_10hv)
+ rsgo     = (rsgo_nld10_sphv_10hv)
+ thesato  = (thesato_nld10_sphv_10hv*delr_thesato_nld10_sphv_10hv)
+ thesatl  = (thesatl_nld10_sphv_10hv)
+ thesatlexp = (thesatlexp_nld10_sphv_10hv)
+ thesatw  = (thesatw_nld10_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld10_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld10_sphv_10hv)
+ stthesatl = (stthesatl_nld10_sphv_10hv)
+ stthesatw = (stthesatw_nld10_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld10_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld10_sphv_10hv)
+ thesatgo = (thesatgo_nld10_sphv_10hv)
+ thesatgl = (thesatgl_nld10_sphv_10hv)
+ thesatgw = (thesatgw_nld10_sphv_10hv*(1-fem))
+ axo      = (axo_nld10_sphv_10hv)
+ axl      = (axl_nld10_sphv_10hv)
+ alpl     = (alpl_nld10_sphv_10hv)
+ alplexp  = (alplexp_nld10_sphv_10hv)
+ alpw     = (alpw_nld10_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld10_sphv_10hv)
+ alp1lexp = (alp1lexp_nld10_sphv_10hv)
+ alp1l2   = (alp1l2_nld10_sphv_10hv)
+ alp1w    = (alp1w_nld10_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld10_sphv_10hv)
+ alp2lexp = (alp2lexp_nld10_sphv_10hv)
+ alp2l2   = (alp2l2_nld10_sphv_10hv)
+ alp2w    = (alp2w_nld10_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld10_sphv_10hv)
+ a1o      = (a1o_nld10_sphv_10hv)
+ a1l      = (a1l_nld10_sphv_10hv)
+ a1w      = (a1w_nld10_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld10_sphv_10hv)
+ sta2o    = (sta2o_nld10_sphv_10hv)
+ a3o      = (a3o_nld10_sphv_10hv)
+ a3l      = (a3l_nld10_sphv_10hv)
+ a3w      = (a3w_nld10_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld10_sphv_10hv)
+ a4l      = (a4l_nld10_sphv_10hv)
+ a4w      = (a4w_nld10_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld10_sphv_10hv)
+ iginvlw  = (iginvlw_nld10_sphv_10hv)
+ igovw    = (igovw_nld10_sphv_10hv)
+ igovdw   = (igovdw_nld10_sphv_10hv)
+ stigo    = (stigo_nld10_sphv_10hv)
+ gc2o     = (gc2o_nld10_sphv_10hv)
+ gc3o     = (gc3o_nld10_sphv_10hv)
+ chibo    = (chibo_nld10_sphv_10hv)
+ agidlw   = (agidlw_nld10_sphv_10hv)
+ agidldw  = (agidldw_nld10_sphv_10hv)
+ bgidlo   = (bgidlo_nld10_sphv_10hv)
+ bgidldo  = (bgidldo_nld10_sphv_10hv)
+ stbgidlo = (stbgidlo_nld10_sphv_10hv)
+ stbgidldo = (stbgidldo_nld10_sphv_10hv)
+ cgidlo   = (cgidlo_nld10_sphv_10hv)
+ cgidldo  = (cgidldo_nld10_sphv_10hv)
+ cgbovl   = (cgbovl_nld10_sphv_10hv)
+ cfrw     = (cfrw_nld10_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld10_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld10_sphv_10hv)
+ nfalw    = (nfalw_nld10_sphv_10hv)
+ nfblw    = (nfblw_nld10_sphv_10hv)
+ nfclw    = (nfclw_nld10_sphv_10hv)
+ efo      = (efo_nld10_sphv_10hv)
+ lintnoi  = (lintnoi_nld10_sphv_10hv)
+ alpnoi   = (alpnoi_nld10_sphv_10hv)
+ kvthoweo = (kvthoweo_nld10_sphv_10hv)
+ kvthowel = (kvthowel_nld10_sphv_10hv)
+ kvthowew = (kvthowew_nld10_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld10_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld10_sphv_10hv)
+ kuowel   = (kuowel_nld10_sphv_10hv)
+ kuowew   = (kuowew_nld10_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld10_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld10_sphv_10hv)
+ rsh      = (rsh_nld10_sphv_10hv)
+ rbulko   = (rbulko_nld10_sphv_10hv)
+ rwello   = (rwello_nld10_sphv_10hv)
+ rjunso   = (rjunso_nld10_sphv_10hv/(w_um+dwrjunso_nld10_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld10_sphv_10hv/(wdrift+dwrjundo_nld10_sphv_10hv*(1-fem)))
+ rint     = (rint_nld10_sphv_10hv)
+ rvpoly   = (rvpoly_nld10_sphv_10hv)
+ rshg     = (rshg_nld10_sphv_10hv)
+ dlsil    = (dlsil_nld10_sphv_10hv)
+ saref    = (saref_nld10_sphv_10hv)
+ sbref    = (sbref_nld10_sphv_10hv)
+ wlod     = (wlod_nld10_sphv_10hv)
+ kuo      = (kuo_nld10_sphv_10hv)
+ kvsat    = (kvsat_nld10_sphv_10hv)
+ tkuo     = (tkuo_nld10_sphv_10hv)
+ lkuo     = (lkuo_nld10_sphv_10hv)
+ wkuo     = (wkuo_nld10_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld10_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld10_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld10_sphv_10hv)
+ kvtho    = (kvtho_nld10_sphv_10hv)
+ lkvtho   = (lkvtho_nld10_sphv_10hv)
+ wkvtho   = (wkvtho_nld10_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld10_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld10_sphv_10hv)
+ wlodvth  = (wlodvth_nld10_sphv_10hv)
+ stetao   = (stetao_nld10_sphv_10hv)
+ lodetao  = (lodetao_nld10_sphv_10hv)
+ scref    = (scref_nld10_sphv_10hv)
+ web      = (web_nld10_sphv_10hv)
+ wec      = (wec_nld10_sphv_10hv)
+ adr1o    = (adr1o_nld10_sphv_10hv)
+ adr1l    = (adr1l_nld10_sphv_10hv)
+ adr1w    = (adr1w_nld10_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld10_sphv_10hv)
+ stadr2o  = (stadr2o_nld10_sphv_10hv)
+ adr3o    = (adr3o_nld10_sphv_10hv)
+ adr3l    = (adr3l_nld10_sphv_10hv)
+ adr3w    = (adr3w_nld10_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld10_sphv_10hv)
+ adr4l    = (adr4l_nld10_sphv_10hv)
+ adr4w    = (adr4w_nld10_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld10_sphv_10hv)
+ adr5l    = (adr5l_nld10_sphv_10hv)
+ adr5w    = (adr5w_nld10_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld10_sphv_10hv)
+ bidr1l   = (bidr1l_nld10_sphv_10hv)
+ bidr1w   = (bidr1w_nld10_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld10_sphv_10hv)
+ bidr2w   = (bidr2w_nld10_sphv_10hv)*(1-fem)
//+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld10_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld10_sphv_10hv*fac_ng_rshldd*delr_rshl_nld10_sphv_10hv*delr_rdsw_relimo*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld10_ronratio))
+ xw       = ((xw_nld10_sphv_10hv+0.5e-6*dela_xw_nld10_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld10_sphv_10hv*(1-fem))
+ xl       = (xl_nld10_sphv_10hv)
+ xlw      = (xlw_nld10_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld10_sphv_10hv)
+ nst      = (nst_nld10_sphv_10hv)
+ ats      = (ats_nld10_sphv_10hv)
+ dfinf    = (dfinf_nld10_sphv_10hv)
+ dfw      = (dfw_nld10_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld10_sphv_10hv)
+ dflw     = (dflw_nld10_sphv_10hv*(1-fem))
+ dp       = (dp_nld10_sphv_10hv)
+ ecrit    = (ecrit_nld10_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ ecorn    = (ecorn_nld10_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ du       = (du_nld10_sphv_10hv)
+ tc1      = (tc1_nld10_sphv_10hv)
+ tc2      = (tc2_nld10_sphv_10hv)
+ tc1l     = (tc1l_nld10_sphv_10hv)
+ tc2l     = (tc2l_nld10_sphv_10hv)
+ tc1w     = (tc1w_nld10_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld10_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld10_sphv_10hv)
+ theacc2  = (theacc2_nld10_sphv_10hv)
+ aacc     = (aacc_nld10_sphv_10hv)
+ rva      = (rva_nld10_sphv_10hv)*(1+2.5/w*(1-fem))
+ dta      = (dta_nld10_sphv_10hv)
+ trj      = (trj_nld10_sphv_10hv)
+ cjarea   = (cjarea_nld10_sphv_10hv)*delr_cj_nld10_sphv_10hv
+ cjlsti   = (cjlsti_nld10_sphv_10hv)*djunc*delr_cj_nld10_sphv_10hv
+ cjlgat   = (cjlgat_nld10_sphv_10hv)*djunc*delr_cj_nld10_sphv_10hv
+ vbiarea  = (vbiarea_nld10_sphv_10hv)
+ vbisti   = (vbisti_nld10_sphv_10hv)
+ vbigat   = (vbigat_nld10_sphv_10hv)
+ parea    = (parea_nld10_sphv_10hv)
+ psti     = (psti_nld10_sphv_10hv)
+ pgat     = (pgat_nld10_sphv_10hv)
+ is1area  = (is1area_nld10_sphv_10hv)
+ ttarea   = (ttarea_nld10_sphv_10hv)
+ is2area  = (is2area_nld10_sphv_10hv)
+ irarea   = (irarea_nld10_sphv_10hv)
+ stis1area = (stis1area_nld10_sphv_10hv)
+ stis2area = (stis2area_nld10_sphv_10hv)
+ stirarea = (stirarea_nld10_sphv_10hv)
+ n1area   = (n1area_nld10_sphv_10hv)
+ n2area   = (n2area_nld10_sphv_10hv)
+ nrarea   = (nrarea_nld10_sphv_10hv)
+ is1lsti  = (is1lsti_nld10_sphv_10hv)
+ ttlsti   = (ttlsti_nld10_sphv_10hv)
+ is2lsti  = (is2lsti_nld10_sphv_10hv)
+ irlsti   = (irlsti_nld10_sphv_10hv)
+ stis1sti = (stis1sti_nld10_sphv_10hv)
+ stis2sti = (stis2sti_nld10_sphv_10hv)
+ stirsti  = (stirsti_nld10_sphv_10hv)
+ n1sti    = (n1sti_nld10_sphv_10hv)
+ n2sti    = (n2sti_nld10_sphv_10hv)
+ nrsti    = (nrsti_nld10_sphv_10hv)
+ is1lgat  = (is1lgat_nld10_sphv_10hv)
+ ttlgat   = (ttlgat_nld10_sphv_10hv)
+ is2lgat  = (is2lgat_nld10_sphv_10hv)
+ irlgat   = (irlgat_nld10_sphv_10hv)
+ stis1gat = (stis1gat_nld10_sphv_10hv)
+ stis2gat = (stis2gat_nld10_sphv_10hv)
+ stirgat  = (stirgat_nld10_sphv_10hv)
+ n1gat    = (n1gat_nld10_sphv_10hv)
+ n2gat    = (n2gat_nld10_sphv_10hv)
+ nrgat    = (nrgat_nld10_sphv_10hv)
+ cjaread  = (cjaread_nld10_sphv_10hv*delr_cj_nld10_sphv_10hv)
+ cjlstid  = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ cjlgatd  = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ vbiaread = (vbiaread_nld10_sphv_10hv)
+ vbistid  = (vbistid_nld10_sphv_10hv)
+ vbigatd  = (vbigatd_nld10_sphv_10hv)
+ paread   = (paread_nld10_sphv_10hv)
+ pstid    = (pstid_nld10_sphv_10hv)
+ pgatd    = (pgatd_nld10_sphv_10hv)
+ is1aread = (is1aread_nld10_sphv_10hv*delr_is_nld10_sphv_10hv)
+ ttaread  = (ttaread_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread = (is2aread_nld10_sphv_10hv*delr_is2_nld10_sphv_10hv)
+ iraread  = (iraread_nld10_sphv_10hv*delr_ir_nld10_sphv_10hv)
+ stis1aread = (stis1aread_nld10_sphv_10hv)
+ stis2aread = (stis2aread_nld10_sphv_10hv)
+ stiraread = (stiraread_nld10_sphv_10hv)
+ n1aread  = (n1aread_nld10_sphv_10hv)
+ n2aread  = (n2aread_nld10_sphv_10hv)
+ nraread  = (nraread_nld10_sphv_10hv)
+ is1lstid = (is1aread_nld10_sphv_10hv*djunc*delr_is_nld10_sphv_10hv)
+ ttlstid  = (ttlstid_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid = (is2aread_nld10_sphv_10hv*djunc*delr_is2_nld10_sphv_10hv)
+ irlstid  = (irlstid_nld10_sphv_10hv*djunc*delr_ir_nld10_sphv_10hv)
+ stis1stid = (stis1stid_nld10_sphv_10hv)
+ stis2stid = (stis2stid_nld10_sphv_10hv)
+ stirstid = (stirstid_nld10_sphv_10hv)
+ n1stid   = (n1stid_nld10_sphv_10hv)
+ n2stid   = (n2stid_nld10_sphv_10hv)
+ nrstid   = (nrstid_nld10_sphv_10hv)
+ is1lgatd = (is1aread_nld10_sphv_10hv*djunc*delr_is_nld10_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lgatd = (is2aread_nld10_sphv_10hv*djunc*delr_is2_nld10_sphv_10hv)
+ irlgatd  = (irlgatd_nld10_sphv_10hv*djunc*delr_ir_nld10_sphv_10hv)
+ stis1gatd = (stis1gatd_nld10_sphv_10hv)
+ stis2gatd = (stis2gatd_nld10_sphv_10hv)
+ stirgatd = (stirgatd_nld10_sphv_10hv)
+ n1gatd   = (n1gatd_nld10_sphv_10hv)
+ n2gatd   = (n2gatd_nld10_sphv_10hv)
+ nrgatd   = (nrgatd_nld10_sphv_10hv)
+ cjaread2 = (cjaread_nld10_sphv_10hv*delr_cj_nld10_sphv_10hv)
+ cjlstid2 = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld10_sphv_10hv)
+ vbistid2 = (vbistid2_nld10_sphv_10hv)
+ paread2  = (paread2_nld10_sphv_10hv)
+ pstid2   = (pstid2_nld10_sphv_10hv)
+ is1aread2 = (is1aread_nld10_sphv_10hv)*delr_is_nld10_sphv_10hv
+ ttaread2 = (ttaread2_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread2 = (is2aread_nld10_sphv_10hv)*delr_is2_nld10_sphv_10hv
+ iraread2 = (iraread2_nld10_sphv_10hv)*delr_ir_nld10_sphv_10hv
+ stis1aread2 = (stis1aread_nld10_sphv_10hv)
+ stis2aread2 = (stis2aread_nld10_sphv_10hv)
+ stiraread2 = (stiraread2_nld10_sphv_10hv)
+ n1aread2 = (n1aread2_nld10_sphv_10hv)
+ n2aread2 = (n2aread2_nld10_sphv_10hv)
+ nraread2 = (nraread2_nld10_sphv_10hv)
+ is1lstid2 = (is1aread_nld10_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid2 = (is2aread_nld10_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_nld10_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld10_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld10_sphv_10hv)
+ stirstid2 = (stirstid2_nld10_sphv_10hv)
+ n1stid2  = (n1stid2_nld10_sphv_10hv)
+ n2stid2  = (n2stid2_nld10_sphv_10hv)
+ nrstid2  = (nrstid2_nld10_sphv_10hv)

+ eais1area = (eais1area_nld10_sphv_10hv)
+ eais2area = (eais2area_nld10_sphv_10hv)
+ eairarea = (eairarea_nld10_sphv_10hv)
+ eais1sti = (eais1sti_nld10_sphv_10hv)
+ eais2sti = (eais2sti_nld10_sphv_10hv)
+ eairsti = (eairsti_nld10_sphv_10hv)
+ eais1gat = (eais1gat_nld10_sphv_10hv)
+ eais2gat = (eais2gat_nld10_sphv_10hv)
+ eairgat = (eairgat_nld10_sphv_10hv)

+ eais1aread = (eais1aread_nld10_sphv_10hv)
+ eais2aread = (eais2aread_nld10_sphv_10hv)
+ eairaread = (eairaread_nld10_sphv_10hv)
+ eais1stid = (eais1stid_nld10_sphv_10hv)
+ eais2stid = (eais2stid_nld10_sphv_10hv)
+ eairstid = (eairstid_nld10_sphv_10hv)
+ eais1gatd = (eais1gatd_nld10_sphv_10hv)
+ eais2gatd = (eais2gatd_nld10_sphv_10hv)
+ eairgatd = (eairgatd_nld10_sphv_10hv)

+ eais1aread2 = (eais1aread2_nld10_sphv_10hv)
+ eais2aread2 = (eais2aread2_nld10_sphv_10hv)
+ eairaread2 = (eairaread2_nld10_sphv_10hv)
+ eais1stid2 = (eais1stid2_nld10_sphv_10hv)
+ eais2stid2 = (eais2stid2_nld10_sphv_10hv)
+ eairstid2 = (eairstid2_nld10_sphv_10hv)

+ ikfarea               = ikfarea_nld10_sphv_10hv
+ ikflsti               = ikfarea_nld10_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld10_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld10_sphv_10hv
+ stikfsti              = stikfarea_nld10_sphv_10hv
+ stikfgat              = stikfarea_nld10_sphv_10hv
+ ikfaread              = ikfaread_nld10_sphv_10hv*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflstid              = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflgatd              = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikfaread2             = ikfaread_nld10_sphv_10hv*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflstid2             = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ stikfaread             = stikfaread_nld10_sphv_10hv
+ stikfstid             = stikfaread_nld10_sphv_10hv
+ stikfgatd             = stikfaread_nld10_sphv_10hv
+ stikfaread2            = stikfaread_nld10_sphv_10hv
+ stikfstid2            = stikfaread_nld10_sphv_10hv

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt    = (1e12)
+ tnom    = (27)
+ is           = (1e-30)
+ n           = (1.0)
+ cj          = (1e-30)
+ pta        = (0)
+ tlevc     = (2)
+ tlev       = (2)
+ bv         = (17.5+bvdss_shift)
+ ibv         = (1e-5/1e-12)

mpowermos (d intg s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i
//cgs_frg_s (intg s) capacitor c=(cpp_ply_sdt*(lovlap+lfrs)*lfring)
//cgd_frg_d (intg d) capacitor c=(cpp_ply_sdt*(lfrd)*lfring)
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
//cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
//cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld10_s_ply_met+lfr_ct_ply_s*cfr_nld10_s_ply_m1ct))
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld10_d_ply_met*(1-fem*(1-0.295))+lfr_ct_ply_d*cfr_nld10_d_ply_m1ct*(1-fem*(1-0.436)))
//cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld10_d_ply_met+lfr_ct_ply_d*cfr_nld10_d_ply_m1ct))
dbodyBV (s rd)  dbodyBV  area=((ad_i)*ng)
rlimit  (rd d)   resistor r=0.01

rgate (g intg) resistor r=((rply*((w+2*0.525*(1-fem))/((lch+lacc)*3*ng))))
xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1

include "./smos10hv_ade_dfrt.scs" section=nld10_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_he_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = (1)
+    selfheat                       = (1)
+    fscale			    = (1)
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_he_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_he_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_he_sphv_10hv
+    nsmm_dela_vfb_nld45b_he_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_he_sphv_10hv
+    nsmm_dela_vtw_nld45b_he_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_he_sphv_10hv
+    nsmm_delr_mobref_nld45b_he_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_he_sphv_10hv
+    nsmm_delr_rsh_nld45b_he_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_he_sphv_10hv
+    nsmm_delr_thesato_nld45b_he_sphv_10hv = tmp_nsmm_delr_thesato_nld45b_he_sphv_10hv
+    nsmm_delr_nsub_nld45b_he_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_he_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_he_vthratio  = 1.0
+    presto_nld45b_he_ronratio  = 0.01/1.6
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.55)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.3)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.45)
+    ldr1 			    = (0.55)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.305)
+    wd2g			    = (0.675)*(1-fem)
+    wg1			    = (0.925)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.55)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lacc                           = (0.552)
+    lch                            = (0.475)
+    lflap                          = (0.7)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w+2*s2r)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w+2*s2r)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.78)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w+2*s2r)+0.5*pi4models*(rin_dr1-sg)*(rin_dr1-sg))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_he_sphv_10hv+tc2_ecrit_nld45b_he_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_he_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_he_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-1.5e-3))
+    delr_tox_nld45b_he_sphv_10hv      = (nom_delr_tox_nld45b_he_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_he_sphv_10hv+nsmm_delr_gox_nld45b_he_sphv_10hv*smm_delr_gox_nld45b_he_sphv_10hv(l,w,ng)))
//+    delr_tox_nld45b_he_sphv_10hv      = (nom_delr_tox_nld45b_he_sphv_10hv*(1.0+nsig_delr_tox_nld45b_he_sphv_10hv*sig_delr_tox_nld45b_he_sphv_10hv+nsmm_delr_gox_nld45b_he_sphv_10hv*smm_delr_gox_nld45b_he_sphv_10hv(l,w,ng)))
+    dela_xw_nld45b_he_sphv_10hv       = (nom_dela_xw_nld45b_he_sphv_10hv+nsig_dela_xw_nld45b_he_sphv_10hv*sig_dela_xw_nld45b_he_sphv_10hv+nsmm_dela_xw_nld45b_he_sphv_10hv*smm_dela_xw_nld45b_he_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_he_sphv_10hv      = (nom_dela_vfb_nld45b_he_sphv_10hv+nsig_dela_vfb_nld45b_he_sphv_10hv*sig_dela_vfb_nld45b_he_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_he_sphv_10hv*smm_dela_vfb_nld45b_he_sphv_10hv(l,w,ng))
+    dela_vtw_nld45b_he_sphv_10hv     = (nom_dela_vtw_nld45b_he_sphv_10hv+nsig_dela_vtw_nld45b_he_sphv_10hv*sig_dela_vtw_nld45b_he_sphv_10hv+nsmm_dela_vtw_nld45b_he_sphv_10hv*smm_dela_vtw_nld45b_he_sphv_10hv(l,w,ng))
+    delr_mobref_nld45b_he_sphv_10hv   = (nom_delr_mobref_nld45b_he_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_he_sphv_10hv*sig_delr_mobref_nld45b_he_sphv_10hv+nsmm_delr_mobref_nld45b_he_sphv_10hv*smm_delr_mobref_nld45b_he_sphv_10hv(l,w,ng)))
+    delr_rsh_nld45b_he_sphv_10hv     = (nom_delr_rsh_nld45b_he_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_he_sphv_10hv*sig_delr_rsh_nld45b_he_sphv_10hv)+nsmm_delr_rsh_nld45b_he_sphv_10hv*smm_delr_rsh_nld45b_he_sphv_10hv(l,w,ng))
+    delr_thesato_nld45b_he_sphv_10hv     = (nom_delr_thesato_nld45b_he_sphv_10hv*(1.0+nsig_delr_thesato_nld45b_he_sphv_10hv*sig_delr_thesato_nld45b_he_sphv_10hv)+nsmm_delr_thesato_nld45b_he_sphv_10hv*smm_delr_thesato_nld45b_he_sphv_10hv(l,w,ng))
+    delr_nsub_nld45b_he_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_he_sphv_10hv*smm_delr_nsub_nld45b_he_sphv_10hv(l,w,ng))
+    delr_cj_nld45b_he_sphv_10hv        = ((nom_delr_cj_nld45b_he_sphv_10hv*(1+nsig_delr_cj_nld45b_he_sphv_10hv*sig_delr_cj_nld45b_he_sphv_10hv)))
+    delr_is_nld45b_he_sphv_10hv = (nom_delr_is_nld45b_he_sphv_10hv*exp(sig_delr_is_nld45b_he_sphv_10hv*nsig_delr_is_nld45b_he_sphv_10hv))
+    delr_is2_nld45b_he_sphv_10hv = (nom_delr_is2_nld45b_he_sphv_10hv*exp(sig_delr_is2_nld45b_he_sphv_10hv*nsig_delr_is2_nld45b_he_sphv_10hv))
+    delr_ir_nld45b_he_sphv_10hv = (nom_delr_ir_nld45b_he_sphv_10hv*exp(sig_delr_ir_nld45b_he_sphv_10hv*nsig_delr_ir_nld45b_he_sphv_10hv))
// binning parameters
+    dwvdscale =(dwvdscale_nld45b_he_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_he_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_he_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_he_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_he_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(-0.45)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ dvth_ng=weff/(weff+0.25)*(0.026)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(-0.01)*(1-fem)
// simple model
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.81)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}

// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (59+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rply*((w+2*3.675*(1-fem))/((lch+lacc+lflap)*3*ng)))
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+     dphibo=(dphibo_nld45b_he_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_he_pspmoscap_10hv+dela_vfb_nld45b_he_sphv_10hv)
+     nsubo=(nsubo_nld45b_he_sphv_10hv)
+     nsubw=(nsubw_nld45b_he_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =(amoscap/l-w_nld45b_he_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_he_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_he_mosb_10hv)
+ wdrift     =(w_nld45b_he_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_he_mosb_10hv)+(stdelvto_nld45b_he_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)
+ factuo     =(factuo_nld45b_he_mosb_10hv)*(1+(stfactuo_nld45b_he_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=((vdscale_nld45b_he_sphv_10hv)*(1+dwvdscale/weff+dwvdscalew/(weff*weff)))
+ stvdscale=(stvdscale_nld45b_he_sphv_10hv)
+ ctgo=(ctgo_nld45b_he_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_he_sphv_10hv)
+ qmc      = (qmc_nld45b_he_sphv_10hv)
+ lvaro    = (lvaro_nld45b_he_sphv_10hv)
+ lvarl    = (lvarl_nld45b_he_sphv_10hv)
+ lvarw    = (lvarw_nld45b_he_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_he_sphv_10hv)
+ wvaro    = (wvaro_nld45b_he_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_he_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_he_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_he_sphv_10hv+0.5e-6*dela_dw_nld45b_he_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_he_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_he_sphv_10hv)
+ dwq      = (dwq_nld45b_he_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_he_sphv_10hv+dela_vfb_nld45b_he_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_he_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_he_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_he_sphv_10hv+dela_vtw_nld45b_he_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_he_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_he_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_he_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_he_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_he_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_he_sphv_10hv)
+ nsubo    = (nsubo_nld45b_he_sphv_10hv*delr_nsub_nld45b_he_sphv_10hv)
+ nsubw    = (nsubw_nld45b_he_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_he_sphv_10hv)
+ npck     = (npck_nld45b_he_sphv_10hv)
+ npckw    = (npckw_nld45b_he_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_he_sphv_10hv)
+ lpck     = (lpck_nld45b_he_sphv_10hv)
+ lpckw    = (lpckw_nld45b_he_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_he_sphv_10hv)
+ fol2     = (fol2_nld45b_he_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_he_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_he_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_he_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_he_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_he_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_he_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_he_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_he_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_he_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_he_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_he_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_he_sphv_10hv)
+ nslpo    = (nslpo_nld45b_he_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_he_sphv_10hv)
+ dphibo   = (dphibo_nld45b_he_sphv_10hv)
+ dphibl   = (dphibl_nld45b_he_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_he_sphv_10hv)
+ dphibw   = (dphibw_nld45b_he_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_he_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_he_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_he_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_he_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_he_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_he_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_he_sphv_10hv)
+ npl      = (npl_nld45b_he_sphv_10hv)
+ cto      = (cto_nld45b_he_sphv_10hv)
+ ctl      = (ctl_nld45b_he_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_he_sphv_10hv)
+ ctw      = (ctw_nld45b_he_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_he_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ lov      = (lov_nld45b_he_sphv_10hv)
+ dlovd    = (dlovd_nld45b_he_sphv_10hv)
+ novo     = (novo_nld45b_he_sphv_10hv)
+ novdo    = (novdo_nld45b_he_sphv_10hv)
+ cfl      = (cfl_nld45b_he_sphv_10hv)
+ cflexp   = (cflexp_nld45b_he_sphv_10hv)
+ cfw      = (cfw_nld45b_he_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_he_sphv_10hv)
+ uo       = (uo_nld45b_he_sphv_10hv*delr_mobref_nld45b_he_sphv_10hv*delr_u0_relimo)*(weff/w)
+ fbet1    = (fbet1_nld45b_he_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_he_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_he_sphv_10hv)
+ lp1w     = (lp1w_nld45b_he_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_he_sphv_10hv)
+ lp2      = (lp2_nld45b_he_sphv_10hv)
+ betw1    = (betw1_nld45b_he_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_he_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_he_sphv_10hv)
+ stbeto   = (stbeto_nld45b_he_sphv_10hv)
+ stbetl   = (stbetl_nld45b_he_sphv_10hv)
+ stbetw   = (stbetw_nld45b_he_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_he_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_he_sphv_10hv)
+ muew     = (muew_nld45b_he_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_he_sphv_10hv)
+ themuo   = (themuo_nld45b_he_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_he_sphv_10hv)
+ cso      = (cso_nld45b_he_sphv_10hv)
+ csl      = (csl_nld45b_he_sphv_10hv)
+ cslexp   = (cslexp_nld45b_he_sphv_10hv)
+ csw      = (csw_nld45b_he_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_he_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_he_sphv_10hv)
+ xcoro    = (xcoro_nld45b_he_sphv_10hv)
+ xcorl    = (xcorl_nld45b_he_sphv_10hv)
+ xcorw    = (xcorw_nld45b_he_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_he_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_he_sphv_10hv)
+ fetao    = (fetao_nld45b_he_sphv_10hv)
+ rsw1     = (rsw1_nld45b_he_sphv_10hv)
+ rsw2     = (rsw2_nld45b_he_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_he_sphv_10hv)
+ rsbo     = (rsbo_nld45b_he_sphv_10hv)
+ rsgo     = (rsgo_nld45b_he_sphv_10hv)
+ thesato  = (thesato_nld45b_he_sphv_10hv*delr_thesato_nld45b_he_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_he_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_he_sphv_10hv)
+ thesatw  = (thesatw_nld45b_he_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_he_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_he_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_he_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_he_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_he_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_he_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_he_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_he_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_he_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_he_sphv_10hv)
+ axl      = (axl_nld45b_he_sphv_10hv)
+ alpl     = (alpl_nld45b_he_sphv_10hv)
+ alplexp  = (alplexp_nld45b_he_sphv_10hv)
+ alpw     = (alpw_nld45b_he_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_he_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_he_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_he_sphv_10hv)
+ alp1w    = (alp1w_nld45b_he_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_he_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_he_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_he_sphv_10hv)
+ alp2w    = (alp2w_nld45b_he_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_he_sphv_10hv)
+ a1o      = (a1o_nld45b_he_sphv_10hv)
+ a1l      = (a1l_nld45b_he_sphv_10hv)
+ a1w      = (a1w_nld45b_he_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_he_sphv_10hv)
+ sta2o    = (sta2o_nld45b_he_sphv_10hv)
+ a3o      = (a3o_nld45b_he_sphv_10hv)
+ a3l      = (a3l_nld45b_he_sphv_10hv)
+ a3w      = (a3w_nld45b_he_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_he_sphv_10hv)
+ a4l      = (a4l_nld45b_he_sphv_10hv)
+ a4w      = (a4w_nld45b_he_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_he_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_he_sphv_10hv)
+ igovw    = (igovw_nld45b_he_sphv_10hv)
+ igovdw   = (igovdw_nld45b_he_sphv_10hv)
+ stigo    = (stigo_nld45b_he_sphv_10hv)
+ gc2o     = (gc2o_nld45b_he_sphv_10hv)
+ gc3o     = (gc3o_nld45b_he_sphv_10hv)
+ chibo    = (chibo_nld45b_he_sphv_10hv)
+ agidlw   = (agidlw_nld45b_he_sphv_10hv*(1-fem))
+ agidldw  = (agidldw_nld45b_he_sphv_10hv*(1-fem))
+ bgidlo   = (bgidlo_nld45b_he_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_he_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_he_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_he_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_he_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_he_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_he_sphv_10hv)
+ cfrw     = (cfrw_nld45b_he_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_he_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_he_sphv_10hv)
+ nfalw    = (nfalw_nld45b_he_sphv_10hv)
+ nfblw    = (nfblw_nld45b_he_sphv_10hv)
+ nfclw    = (nfclw_nld45b_he_sphv_10hv)
+ efo      = (efo_nld45b_he_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_he_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_he_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_he_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_he_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_he_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_he_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_he_sphv_10hv)
+ kuowel   = (kuowel_nld45b_he_sphv_10hv)
+ kuowew   = (kuowew_nld45b_he_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_he_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_he_sphv_10hv)
+ rsh      = (rsh_nld45b_he_sphv_10hv)
+ rbulko   = (rbulko_nld45b_he_sphv_10hv)
+ rwello   = (rwello_nld45b_he_sphv_10hv)
+ rjunso   = (rjunso_nld45b_he_sphv_10hv/(weff+dwrjunso_nld45b_he_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_he_sphv_10hv/(weff+dwrjundo_nld45b_he_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_he_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_he_sphv_10hv)
+ rshg     = (rshg_nld45b_he_sphv_10hv)
+ dlsil    = (dlsil_nld45b_he_sphv_10hv)
+ saref    = (saref_nld45b_he_sphv_10hv)
+ sbref    = (sbref_nld45b_he_sphv_10hv)
+ wlod     = (wlod_nld45b_he_sphv_10hv)
+ kuo      = (kuo_nld45b_he_sphv_10hv)
+ kvsat    = (kvsat_nld45b_he_sphv_10hv)
+ tkuo     = (tkuo_nld45b_he_sphv_10hv)
+ lkuo     = (lkuo_nld45b_he_sphv_10hv)
+ wkuo     = (wkuo_nld45b_he_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_he_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_he_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_he_sphv_10hv)
+ kvtho    = (kvtho_nld45b_he_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_he_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_he_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_he_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_he_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_he_sphv_10hv)
+ stetao   = (stetao_nld45b_he_sphv_10hv)
+ lodetao  = (lodetao_nld45b_he_sphv_10hv)
+ scref    = (scref_nld45b_he_sphv_10hv)
+ web      = (web_nld45b_he_sphv_10hv)
+ wec      = (wec_nld45b_he_sphv_10hv)
+ adr1o    = (adr1o_nld45b_he_sphv_10hv)
+ adr1l    = (adr1l_nld45b_he_sphv_10hv)
+ adr1w    = (adr1w_nld45b_he_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld45b_he_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_he_sphv_10hv)
+ adr3o    = (adr3o_nld45b_he_sphv_10hv)
+ adr3l    = (adr3l_nld45b_he_sphv_10hv)
+ adr3w    = (adr3w_nld45b_he_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_he_sphv_10hv)
+ adr4l    = (adr4l_nld45b_he_sphv_10hv)
+ adr4w    = (adr4w_nld45b_he_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_he_sphv_10hv)
+ adr5l    = (adr5l_nld45b_he_sphv_10hv)
+ adr5w    = (adr5w_nld45b_he_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_he_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_he_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_he_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_he_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_he_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_he_sphv_10hv)
+ strthao   = (strthao_nld45b_he_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld45b_he_sphv_10hv*delr_rsh_nld45b_he_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_he_ronratio))*(fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_he_sphv_10hv+(1e-6)*dela_xw_nld45b_he_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_he_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_he_sphv_10hv)
+ xlw      = (xlw_nld45b_he_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_he_sphv_10hv)
+ nst      = (nst_nld45b_he_sphv_10hv)
+ ats      = (ats_nld45b_he_sphv_10hv)
+ dfinf    = (dfinf_nld45b_he_sphv_10hv)
+ dfw      = (dfw_nld45b_he_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_he_sphv_10hv)
+ dflw     = (dflw_nld45b_he_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_he_sphv_10hv)
+ ecrit    = (ecrit_nld45b_he_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_he_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ du       = (du_nld45b_he_sphv_10hv)
+ tc1      = (tc1_nld45b_he_sphv_10hv)
+ tc2      = (tc2_nld45b_he_sphv_10hv)
+ tc1l     = (tc1l_nld45b_he_sphv_10hv)
+ tc2l     = (tc2l_nld45b_he_sphv_10hv)
+ tc1w     = (tc1w_nld45b_he_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_he_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_he_sphv_10hv)
+ theacc2  = (theacc2_nld45b_he_sphv_10hv)
+ aacc     = (aacc_nld45b_he_sphv_10hv)
+ rva      = (rva_nld45b_he_sphv_10hv)
+ dta      = (dta_nld45b_he_sphv_10hv)
+ trj      = (trj_nld45b_he_sphv_10hv)
+ cjarea   = (cjarea_nld45b_he_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_he_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_he_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_he_sphv_10hv)
+ vbisti   = (vbisti_nld45b_he_sphv_10hv)
+ vbigat   = (vbigat_nld45b_he_sphv_10hv)
+ parea    = (parea_nld45b_he_sphv_10hv)
+ psti     = (psti_nld45b_he_sphv_10hv)
+ pgat     = (pgat_nld45b_he_sphv_10hv)
+ is1area  = (is1area_nld45b_he_sphv_10hv)
+ ttarea   = (ttarea_nld45b_he_sphv_10hv)
+ is2area  = (is2area_nld45b_he_sphv_10hv)
+ irarea   = (irarea_nld45b_he_sphv_10hv)
+ stis1area = (stis1area_nld45b_he_sphv_10hv)
+ stis2area = (stis2area_nld45b_he_sphv_10hv)
+ stirarea = (stirarea_nld45b_he_sphv_10hv)
+ n1area   = (n1area_nld45b_he_sphv_10hv)
+ n2area   = (n2area_nld45b_he_sphv_10hv)
+ nrarea   = (nrarea_nld45b_he_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_he_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_he_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_he_sphv_10hv)
+ irlsti   = (irlsti_nld45b_he_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_he_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_he_sphv_10hv)
+ stirsti  = (stirsti_nld45b_he_sphv_10hv)
+ n1sti    = (n1sti_nld45b_he_sphv_10hv)
+ n2sti    = (n2sti_nld45b_he_sphv_10hv)
+ nrsti    = (nrsti_nld45b_he_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_he_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_he_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_he_sphv_10hv)
+ irlgat   = (irlgat_nld45b_he_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_he_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_he_sphv_10hv)
+ stirgat  = (stirgat_nld45b_he_sphv_10hv)
+ n1gat    = (n1gat_nld45b_he_sphv_10hv)
+ n2gat    = (n2gat_nld45b_he_sphv_10hv)
+ nrgat    = (nrgat_nld45b_he_sphv_10hv)
+ cjaread  = (cjaread_nld45b_he_sphv_10hv*delr_cj_nld45b_he_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_he_sphv_10hv)
+ vbistid  = (vbistid_nld45b_he_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_he_sphv_10hv)
+ paread   = (paread_nld45b_he_sphv_10hv)
+ pstid    = (pstid_nld45b_he_sphv_10hv)
+ pgatd    = (pgatd_nld45b_he_sphv_10hv)
+ is1aread = (is1aread_nld45b_he_sphv_10hv*delr_is_nld45b_he_sphv_10hv)
+ ttaread  = (ttaread_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2aread = (is2aread_nld45b_he_sphv_10hv*delr_is2_nld45b_he_sphv_10hv)
+ iraread  = (iraread_nld45b_he_sphv_10hv*delr_ir_nld45b_he_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_he_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_he_sphv_10hv)
+ stiraread = (stiraread_nld45b_he_sphv_10hv)
+ n1aread  = (n1aread_nld45b_he_sphv_10hv)
+ n2aread  = (n2aread_nld45b_he_sphv_10hv)
+ nraread  = (nraread_nld45b_he_sphv_10hv)
+ is1lstid = (is1aread_nld45b_he_sphv_10hv*djunc*delr_is_nld45b_he_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lstid = (is2aread_nld45b_he_sphv_10hv*djunc*delr_is2_nld45b_he_sphv_10hv)
+ irlstid  = (iraread_nld45b_he_sphv_10hv*djunc*delr_ir_nld45b_he_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_he_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_he_sphv_10hv)
+ stirstid = (stirstid_nld45b_he_sphv_10hv)
+ n1stid   = (n1stid_nld45b_he_sphv_10hv)
+ n2stid   = (n2stid_nld45b_he_sphv_10hv)
+ nrstid   = (nrstid_nld45b_he_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_he_sphv_10hv*djunc*delr_is_nld45b_he_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lgatd = (is2aread_nld45b_he_sphv_10hv*djunc*delr_is2_nld45b_he_sphv_10hv)
+ irlgatd  = (iraread_nld45b_he_sphv_10hv*djunc*delr_ir_nld45b_he_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_he_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_he_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_he_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_he_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_he_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_he_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_he_sphv_10hv*delr_cj_nld45b_he_sphv_10hv)
+ cjlstid2 = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_he_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_he_sphv_10hv)
+ paread2  = (paread2_nld45b_he_sphv_10hv)
+ pstid2   = (pstid2_nld45b_he_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_he_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2aread2 = (is2aread_nld45b_he_sphv_10hv)
+ iraread2 = (iraread2_nld45b_he_sphv_10hv*delr_ir_nld45b_he_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_he_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_he_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_he_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_he_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_he_sphv_10hv)
+ nraread2 = (nraread2_nld45b_he_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_he_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lstid2 = (is2aread_nld45b_he_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_he_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld45b_he_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_he_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_he_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_he_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_he_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_he_sphv_10hv)
+ eais1area		= eais1area_nld45b_he_sphv_10hv
+ eais2area		= eais2area_nld45b_he_sphv_10hv
+ eairarea		= eairarea_nld45b_he_sphv_10hv
+ eais1sti		= eais1sti_nld45b_he_sphv_10hv
+ eais2sti		= eais2sti_nld45b_he_sphv_10hv
+ eairsti	  = eairsti_nld45b_he_sphv_10hv
+ eais1gat		= eais1gat_nld45b_he_sphv_10hv
+ eais2gat		= eais2gat_nld45b_he_sphv_10hv
+ eairgat	  = eairgat_nld45b_he_sphv_10hv
+ eais1aread		= eais1aread_nld45b_he_sphv_10hv
+ eais2aread		= eais2aread_nld45b_he_sphv_10hv
+ eairaread		= eairaread_nld45b_he_sphv_10hv
+ eais1stid		= eais1stid_nld45b_he_sphv_10hv
+ eais2stid		= eais2stid_nld45b_he_sphv_10hv
+ eairstid		= eairstid_nld45b_he_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_he_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_he_sphv_10hv
+ eairgatd		= eairgatd_nld45b_he_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_he_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_he_sphv_10hv
+ eairaread2		= eairaread2_nld45b_he_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_he_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_he_sphv_10hv
+ eairstid2		= eairstid2_nld45b_he_sphv_10hv
+ ikfarea               = ikfarea_nld45b_he_sphv_10hv
+ ikflsti               = ikfarea_nld45b_he_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_he_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_he_sphv_10hv
+ stikfsti              = stikfarea_nld45b_he_sphv_10hv
+ stikfgat              = stikfarea_nld45b_he_sphv_10hv
+ ikfaread              = ikfaread_nld45b_he_sphv_10hv*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_he_sphv_10hv*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_he_sphv_10hv
+ stikfstid             = stikfaread_nld45b_he_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_he_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_he_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_he_sphv_10hv



include "./smos10hv_ade_dfrt.scs" section=nld45b_he_10hv_dfrt
ends


//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_tlp_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = (1)
+    selfheat                       = (1)
+    fscale			    = (1)
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_tlp_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_tlp_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_tlp_sphv_10hv
+    nsmm_dela_vfb_nld45b_tlp_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_tlp_sphv_10hv
+    nsmm_dela_vtw_nld45b_tlp_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_tlp_sphv_10hv
+    nsmm_delr_mobref_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_tlp_sphv_10hv
+    nsmm_delr_rsh_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_tlp_sphv_10hv
+    nsmm_delr_vdscale_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_vdscale_nld45b_tlp_sphv_10hv
+    nsmm_delr_thesato_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_thesato_nld45b_tlp_sphv_10hv
+    nsmm_delr_nsub_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_tlp_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_tlp_vthratio = 1.0
+    presto_nld45b_tlp_ronratio = 0.01/1.6
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.55)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.7)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.5)
+    ldr1 			    = (0.55)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.505)
+    wd2g			    = (0.75)*(1-fem)
+    wg1			    = (1.45)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.55)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w+2*s2r)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w+2*s2r)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.78)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w+2*s2r)+0.5*pi4models*(rin_dr1-sg)*(rin_dr1-sg))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.499)
+    lacc                           = (0.539)
+    lch                            = (0.499)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    lflap                          = (1.05)
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*(-0.095))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*(0.505))*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    arplyfld_d                      = (apoly-ahole) //changed from ams3p8 name aplyfld_d, conflictd with psp_cap
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rgateout                       = (rply*(w+2*4.5*(1-fem))/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*arplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_tlp_sphv_10hv+tc2_ecrit_nld45b_tlp_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_tlp_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_tlp_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-1.5e-3))
+    delr_tox_nld45b_tlp_sphv_10hv      = (nom_delr_tox_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_tlp_sphv_10hv+nsmm_delr_gox_nld45b_tlp_sphv_10hv*smm_delr_gox_nld45b_tlp_sphv_10hv(l,w,ng)))
//+    delr_tox_nld45b_tlp_sphv_10hv      = (nom_delr_tox_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_tox_nld45b_tlp_sphv_10hv*sig_delr_tox_nld45b_tlp_sphv_10hv+nsmm_delr_gox_nld45b_tlp_sphv_10hv*smm_delr_gox_nld45b_tlp_sphv_10hv(l,w,ng)))
+    dela_xw_nld45b_tlp_sphv_10hv       = (nom_dela_xw_nld45b_tlp_sphv_10hv+nsig_dela_xw_nld45b_tlp_sphv_10hv*sig_dela_xw_nld45b_tlp_sphv_10hv+nsmm_dela_xw_nld45b_tlp_sphv_10hv*smm_dela_xw_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_tlp_sphv_10hv      = (nom_dela_vfb_nld45b_tlp_sphv_10hv+nsig_dela_vfb_nld45b_tlp_sphv_10hv*sig_dela_vfb_nld45b_tlp_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_tlp_sphv_10hv*smm_dela_vfb_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vtw_nld45b_tlp_sphv_10hv     = (nom_dela_vtw_nld45b_tlp_sphv_10hv+nsig_dela_vtw_nld45b_tlp_sphv_10hv*sig_dela_vtw_nld45b_tlp_sphv_10hv+nsmm_dela_vtw_nld45b_tlp_sphv_10hv*smm_dela_vtw_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_mobref_nld45b_tlp_sphv_10hv   = (nom_delr_mobref_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_tlp_sphv_10hv*sig_delr_mobref_nld45b_tlp_sphv_10hv+nsmm_delr_mobref_nld45b_tlp_sphv_10hv*smm_delr_mobref_nld45b_tlp_sphv_10hv(l,w,ng)))
+    delr_rsh_nld45b_tlp_sphv_10hv     = (nom_delr_rsh_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_tlp_sphv_10hv*sig_delr_rsh_nld45b_tlp_sphv_10hv)+nsmm_delr_rsh_nld45b_tlp_sphv_10hv*smm_delr_rsh_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_vdscale_nld45b_tlp_sphv_10hv     = (nom_delr_vdscale_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_vdscale_nld45b_tlp_sphv_10hv*sig_delr_vdscale_nld45b_tlp_sphv_10hv)+nsmm_delr_vdscale_nld45b_tlp_sphv_10hv*smm_delr_vdscale_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_thesato_nld45b_tlp_sphv_10hv     = (nom_delr_thesato_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_thesato_nld45b_tlp_sphv_10hv*sig_delr_thesato_nld45b_tlp_sphv_10hv)+nsmm_delr_thesato_nld45b_tlp_sphv_10hv*smm_delr_thesato_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_tlp_mosb_10hv      = (nom_dela_vfb_nld45b_tlp_mosb_10hv+nsig_dela_vfb_nld45b_tlp_mosb_10hv*sig_dela_vfb_nld45b_tlp_mosb_10hv)
+    delr_nsub_nld45b_tlp_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_tlp_sphv_10hv*smm_delr_nsub_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_cj_nld45b_tlp_sphv_10hv        = ((nom_delr_cj_nld45b_tlp_sphv_10hv*(1+nsig_delr_cj_nld45b_tlp_sphv_10hv*sig_delr_cj_nld45b_tlp_sphv_10hv)))
+    delr_is_nld45b_tlp_sphv_10hv = (nom_delr_is_nld45b_tlp_sphv_10hv*exp(sig_delr_is_nld45b_tlp_sphv_10hv*nsig_delr_is_nld45b_tlp_sphv_10hv))
+    delr_is2_nld45b_tlp_sphv_10hv = (nom_delr_is2_nld45b_tlp_sphv_10hv*exp(sig_delr_is2_nld45b_tlp_sphv_10hv*nsig_delr_is2_nld45b_tlp_sphv_10hv))
+    delr_ir_nld45b_tlp_sphv_10hv = (nom_delr_ir_nld45b_tlp_sphv_10hv*exp(sig_delr_ir_nld45b_tlp_sphv_10hv*nsig_delr_ir_nld45b_tlp_sphv_10hv))
// bin parameters
+    dwvdscale =(dwvdscale_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_tlp_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(3)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ uo_ng_del =	  (0.12)
+ uo_ng_fac =	  (ngeff/(ngeff+uo_ng_del))/(2/(2+uo_ng_del))
+ dvth_ng=(0)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0.1)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ adr1w_ng_del =   (0.45)
+ adr1w_ng_fac =   (ngeff/(ngeff+adr1w_ng_del))/(2/(2+adr1w_ng_del))
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(0.09)*(1-fem)
// simple model
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.78)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}

// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (69+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rgatetot)
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+     dphibo=(dphibo_nld45b_tlp_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_tlp_pspmoscap_10hv+dela_vfb_nld45b_tlp_sphv_10hv)
+     nsubo=(nsubo_nld45b_tlp_sphv_10hv)
+     nsubw=(nsubw_nld45b_tlp_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =(amoscap/l-w_nld45b_tlp_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_tlp_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_tlp_mosb_10hv)
+ wdrift     =(w_nld45b_tlp_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_tlp_mosb_10hv)+(stdelvto_nld45b_tlp_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)+(dela_vfb_nld45b_tlp_mosb_10hv)
+ factuo     =(factuo_nld45b_tlp_mosb_10hv)*(1+(stfactuo_nld45b_tlp_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=(vdscale_nld45b_tlp_sphv_10hv)*(1+dwvdscale/weff+dwvdscalew/(weff*weff))*(delr_vdscale_nld45b_tlp_sphv_10hv)
+ stvdscale=(stvdscale_nld45b_tlp_sphv_10hv)
+ ctgo=(ctgo_nld45b_tlp_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (1)
+ swexp    = (1)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_tlp_sphv_10hv)
+ qmc      = (qmc_nld45b_tlp_sphv_10hv)
+ lvaro    = (lvaro_nld45b_tlp_sphv_10hv)
+ lvarl    = (lvarl_nld45b_tlp_sphv_10hv)
+ lvarw    = (lvarw_nld45b_tlp_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_tlp_sphv_10hv)
+ wvaro    = (wvaro_nld45b_tlp_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_tlp_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_tlp_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_tlp_sphv_10hv+0.5e-6*dela_dw_nld45b_tlp_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_tlp_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_tlp_sphv_10hv)
+ dwq      = (dwq_nld45b_tlp_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_tlp_sphv_10hv+dela_vfb_nld45b_tlp_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_tlp_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_tlp_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_tlp_sphv_10hv+dela_vtw_nld45b_tlp_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_tlp_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_tlp_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_tlp_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_tlp_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_tlp_sphv_10hv)
+ nsubo    = (nsubo_nld45b_tlp_sphv_10hv*delr_nsub_nld45b_tlp_sphv_10hv)
+ nsubw    = (nsubw_nld45b_tlp_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_tlp_sphv_10hv)
+ npck     = (npck_nld45b_tlp_sphv_10hv)
+ npckw    = (npckw_nld45b_tlp_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_tlp_sphv_10hv)
+ lpck     = (lpck_nld45b_tlp_sphv_10hv)
+ lpckw    = (lpckw_nld45b_tlp_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_tlp_sphv_10hv)
+ fol2     = (fol2_nld45b_tlp_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_tlp_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_tlp_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_tlp_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_tlp_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_tlp_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_tlp_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_tlp_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_tlp_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_tlp_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_tlp_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_tlp_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_tlp_sphv_10hv)
+ nslpo    = (nslpo_nld45b_tlp_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_tlp_sphv_10hv)
+ dphibo   = (dphibo_nld45b_tlp_sphv_10hv)
+ dphibl   = (dphibl_nld45b_tlp_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_tlp_sphv_10hv)
+ dphibw   = (dphibw_nld45b_tlp_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_tlp_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_tlp_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_tlp_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_tlp_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_tlp_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_tlp_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_tlp_sphv_10hv)
+ npl      = (npl_nld45b_tlp_sphv_10hv)
+ cto      = (cto_nld45b_tlp_sphv_10hv)
+ ctl      = (ctl_nld45b_tlp_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_tlp_sphv_10hv)
+ ctw      = (ctw_nld45b_tlp_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_tlp_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ lov      = (lov_nld45b_tlp_sphv_10hv)
+ dlovd    = (dlovd_nld45b_tlp_sphv_10hv)
+ novo     = (novo_nld45b_tlp_sphv_10hv)
+ novdo    = (novdo_nld45b_tlp_sphv_10hv)
+ cfl      = (cfl_nld45b_tlp_sphv_10hv)
+ cflexp   = (cflexp_nld45b_tlp_sphv_10hv)
+ cfw      = (cfw_nld45b_tlp_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_tlp_sphv_10hv)
+ uo       = (uo_nld45b_tlp_sphv_10hv*delr_mobref_nld45b_tlp_sphv_10hv*delr_u0_relimo)*(weff/w)*(uo_ng_fac)
+ fbet1    = (fbet1_nld45b_tlp_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_tlp_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_tlp_sphv_10hv)
+ lp1w     = (lp1w_nld45b_tlp_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_tlp_sphv_10hv)
+ lp2      = (lp2_nld45b_tlp_sphv_10hv)
+ betw1    = (betw1_nld45b_tlp_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_tlp_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_tlp_sphv_10hv)
+ stbeto   = (stbeto_nld45b_tlp_sphv_10hv)
+ stbetl   = (stbetl_nld45b_tlp_sphv_10hv)
+ stbetw   = (stbetw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_tlp_sphv_10hv)
+ muew     = (muew_nld45b_tlp_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_tlp_sphv_10hv)
+ themuo   = (themuo_nld45b_tlp_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_tlp_sphv_10hv)
+ cso      = (cso_nld45b_tlp_sphv_10hv)
+ csl      = (csl_nld45b_tlp_sphv_10hv)
+ cslexp   = (cslexp_nld45b_tlp_sphv_10hv)
+ csw      = (csw_nld45b_tlp_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_tlp_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_tlp_sphv_10hv)
+ xcoro    = (xcoro_nld45b_tlp_sphv_10hv)
+ xcorl    = (xcorl_nld45b_tlp_sphv_10hv)
+ xcorw    = (xcorw_nld45b_tlp_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_tlp_sphv_10hv)
+ fetao    = (fetao_nld45b_tlp_sphv_10hv)
+ rsw1     = (rsw1_nld45b_tlp_sphv_10hv)
+ rsw2     = (rsw2_nld45b_tlp_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_tlp_sphv_10hv)
+ rsbo     = (rsbo_nld45b_tlp_sphv_10hv)
+ rsgo     = (rsgo_nld45b_tlp_sphv_10hv)
+ thesato  = (thesato_nld45b_tlp_sphv_10hv*delr_thesato_nld45b_tlp_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_tlp_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_tlp_sphv_10hv)
+ thesatw  = (thesatw_nld45b_tlp_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_tlp_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_tlp_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_tlp_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_tlp_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_tlp_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_tlp_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_tlp_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_tlp_sphv_10hv)
+ axl      = (axl_nld45b_tlp_sphv_10hv)
+ alpl     = (alpl_nld45b_tlp_sphv_10hv)
+ alplexp  = (alplexp_nld45b_tlp_sphv_10hv)
+ alpw     = (alpw_nld45b_tlp_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_tlp_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_tlp_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_tlp_sphv_10hv)
+ alp1w    = (alp1w_nld45b_tlp_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_tlp_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_tlp_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_tlp_sphv_10hv)
+ alp2w    = (alp2w_nld45b_tlp_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_tlp_sphv_10hv)
+ a1o      = (a1o_nld45b_tlp_sphv_10hv)
+ a1l      = (a1l_nld45b_tlp_sphv_10hv)
+ a1w      = (a1w_nld45b_tlp_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_tlp_sphv_10hv)
+ sta2o    = (sta2o_nld45b_tlp_sphv_10hv)
+ a3o      = (a3o_nld45b_tlp_sphv_10hv)
+ a3l      = (a3l_nld45b_tlp_sphv_10hv)
+ a3w      = (a3w_nld45b_tlp_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_tlp_sphv_10hv)
+ a4l      = (a4l_nld45b_tlp_sphv_10hv)
+ a4w      = (a4w_nld45b_tlp_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_tlp_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_tlp_sphv_10hv)
+ igovw    = (igovw_nld45b_tlp_sphv_10hv)
+ igovdw   = (igovdw_nld45b_tlp_sphv_10hv)
+ stigo    = (stigo_nld45b_tlp_sphv_10hv)
+ gc2o     = (gc2o_nld45b_tlp_sphv_10hv)
+ gc3o     = (gc3o_nld45b_tlp_sphv_10hv)
+ chibo    = (chibo_nld45b_tlp_sphv_10hv)
+ agidlw   = (agidlw_nld45b_tlp_sphv_10hv*(1-fem))
+ agidldw  = (agidldw_nld45b_tlp_sphv_10hv*(1-fem))
+ bgidlo   = (bgidlo_nld45b_tlp_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_tlp_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_tlp_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_tlp_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_tlp_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_tlp_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_tlp_sphv_10hv)
+ cfrw     = (cfrw_nld45b_tlp_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_tlp_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_tlp_sphv_10hv)
+ nfalw    = (nfalw_nld45b_tlp_sphv_10hv)
+ nfblw    = (nfblw_nld45b_tlp_sphv_10hv)
+ nfclw    = (nfclw_nld45b_tlp_sphv_10hv)
+ efo      = (efo_nld45b_tlp_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_tlp_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_tlp_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_tlp_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_tlp_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_tlp_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_tlp_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_tlp_sphv_10hv)
+ kuowel   = (kuowel_nld45b_tlp_sphv_10hv)
+ kuowew   = (kuowew_nld45b_tlp_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_tlp_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_tlp_sphv_10hv)
+ rsh      = (rsh_nld45b_tlp_sphv_10hv)
+ rbulko   = (rbulko_nld45b_tlp_sphv_10hv)
+ rwello   = (rwello_nld45b_tlp_sphv_10hv)
+ rjunso   = (rjunso_nld45b_tlp_sphv_10hv/(weff+dwrjunso_nld45b_tlp_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_tlp_sphv_10hv/(weff+dwrjundo_nld45b_tlp_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_tlp_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_tlp_sphv_10hv)
+ rshg     = (rshg_nld45b_tlp_sphv_10hv)
+ dlsil    = (dlsil_nld45b_tlp_sphv_10hv)
+ saref    = (saref_nld45b_tlp_sphv_10hv)
+ sbref    = (sbref_nld45b_tlp_sphv_10hv)
+ wlod     = (wlod_nld45b_tlp_sphv_10hv)
+ kuo      = (kuo_nld45b_tlp_sphv_10hv)
+ kvsat    = (kvsat_nld45b_tlp_sphv_10hv)
+ tkuo     = (tkuo_nld45b_tlp_sphv_10hv)
+ lkuo     = (lkuo_nld45b_tlp_sphv_10hv)
+ wkuo     = (wkuo_nld45b_tlp_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_tlp_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_tlp_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_tlp_sphv_10hv)
+ kvtho    = (kvtho_nld45b_tlp_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_tlp_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_tlp_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_tlp_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_tlp_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_tlp_sphv_10hv)
+ stetao   = (stetao_nld45b_tlp_sphv_10hv)
+ lodetao  = (lodetao_nld45b_tlp_sphv_10hv)
+ scref    = (scref_nld45b_tlp_sphv_10hv)
+ web      = (web_nld45b_tlp_sphv_10hv)
+ wec      = (wec_nld45b_tlp_sphv_10hv)
+ adr1o    = (adr1o_nld45b_tlp_sphv_10hv)
+ adr1l    = (adr1l_nld45b_tlp_sphv_10hv)
+ adr1w    = ((adr1w_nld45b_tlp_sphv_10hv)/(weff)*(adr1w_ng_fac))*(1-fem)
+ adr2o    = (adr2o_nld45b_tlp_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_tlp_sphv_10hv)
+ adr3o    = (adr3o_nld45b_tlp_sphv_10hv)
+ adr3l    = (adr3l_nld45b_tlp_sphv_10hv)
+ adr3w    = (adr3w_nld45b_tlp_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_tlp_sphv_10hv)
+ adr4l    = (adr4l_nld45b_tlp_sphv_10hv)
+ adr4w    = (adr4w_nld45b_tlp_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_tlp_sphv_10hv)
+ adr5l    = (adr5l_nld45b_tlp_sphv_10hv)
+ adr5w    = (adr5w_nld45b_tlp_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_tlp_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_tlp_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_tlp_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_tlp_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_tlp_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_tlp_sphv_10hv)
+ strthao   = (strthao_nld45b_tlp_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld45b_tlp_sphv_10hv*delr_rsh_nld45b_tlp_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_tlp_ronratio))*(fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_tlp_sphv_10hv+(1e-6)*dela_xw_nld45b_tlp_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_tlp_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_tlp_sphv_10hv)
+ xlw      = (xlw_nld45b_tlp_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_tlp_sphv_10hv)
+ nst      = (nst_nld45b_tlp_sphv_10hv)
+ ats      = (ats_nld45b_tlp_sphv_10hv)
+ dfinf    = (dfinf_nld45b_tlp_sphv_10hv)
+ dfw      = (dfw_nld45b_tlp_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_tlp_sphv_10hv)
+ dflw     = (dflw_nld45b_tlp_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_tlp_sphv_10hv)
+ ecrit    = (ecrit_nld45b_tlp_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_tlp_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ du       = (du_nld45b_tlp_sphv_10hv)
+ tc1      = (tc1_nld45b_tlp_sphv_10hv)
+ tc2      = (tc2_nld45b_tlp_sphv_10hv)
+ tc1l     = (tc1l_nld45b_tlp_sphv_10hv)
+ tc2l     = (tc2l_nld45b_tlp_sphv_10hv)
+ tc1w     = (tc1w_nld45b_tlp_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_tlp_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_tlp_sphv_10hv)
+ theacc2  = (theacc2_nld45b_tlp_sphv_10hv)
+ aacc     = (aacc_nld45b_tlp_sphv_10hv)
+ rva      = (rva_nld45b_tlp_sphv_10hv)
+ dta      = (dta_nld45b_tlp_sphv_10hv)
+ trj      = (trj_nld45b_tlp_sphv_10hv)
+ cjarea   = (cjarea_nld45b_tlp_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_tlp_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_tlp_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_tlp_sphv_10hv)
+ vbisti   = (vbisti_nld45b_tlp_sphv_10hv)
+ vbigat   = (vbigat_nld45b_tlp_sphv_10hv)
+ parea    = (parea_nld45b_tlp_sphv_10hv)
+ psti     = (psti_nld45b_tlp_sphv_10hv)
+ pgat     = (pgat_nld45b_tlp_sphv_10hv)
+ is1area  = (is1area_nld45b_tlp_sphv_10hv)
+ ttarea   = (ttarea_nld45b_tlp_sphv_10hv)
+ is2area  = (is2area_nld45b_tlp_sphv_10hv)
+ irarea   = (irarea_nld45b_tlp_sphv_10hv)
+ stis1area = (stis1area_nld45b_tlp_sphv_10hv)
+ stis2area = (stis2area_nld45b_tlp_sphv_10hv)
+ stirarea = (stirarea_nld45b_tlp_sphv_10hv)
+ n1area   = (n1area_nld45b_tlp_sphv_10hv)
+ n2area   = (n2area_nld45b_tlp_sphv_10hv)
+ nrarea   = (nrarea_nld45b_tlp_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_tlp_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_tlp_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_tlp_sphv_10hv)
+ irlsti   = (irlsti_nld45b_tlp_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_tlp_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_tlp_sphv_10hv)
+ stirsti  = (stirsti_nld45b_tlp_sphv_10hv)
+ n1sti    = (n1sti_nld45b_tlp_sphv_10hv)
+ n2sti    = (n2sti_nld45b_tlp_sphv_10hv)
+ nrsti    = (nrsti_nld45b_tlp_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_tlp_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_tlp_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_tlp_sphv_10hv)
+ irlgat   = (irlgat_nld45b_tlp_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_tlp_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_tlp_sphv_10hv)
+ stirgat  = (stirgat_nld45b_tlp_sphv_10hv)
+ n1gat    = (n1gat_nld45b_tlp_sphv_10hv)
+ n2gat    = (n2gat_nld45b_tlp_sphv_10hv)
+ nrgat    = (nrgat_nld45b_tlp_sphv_10hv)
+ cjaread  = (cjaread_nld45b_tlp_sphv_10hv*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_tlp_sphv_10hv)
+ vbistid  = (vbistid_nld45b_tlp_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_tlp_sphv_10hv)
+ paread   = (paread_nld45b_tlp_sphv_10hv)
+ pstid    = (pstid_nld45b_tlp_sphv_10hv)
+ pgatd    = (pgatd_nld45b_tlp_sphv_10hv)
+ is1aread = (is1aread_nld45b_tlp_sphv_10hv*delr_is_nld45b_tlp_sphv_10hv)
+ ttaread  = (ttaread_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2aread = (is2aread_nld45b_tlp_sphv_10hv*delr_is2_nld45b_tlp_sphv_10hv)
+ iraread  = (iraread_nld45b_tlp_sphv_10hv*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_tlp_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_tlp_sphv_10hv)
+ stiraread = (stiraread_nld45b_tlp_sphv_10hv)
+ n1aread  = (n1aread_nld45b_tlp_sphv_10hv)
+ n2aread  = (n2aread_nld45b_tlp_sphv_10hv)
+ nraread  = (nraread_nld45b_tlp_sphv_10hv)
+ is1lstid = (is1aread_nld45b_tlp_sphv_10hv*djunc*delr_is_nld45b_tlp_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lstid = (is2aread_nld45b_tlp_sphv_10hv*djunc*delr_is2_nld45b_tlp_sphv_10hv)
+ irlstid  = (iraread_nld45b_tlp_sphv_10hv*djunc*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_tlp_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_tlp_sphv_10hv)
+ stirstid = (stirstid_nld45b_tlp_sphv_10hv)
+ n1stid   = (n1stid_nld45b_tlp_sphv_10hv)
+ n2stid   = (n2stid_nld45b_tlp_sphv_10hv)
+ nrstid   = (nrstid_nld45b_tlp_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_tlp_sphv_10hv*djunc*delr_is_nld45b_tlp_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lgatd = (is2aread_nld45b_tlp_sphv_10hv*djunc*delr_is2_nld45b_tlp_sphv_10hv)
+ irlgatd  = (iraread_nld45b_tlp_sphv_10hv*djunc*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_tlp_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_tlp_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_tlp_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_tlp_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_tlp_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_tlp_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_tlp_sphv_10hv*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlstid2 = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_tlp_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_tlp_sphv_10hv)
+ paread2  = (paread2_nld45b_tlp_sphv_10hv)
+ pstid2   = (pstid2_nld45b_tlp_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_tlp_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2aread2 = (is2aread_nld45b_tlp_sphv_10hv)
+ iraread2 = (iraread2_nld45b_tlp_sphv_10hv*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_tlp_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_tlp_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_tlp_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_tlp_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_tlp_sphv_10hv)
+ nraread2 = (nraread2_nld45b_tlp_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_tlp_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lstid2 = (is2aread_nld45b_tlp_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_tlp_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld45b_tlp_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_tlp_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_tlp_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_tlp_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_tlp_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_tlp_sphv_10hv)
+ eais1area		= eais1area_nld45b_tlp_sphv_10hv
+ eais2area		= eais2area_nld45b_tlp_sphv_10hv
+ eairarea		= eairarea_nld45b_tlp_sphv_10hv
+ eais1sti		= eais1sti_nld45b_tlp_sphv_10hv
+ eais2sti		= eais2sti_nld45b_tlp_sphv_10hv
+ eairsti	  = eairsti_nld45b_tlp_sphv_10hv
+ eais1gat		= eais1gat_nld45b_tlp_sphv_10hv
+ eais2gat		= eais2gat_nld45b_tlp_sphv_10hv
+ eairgat	  = eairgat_nld45b_tlp_sphv_10hv
+ eais1aread		= eais1aread_nld45b_tlp_sphv_10hv
+ eais2aread		= eais2aread_nld45b_tlp_sphv_10hv
+ eairaread		= eairaread_nld45b_tlp_sphv_10hv
+ eais1stid		= eais1stid_nld45b_tlp_sphv_10hv
+ eais2stid		= eais2stid_nld45b_tlp_sphv_10hv
+ eairstid		= eairstid_nld45b_tlp_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_tlp_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_tlp_sphv_10hv
+ eairgatd		= eairgatd_nld45b_tlp_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_tlp_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_tlp_sphv_10hv
+ eairaread2		= eairaread2_nld45b_tlp_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_tlp_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_tlp_sphv_10hv
+ eairstid2		= eairstid2_nld45b_tlp_sphv_10hv
+ ikfarea               = ikfarea_nld45b_tlp_sphv_10hv
+ ikflsti               = ikfarea_nld45b_tlp_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_tlp_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_tlp_sphv_10hv
+ stikfsti              = stikfarea_nld45b_tlp_sphv_10hv
+ stikfgat              = stikfarea_nld45b_tlp_sphv_10hv
+ ikfaread              = ikfaread_nld45b_tlp_sphv_10hv*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_tlp_sphv_10hv*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfstid             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_tlp_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_tlp_sphv_10hv




include "./smos10hv_ade_dfrt.scs" section=nld45b_tlp_10hv_dfrt
ends

// nld100_10hv

subckt nld100_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model, release value
// they are instance parameters, but invisible to the designers,  this means CDF will not use those parameters.
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
//*support mismatch
//*******************************************************************************************************
+    nsmm_delr_tox_nld100_sphv_10hv  = tmp_nsmm_delr_tox_nld100_sphv_10hv
+    nsmm_dela_dw_nld100_sphv_10hv   = tmp_nsmm_dela_dw_nld100_sphv_10hv
+    nsmm_dela_vfb_nld100_sphv_10hv  = tmp_nsmm_dela_vfb_nld100_sphv_10hv
+    nsmm_delr_mobref_nld100_sphv_10hv = tmp_nsmm_delr_mobref_nld100_sphv_10hv
+    nsmm_delr_rshl_nld100_sphv_10hv = tmp_nsmm_delr_rshl_nld100_sphv_10hv
+    nsmm_delr_nsub_nld100_sphv_10hv = tmp_nsmm_delr_nsub_nld100_sphv_10hv
+    l                              = (0.65)
//*******************************************************************************************************
//*relimo model parameters
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+    vfbmm_temp = sqrt(1-2.45e-3*(temp-27))
+    delr_tox_nld100_sphv_10hv      = (nom_delr_tox_nld100_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld100_sphv_10hv+nsmm_delr_tox_nld100_sphv_10hv*smm_delr_tox_nld100_sphv_10hv(l,w)/sqrt(ng)))
//+    delr_tox_nld100_sphv_10hv      = (nom_delr_tox_nld100_sphv_10hv*(1.0+nsig_delr_tox_nld100_sphv_10hv*sig_delr_tox_nld100_sphv_10hv+nsmm_delr_tox_nld100_sphv_10hv*smm_delr_tox_nld100_sphv_10hv(l,w)/sqrt(ng)))
+    dela_dw_nld100_sphv_10hv       = (nsmm_dela_dw_nld100_sphv_10hv*smm_dela_dw_nld100_sphv_10hv(l,w)/sqrt(ng))
+    dela_vfb_nld100_sphv_10hv      = (nom_dela_vfb_nld100_sphv_10hv+nsig_dela_vfb_nld100_sphv_10hv*sig_dela_vfb_nld100_sphv_10hv+nsmm_dela_vfb_nld100_sphv_10hv*smm_dela_vfb_nld100_sphv_10hv(l,w)*(vfbmm_temp)/sqrt(ng))
+    dela_vfbw_nld100_sphv_10hv     = (nom_dela_vfbw_nld100_sphv_10hv+nsig_dela_vfbw_nld100_sphv_10hv*sig_dela_vfbw_nld100_sphv_10hv)
+    delr_mobref_nld100_sphv_10hv   = (1.0+nsmm_delr_mobref_nld100_sphv_10hv*smm_delr_mobref_nld100_sphv_10hv(l,w)/sqrt(ng))
+    dela_vdscale_nld100_sphv_10hv   = (nom_dela_vdscale_nld100_sphv_10hv+nsig_dela_vdscale_nld100_sphv_10hv*sig_dela_vdscale_nld100_sphv_10hv)
+    dela_vdscalew_nld100_sphv_10hv   = (nom_dela_vdscalew_nld100_sphv_10hv+nsig_dela_vdscalew_nld100_sphv_10hv*sig_dela_vdscalew_nld100_sphv_10hv)
+    dela_thesatgo_nld100_sphv_10hv   = (nom_dela_thesatgo_nld100_sphv_10hv+nsig_dela_thesatgo_nld100_sphv_10hv*sig_dela_thesatgo_nld100_sphv_10hv)
+    delr_rshl_nld100_sphv_10hv     = (nom_delr_rshl_nld100_sphv_10hv*(1.0+nsig_delr_rshl_nld100_sphv_10hv*sig_delr_rshl_nld100_sphv_10hv+nsmm_delr_rshl_nld100_sphv_10hv*smm_delr_rshl_nld100_sphv_10hv(l,w)/sqrt(ng)))
+    dela_xw_nld100_sphv_10hv       = (nom_dela_xw_nld100_sphv_10hv+nsig_dela_xw_nld100_sphv_10hv*sig_dela_xw_nld100_sphv_10hv)
+    delr_nsub_nld100_sphv_10hv     = (1+nsmm_delr_nsub_nld100_sphv_10hv*smm_delr_nsub_nld100_sphv_10hv(l,w)/sqrt(ng))
+    delr_cj_nld100_sphv_10hv 	        =(nom_delr_cj_nld100_sphv_10hv*(1.0+nsig_delr_cj_nld100_sphv_10hv*sig_delr_cj_nld100_sphv_10hv))
+    delr_is_nld100_sphv_10hv    	=(nom_delr_is_nld100_sphv_10hv*exp(nsig_delr_is_nld100_sphv_10hv*sig_delr_is_nld100_sphv_10hv))
+    delr_is2_nld100_sphv_10hv    	=(nom_delr_is2_nld100_sphv_10hv*exp(nsig_delr_is2_nld100_sphv_10hv*sig_delr_is2_nld100_sphv_10hv))
+    delr_ir_nld100_sphv_10hv 	        =(nom_delr_ir_nld100_sphv_10hv*exp(nsig_delr_ir_nld100_sphv_10hv*sig_delr_ir_nld100_sphv_10hv))

//dummy gate parameters
+    ng_dmy=(2*sti_dummy)
+    ngeff=(ng+ng_dmy)
+    ndi_eff=(ngeff/2)
+    nsi_eff=((ngeff-2)/2)


//*******************************************************************************************************
//*global and process variables
//*******************************************************************************************************
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    djunc                          = (2.5e-6)  //should not scaled by scale as it is vertical


//*********************************************************************************
//*  fixed parameters and expressions
//*********************************************************************************
+    lch                            = (0.65) // alias to l
+    lacc                           = (0.6)  // alias to ldr1
//+    wdel                           = (2.15)*(1-fem)// =wncom-w
+    ld                             = (6.455)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lch+lacc+ld)  //this distance is the same inside the device and at the edge finger.
+    lflap 			    = (2.15)
+    xiso                           = (1.275)
+    yiso                           = ((10.96)*(1-fem))
+    wdrift                         = (w)
+    ldrift                         = (5.5)
+    ldr1                           = (0.6)
+    lacts                          = (0.455)
+    lactd                          = (1.21)

//*calculated dimensions
+    numbernplus                    = (int_round((w-(0.18*2+0.42)*(1-fem))/0.84))+1*(1-fem)
+    weff                           = (numbernplus*0.42)	// will apply to uoeff=uo*weff/w

//*extracted dimensions
+    lovlap                         = (0.00)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrs                           = (0.02)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrd                           = (0)       // tune par for cfr_ply_s & cfr_ply_d
+    tfact_ecrit=1+(tc1_ecrit_nld100_sphv_10hv+tc2_ecrit_nld100_sphv_10hv*(temp-tnom))*(temp-tnom)

//*simple model factor
+    swdrlin  = (2)  
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*1.01)


//*------------------------------------
//*calculations for parasitic diodes
//*------------------------------------
//*ncom to pepi (drain to source+body)
+    rncom_end                      = 1.25
+    od2ncom                        = 9.2
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*od2ncom*(1-fem))
+    ancom                          = (xncom*yncom-0.5*(4-pi4models)*rncom_end*rncom_end*(1-fem))
+    pncom                          = (2*xncom+yncom-(4-pi4models)*rncom_end)*(1-fem)
//*junc par for sphv input
+    pd2_i          =2*(0.5*ldrift+0.5*lactd)*(1-fem)
+    pd_i           =(pncom-pd2_i)
+    ad2_i          =((0.5*ldrift+0.5*lactd)*yncom)
+    ad_i           =(ancom-ad2_i)
+    as_i           =0
+    ps_i           =0

//*capacitance to sub ng total
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub*(1-fem)+ysub))

//*-------------------------------------------------------
//*source drain capacitance area and length calculations
//*m1 and m2 parasitic capacitances ignored
//*-------------------------------------------------------
//*poly over field parasitic to drain and source
+    od2poly_w        =10.35
+    xpoly            =(lch+lacc+ld)
+    ypoly            =(w+od2poly_w*2*(1-fem))
+    lsplit           =0.7
+    od2poly_inner_l  =3
+    rhole        =0.6
+    od2poly_inner_w  =4.5

+    aplyfld_s        =xpoly*ypoly-ancom-w*lch
+    pplyfld_s        =(od2poly_w+xpoly)*2*(1-fem)
+    cgs_ply_fld_nld100=(aplyfld_s*cpp_ply_fld+pplyfld_s*cfr_ply_fld)	//ng=1

+    xhole            =(od2poly_inner_l+0.5*lactd)
+    yhole            =(w+od2poly_inner_w*2*(1-fem))
+    ahole            =xhole*yhole-(4-pi4models)*0.5*rhole*rhole*(1-fem)
+    phole            =(yhole+xhole*2*(1-fem)-(4-pi4models)*rhole*(1-fem))
+    psplit           =(w+(od2poly_inner_w*4+lsplit*2)*(1-fem))
+    aplyfld_d        =(ancom-w*lacc-lsplit*yhole-ahole)
+    pplyfld_d        =(psplit+phole)
+    cgd_ply_fld_nld100=(aplyfld_d*cpp_ply_fld+0*pplyfld_d*cfr_ply_fld)	//ng=1, turn off pplyfld_d to fit cgd data

// calculation for poly over field parasitic capaciance
+ dwcgdfldmoscap=32.5*(1-fem)
+ dwcgd_ply_fld=15*(1-fem)
+ cgd_ply_fld=0.85e-16*(w+dwcgd_ply_fld)

// parameters for veriloga
+ vp_nld100_10hv = (45-4)
+ dvp_nld100_10hv = (7)
+ type_nld100_10hv = (1)

//*accumulation area (poly over accum area)
//+ area_accum    = (((w+2*wdel*(1-fem))*lacc+0.5*pi4models*(1-fem)*((ld+lacc)*(ld+lacc)-(ld*ld))))
//+ ldr1_i	=((area_accum/w))   //ng=1 for sphv input

//*fringing capacitance (source side edge of poly wall)
+    lfring_s   = (w)

//*fringing capacitance (drain side edge of poly wall to aa)
+    lfring_d   = (w)

+    cfr_ply_s=(lfring_s)*(lfrs+lovlap)*cpp_ply_sdt   //ng=1
+    cfr_ply_d=(lfring_d)*(lfrd+lovlap)*cpp_ply_sdt   //ng=1


//*parasitic psp mosfet (poly over active on phv+pepi not over channel)
//+    xmosend                        = (2*(lch+lacc+ld))
//+    ymosend                        = (9.85)
//+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*wdel+0.5*pi4models*(ld+lacc)*(ld+lacc))))
//+    wmosend                        = ((amosend/lch)*(1-fem)+fem*1e-3)  //ng=1


//*m1 to poly gate capacitance:
// *check final pcell later
// *total width of source contacts facing gate
+    number_ct_s                    = (int_round((w+(2*8.85-0.18)*(1-fem))/(0.18+0.24))+1*(1-fem))
+    lfr_ct_ply_s                   = (number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-(2*0.075+0.18)*(1-fem))/(0.18+0.24))+1*(1-fem))
+    lfr_ct_ply_d                   = (number_ct_d*0.18)
+    lfr_m1_ply_s                   = ((w+2*8.85*(1-fem))-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (w-lfr_ct_ply_d)
+    cfr_s_ply_met_nld100_sphv_10hv           = (nom_cfr_s_ply_met_nld100_sphv_10hv*(nom_delr_cfr_s_ply_met_nld100_sphv_10hv+nsig_delr_cfr_s_ply_met_nld100_sphv_10hv*sig_delr_cfr_s_ply_met_nld100_sphv_10hv))
+    cfr_d_ply_met_nld100_sphv_10hv           = (nom_cfr_d_ply_met_nld100_sphv_10hv*(nom_delr_cfr_d_ply_met_nld100_sphv_10hv+nsig_delr_cfr_d_ply_met_nld100_sphv_10hv*sig_delr_cfr_d_ply_met_nld100_sphv_10hv))
+    cfr_s_ply_m1ct_nld100_sphv_10hv          = (nom_cfr_s_ply_m1ct_nld100_sphv_10hv*(nom_delr_cfr_s_ply_m1ct_nld100_sphv_10hv+nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv*sig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv))
+    cfr_d_ply_m1ct_nld100_sphv_10hv          = (nom_cfr_d_ply_m1ct_nld100_sphv_10hv*(nom_delr_cfr_d_ply_m1ct_nld100_sphv_10hv+nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv*sig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv))

+    cgs_ply_m1=(lfr_m1_ply_s*cfr_s_ply_met_nld100_sphv_10hv+lfr_ct_ply_s*cfr_s_ply_m1ct_nld100_sphv_10hv)
+    cgd_ply_m1=(lfr_m1_ply_d*cfr_d_ply_met_nld100_sphv_10hv+lfr_ct_ply_d*cfr_d_ply_m1ct_nld100_sphv_10hv)


//*poly gate resistance calculations
+    rgate                       = (rply*(w+2*10.35*(1-fem))/((lch+lacc+lflap)*3))

//**parameters for multi ng
+    fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*0.048*(1-fem))
+    fac_a_ng_vfbo= ((ngeff/(ngeff+0.2)-2/(2+0.2))*(-0.045))*(1-fem)
+    fac_r_ng_uo=(1+(ngeff/(ngeff+2)-2/(2+2))*0.11*(w/(w+4.0))*(1-fem))
+    fac_r_ng_ecrit=(1+(ngeff/(ngeff+1)-2/(2+1))*0.5*(w/(w+10.0))*(1-fem))

// parameters for the self-heating
+    w_heat    =w
+    l_heat    =lcell*ng
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f     =((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld100_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld100_sphv_10hv)*ngeff  //ng=1
+    cth_f     =((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff		//ng=1

// parasitic capacitance caused by dummy gate
//+     aply_fld_cgd_dmy=(0)
//+     pply_fld_cgd_dmy=(0)
//+     cgd_ply_fld_dmy=(0)

// parameters for the D/B diode trr
+ tt_nld100_10hv = 1.0e-9*maxa(6000*1/(w+20),0,1e-12)

// parameters for the BV diode
+ dcbv_nld100_10hv = (125)

// bin parameters
+    dwecrit =(dwecrit_nld100_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld100_sphv_10hv)*(1-fem)

// BV diode model card:
model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt   = (1e12)
+ tnom    = (27)
+ is      = (1e-30)
+ n       = (1.0)
+ cj      = (1e-30)
+ pta     = (0)
+ tlevc   = (2)
+ tlev    = (2)
+ bv      = (dcbv_nld100_10hv+bvdss_shift)
+ ibv     = (1e-5/1e-12)

model pspmoscap psp103t type=n
+tr=27
+toxo=toxo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv
+dphibo=dphibo_nld100_sphv_10hv-0.35
+dphibw=(dphibw_nld100_sphv_10hv+3.75)*(1-fem)
+vfbo=vfbo_nld100_sphv_10hv+dela_vfb_nld100_sphv_10hv-0.2
+nsubo=nsubo_nld100_sphv_10hv
+nsubw=(nsubw_nld100_sphv_10hv-1.4)*(1-fem)
+rtho=1e18 ctho=0 dwq=(0*(1-fem))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale  = (vdscale_nld100_sphv_10hv+dela_vdscale_nld100_sphv_10hv+(vdscalew_nld100_sphv_10hv+dela_vdscalew_nld100_sphv_10hv)*(1-fem)/w)
+ vdscaleb = (vdscaleb_nld100_sphv_10hv)
+ stvdscale= (stvdscale_nld100_sphv_10hv+(stvdscalew_nld100_sphv_10hv)*(1-fem)/w)
+ ctgo     = (0.02)
+ ctbo     = (0)
+ stcto    = (1.3)
+ strthao  = (1.55)
+ tr	   = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (1)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ qmc	   = (qmc_nld100_sphv_10hv)
+ lvaro    = (lvaro_nld100_sphv_10hv)
+ lvarl    = (lvarl_nld100_sphv_10hv)
+ lvarw    = (lvarw_nld100_sphv_10hv*(1-fem))
+ lap	   = (lap_nld100_sphv_10hv)
+ wvaro    = (wvaro_nld100_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld100_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld100_sphv_10hv*(1-fem))
+ wot	   = ((wot_nld100_sphv_10hv+0.5e-6*dela_dw_nld100_sphv_10hv)*(1-fem))
+ dlq	   = (dlq_nld100_sphv_10hv)
+ dwq	   = (dwq_nld100_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld100_sphv_10hv+dela_vfb_nld100_sphv_10hv+dela_vth_relimo+fac_a_ng_vfbo)
+ vfbl     = (vfbl_nld100_sphv_10hv)
+ vfbw     = ((vfbw_nld100_sphv_10hv+dela_vfbw_nld100_sphv_10hv)*(1-fem))
+ vfblw    = (vfblw_nld100_sphv_10hv*(1-fem))
+ stvfbo   = (stvfbo_nld100_sphv_10hv)*(1-maxa(-9e-3*(temp-27), 0, 1e-12))
+ stvfbl   = (stvfbl_nld100_sphv_10hv)
+ stvfbw   = (stvfbw_nld100_sphv_10hv*(1-maxa(-18e-2*(temp-27), 0, 1e-12))*(1-fem))
+ stvfblw  = (stvfblw_nld100_sphv_10hv*(1-fem))
+ toxo     = (toxo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ epsroxo  = (epsroxo_nld100_sphv_10hv)
+ nsubo    = (nsubo_nld100_sphv_10hv*delr_nsub_nld100_sphv_10hv)
+ nsubw    = (nsubw_nld100_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld100_sphv_10hv)
+ npck     = (npck_nld100_sphv_10hv)
+ npckw    = (npckw_nld100_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld100_sphv_10hv)
+ lpck     = (lpck_nld100_sphv_10hv)
+ lpckw    = (lpckw_nld100_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld100_sphv_10hv)
+ fol2     = (fol2_nld100_sphv_10hv)
+ facneffaco = (facneffaco_nld100_sphv_10hv)
+ facneffacl = (facneffacl_nld100_sphv_10hv)
+ facneffacw = (facneffacw_nld100_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld100_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld100_sphv_10hv)
+ gfacnudl = (gfacnudl_nld100_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld100_sphv_10hv)
+ gfacnudw = (gfacnudw_nld100_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld100_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld100_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld100_sphv_10hv)
+ vnsubo   = (vnsubo_nld100_sphv_10hv)
+ nslpo    = (nslpo_nld100_sphv_10hv)
+ dnsubo   = (dnsubo_nld100_sphv_10hv)
+ dphibo   = (dphibo_nld100_sphv_10hv)
+ dphibl   = (dphibl_nld100_sphv_10hv)
+ dphiblexp = (dphiblexp_nld100_sphv_10hv)
+ dphibw   = (dphibw_nld100_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld100_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld100_sphv_10hv)
+ delvtacl = (delvtacl_nld100_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld100_sphv_10hv)
+ delvtacw = (delvtacw_nld100_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_nld100_sphv_10hv*(1-fem))
+ npo	   = (npo_nld100_sphv_10hv)
+ npl	   = (npl_nld100_sphv_10hv)
+ cto	   = (cto_nld100_sphv_10hv)
+ ctl	   = (ctl_nld100_sphv_10hv)
+ ctlexp   = (ctlexp_nld100_sphv_10hv)
+ ctw	   = (ctw_nld100_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld100_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ toxovdo  = (toxovdo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ lov	   = (lov_nld100_sphv_10hv)
+ dlovd    = (dlovd_nld100_sphv_10hv)
+ novo     = (novo_nld100_sphv_10hv)
+ novdo    = (novdo_nld100_sphv_10hv)
+ cfl	   = (cfl_nld100_sphv_10hv)
+ cflexp   = (cflexp_nld100_sphv_10hv)
+ cfw	   = (cfw_nld100_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld100_sphv_10hv)
+ uo	   = (uo_nld100_sphv_10hv*(weff/w)*delr_mobref_nld100_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_nld100_sphv_10hv)
+ fbet1w   = (fbet1w_nld100_sphv_10hv*(1-fem))
+ lp1	   = (lp1_nld100_sphv_10hv)
+ lp1w     = (lp1w_nld100_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld100_sphv_10hv)
+ lp2	   = (lp2_nld100_sphv_10hv)
+ betw1    = (betw1_nld100_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld100_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld100_sphv_10hv)
+ stbeto   = (stbeto_nld100_sphv_10hv)
+ stbetl   = (stbetl_nld100_sphv_10hv)
+ stbetw   = (stbetw_nld100_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_nld100_sphv_10hv*(1-fem))
+ mueo     = (mueo_nld100_sphv_10hv)
+ muew     = (muew_nld100_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld100_sphv_10hv)
+ themuo   = (themuo_nld100_sphv_10hv)
+ stthemuo = (stthemuo_nld100_sphv_10hv)
+ cso	   = (cso_nld100_sphv_10hv)
+ csl	   = (csl_nld100_sphv_10hv)
+ cslexp   = (cslexp_nld100_sphv_10hv)
+ csw	   = (csw_nld100_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld100_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld100_sphv_10hv)
+ xcoro    = (xcoro_nld100_sphv_10hv)
+ xcorl    = (xcorl_nld100_sphv_10hv)
+ xcorw    = (xcorw_nld100_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_nld100_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_nld100_sphv_10hv)
+ fetao    = (fetao_nld100_sphv_10hv)
+ rsw1     = (rsw1_nld100_sphv_10hv)
+ rsw2     = (rsw2_nld100_sphv_10hv*(1-fem))
+ strso    = (strso_nld100_sphv_10hv)
+ rsbo     = (rsbo_nld100_sphv_10hv)
+ rsgo     = (rsgo_nld100_sphv_10hv)
+ thesato  = ((thesato_nld100_sphv_10hv)*(1+maxa(-0.5e-2*(w/(w+(1-fem)*3.0))*(temp-27),0,1e-9)))
+ thesatl  = (thesatl_nld100_sphv_10hv)
+ thesatlexp = (thesatlexp_nld100_sphv_10hv)
+ thesatw  = (thesatw_nld100_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld100_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld100_sphv_10hv)
+ stthesatl = (stthesatl_nld100_sphv_10hv)
+ stthesatw = (stthesatw_nld100_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_nld100_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_nld100_sphv_10hv)
+ thesatgo = (thesatgo_nld100_sphv_10hv+dela_thesatgo_nld100_sphv_10hv)
+ thesatgl = (thesatgl_nld100_sphv_10hv)
+ thesatgw = ((thesatgw_nld100_sphv_10hv)*(1-fem))
+ axo	   = (axo_nld100_sphv_10hv)
+ axl	   = (axl_nld100_sphv_10hv)
+ alpl     = (alpl_nld100_sphv_10hv)
+ alplexp  = (alplexp_nld100_sphv_10hv)
+ alpw     = (alpw_nld100_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld100_sphv_10hv)
+ alp1lexp = (alp1lexp_nld100_sphv_10hv)
+ alp1l2   = (alp1l2_nld100_sphv_10hv)
+ alp1w    = (alp1w_nld100_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld100_sphv_10hv)
+ alp2lexp = (alp2lexp_nld100_sphv_10hv)
+ alp2l2   = (alp2l2_nld100_sphv_10hv)
+ alp2w    = (alp2w_nld100_sphv_10hv*(1-fem))
+ vpo	   = (vpo_nld100_sphv_10hv)
+ a1o	   = (a1o_nld100_sphv_10hv)
+ a1l	   = (a1l_nld100_sphv_10hv)
+ a1w	   = (a1w_nld100_sphv_10hv*(1-fem))
+ a2o	   = (a2o_nld100_sphv_10hv)
+ sta2o    = (sta2o_nld100_sphv_10hv)
+ a3o	   = (a3o_nld100_sphv_10hv)
+ a3l	   = (a3l_nld100_sphv_10hv)
+ a3w	   = (a3w_nld100_sphv_10hv*(1-fem))
+ a4o	   = (a4o_nld100_sphv_10hv)
+ a4l	   = (a4l_nld100_sphv_10hv)
+ a4w	   = (a4w_nld100_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld100_sphv_10hv)
+ iginvlw  = (iginvlw_nld100_sphv_10hv)
+ igovw    = (igovw_nld100_sphv_10hv)
+ igovdw   = (igovdw_nld100_sphv_10hv)
+ stigo    = (stigo_nld100_sphv_10hv)
+ gc2o     = (gc2o_nld100_sphv_10hv)
+ gc3o     = (gc3o_nld100_sphv_10hv)
+ chibo    = (chibo_nld100_sphv_10hv)
+ agidlw   = (agidlw_nld100_sphv_10hv)
+ agidldw  = (agidldw_nld100_sphv_10hv)
+ bgidlo   = (bgidlo_nld100_sphv_10hv)
+ bgidldo  = (bgidldo_nld100_sphv_10hv)
+ stbgidlo = (stbgidlo_nld100_sphv_10hv)
+ stbgidldo = (stbgidldo_nld100_sphv_10hv)
+ cgidlo   = (cgidlo_nld100_sphv_10hv)
+ cgidldo  = (cgidldo_nld100_sphv_10hv)
+ cgbovl   = (cgbovl_nld100_sphv_10hv)
+ cfrw     = (cfrw_nld100_sphv_10hv)
+ cfrdw    = (cfrdw_nld100_sphv_10hv)
+ fnto     = (fnto_nld100_sphv_10hv)
+ nfalw    = (nfalw_nld100_sphv_10hv)
+ nfblw    = (nfblw_nld100_sphv_10hv)
+ nfclw    = (nfclw_nld100_sphv_10hv)
+ efo	   = (efo_nld100_sphv_10hv)
+ lintnoi  = (lintnoi_nld100_sphv_10hv)
+ alpnoi   = (alpnoi_nld100_sphv_10hv)
+ kvthoweo = (kvthoweo_nld100_sphv_10hv)
+ kvthowel = (kvthowel_nld100_sphv_10hv)
+ kvthowew = (kvthowew_nld100_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_nld100_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_nld100_sphv_10hv)
+ kuowel   = (kuowel_nld100_sphv_10hv)
+ kuowew   = (kuowew_nld100_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_nld100_sphv_10hv*(1-fem))
+ rgo	   = (rgo_nld100_sphv_10hv)
+ rsh	   = (rsh_nld100_sphv_10hv)
+ rbulko   = (rbulko_nld100_sphv_10hv)
+ rwello   = (rwello_nld100_sphv_10hv)
+ rjunso   = (rjunso_nld100_sphv_10hv/(w+(1-fem)*dwrjunso_nld100_sphv_10hv))
+ rjundo   = ((rjundo_nld100_sphv_10hv/(w+(1-fem)*dwrjundo_nld100_sphv_10hv))*(1+0.4e-3*(temp-27)))
+ rint     = (rint_nld100_sphv_10hv)
+ rvpoly   = (rvpoly_nld100_sphv_10hv)
+ rshg     = (rshg_nld100_sphv_10hv)
+ dlsil    = (dlsil_nld100_sphv_10hv)
+ saref    = (saref_nld100_sphv_10hv)
+ sbref    = (sbref_nld100_sphv_10hv)
+ wlod     = (wlod_nld100_sphv_10hv)
+ kuo	   = (kuo_nld100_sphv_10hv)
+ kvsat    = (kvsat_nld100_sphv_10hv)
+ tkuo     = (tkuo_nld100_sphv_10hv)
+ lkuo     = (lkuo_nld100_sphv_10hv)
+ wkuo     = (wkuo_nld100_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_nld100_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_nld100_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld100_sphv_10hv)
+ kvtho    = (kvtho_nld100_sphv_10hv)
+ lkvtho   = (lkvtho_nld100_sphv_10hv)
+ wkvtho   = (wkvtho_nld100_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_nld100_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_nld100_sphv_10hv)
+ wlodvth  = (wlodvth_nld100_sphv_10hv)
+ stetao   = (stetao_nld100_sphv_10hv)
+ lodetao  = (lodetao_nld100_sphv_10hv)
+ scref    = (scref_nld100_sphv_10hv)
+ web	   = (web_nld100_sphv_10hv)
+ wec	   = (wec_nld100_sphv_10hv)
+ adr1o    = (adr1o_nld100_sphv_10hv)
+ adr1l    = (adr1l_nld100_sphv_10hv)
+ adr1w    = (adr1w_nld100_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_nld100_sphv_10hv)
+ stadr2o  = (stadr2o_nld100_sphv_10hv)
+ adr3o    = (adr3o_nld100_sphv_10hv)
+ adr3l    = (adr3l_nld100_sphv_10hv)
+ adr3w    = (adr3w_nld100_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_nld100_sphv_10hv)
+ adr4l    = (adr4l_nld100_sphv_10hv)
+ adr4w    = (adr4w_nld100_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_nld100_sphv_10hv)
+ adr5l    = (adr5l_nld100_sphv_10hv)
+ adr5w    = (adr5w_nld100_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_nld100_sphv_10hv)
+ bidr1l   = (bidr1l_nld100_sphv_10hv)
+ bidr1w   = (bidr1w_nld100_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_nld100_sphv_10hv)
+ bidr2w   = (bidr2w_nld100_sphv_10hv*(1-fem))
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld100_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld100_sphv_10hv*delr_rshl_nld100_sphv_10hv*delr_rdsw_relimo*fac_r_ng_rshldd)*fac_rshldd)
+ xw	   = ((xw_nld100_sphv_10hv+1.0e-6*dela_xw_nld100_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld100_sphv_10hv*(1-fem))
+ xl	   = (xl_nld100_sphv_10hv)
+ xlw	   = (xlw_nld100_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld100_sphv_10hv)
+ nst	   = (nst_nld100_sphv_10hv)
+ ats	   = (ats_nld100_sphv_10hv)
+ dfinf    = (dfinf_nld100_sphv_10hv)
+ dfw	   = (dfw_nld100_sphv_10hv*(1-fem))
+ dfl	   = (dfl_nld100_sphv_10hv)
+ dflw     = (dflw_nld100_sphv_10hv*(1-fem))
+ dp	   = (dp_nld100_sphv_10hv)
+ ecrit    = (ecrit_nld100_sphv_10hv*tfact_ecrit*fac_r_ng_ecrit)*(1+dwecrit/w+dwecritw/(w*w))
+ ecorn    = (ecorn_nld100_sphv_10hv)*(1+dwecrit/w+dwecritw/(w*w))
+ du	   = (du_nld100_sphv_10hv)
+ tc1	   = (tc1_nld100_sphv_10hv)
+ tc2	   = (tc2_nld100_sphv_10hv)
+ tc1l     = (tc1l_nld100_sphv_10hv)
+ tc2l     = (tc2l_nld100_sphv_10hv)
+ tc1w     = (tc1w_nld100_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld100_sphv_10hv*(1-fem))
+ theacc   = (theacc_nld100_sphv_10hv)
+ theacc2  = (theacc2_nld100_sphv_10hv)
+ aacc     = (aacc_nld100_sphv_10hv)
+ rva	   = (rva_nld100_sphv_10hv)
+ dta	   = (dta_nld100_sphv_10hv)
+ trj	   = (27)
+ cjarea   = (cjarea_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlsti   = (cjlsti_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlgat   = (cjlgat_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiarea  = (vbiarea_nld100_sphv_10hv)
+ vbisti   = (vbisti_nld100_sphv_10hv)
+ vbigat   = (vbigat_nld100_sphv_10hv)
+ parea    = (parea_nld100_sphv_10hv)
+ psti     = (psti_nld100_sphv_10hv)
+ pgat     = (pgat_nld100_sphv_10hv)
+ is1area  = (is1area_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttarea   = (tt_nld100_10hv)
+ is2area  = (is2area_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irarea   = (irarea_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1area = (stis1area_nld100_sphv_10hv)
+ stis2area = (stis2area_nld100_sphv_10hv)
+ stirarea = (stirarea_nld100_sphv_10hv)
+ n1area   = (n1area_nld100_sphv_10hv)
+ n2area   = (n2area_nld100_sphv_10hv)
+ nrarea   = (nrarea_nld100_sphv_10hv)
+ is1lsti  = (is1lsti_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlsti   = (tt_nld100_10hv)
+ is2lsti  = (is2lsti_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irlsti   = (irlsti_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1sti = (stis1sti_nld100_sphv_10hv)
+ stis2sti = (stis2sti_nld100_sphv_10hv)
+ stirsti  = (stirsti_nld100_sphv_10hv)
+ n1sti    = (n1sti_nld100_sphv_10hv)
+ n2sti    = (n2sti_nld100_sphv_10hv)
+ nrsti    = (nrsti_nld100_sphv_10hv)
+ is1lgat  = (is1lgat_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlgat   = (tt_nld100_10hv)
+ is2lgat  = (is2lgat_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irlgat   = (irlgat_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1gat = (stis1gat_nld100_sphv_10hv)
+ stis2gat = (stis2gat_nld100_sphv_10hv)
+ stirgat  = (stirgat_nld100_sphv_10hv)
+ n1gat    = (n1gat_nld100_sphv_10hv)
+ n2gat    = (n2gat_nld100_sphv_10hv)
+ nrgat    = (nrgat_nld100_sphv_10hv)
+ cjaread  = (cjaread_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlstid  = (cjlstid_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlgatd  = (cjlgatd_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiaread = (vbiaread_nld100_sphv_10hv)
+ vbistid  = (vbistid_nld100_sphv_10hv)
+ vbigatd  = (vbigatd_nld100_sphv_10hv)
+ paread   = (paread_nld100_sphv_10hv)
+ pstid    = (pstid_nld100_sphv_10hv)
+ pgatd    = (pgatd_nld100_sphv_10hv)
+ is1aread = (is1aread_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttaread  = (tt_nld100_10hv)
+ is2aread = (is2aread_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ iraread  = (iraread_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1aread = (stis1aread_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2aread = (stis2aread_nld100_sphv_10hv)
+ stiraread = (stiraread_nld100_sphv_10hv)
+ n1aread  = (n1aread_nld100_sphv_10hv)
+ n2aread  = (n2aread_nld100_sphv_10hv)
+ nraread  = (nraread_nld100_sphv_10hv)
+ is1lstid = (is1lstid_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlstid  = (tt_nld100_10hv)
+ is2lstid = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlstid  = (irlstid_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1stid = (stis1stid_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2stid = (stis2stid_nld100_sphv_10hv)
+ stirstid = (stirstid_nld100_sphv_10hv)
+ n1stid   = (n1stid_nld100_sphv_10hv)
+ n2stid   = (n2stid_nld100_sphv_10hv)
+ nrstid   = (nrstid_nld100_sphv_10hv)
+ is1lgatd = (is1lgatd_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlgatd  = (tt_nld100_10hv)
+ is2lgatd = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlgatd  = (irlgatd_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1gatd = (stis1gatd_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2gatd = (stis2gatd_nld100_sphv_10hv)
+ stirgatd = (stirgatd_nld100_sphv_10hv)
+ n1gatd   = (n1gatd_nld100_sphv_10hv)
+ n2gatd   = (n2gatd_nld100_sphv_10hv)
+ nrgatd   = (nrgatd_nld100_sphv_10hv)
+ cjaread2 = (cjaread_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlstid2 = (cjlstid_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld100_sphv_10hv)
+ vbistid2 = (vbistid2_nld100_sphv_10hv)
+ paread2  = (paread2_nld100_sphv_10hv)
+ pstid2   = (pstid2_nld100_sphv_10hv)
+ is1aread2 = (is1aread2_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttaread2 = (tt_nld100_10hv)
+ is2aread2 = (is2aread_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ iraread2 = (iraread2_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1aread2 = (stis1aread_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2aread2 = (stis2aread_nld100_sphv_10hv)
+ stiraread2 = (stiraread2_nld100_sphv_10hv)
+ n1aread2 = (n1aread2_nld100_sphv_10hv)*(1+(1-fem)*0.1/w)
+ n2aread2 = (n2aread2_nld100_sphv_10hv)
+ nraread2 = (nraread2_nld100_sphv_10hv)
+ is1lstid2 = (is1aread_nld100_sphv_10hv*djunc*delr_is_nld100_sphv_10hv)
+ ttlstid2 = (tt_nld100_10hv)
+ is2lstid2 = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlstid2 = (irlstid2_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2stid2 = (stis2stid2_nld100_sphv_10hv)
+ stirstid2 = (stirstid2_nld100_sphv_10hv)
+ n1stid2  = (n1stid2_nld100_sphv_10hv)
+ n2stid2  = (n2stid2_nld100_sphv_10hv)
+ nrstid2  = (nrstid2_nld100_sphv_10hv)
+ eairarea	  = (1.12)
+ eairaread	  = (1.12)
+ eairaread2	  = (1.12)
+ eairgat	  = (1.12)
+ eairgatd	  = (1.12)
+ eairsti	  = (1.12)
+ eairstid	  = (1.12)
+ eairstid2	  = (1.12)
+ eais1area	  = (1.12)
+ eais1aread	  = (1.12)
+ eais1aread2	  = (1.12)
+ eais1gat	  = (1.12)
+ eais1gatd	  = (1.12)
+ eais1sti	  = (1.12)
+ eais1stid	  = (1.12)
+ eais1stid2	  = (1.12)
+ eais2area	  = (1.12)
+ eais2aread	  = (1.12)
+ eais2aread2	  = (1.12)
+ eais2gat	  = (1.12)
+ eais2gatd	  = (1.12)
+ eais2sti	  = (1.12)
+ eais2stid	  = (1.12)
+ eais2stid2	  = (1.12)
+ ikfarea               = ikfarea_nld100_sphv_10hv
+ ikflsti               = ikfarea_nld100_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld100_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld100_sphv_10hv
+ stikfsti              = stikfarea_nld100_sphv_10hv
+ stikfgat              = stikfarea_nld100_sphv_10hv
+ ikfaread              = ikfaread_nld100_sphv_10hv*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflstid              = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflgatd              = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikfaread2             = ikfaread_nld100_sphv_10hv*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflstid2             = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ stikfaread             = stikfaread_nld100_sphv_10hv
+ stikfstid             = stikfaread_nld100_sphv_10hv
+ stikfgatd             = stikfaread_nld100_sphv_10hv
+ stikfaread2            = stikfaread_nld100_sphv_10hv
+ stikfstid2            = stikfaread_nld100_sphv_10hv

// ****** ckt elements:
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
//mendcap   (s  intg s  s  dtemp) pspmoscap l=lch w=(wmosend) mult=ng

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=p
+    tr    = 27
+    toxo  = 380e-9
+    vfbo  = 0
+    nsubo = 4.5e22
+    npck  = 1e22
+    lpck  = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo    = 0


cgd_fld (intg d) capacitor c=(cgd_ply_fld)  m=ng

cgs_fld       (intg s)  capacitor c=(cgs_ply_fld_nld100) m=ng
cgs_ply_cfr   (intg s)  capacitor c=(cfr_ply_s) m=ng
cgd_m1        (intg d) capacitor c=(cgd_ply_m1)  m=ng
cgs_m1        (intg s) capacitor c=(cgs_ply_m1)  m=ng
rgate     (g intg) resistor r=rgate m=ng
dbodyBV (s rs)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rs d)   resistor r=0.01
xdsub     (s sub) cdgontub_box_sub_10hv  area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1


//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


cgd_fld_dmy (s d) capacitor c=(cgd_ply_fld)  m=ng_dmy
cgd_m1_dmy  (s d) capacitor c=(cgd_ply_m1)  m=ng_dmy


}



include "./smos10hv_ade_dfrt.scs" section=nld100_10hv_dfrt
ends
// pld100_10hv

//ahdl_include "./veriloga/v2.0.16/sphv.va"
subckt pld100_10hv (d g s sub)

parameters
+ w				    = (5)
+ ng				    = (2)
+ sti_dummy			    = (0)
+ lpe				    = (0)
+ fem				    = (0)
+ soa				    = (1)
+ selfheat			    = (1)
+ mode_rthcth			    = (1)
+ dela_vth_relimo		    = (0)
+ dela_vth_relimo_mod		    = (0)
+ delr_u0_relimo		    = (1)
+ delr_rdsw_relimo		    = (1)
+ delr_a0_relimo		    = (1)

+ l				    = (0.5)
+ tn                                = (27+273.15)
+ delt                              = (temp+273.15-tn)
+ rs_poly_gate                      = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply                              = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))

+ nsmm_delr_tox_pld100_sphv_10hv    = tmp_nsmm_delr_tox_pld100_sphv_10hv
+ nsmm_dela_vfb_pld100_sphv_10hv    = tmp_nsmm_dela_vfb_pld100_sphv_10hv
+ nsmm_dela_vtw_pld100_sphv_10hv    = tmp_nsmm_dela_vtw_pld100_sphv_10hv
+ nsmm_delr_uch_pld100_sphv_10hv    = tmp_nsmm_delr_uch_pld100_sphv_10hv
+ nsmm_delr_res_pld100_sphv_10hv    = tmp_nsmm_delr_res_pld100_sphv_10hv
+ nsmm_dela_dwox_pld100_sphv_10hv   = tmp_nsmm_dela_dwox_pld100_sphv_10hv
+ nsmm_delr_nsub_pld100_sphv_10hv   = tmp_nsmm_delr_nsub_pld100_sphv_10hv

//process parameters
+ delr_tox_pld100_sphv_10hv         = (nom_delr_tox_pld100_sphv_10hv*(1+sig_delr_tox_pld100_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld100_sphv_10hv*smm_delr_tox_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld100_sphv_10hv         = (nom_dela_vfb_pld100_sphv_10hv+(sig_dela_vfb_pld100_sphv_10hv*nsig_dela_vfb_pld100_sphv_10hv)+nsmm_dela_vfb_pld100_sphv_10hv*smm_dela_vfb_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld100_sphv_10hv         = (nom_dela_vtw_pld100_sphv_10hv+(sig_dela_vtw_pld100_sphv_10hv*nsig_dela_vtw_pld100_sphv_10hv)+nsmm_dela_vtw_pld100_sphv_10hv*smm_dela_vtw_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld100_sphv_10hv         = (nom_delr_uch_pld100_sphv_10hv*(1+sig_delr_uch_pld100_sphv_10hv*nsig_delr_uch_pld100_sphv_10hv+nsmm_delr_uch_pld100_sphv_10hv*smm_delr_uch_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld100_sphv_10hv         = (nom_delr_res_pld100_sphv_10hv*(1+sig_delr_res_pld100_sphv_10hv*nsig_delr_res_pld100_sphv_10hv+nsmm_delr_res_pld100_sphv_10hv*smm_delr_res_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld100_sphv_10hv        = (nom_dela_dwox_pld100_sphv_10hv+(sig_dela_dwox_pld100_sphv_10hv*nsig_dela_dwox_pld100_sphv_10hv)+nsmm_dela_dwox_pld100_sphv_10hv*smm_dela_dwox_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld100_sphv_10hv        = (1+nsmm_delr_nsub_pld100_sphv_10hv*smm_delr_nsub_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld100_sphv_10hv	    = (nom_delr_cj_pld100_sphv_10hv*(1.0+nsig_delr_cj_pld100_sphv_10hv*sig_delr_cj_pld100_sphv_10hv))
+ delr_is_pld100_sphv_10hv	    = (nom_delr_is_pld100_sphv_10hv*exp(nsig_delr_is_pld100_sphv_10hv*sig_delr_is_pld100_sphv_10hv))
+ delr_is2_pld100_sphv_10hv	    = (nom_delr_is2_pld100_sphv_10hv*exp(nsig_delr_is2_pld100_sphv_10hv*sig_delr_is2_pld100_sphv_10hv))
+ delr_ir_pld100_sphv_10hv	    = (nom_delr_ir_pld100_sphv_10hv*exp(nsig_delr_ir_pld100_sphv_10hv*sig_delr_ir_pld100_sphv_10hv))
+ dela_dw_pld100_sphv_10hv          = (nom_dela_dw_pld100_sphv_10hv+(sig_dela_dw_pld100_sphv_10hv*nsig_dela_dw_pld100_sphv_10hv))
+ delr_thesat_pld100_sphv_10hv      = (nom_delr_thesat_pld100_sphv_10hv*(1+sig_delr_thesat_pld100_sphv_10hv*nsig_delr_thesat_pld100_sphv_10hv))
+ delr_vdscale_pld100_sphv_10hv     = (nom_delr_vdscale_pld100_sphv_10hv*(1+sig_delr_vdscale_pld100_sphv_10hv*nsig_delr_vdscale_pld100_sphv_10hv))
+ delr_vdscalew_pld100_sphv_10hv    = (nom_delr_vdscalew_pld100_sphv_10hv*(1+sig_delr_vdscalew_pld100_sphv_10hv*nsig_delr_vdscalew_pld100_sphv_10hv))
+ delr_theacc2_pld100_sphv_10hv     = (nom_delr_theacc2_pld100_sphv_10hv*(1+sig_delr_theacc2_pld100_sphv_10hv*nsig_delr_theacc2_pld100_sphv_10hv))


parameters
//+ nde=(fmod(ng,2))
+ nde              = (0)
+ nse              = (2-nde)
+ nd               = ((ng+nde)/2)
+ ns               = (1-nde+nd)
+ ndi              = (nd-nde)
+ nsi              = (ns-nse)

//dummy parameters
+ ng_dmy           = (2*sti_dummy)
+ ngeff            = (ng+ng_dmy)
+ ndi_eff          = (ngeff/2)
+ nsi_eff          = ((ngeff-2)/2)

+ wdrift           = (w)
+ ldrift           = (7.0)
+ ldr1             = (0.55)
+ lacts            = (0.3)
+ lactd            = (1.32)
+ lactg            = (0.35)
+ lacts_i          = (0.39)

// junction area and perimeter calculation
// because s and b are shorted, so let as=ps=0
+ as               = (w*lacts)*0
+ ps               = ((w+lacts)*2)*0
+ w2nhv            = (11.4)
+ rnhv_inner       = (1.4)
+ rnhv_a_inner     = rnhv_inner*rnhv_inner*pi4models
+ rnhv_p_inner     = 2*rnhv_inner*pi4models
+ rnhv_daera       = (rnhv_inner*rnhv_inner-rnhv_a_inner/4.0)*(1-fem)
+ ad               = ((ldr1+lactg+ldrift/2)*(w+2*w2nhv*(1-fem))-rnhv_daera*2)
+ pd               = ((ldr1+lactg+ldrift/2)*2*(1-fem)+(w+2*w2nhv*(1-fem))-4*rnhv_inner*(1-fem)+rnhv_inner*pi4models*(1-fem))
+ ad2              = ((ldrift/2+lactd/2)*(w+2*w2nhv*(1-fem)))
+ pd2              = (ldrift+lactd)*(1-fem)

// nbl-oxide-sub box cap calculation
+ lb2b_d           = (17.12)
+ lp2p_s           = (0.99)
+ lp2dt_s          = (3.66)
+ w2dt             = (14.9)
+ xlnbl            = (lp2dt_s*nse+l*ngeff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl            = (w+2*w2dt*(1-fem))
+ alnbl            = (xlnbl*ylnbl)
+ plnbl            = (2*(xlnbl*(1-fem)+ylnbl))

// rth and cth calculation
+ w_heat           = (w)
+ l_heat           = (lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f            = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld100_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld100_sphv_10hv)*ngeff
+ cth_f            = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

+ djunc            = (2.5*1e-06)

+ tfact_ecrit      = (1+(tc1_ecrit_pld100_sphv_10hv+tc2_ecrit_pld100_sphv_10hv*(temp-tnom))*(temp-tnom))

// calculation for poly over field parasitic capacitance
// calculation for parasitic Cgd
// cgd_ply_fld is not used. Instead, use fitting one come with psp moscap Cgd
+ plysplit_aera    = (w+3.2*2*(1-fem))*0.7
+ plysplit_peri    = (w+3.2*4*(1-fem)+0.7*2*(1-fem))
+ w2ply_inner      = (5.55)
+ w2ply_outer      = (12.4)
+ lp2p_d           = (9.12)
+ lp2p_d_narrow    = (7.92)
+ l_polyear        = (lp2p_d-lp2p_d_narrow)/2
+ dw_polyear       = (1.0)
//+ aply_fld_cgd       = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d+2.0*l_polyear*(w-2*dw_polyear*(1-fem))-4.0*rnhv_daera-2.0*plysplit_aera-w*ldr1*2)/2*ng*(0.85*0+0.85*0.85)
//+ pply_fld_cgd       = (w+2*w2ply_inner*(1-fem)+2*l_polyear*(1-fem)+lp2p_d*(1-fem)+plysplit_peri*1)*ng*(0+1)      //ignore polywin2 perimeter for it's width is just of 0.7
//+ cgd_ply_fld        = (aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld)         using psp moscap to replace it

// parasitic capacitnace caused by dummy gate
// cgd_ply_fld_dmy is not used. Instead, use fitting one come with psp moscap Cgd
//+ aply_fld_cgd_dmy   = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d+2.0*l_polyear*(w-2*dw_polyear*(1-fem))-4.0*rnhv_daera-2.0*plysplit_aera-w*ldr1*2)/2*ng_dmy*(0.85*0+0.85*0.85)
//+ pply_fld_cgd_dmy   = (w+2*w2ply_inner*(1-fem)+2*l_polyear*(1-fem)+lp2p_d*(1-fem)+plysplit_peri*1)*ng_dmy*(0+1)      //ignore polywin2 perimeter for it is just width of 0.7
//+ cgd_ply_fld_dmy    = (aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld)         using psp moscap to replace it

// calculation for parasitic Cgs. For dummy gate, g and s are shorted, so no cgs.
+ aply_fld_cgs     = ((w+2*w2ply_outer*(1-fem))*(2*l+lb2b_d)-(w+2*w2nhv*(1-fem))*lb2b_d+4*rnhv_daera-l*w*2)/2*ng
+ pply_fld_cgs     = (2*w2ply_outer+2*l+lb2b_d)*ng*(1-fem)
+ cgs_ply_fld      = (aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld)+2.3e-15*ng*0.8

//copied from pld90b for psp moscap part, updating the parameters
// calculation for poly over field parasitic capaciance
+ cgd_ply_fld_pp   = 2.7e-17
+ cgs_ply_fld_pp   = 6.0e-15
+ dwcgdfldmoscap   = 35.7*(1-fem)
+ dwcgd_ply_fld    = 35.4667*(1-fem)
+ cgd_ply_fld      = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng
//+ cgs_ply_fld    = cgs_ply_fld_pp*(1-fem)*ng                not use this equ, still used cgs calculated from layout
// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy  = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng_dmy


// parameters for veriloga
+ vp_pld100_10hv   = (32)
+ dvp_pld100_10hv  = (4.5)
+ type_pld100_10hv = (-1)


//calculation for rgate
+ lovlap 	   = (0.5+0.55-0.913-0.078)
+ length 	   = (0.913+0.078+lovlap+2.75)


// simple model factor
+ swdrlin  = (2)  
+ fac_rshldd       = ((swdrlin==0)+(swdrlin==2)*0.88848)

// multiple-ng effect
+ fac_r_ng_rshldd  = (1+(ngeff/(ngeff+0.5*(1-fem))-2/(2+0.5))*0.2034*(1+1.25*(1-fem)/w))
+ fac_a_ng_vfbo    = (ngeff/(ngeff+0.5*(1-fem))-2/(2+0.5))*0.0756*(w/(w+2.75*(1-fem)))
+ fac_r_ng_thesato = (1+(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.765)


// parameters for the BV diode
+ dcbv_pld100_10hv = (122)

// parasitic cgd and cgs between m2 and m3, in p39e cv duts, used for model extraction, and flagged out in final model
//+ cpp_m3_m2        = (6.72904e-17)
//+ cfr_m3_m2        = (4.42231e-17)
//+ no_m2_m3         = int((w+2*w2ply_inner+1.8+1e-6)/(7.8*2))
//+ m2_m3_a          = (2.44*6)*no_m2_m3*ng
//+ m2_m3_p          = (2.44+6)*2*no_m2_m3*ng
//+ cgd_m2_m3        = (m2_m3_a*cpp_m3_m2+m2_m3_p*cfr_m3_m2)
//+ cgs_m2_m3        = (m2_m3_a*cpp_m3_m2+m2_m3_p*cfr_m3_m2)

model dbodyBV diode
+ allow_scaling    = (yes)
+ jmax  	   = (1e12)
+ jmelt 	   = (1e12)
+ tnom  	   = (27)
+ is		   = (1e-30)
+ n		   = (1.0)
+ cj		   = (1e-30)
+ pta		   = (0)
+ tlevc 	   = (2)
+ tlev  	   = (2)
+ bv		   = (dcbv_pld100_10hv+bvdss_shift)
+ ibv		   = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ngeff)
rlimit (rd s) resistor r=0.01


// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w                = w
+ l                = l
+ ldrift           = ldrift
+ wdrift           = wdrift
+ ldr1             = ldr1
+ mult             = ng
+ ad               = ad
+ pd               = pd
+ as               = as
+ ps               = ps
+ ad2              = ad2
+ pd2              = pd2


model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi       = 1
+ swdrlin      = swdrlin
+ xvsat        = xvsat_pld100_sphv_10hv
+ qmc          = qmc_pld100_sphv_10hv
+ lvaro        = lvaro_pld100_sphv_10hv
+ lvarl        = lvarl_pld100_sphv_10hv
+ lvarw        = lvarw_pld100_sphv_10hv*(1-fem)
+ lap          = lap_pld100_sphv_10hv
+ wvaro        = (wvaro_pld100_sphv_10hv+dela_dw_pld100_sphv_10hv)*(1-fem)
+ wvarl        = wvarl_pld100_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld100_sphv_10hv*(1-fem)
+ wot          = wot_pld100_sphv_10hv*(1-fem)
+ dlq          = dlq_pld100_sphv_10hv
+ dwq          = dwq_pld100_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld100_sphv_10hv+dela_vfb_pld100_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo
+ vfbl         = vfbl_pld100_sphv_10hv
+ vfbw         = (vfbw_pld100_sphv_10hv+dela_vtw_pld100_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld100_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld100_sphv_10hv
+ stvfbl       = stvfbl_pld100_sphv_10hv
+ stvfbw       = stvfbw_pld100_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld100_sphv_10hv*(1-fem)
+ toxo         = toxo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ epsroxo      = epsroxo_pld100_sphv_10hv
+ nsubo        = nsubo_pld100_sphv_10hv*delr_nsub_pld100_sphv_10hv
+ nsubw        = nsubw_pld100_sphv_10hv*(1-fem)
+ wseg         = wseg_pld100_sphv_10hv
+ npck         = npck_pld100_sphv_10hv
+ npckw        = npckw_pld100_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld100_sphv_10hv
+ lpck         = lpck_pld100_sphv_10hv
+ lpckw        = lpckw_pld100_sphv_10hv*(1-fem)
+ fol1         = fol1_pld100_sphv_10hv
+ fol2         = fol2_pld100_sphv_10hv
+ facneffaco   = facneffaco_pld100_sphv_10hv
+ facneffacl   = facneffacl_pld100_sphv_10hv
+ facneffacw   = facneffacw_pld100_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld100_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld100_sphv_10hv
+ gfacnudl     = gfacnudl_pld100_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld100_sphv_10hv
+ gfacnudw     = gfacnudw_pld100_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld100_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld100_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld100_sphv_10hv
+ vnsubo       = vnsubo_pld100_sphv_10hv
+ nslpo        = nslpo_pld100_sphv_10hv
+ dnsubo       = dnsubo_pld100_sphv_10hv
+ dphibo       = dphibo_pld100_sphv_10hv
+ dphibl       = dphibl_pld100_sphv_10hv
+ dphiblexp    = dphiblexp_pld100_sphv_10hv
+ dphibw       = dphibw_pld100_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld100_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld100_sphv_10hv
+ delvtacl     = delvtacl_pld100_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld100_sphv_10hv
+ delvtacw     = delvtacw_pld100_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld100_sphv_10hv*(1-fem)
+ npo          = npo_pld100_sphv_10hv
+ npl          = npl_pld100_sphv_10hv
+ cto          = cto_pld100_sphv_10hv
+ ctl          = ctl_pld100_sphv_10hv
+ ctlexp       = ctlexp_pld100_sphv_10hv
+ ctw          = ctw_pld100_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld100_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld100_sphv_10hv
+ ctbo         = ctbo_pld100_sphv_10hv
+ stcto        = stcto_pld100_sphv_10hv
+ toxovo       = toxovo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ toxovdo      = toxovdo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ lov          = lov_pld100_sphv_10hv
+ dlovd        = dlovd_pld100_sphv_10hv
+ novo         = novo_pld100_sphv_10hv
+ novdo        = novdo_pld100_sphv_10hv
+ cfl          = cfl_pld100_sphv_10hv
+ cflexp       = cflexp_pld100_sphv_10hv
+ cfw          = cfw_pld100_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld100_sphv_10hv
+ uo           = uo_pld100_sphv_10hv*delr_uch_pld100_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld100_sphv_10hv
+ fbet1w       = fbet1w_pld100_sphv_10hv*(1-fem)
+ lp1          = lp1_pld100_sphv_10hv
+ lp1w         = lp1w_pld100_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld100_sphv_10hv
+ lp2          = lp2_pld100_sphv_10hv
+ betw1        = betw1_pld100_sphv_10hv*(1-fem)
+ betw2        = betw2_pld100_sphv_10hv*(1-fem)
+ wbet         = wbet_pld100_sphv_10hv
+ stbeto       = stbeto_pld100_sphv_10hv
+ stbetl       = stbetl_pld100_sphv_10hv
+ stbetw       = stbetw_pld100_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld100_sphv_10hv*(1-fem)
+ mueo         = mueo_pld100_sphv_10hv
+ muew         = muew_pld100_sphv_10hv*(5/w)*(1-fem)
+ stmueo       = stmueo_pld100_sphv_10hv
+ themuo       = themuo_pld100_sphv_10hv
+ stthemuo     = stthemuo_pld100_sphv_10hv
+ cso          = cso_pld100_sphv_10hv
+ csl          = csl_pld100_sphv_10hv
+ cslexp       = cslexp_pld100_sphv_10hv
+ csw          = csw_pld100_sphv_10hv*(1-fem)
+ cslw         = cslw_pld100_sphv_10hv*(1-fem)
+ stcso        = stcso_pld100_sphv_10hv
+ xcoro        = xcoro_pld100_sphv_10hv
+ xcorl        = xcorl_pld100_sphv_10hv
+ xcorw        = xcorw_pld100_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld100_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld100_sphv_10hv
+ fetao        = fetao_pld100_sphv_10hv
+ rsw1         = rsw1_pld100_sphv_10hv
+ rsw2         = rsw2_pld100_sphv_10hv*(1-fem)
+ strso        = strso_pld100_sphv_10hv
+ rsbo         = rsbo_pld100_sphv_10hv
+ rsgo         = rsgo_pld100_sphv_10hv
+ thesato      = thesato_pld100_sphv_10hv*delr_thesat_pld100_sphv_10hv*fac_r_ng_thesato
+ thesatl      = thesatl_pld100_sphv_10hv
+ thesatlexp   = thesatlexp_pld100_sphv_10hv
+ thesatw      = thesatw_pld100_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld100_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld100_sphv_10hv
+ stthesatl    = stthesatl_pld100_sphv_10hv
+ stthesatw    = stthesatw_pld100_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld100_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld100_sphv_10hv
+ thesatgo     = thesatgo_pld100_sphv_10hv
+ thesatgl     = thesatgl_pld100_sphv_10hv
+ thesatgw     = thesatgw_pld100_sphv_10hv*(1-fem)
+ vdscale      = (vdscale_pld100_sphv_10hv*delr_vdscale_pld100_sphv_10hv*(1+vdscalew_pld100_sphv_10hv*delr_vdscalew_pld100_sphv_10hv*(1-fem)/w))
+ vdscaleb     = (vdscaleb_pld100_sphv_10hv*(1+vdscalew_pld100_sphv_10hv*(1-fem)/w))
+ stvdscale    = stvdscale_pld100_sphv_10hv
+ axo          = axo_pld100_sphv_10hv
+ axl          = axl_pld100_sphv_10hv
+ alpl         = alpl_pld100_sphv_10hv
+ alplexp      = alplexp_pld100_sphv_10hv
+ alpw         = alpw_pld100_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld100_sphv_10hv
+ alp1lexp     = alp1lexp_pld100_sphv_10hv
+ alp1l2       = alp1l2_pld100_sphv_10hv
+ alp1w        = alp1w_pld100_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld100_sphv_10hv
+ alp2lexp     = alp2lexp_pld100_sphv_10hv
+ alp2l2       = alp2l2_pld100_sphv_10hv
+ alp2w        = alp2w_pld100_sphv_10hv*(1-fem)
+ vpo          = vpo_pld100_sphv_10hv
+ a1o          = a1o_pld100_sphv_10hv
+ a1l          = a1l_pld100_sphv_10hv
+ a1w          = a1w_pld100_sphv_10hv*(1-fem)
+ a2o          = a2o_pld100_sphv_10hv
+ sta2o        = sta2o_pld100_sphv_10hv
+ a3o          = a3o_pld100_sphv_10hv
+ a3l          = a3l_pld100_sphv_10hv
+ a3w          = a3w_pld100_sphv_10hv*(1-fem)
+ a4o          = a4o_pld100_sphv_10hv
+ a4l          = a4l_pld100_sphv_10hv
+ a4w          = a4w_pld100_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld100_sphv_10hv
+ iginvlw      = iginvlw_pld100_sphv_10hv
+ igovw        = igovw_pld100_sphv_10hv
+ igovdw       = igovdw_pld100_sphv_10hv
+ stigo        = stigo_pld100_sphv_10hv
+ gc2o         = gc2o_pld100_sphv_10hv
+ gc3o         = gc3o_pld100_sphv_10hv
+ chibo        = chibo_pld100_sphv_10hv
+ agidlw       = agidlw_pld100_sphv_10hv
+ agidldw      = agidldw_pld100_sphv_10hv
+ bgidlo       = bgidlo_pld100_sphv_10hv
+ bgidldo      = bgidldo_pld100_sphv_10hv
+ stbgidlo     = stbgidlo_pld100_sphv_10hv
+ stbgidldo    = stbgidldo_pld100_sphv_10hv
+ cgidlo       = cgidlo_pld100_sphv_10hv
+ cgidldo      = cgidldo_pld100_sphv_10hv
+ cgbovl       = cgbovl_pld100_sphv_10hv
+ cfrw         = cfrw_pld100_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld100_sphv_10hv*(1-fem)
+ fnto         = fnto_pld100_sphv_10hv
+ nfalw        = nfalw_pld100_sphv_10hv
+ nfblw        = nfblw_pld100_sphv_10hv
+ nfclw        = nfclw_pld100_sphv_10hv
+ efo          = efo_pld100_sphv_10hv
+ lintnoi      = lintnoi_pld100_sphv_10hv
+ alpnoi       = alpnoi_pld100_sphv_10hv
+ kvthoweo     = kvthoweo_pld100_sphv_10hv
+ kvthowel     = kvthowel_pld100_sphv_10hv
+ kvthowew     = kvthowew_pld100_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld100_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld100_sphv_10hv
+ kuowel       = kuowel_pld100_sphv_10hv
+ kuowew       = kuowew_pld100_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld100_sphv_10hv*(1-fem)
+ rgo          = rgo_pld100_sphv_10hv
+ rsh          = rsh_pld100_sphv_10hv
+ rbulko       = rbulko_pld100_sphv_10hv
+ rwello       = rwello_pld100_sphv_10hv
+ rjunso       = rjunso_pld100_sphv_10hv/(w+dwrjunso_pld100_sphv_10hv*(1-fem))*(1+5.0e-4*(temp-27))
+ rjundo       = rjundo_pld100_sphv_10hv/(w+dwrjundo_pld100_sphv_10hv*(1-fem))*(1+5.0e-4*(temp-27))
+ rint         = rint_pld100_sphv_10hv
+ rvpoly       = rvpoly_pld100_sphv_10hv
+ rshg         = rshg_pld100_sphv_10hv
+ dlsil        = dlsil_pld100_sphv_10hv
+ saref        = saref_pld100_sphv_10hv
+ sbref        = sbref_pld100_sphv_10hv
+ wlod         = wlod_pld100_sphv_10hv
+ kuo          = kuo_pld100_sphv_10hv
+ kvsat        = kvsat_pld100_sphv_10hv
+ tkuo         = tkuo_pld100_sphv_10hv
+ lkuo         = lkuo_pld100_sphv_10hv
+ wkuo         = wkuo_pld100_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld100_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld100_sphv_10hv
+ wlodkuo      = wlodkuo_pld100_sphv_10hv
+ kvtho        = kvtho_pld100_sphv_10hv
+ lkvtho       = lkvtho_pld100_sphv_10hv
+ wkvtho       = wkvtho_pld100_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld100_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld100_sphv_10hv
+ wlodvth      = wlodvth_pld100_sphv_10hv
+ stetao       = stetao_pld100_sphv_10hv
+ lodetao      = lodetao_pld100_sphv_10hv
+ scref        = scref_pld100_sphv_10hv
+ web          = web_pld100_sphv_10hv
+ wec          = wec_pld100_sphv_10hv
+ adr1o        = adr1o_pld100_sphv_10hv
+ adr1l        = adr1l_pld100_sphv_10hv
+ adr1w        = adr1w_pld100_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld100_sphv_10hv
+ stadr2o      = stadr2o_pld100_sphv_10hv
+ adr3o        = adr3o_pld100_sphv_10hv
+ adr3l        = adr3l_pld100_sphv_10hv
+ adr3w        = adr3w_pld100_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld100_sphv_10hv
+ adr4l        = adr4l_pld100_sphv_10hv
+ adr4w        = adr4w_pld100_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld100_sphv_10hv
+ adr5l        = adr5l_pld100_sphv_10hv
+ adr5w        = adr5w_pld100_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld100_sphv_10hv
+ bidr1l       = bidr1l_pld100_sphv_10hv
+ bidr1w       = bidr1w_pld100_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld100_sphv_10hv
+ bidr2w       = bidr2w_pld100_sphv_10hv*(1-fem)
+ rtho         = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld100_sphv_10hv
+ strthao      = strthao_pld100_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld100_sphv_10hv*delr_res_pld100_sphv_10hv*fac_r_ng_rshldd*fac_rshldd*delr_rdsw_relimo)
+ xw           = xw_pld100_sphv_10hv*(1-fem)
+ nwxw         = (nwxw_pld100_sphv_10hv+1.0e-12*dela_dwox_pld100_sphv_10hv)*(1-fem)
+ xl           = xl_pld100_sphv_10hv
+ xlw          = xlw_pld100_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld100_sphv_10hv
+ nst          = nst_pld100_sphv_10hv
+ ats          = ats_pld100_sphv_10hv
+ dfinf        = dfinf_pld100_sphv_10hv
+ dfw          = dfw_pld100_sphv_10hv*(1-fem)
+ dfl          = dfl_pld100_sphv_10hv
+ dflw         = dflw_pld100_sphv_10hv*(1-fem)
+ dp           = dp_pld100_sphv_10hv
+ ecrit        = ecrit_pld100_sphv_10hv*tfact_ecrit/(1+ecritw_pld100_sphv_10hv*(1-fem)/w**1.5)
+ ecorn        = ecorn_pld100_sphv_10hv*tfact_ecrit/(1+ecritw_pld100_sphv_10hv*(1-fem)/w**1.5)
+ du           = du_pld100_sphv_10hv
+ tc1          = tc1_pld100_sphv_10hv
+ tc2          = tc2_pld100_sphv_10hv
+ tc1l         = tc1l_pld100_sphv_10hv
+ tc2l         = tc2l_pld100_sphv_10hv
+ tc1w         = tc1w_pld100_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld100_sphv_10hv*(1-fem)
+ theacc       = theacc_pld100_sphv_10hv
+ theacc2      = theacc2_pld100_sphv_10hv*delr_theacc2_pld100_sphv_10hv
+ rva          = rva_pld100_sphv_10hv
+ dta          = dta_pld100_sphv_10hv
+ trj          = trj_pld100_sphv_10hv
+ cjarea       = cjarea_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlsti       = cjlsti_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlgat       = cjarea_pld100_sphv_10hv*djunc*delr_cj_pld100_sphv_10hv
+ vbiarea      = vbiarea_pld100_sphv_10hv
+ vbisti       = vbisti_pld100_sphv_10hv
+ vbigat       = vbigat_pld100_sphv_10hv
+ parea        = parea_pld100_sphv_10hv
+ psti         = psti_pld100_sphv_10hv
+ pgat         = pgat_pld100_sphv_10hv
+ is1area      = is1area_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttarea       = ttarea_pld100_sphv_10hv
+ is2area      = is2area_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irarea       = irarea_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1area    = stis1area_pld100_sphv_10hv
+ stis2area    = stis2area_pld100_sphv_10hv
+ stirarea     = stirarea_pld100_sphv_10hv
+ n1area       = n1area_pld100_sphv_10hv
+ n2area       = n2area_pld100_sphv_10hv
+ nrarea       = nrarea_pld100_sphv_10hv
+ is1lsti      = is1lsti_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlsti       = ttlsti_pld100_sphv_10hv
+ is2lsti      = is2lsti_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlsti       = irlsti_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1sti     = stis1sti_pld100_sphv_10hv
+ stis2sti     = stis2sti_pld100_sphv_10hv
+ stirsti      = stirsti_pld100_sphv_10hv
+ n1sti        = n1sti_pld100_sphv_10hv
+ n2sti        = n2sti_pld100_sphv_10hv
+ nrsti        = nrsti_pld100_sphv_10hv
+ is1lgat      = is1area_pld100_sphv_10hv*djunc*delr_is_pld100_sphv_10hv
+ ttlgat       = ttlgat_pld100_sphv_10hv
+ is2lgat      = is2area_pld100_sphv_10hv*djunc*delr_is2_pld100_sphv_10hv
+ irlgat       = irarea_pld100_sphv_10hv*djunc*delr_ir_pld100_sphv_10hv
+ stis1gat     = stis1gat_pld100_sphv_10hv
+ stis2gat     = stis2gat_pld100_sphv_10hv
+ stirgat      = stirgat_pld100_sphv_10hv
+ n1gat        = n1gat_pld100_sphv_10hv
+ n2gat        = n2gat_pld100_sphv_10hv
+ nrgat        = nrgat_pld100_sphv_10hv
+ cjaread      = cjaread_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlstid      = cjlstid_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlgatd      = cjlgatd_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ vbiaread     = vbiaread_pld100_sphv_10hv
+ vbistid      = vbistid_pld100_sphv_10hv
+ vbigatd      = vbigatd_pld100_sphv_10hv
+ paread       = paread_pld100_sphv_10hv
+ pstid        = pstid_pld100_sphv_10hv
+ pgatd        = pgatd_pld100_sphv_10hv
+ is1aread     = is1aread_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttaread      = ttaread_pld100_sphv_10hv
+ is2aread     = is2aread_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ iraread      = iraread_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1aread   = stis1aread_pld100_sphv_10hv
+ stis2aread   = stis2aread_pld100_sphv_10hv
+ stiraread    = stiraread_pld100_sphv_10hv
+ n1aread      = n1aread_pld100_sphv_10hv
+ n2aread      = n2aread_pld100_sphv_10hv
+ nraread      = nraread_pld100_sphv_10hv
+ is1lstid     = is1lstid_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlstid      = ttlstid_pld100_sphv_10hv
+ is2lstid     = is2lstid_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlstid      = irlstid_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1stid    = stis1stid_pld100_sphv_10hv
+ stis2stid    = stis2stid_pld100_sphv_10hv
+ stirstid     = stirstid_pld100_sphv_10hv
+ n1stid       = n1stid_pld100_sphv_10hv
+ n2stid       = n2stid_pld100_sphv_10hv
+ nrstid       = nrstid_pld100_sphv_10hv
+ is1lgatd     = is1lgatd_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlgatd      = ttlgatd_pld100_sphv_10hv
+ is2lgatd     = is2lgatd_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlgatd      = irlgatd_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1gatd    = stis1gatd_pld100_sphv_10hv
+ stis2gatd    = stis2gatd_pld100_sphv_10hv
+ stirgatd     = stirgatd_pld100_sphv_10hv
+ n1gatd       = n1gatd_pld100_sphv_10hv
+ n2gatd       = n2gatd_pld100_sphv_10hv
+ nrgatd       = nrgatd_pld100_sphv_10hv
+ cjaread2     = cjaread2_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlstid2     = cjlstid2_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ vbiaread2    = vbiaread2_pld100_sphv_10hv
+ vbistid2     = vbistid2_pld100_sphv_10hv
+ paread2      = paread2_pld100_sphv_10hv
+ pstid2       = pstid2_pld100_sphv_10hv
+ is1aread2    = is1aread2_pld100_sphv_10hv*delr_is_pld100_sphv_10hv/(1+20*(1-fem)/w)
+ ttaread2     = ttaread2_pld100_sphv_10hv
+ is2aread2    = is2aread2_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ iraread2     = iraread2_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1aread2  = stis1aread2_pld100_sphv_10hv
+ stis2aread2  = stis2aread2_pld100_sphv_10hv
+ stiraread2   = stiraread2_pld100_sphv_10hv
+ n1aread2     = n1aread2_pld100_sphv_10hv
+ n2aread2     = n2aread2_pld100_sphv_10hv
+ nraread2     = nraread2_pld100_sphv_10hv
+ is1lstid2    = is1lstid2_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlstid2     = ttlstid2_pld100_sphv_10hv
+ is2lstid2    = is2lstid2_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlstid2     = irlstid2_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1stid2   = stis1stid2_pld100_sphv_10hv
+ stis2stid2   = stis2stid2_pld100_sphv_10hv
+ stirstid2    = stirstid2_pld100_sphv_10hv
+ n1stid2      = n1stid2_pld100_sphv_10hv
+ n2stid2      = n2stid2_pld100_sphv_10hv
+ nrstid2      = nrstid2_pld100_sphv_10hv
+ aacc         = aacc_pld100_sphv_10hv
+ eais1area    = eais1area_pld100_sphv_10hv
+ eais2area    = eais2area_pld100_sphv_10hv
+ eairarea     = eairarea_pld100_sphv_10hv
+ eais1sti     = eais1sti_pld100_sphv_10hv
+ eais2sti     = eais2sti_pld100_sphv_10hv
+ eairsti      = eairsti_pld100_sphv_10hv
+ eais1gat     = eais1gat_pld100_sphv_10hv
+ eais2gat     = eais2gat_pld100_sphv_10hv
+ eairgat      = eairgat_pld100_sphv_10hv
+ eais1aread   = eais1aread_pld100_sphv_10hv
+ eais2aread   = eais2aread_pld100_sphv_10hv
+ eairaread    = eairaread_pld100_sphv_10hv
+ eais1stid    = eais1stid_pld100_sphv_10hv
+ eais2stid    = eais2stid_pld100_sphv_10hv
+ eairstid     = eairstid_pld100_sphv_10hv
+ eais1gatd    = eais1gatd_pld100_sphv_10hv
+ eais2gatd    = eais2gatd_pld100_sphv_10hv
+ eairgatd     = eairgatd_pld100_sphv_10hv
+ eais1aread2  = eais1aread2_pld100_sphv_10hv
+ eais2aread2  = eais2aread2_pld100_sphv_10hv
+ eairaread2   = eairaread2_pld100_sphv_10hv
+ eais1stid2   = eais1stid2_pld100_sphv_10hv
+ eais2stid2   = eais2stid2_pld100_sphv_10hv
+ eairstid2    = eairstid2_pld100_sphv_10hv
+ ikfaread     = ikfaread_pld100_sphv_10hv
+ ikflstid     = ikflstid_pld100_sphv_10hv
+ ikflgatd     = ikflgatd_pld100_sphv_10hv
+ ikfaread2    = ikfaread2_pld100_sphv_10hv*(w/(w+dwikfaread_pld100_sphv_10hv*(1-fem)))
+ ikflstid2    = ikflstid2_pld100_sphv_10hv
+ stikfaread   = stikfaread_pld100_sphv_10hv
+ stikfstid    = stikfstid_pld100_sphv_10hv
+ stikfgatd    = stikfgatd_pld100_sphv_10hv


// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr    = 27
+    toxo  = 320e-9
+    vfbo  = 0
+    nsubo = 6.1523e22
+    npck  = 1e21
+    lpck  = 1e-6
+    rtho  = 1e18
+    ctho  = 0
+    uo    = 0


cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cgs_ply_fld)
rgate (g gi) resistor r=(rply*((w+2*12.175*(1-fem))/(length*3*ng)))
xdsub (s sub) cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)) perim=(plnbl*(1-lpe)) soa=1
//cgd_m3_m2_dut (g d) capacitor c=(cgd_m2_m3)    //this is from p39e duts layout, flag out in final model
//cgs_m3_m2_dut (g s) capacitor c=(cgs_m2_m3)    //this is from p39e duts layout, flag out in final model

if (ng_dmy>=2) {


amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}


include "./smos10hv_ade_dfrt.scs" section=pld100_10hv_dfrt
ends

// nld90b_10hv

subckt nld90b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model, release value
// they are instance parameter, but invisible to the designers,  this means CDF will not use those parameters.
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
// parameters to contorl self-heating model, extraction value:
//+    selfheat                       = (1)
//+    mode_rthcth                    = (2)
//*support mismatch
//*******************************************************************************************************
+    nsmm_delr_tox_nld90b_sphv_10hv  = tmp_nsmm_delr_tox_nld90b_sphv_10hv
+    nsmm_dela_dw_nld90b_sphv_10hv   = tmp_nsmm_dela_dw_nld90b_sphv_10hv
+    nsmm_dela_vfb_nld90b_sphv_10hv  = tmp_nsmm_dela_vfb_nld90b_sphv_10hv
+    nsmm_delr_mobref_nld90b_sphv_10hv = tmp_nsmm_delr_mobref_nld90b_sphv_10hv
+    nsmm_delr_rshl_nld90b_sphv_10hv = tmp_nsmm_delr_rshl_nld90b_sphv_10hv
+    nsmm_delr_nsub_nld90b_sphv_10hv = tmp_nsmm_delr_nsub_nld90b_sphv_10hv
+    l                              = (0.65)
//*******************************************************************************************************
//*relimo model parameters
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld90b_vthratio     = 1.0
+    presto_nld90b_ronratio     = 0.01/0.74
//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+    vfbmm_temp = sqrt(1-2.45e-3*(temp-27))
+    delr_tox_nld90b_sphv_10hv      = (nom_delr_tox_nld90b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld90b_sphv_10hv+nsmm_delr_tox_nld90b_sphv_10hv*smm_delr_tox_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
//+    delr_tox_nld90b_sphv_10hv      = (nom_delr_tox_nld90b_sphv_10hv*(1.0+nsig_delr_tox_nld90b_sphv_10hv*sig_delr_tox_nld90b_sphv_10hv+nsmm_delr_tox_nld90b_sphv_10hv*smm_delr_tox_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld90b_sphv_10hv       = (nom_dela_dw_nld90b_sphv_10hv+nsig_dela_dw_nld90b_sphv_10hv*sig_dela_dw_nld90b_sphv_10hv+nsmm_dela_dw_nld90b_sphv_10hv*smm_dela_dw_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_nld90b_sphv_10hv      = (nom_dela_vfb_nld90b_sphv_10hv+nsig_dela_vfb_nld90b_sphv_10hv*sig_dela_vfb_nld90b_sphv_10hv+nsmm_dela_vfb_nld90b_sphv_10hv*smm_dela_vfb_nld90b_sphv_10hv(l,w)*(vfbmm_temp)/sqrt(ng/2))
+    dela_vtwl_nld90b_sphv_10hv     = (nom_dela_vtwl_nld90b_sphv_10hv+nsig_dela_vtwl_nld90b_sphv_10hv*sig_dela_vtwl_nld90b_sphv_10hv)
+    delr_mobref_nld90b_sphv_10hv   = (nom_delr_mobref_nld90b_sphv_10hv*(1.0+nsig_delr_mobref_nld90b_sphv_10hv*sig_delr_mobref_nld90b_sphv_10hv+nsmm_delr_mobref_nld90b_sphv_10hv*smm_delr_mobref_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_ids_nld90b_sphv_10hv   = (nom_delr_ids_nld90b_sphv_10hv*(1.0+nsig_delr_ids_nld90b_sphv_10hv*sig_delr_ids_nld90b_sphv_10hv))
+    delr_rshl_nld90b_sphv_10hv     = (nom_delr_rshl_nld90b_sphv_10hv*(1.0+nsig_delr_rshl_nld90b_sphv_10hv*sig_delr_rshl_nld90b_sphv_10hv)+nsmm_delr_rshl_nld90b_sphv_10hv*smm_delr_rshl_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld90b_sphv_10hv       = (nom_dela_xw_nld90b_sphv_10hv+nsig_dela_xw_nld90b_sphv_10hv*sig_dela_xw_nld90b_sphv_10hv)
+    delr_nsub_nld90b_sphv_10hv     = (1+nsmm_delr_nsub_nld90b_sphv_10hv*smm_delr_nsub_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_cj_nld90b_sphv_10hv 	        =(nom_delr_cj_nld90b_sphv_10hv*(1.0+nsig_delr_cj_nld90b_sphv_10hv*sig_delr_cj_nld90b_sphv_10hv))
+    delr_is_nld90b_sphv_10hv    	=(nom_delr_is_nld90b_sphv_10hv*exp(nsig_delr_is_nld90b_sphv_10hv*sig_delr_is_nld90b_sphv_10hv))
+    delr_is2_nld90b_sphv_10hv    	=(nom_delr_is2_nld90b_sphv_10hv*exp(nsig_delr_is2_nld90b_sphv_10hv*sig_delr_is2_nld90b_sphv_10hv))
+    delr_ir_nld90b_sphv_10hv 	        =(nom_delr_ir_nld90b_sphv_10hv*exp(nsig_delr_ir_nld90b_sphv_10hv*sig_delr_ir_nld90b_sphv_10hv))

//dummy gate parameters
+    ng_dmy=(2*sti_dummy)
+    ngeff=(ng+ng_dmy)
+    ndi_eff=(ngeff/2)
+    nsi_eff=((ngeff-2)/2)


//*******************************************************************************************************
//*global and process variables
//*******************************************************************************************************
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+ rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    djunc                          = (2.5e-6)  //should not scaled by scale as it is vertical


//*********************************************************************************
//*  fixed parameters and expressions
//*********************************************************************************

+    lch                            = (0.65) // alias to l
+    lacc                           = (0.6)  // alias to ldr1
+    wdel                           = (1.545)*(1-fem)
+    ld                             = (5.555)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lch+lacc+ld)  //this distance is the same inside the device and at the edge finger.
+    lflap 			    = (2.5)
+    xiso                           = (1.275)
+    yiso                           = ((9.46)*(1-fem))
+    wdrift                         = (w)
+    ldrift                         = (4.49)
+    ldr1                           = (0.6)
+    lacts                          = (0.455)
+    lactd                          = (1.41)
//*calculated dimensions
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff                           = (numbernplus*0.42)

//*extracted dimensions
+    lovlap                         = (0.00)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrs                           = (0.02)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrd                           = (0)       // tune par for cfr_ply_s & cfr_ply_d
+ tfact_ecrit=1+(tc1_ecrit_nld90b_sphv_10hv+tc2_ecrit_nld90b_sphv_10hv*(temp-tnom))*(temp-tnom)

//*simple model factor
+ swdrlin  = (2)  
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*1.0139)


//*****************************************************
//*parasitic resistance and capacitance calculations
//*****************************************************
//*------------------------------------
//*calculations for parasitic diodes
//*------------------------------------
//*ncom+hvnw to pepi (drain to source+body)
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom*(1-fem))*ng)
+    pncom                          = ((2*wdel+pi4models*xncom)*(1-fem)*ng)
+    chncom                         = (w*ng)
//*junc par for sphv input
+ pd_i=(chncom/ng)
+ pd2_i=(pncom/ng )
+ ad_i=((xncom-0.5*ldrift-0.5*lactd)*yncom)
+ ad2_i=(ancom/ng-ad_i)
+ as_i=0
+ ps_i=0

//*capacitance to sub ng total
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))

//*-------------------------------------------------------
//*source drain capacitance area and length calculations
//*m1 and m2 parasitic capacitances ignored
//*-------------------------------------------------------
//*poly over field parasitic to drain (lflap)
+    rpolyhole                      = (2.355)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.12*(1-fem))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole*(1-fem)))
+    apoly                          = (((w+2*1.545*(1-fem))*rpoly+0.5*pi4models*rpoly*rpoly*(1-fem)))
+    aplyfld_d                      = (apoly-ahole)
+    phole                          = (((w+2*0.12*(1-fem))+pi4models*rpolyhole*(1-fem)))
+    ppoly                          = (((w+2*1.545*(1-fem))+pi4models*rpoly*(1-fem)))
+    pplyfld_d                      = (ppoly+phole)
//+ cgd_ply_fld_nld90b=(aplyfld_d*cpp_ply_fld+0*pplyfld_d*cfr_ply_fld)

//*poly over field parasitic to source (top and bottom poly over field)
+    aplyfld_s                      = ((2*(l+ldr1+ld)*0.5)*(1-fem))
+    pplyfld_s                      = ((2*(l+ldr1+ld+0.5))*(1-fem))
+ cgs_ply_fld_nld90b=(aplyfld_s*cpp_ply_fld+pplyfld_s*cfr_ply_fld)

//*accumulation area (poly over accum area)
+ area_accum    = (((w+2*1.545*(1-fem))*lacc+0.5*pi4models*(1-fem)*((ld+lacc)*(ld+lacc)-(ld*ld))))
+ ldr1_i	=((area_accum/w))

//*fringing capacitance (source side edge of poly wall)
+    lfring_s   = ((w+2*8.35*(1-fem)))

//*fringing capacitance (drain side edge of poly wall to aa)
+    lfring_d=(((w+2*1.545*(1-fem))+(pi4models*ld)*(1-fem)))

+ cfr_ply_s=(lfring_s)*(lfrs+lovlap)*cpp_ply_sdt
+ cfr_ply_d=(lfring_d)*(lfrd+lovlap)*cpp_ply_sdt


//*delta_w due to p+ poly over active on phv+pepi (edge)
+    wmosendpg  		    = (13*(1-fem)+fem*1e-3)

//*parasitic psp mosfet due to p+ poly over active on phv+pepi (channel+edge)
+    rationpg			    = (0.8)
+    wchpg			    = (w-weff)*rationpg
+    wpg			    = (wchpg+wmosendpg)

//*delta_w due to n+ poly over active on phv+pepi (edge)
//*implemented in sphv via dlqs to introduce different delta_w for channel (dwqs) than for drift overlap (dwq_nld90b_sphv_10hv)
+    wmosendng  		    = (42*(1-fem)+fem*1e-3)
+    weff_psp			    = (w*1e-6+wvaro_nld90b_sphv_10hv-2*wot_nld90b_sphv_10hv+dwq_nld90b_sphv_10hv)
+    leff_psp			    = (lch*1e-6+lvaro_nld90b_sphv_10hv-lap_nld90b_sphv_10hv+dlq_nld90b_sphv_10hv)
+    dwqs			    = (wmosendng-wchpg)*1e-6
+    dlqs			    = (dlq_nld90b_sphv_10hv+(dwqs-dwq_nld90b_sphv_10hv)*leff_psp/weff_psp)

// parameters for veriloga
+ vp_nld90b_10hv = (45)
+ dvp_nld90b_10hv = (5)
+ type_nld90b_10hv = (1)


//*m1 to poly gate capacitance:
// *check final pcell later
// *total width of source contacts facing gate
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.74*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (number_ct_d*0.18)
+    lfr_m1_ply_s                   = ((w+2*0.555*(1-fem))-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = ((w+2*0.17*(1-fem))-lfr_ct_ply_d)
+    cfr_s_ply_met_nld90b_sphv_10hv           = (nom_cfr_s_ply_met_nld90b_sphv_10hv*(nom_delr_cfr_s_ply_met_nld90b_sphv_10hv+nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv*sig_delr_cfr_s_ply_met_nld90b_sphv_10hv))
+    cfr_d_ply_met_nld90b_sphv_10hv           = (nom_cfr_d_ply_met_nld90b_sphv_10hv*(nom_delr_cfr_d_ply_met_nld90b_sphv_10hv+nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv*sig_delr_cfr_d_ply_met_nld90b_sphv_10hv))
+    cfr_s_ply_m1ct_nld90b_sphv_10hv          = (nom_cfr_s_ply_m1ct_nld90b_sphv_10hv*(nom_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv+nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv*sig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv))
+    cfr_d_ply_m1ct_nld90b_sphv_10hv          = (nom_cfr_d_ply_m1ct_nld90b_sphv_10hv*(nom_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv+nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv*sig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv))

+ cgs_ply_m1=(lfr_m1_ply_s*cfr_s_ply_met_nld90b_sphv_10hv+lfr_ct_ply_s*cfr_s_ply_m1ct_nld90b_sphv_10hv)
+ cgd_ply_m1=(lfr_m1_ply_d*cfr_d_ply_met_nld90b_sphv_10hv+lfr_ct_ply_d*cfr_d_ply_m1ct_nld90b_sphv_10hv)

//*poly gate resistance calculations

+    rgateout                       = (rply*(w+2*8.625*(1-fem))/((lch+lacc)*3))
+    rgatein                        = (rply*(aplyfld_d/(lflap))/(lflap*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*0.04)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+0.2)-2/(2+0.2))*(-0.045)*((w+2.0)/w))
+ fac_r_ng_uo=(1+(ngeff/(ngeff+2)-2/(2+2))*0.04*(w/(w+1.5)))


// parameters for the self-heating
+    w_heat=w
+    l_heat=lcell*ng
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld90b_sphv_10hv)*ngeff
+ cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

// parasitic capacitance caused by dummy gate
+     aply_fld_cgd_dmy=(0)
+     pply_fld_cgd_dmy=(0)
+     cgd_ply_fld_dmy=(0)

// parameters for the D/B diode trr
+ tt_nld90b_10hv = 1.0e-9*maxa(311.27*(1-0.018882963*w),0,1e-12)

// parameters for the BV diode
+ dcbv_nld90b_10hv = (115)


// BV diode model card:
model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt   = (1e12)
+ tnom    = (27)
+ is      = (1e-30)
+ n       = (1.0)
+ cj      = (1e-30)
+ pta     = (0)
+ tlevc   = (2)
+ tlev    = (2)
+ bv      = (dcbv_nld90b_10hv+bvdss_shift)
+ ibv     = (1e-5/1e-12)


model pspmoscapgsp psp103t type=n
+ tr	 = 27
+ toxo   = toxo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv
+ vfbo   = vfbo_nld90b_sphv_10hv+dela_vfb_nld90b_sphv_10hv+1.1
+ vfbw   = vfbw_nld90b_sphv_10hv-1.2
+ dphibo = dphibo_nld90b_sphv_10hv-0.25
+ dphibw = (dphibw_nld90b_sphv_10hv+3.75)*(1-fem)
+ nsubo  = nsubo_nld90b_sphv_10hv*0.1
+ nsubw  = (nsubw_nld90b_sphv_10hv-1.4)*(1-fem)
+ rtho   = 1e18
+ ctho   = 0
+ uo	 = 0


model sphvt_simkit sphvt
+ type     = (n)
+ vdscale  = (1.18+(-0.24)*(1-fem)/w)*delr_ids_nld90b_sphv_10hv
+ vdscaleb = (0)
+ stvdscale= (-0.1+(-0.55)*(1-fem)/w)
+ ctgo     = (0.02)
+ ctbo     = (0)
+ stcto    = (1.3)
+ strthao  = (1.55)
+ tr	   = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (1)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ qmc	   = (qmc_nld90b_sphv_10hv)
+ lvaro    = (lvaro_nld90b_sphv_10hv)
+ lvarl    = (lvarl_nld90b_sphv_10hv)
+ lvarw    = (lvarw_nld90b_sphv_10hv*(1-fem))
+ lap	   = (lap_nld90b_sphv_10hv)
+ wvaro    = (wvaro_nld90b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld90b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld90b_sphv_10hv*(1-fem))
+ wot	   = ((wot_nld90b_sphv_10hv+0.5e-6*dela_dw_nld90b_sphv_10hv)*(1-fem))
+ dlq	   = (dlqs)
+ dwq	   = (dwq_nld90b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld90b_sphv_10hv+dela_vfb_nld90b_sphv_10hv+dela_vth_relimo+fac_a_ng_vfbo+hvgsvthdegr*presto_nld90b_vthratio)
+ vfbl     = (vfbl_nld90b_sphv_10hv)
+ vfbw     = (vfbw_nld90b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld90b_sphv_10hv+dela_vtwl_nld90b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld90b_sphv_10hv)*(1-maxa(-9e-3*(temp-27), 0, 1e-12))
+ stvfbl   = (stvfbl_nld90b_sphv_10hv)
+ stvfbw   = (stvfbw_nld90b_sphv_10hv*(1-maxa(-18e-2*(temp-27), 0, 1e-12))*(1-fem))
+ stvfblw  = (stvfblw_nld90b_sphv_10hv*(1-fem))
+ toxo     = (toxo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ epsroxo  = (epsroxo_nld90b_sphv_10hv)
+ nsubo    = (nsubo_nld90b_sphv_10hv*delr_nsub_nld90b_sphv_10hv)
+ nsubw    = (nsubw_nld90b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld90b_sphv_10hv)
+ npck     = (npck_nld90b_sphv_10hv)
+ npckw    = (npckw_nld90b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld90b_sphv_10hv)
+ lpck     = (lpck_nld90b_sphv_10hv)
+ lpckw    = (lpckw_nld90b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld90b_sphv_10hv)
+ fol2     = (fol2_nld90b_sphv_10hv)
+ facneffaco = (facneffaco_nld90b_sphv_10hv)
+ facneffacl = (facneffacl_nld90b_sphv_10hv)
+ facneffacw = (facneffacw_nld90b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld90b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld90b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld90b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld90b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld90b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld90b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld90b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld90b_sphv_10hv)
+ vnsubo   = (vnsubo_nld90b_sphv_10hv)
+ nslpo    = (nslpo_nld90b_sphv_10hv)
+ dnsubo   = (dnsubo_nld90b_sphv_10hv)
+ dphibo   = (dphibo_nld90b_sphv_10hv)
+ dphibl   = (dphibl_nld90b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld90b_sphv_10hv)
+ dphibw   = (dphibw_nld90b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld90b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld90b_sphv_10hv)
+ delvtacl = (delvtacl_nld90b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld90b_sphv_10hv)
+ delvtacw = (delvtacw_nld90b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_nld90b_sphv_10hv*(1-fem))
+ npo	   = (npo_nld90b_sphv_10hv)
+ npl	   = (npl_nld90b_sphv_10hv)
+ cto	   = (cto_nld90b_sphv_10hv)
+ ctl	   = (ctl_nld90b_sphv_10hv)
+ ctlexp   = (ctlexp_nld90b_sphv_10hv)
+ ctw	   = (ctw_nld90b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld90b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ toxovdo  = (toxovdo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ lov	   = (lov_nld90b_sphv_10hv)
+ dlovd    = (dlovd_nld90b_sphv_10hv)
+ novo     = (novo_nld90b_sphv_10hv)
+ novdo    = (novdo_nld90b_sphv_10hv)
+ cfl	   = (cfl_nld90b_sphv_10hv)
+ cflexp   = (cflexp_nld90b_sphv_10hv)
+ cfw	   = (cfw_nld90b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld90b_sphv_10hv)
+ uo	   = (uo_nld90b_sphv_10hv*(weff/w)*delr_mobref_nld90b_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_nld90b_sphv_10hv)
+ fbet1w   = (fbet1w_nld90b_sphv_10hv*(1-fem))
+ lp1	   = (lp1_nld90b_sphv_10hv)
+ lp1w     = (lp1w_nld90b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld90b_sphv_10hv)
+ lp2	   = (lp2_nld90b_sphv_10hv)
+ betw1    = (betw1_nld90b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld90b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld90b_sphv_10hv)
+ stbeto   = (stbeto_nld90b_sphv_10hv)
+ stbetl   = (stbetl_nld90b_sphv_10hv)
+ stbetw   = (stbetw_nld90b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_nld90b_sphv_10hv*(1-fem))
+ mueo     = (mueo_nld90b_sphv_10hv)
+ muew     = (muew_nld90b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld90b_sphv_10hv)
+ themuo   = (themuo_nld90b_sphv_10hv)
+ stthemuo = (stthemuo_nld90b_sphv_10hv)
+ cso	   = (cso_nld90b_sphv_10hv)
+ csl	   = (csl_nld90b_sphv_10hv)
+ cslexp   = (cslexp_nld90b_sphv_10hv)
+ csw	   = (csw_nld90b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld90b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld90b_sphv_10hv)
+ xcoro    = (xcoro_nld90b_sphv_10hv)
+ xcorl    = (xcorl_nld90b_sphv_10hv)
+ xcorw    = (xcorw_nld90b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_nld90b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_nld90b_sphv_10hv)
+ fetao    = (fetao_nld90b_sphv_10hv)
+ rsw1     = (rsw1_nld90b_sphv_10hv)
+ rsw2     = (rsw2_nld90b_sphv_10hv*(1-fem))
+ strso    = (strso_nld90b_sphv_10hv)
+ rsbo     = (rsbo_nld90b_sphv_10hv)
+ rsgo     = (rsgo_nld90b_sphv_10hv)
+ thesato  = ((thesato_nld90b_sphv_10hv)*(1+maxa(-0.5e-2*(w/(w+(1-fem)*3.0))*(temp-27),0,1e-9)))
+ thesatl  = (thesatl_nld90b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld90b_sphv_10hv)
+ thesatw  = (thesatw_nld90b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld90b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld90b_sphv_10hv)
+ stthesatl = (stthesatl_nld90b_sphv_10hv)
+ stthesatw = (stthesatw_nld90b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_nld90b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_nld90b_sphv_10hv)
+ thesatgo = (thesatgo_nld90b_sphv_10hv)
+ thesatgl = (thesatgl_nld90b_sphv_10hv)
+ thesatgw = ((thesatgw_nld90b_sphv_10hv)*(1-fem))
+ axo	   = (axo_nld90b_sphv_10hv)
+ axl	   = (axl_nld90b_sphv_10hv)
+ alpl     = (alpl_nld90b_sphv_10hv)
+ alplexp  = (alplexp_nld90b_sphv_10hv)
+ alpw     = (alpw_nld90b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld90b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld90b_sphv_10hv)
+ alp1l2   = (alp1l2_nld90b_sphv_10hv)
+ alp1w    = (alp1w_nld90b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld90b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld90b_sphv_10hv)
+ alp2l2   = (alp2l2_nld90b_sphv_10hv)
+ alp2w    = (alp2w_nld90b_sphv_10hv*(1-fem))
+ vpo	   = (vpo_nld90b_sphv_10hv)
+ a1o	   = (a1o_nld90b_sphv_10hv)
+ a1l	   = (a1l_nld90b_sphv_10hv)
+ a1w	   = (a1w_nld90b_sphv_10hv*(1-fem))
+ a2o	   = (a2o_nld90b_sphv_10hv)
+ sta2o    = (sta2o_nld90b_sphv_10hv)
+ a3o	   = (a3o_nld90b_sphv_10hv)
+ a3l	   = (a3l_nld90b_sphv_10hv)
+ a3w	   = (a3w_nld90b_sphv_10hv*(1-fem))
+ a4o	   = (a4o_nld90b_sphv_10hv)
+ a4l	   = (a4l_nld90b_sphv_10hv)
+ a4w	   = (a4w_nld90b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld90b_sphv_10hv)
+ iginvlw  = (iginvlw_nld90b_sphv_10hv)
+ igovw    = (igovw_nld90b_sphv_10hv)
+ igovdw   = (igovdw_nld90b_sphv_10hv)
+ stigo    = (stigo_nld90b_sphv_10hv)
+ gc2o     = (gc2o_nld90b_sphv_10hv)
+ gc3o     = (gc3o_nld90b_sphv_10hv)
+ chibo    = (chibo_nld90b_sphv_10hv)
+ agidlw   = (agidlw_nld90b_sphv_10hv)
+ agidldw  = (agidldw_nld90b_sphv_10hv)
+ bgidlo   = (bgidlo_nld90b_sphv_10hv)
+ bgidldo  = (bgidldo_nld90b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld90b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld90b_sphv_10hv)
+ cgidlo   = (cgidlo_nld90b_sphv_10hv)
+ cgidldo  = (cgidldo_nld90b_sphv_10hv)
+ cgbovl   = (cgbovl_nld90b_sphv_10hv)
+ cfrw     = (cfrw_nld90b_sphv_10hv)
+ cfrdw    = (cfrdw_nld90b_sphv_10hv)
+ fnto     = (fnto_nld90b_sphv_10hv)
+ nfalw    = (nfalw_nld90b_sphv_10hv)
+ nfblw    = (nfblw_nld90b_sphv_10hv)
+ nfclw    = (nfclw_nld90b_sphv_10hv)
+ efo	   = (efo_nld90b_sphv_10hv)
+ lintnoi  = (lintnoi_nld90b_sphv_10hv)
+ alpnoi   = (alpnoi_nld90b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld90b_sphv_10hv)
+ kvthowel = (kvthowel_nld90b_sphv_10hv)
+ kvthowew = (kvthowew_nld90b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_nld90b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_nld90b_sphv_10hv)
+ kuowel   = (kuowel_nld90b_sphv_10hv)
+ kuowew   = (kuowew_nld90b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_nld90b_sphv_10hv*(1-fem))
+ rgo	   = (rgo_nld90b_sphv_10hv)
+ rsh	   = (rsh_nld90b_sphv_10hv)
+ rbulko   = (rbulko_nld90b_sphv_10hv)
+ rwello   = (rwello_nld90b_sphv_10hv)
+ rjunso   = (rjunso_nld90b_sphv_10hv/(w+(1-fem)*dwrjunso_nld90b_sphv_10hv))
+ rjundo   = ((rjundo_nld90b_sphv_10hv/(w+(1-fem)*dwrjundo_nld90b_sphv_10hv))*(1+1.0e-3*(temp-27)))
+ rint     = (rint_nld90b_sphv_10hv)
+ rvpoly   = (rvpoly_nld90b_sphv_10hv)
+ rshg     = (rshg_nld90b_sphv_10hv)
+ dlsil    = (dlsil_nld90b_sphv_10hv)
+ saref    = (saref_nld90b_sphv_10hv)
+ sbref    = (sbref_nld90b_sphv_10hv)
+ wlod     = (wlod_nld90b_sphv_10hv)
+ kuo	   = (kuo_nld90b_sphv_10hv)
+ kvsat    = (kvsat_nld90b_sphv_10hv)
+ tkuo     = (tkuo_nld90b_sphv_10hv)
+ lkuo     = (lkuo_nld90b_sphv_10hv)
+ wkuo     = (wkuo_nld90b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_nld90b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_nld90b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld90b_sphv_10hv)
+ kvtho    = (kvtho_nld90b_sphv_10hv)
+ lkvtho   = (lkvtho_nld90b_sphv_10hv)
+ wkvtho   = (wkvtho_nld90b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_nld90b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_nld90b_sphv_10hv)
+ wlodvth  = (wlodvth_nld90b_sphv_10hv)
+ stetao   = (stetao_nld90b_sphv_10hv)
+ lodetao  = (lodetao_nld90b_sphv_10hv)
+ scref    = (scref_nld90b_sphv_10hv)
+ web	   = (web_nld90b_sphv_10hv)
+ wec	   = (wec_nld90b_sphv_10hv)
+ adr1o    = (adr1o_nld90b_sphv_10hv)
+ adr1l    = (adr1l_nld90b_sphv_10hv)
+ adr1w    = (adr1w_nld90b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_nld90b_sphv_10hv)
+ stadr2o  = (stadr2o_nld90b_sphv_10hv)
+ adr3o    = (adr3o_nld90b_sphv_10hv)
+ adr3l    = (adr3l_nld90b_sphv_10hv)
+ adr3w    = (adr3w_nld90b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_nld90b_sphv_10hv)
+ adr4l    = (adr4l_nld90b_sphv_10hv)
+ adr4w    = (adr4w_nld90b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_nld90b_sphv_10hv)
+ adr5l    = (adr5l_nld90b_sphv_10hv)
+ adr5w    = (adr5w_nld90b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_nld90b_sphv_10hv)
+ bidr1l   = (bidr1l_nld90b_sphv_10hv)
+ bidr1w   = (bidr1w_nld90b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_nld90b_sphv_10hv)
+ bidr2w   = (bidr2w_nld90b_sphv_10hv*(1-fem))
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld90b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld90b_sphv_10hv*delr_rshl_nld90b_sphv_10hv*delr_rdsw_relimo*fac_r_ng_rshldd)*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld90b_ronratio))
+ xw	   = ((xw_nld90b_sphv_10hv+1.0e-6*dela_xw_nld90b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld90b_sphv_10hv*(1-fem))
+ xl	   = (xl_nld90b_sphv_10hv)
+ xlw	   = (xlw_nld90b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld90b_sphv_10hv)
+ nst	   = (nst_nld90b_sphv_10hv)
+ ats	   = (ats_nld90b_sphv_10hv)
+ dfinf    = (dfinf_nld90b_sphv_10hv)
+ dfw	   = (dfw_nld90b_sphv_10hv*(1-fem))
+ dfl	   = (dfl_nld90b_sphv_10hv)
+ dflw     = (dflw_nld90b_sphv_10hv*(1-fem))
+ dp	   = (dp_nld90b_sphv_10hv)
+ ecrit    = (ecrit_nld90b_sphv_10hv*tfact_ecrit)
+ ecorn    = (ecorn_nld90b_sphv_10hv)
+ du	   = (du_nld90b_sphv_10hv)
+ tc1	   = (tc1_nld90b_sphv_10hv)
+ tc2	   = (tc2_nld90b_sphv_10hv)
+ tc1l     = (tc1l_nld90b_sphv_10hv)
+ tc2l     = (tc2l_nld90b_sphv_10hv)
+ tc1w     = (tc1w_nld90b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld90b_sphv_10hv*(1-fem))
+ theacc   = (theacc_nld90b_sphv_10hv)
+ theacc2  = (theacc2_nld90b_sphv_10hv)
+ aacc     = (aacc_nld90b_sphv_10hv)
+ rva	   = (rva_nld90b_sphv_10hv)
+ dta	   = (dta_nld90b_sphv_10hv)
+ trj	   = (27)
+ cjarea   = (cjarea_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlsti   = (cjlsti_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlgat   = (cjlgat_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ vbiarea  = (vbiarea_nld90b_sphv_10hv)
+ vbisti   = (vbisti_nld90b_sphv_10hv)
+ vbigat   = (vbigat_nld90b_sphv_10hv)
+ parea    = (parea_nld90b_sphv_10hv)
+ psti     = (psti_nld90b_sphv_10hv)
+ pgat     = (pgat_nld90b_sphv_10hv)
+ is1area  = (is1area_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttarea   = (tt_nld90b_10hv)
+ is2area  = (is2area_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irarea   = (irarea_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1area = (stis1area_nld90b_sphv_10hv)
+ stis2area = (stis2area_nld90b_sphv_10hv)
+ stirarea = (stirarea_nld90b_sphv_10hv)
+ n1area   = (n1area_nld90b_sphv_10hv)
+ n2area   = (n2area_nld90b_sphv_10hv)
+ nrarea   = (nrarea_nld90b_sphv_10hv)
+ is1lsti  = (is1lsti_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttlsti   = (tt_nld90b_10hv)
+ is2lsti  = (is2lsti_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irlsti   = (irlsti_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1sti = (stis1sti_nld90b_sphv_10hv)
+ stis2sti = (stis2sti_nld90b_sphv_10hv)
+ stirsti  = (stirsti_nld90b_sphv_10hv)
+ n1sti    = (n1sti_nld90b_sphv_10hv)
+ n2sti    = (n2sti_nld90b_sphv_10hv)
+ nrsti    = (nrsti_nld90b_sphv_10hv)
+ is1lgat  = (is1lgat_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttlgat   = (tt_nld90b_10hv)
+ is2lgat  = (is2lgat_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irlgat   = (irlgat_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1gat = (stis1gat_nld90b_sphv_10hv)
+ stis2gat = (stis2gat_nld90b_sphv_10hv)
+ stirgat  = (stirgat_nld90b_sphv_10hv)
+ n1gat    = (n1gat_nld90b_sphv_10hv)
+ n2gat    = (n2gat_nld90b_sphv_10hv)
+ nrgat    = (nrgat_nld90b_sphv_10hv)
+ cjaread  = (cjaread_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlstid  = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ cjlgatd  = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ vbiaread = (vbiaread_nld90b_sphv_10hv)
+ vbistid  = (vbigatd_nld90b_sphv_10hv)
+ vbigatd  = (vbigatd_nld90b_sphv_10hv)
+ paread   = (paread_nld90b_sphv_10hv)
+ pstid    = (pgatd_nld90b_sphv_10hv)
+ pgatd    = (pgatd_nld90b_sphv_10hv)
+ is1aread = (is1aread_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttaread  = (tt_nld90b_10hv)
+ is2aread = (is2aread_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ iraread  = (iraread_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1aread = (stis1aread_nld90b_sphv_10hv)
+ stis2aread = (stis2aread_nld90b_sphv_10hv)
+ stiraread = (stiraread_nld90b_sphv_10hv)
+ n1aread  = (n1aread_nld90b_sphv_10hv)
+ n2aread  = (n2aread_nld90b_sphv_10hv)
+ nraread  = (nraread_nld90b_sphv_10hv)
+ is1lstid = (is1lstid_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlstid  = (tt_nld90b_10hv)
+ is2lstid = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlstid  = (irlstid_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1stid = (stis1stid_nld90b_sphv_10hv)
+ stis2stid = (stis2stid_nld90b_sphv_10hv)
+ stirstid = (stirstid_nld90b_sphv_10hv)
+ n1stid   = (n1stid_nld90b_sphv_10hv)
+ n2stid   = (n2stid_nld90b_sphv_10hv)
+ nrstid   = (nrstid_nld90b_sphv_10hv)
+ is1lgatd = (is1lgatd_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlgatd  = (tt_nld90b_10hv)
+ is2lgatd = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlgatd  = (irlgatd_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld90b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld90b_sphv_10hv)
+ stirgatd = (stirgatd_nld90b_sphv_10hv)
+ n1gatd   = (n1gatd_nld90b_sphv_10hv)
+ n2gatd   = (n2gatd_nld90b_sphv_10hv)
+ nrgatd   = (nrgatd_nld90b_sphv_10hv)
+ cjaread2 = (cjaread_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlstid2 = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ vbiaread2 = (vbiaread_nld90b_sphv_10hv)
+ vbistid2 = (vbistid2_nld90b_sphv_10hv)
+ paread2  = (paread_nld90b_sphv_10hv)
+ pstid2   = (pstid2_nld90b_sphv_10hv)
+ is1aread2 = (is1aread2_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttaread2 = (tt_nld90b_10hv)
+ is2aread2 = (is2aread_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ iraread2 = (iraread2_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1aread2 = (stis1aread_nld90b_sphv_10hv)*(1-(1-fem)*5.0/w)
+ stis2aread2 = (stis2aread_nld90b_sphv_10hv)
+ stiraread2 = (stiraread2_nld90b_sphv_10hv)
+ n1aread2 = (n1aread2_nld90b_sphv_10hv)*(1+(1-fem)*0.1/w)
+ n2aread2 = (n2aread2_nld90b_sphv_10hv)
+ nraread2 = (nraread2_nld90b_sphv_10hv)
+ is1lstid2 = (is1aread_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlstid2 = (tt_nld90b_10hv)
+ is2lstid2 = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlstid2 = (irlstid2_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld90b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld90b_sphv_10hv)
+ stirstid2 = (stirstid2_nld90b_sphv_10hv)
+ n1stid2  = (n1stid2_nld90b_sphv_10hv)
+ n2stid2  = (n2stid2_nld90b_sphv_10hv)
+ nrstid2  = (nrstid2_nld90b_sphv_10hv)
+ eairarea	  = (1.12)
+ eairaread	  = (1.12)
+ eairaread2	  = (1.12)
+ eairgat	  = (1.12)
+ eairgatd	  = (1.12)
+ eairsti	  = (1.12)
+ eairstid	  = (1.12)
+ eairstid2	  = (1.12)
+ eais1area	  = (1.12)
+ eais1aread	  = (1.12)
+ eais1aread2	  = (1.12)
+ eais1gat	  = (1.12)
+ eais1gatd	  = (1.12)
+ eais1sti	  = (1.12)
+ eais1stid	  = (1.12)
+ eais1stid2	  = (1.12)
+ eais2area	  = (1.12)
+ eais2aread	  = (1.12)
+ eais2aread2	  = (1.12)
+ eais2gat	  = (1.12)
+ eais2gatd	  = (1.12)
+ eais2sti	  = (1.12)
+ eais2stid	  = (1.12)
+ eais2stid2	  = (1.12)
+ ikfarea               = ikfarea_nld90b_sphv_10hv
+ ikflsti               = ikfarea_nld90b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld90b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld90b_sphv_10hv
+ stikfsti              = stikfarea_nld90b_sphv_10hv
+ stikfgat              = stikfarea_nld90b_sphv_10hv
+ ikfaread              = ikfaread_nld90b_sphv_10hv*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflstid              = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflgatd              = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikfaread2             = ikfaread_nld90b_sphv_10hv*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflstid2             = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ stikfaread             = stikfaread_nld90b_sphv_10hv
+ stikfstid             = stikfaread_nld90b_sphv_10hv
+ stikfgatd             = stikfaread_nld90b_sphv_10hv
+ stikfaread2            = stikfaread_nld90b_sphv_10hv
+ stikfstid2            = stikfaread_nld90b_sphv_10hv

// ******  elements:
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1_i mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
mendcapp  (s intg s s dtemp) pspmoscapgsp l=lch w=(wpg) mult=ng

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=p
+    tr    = 27
+    toxo  = 380e-9
+    vfbo  = 0
+    nsubo = 1.5e22
+    npck  = 1e22
+    lpck  = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo    = 0



cgs_fld       (intg s)  capacitor c=(cgs_ply_fld_nld90b) m=ng
cgs_ply_cfr   (intg s)  capacitor c=(cfr_ply_s) m=ng
cgs_m1        (intg s) capacitor c=(cgs_ply_m1)  m=ng
rgate     (g intg) resistor r=rgatetot m=ng
dbodyBV (s rs)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rs d)   resistor r=0.01
xdsub     (s sub) cdgontub_box_sub_10hv  area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1

//dummy_gate model
if (ng_dmy>=2) {
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1_i mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

}


include "./smos10hv_ade_dfrt.scs" section=nld90b_10hv_dfrt
ends
// pld65_10hv

subckt pld65_10hv (d g s sub)

parameters
+ w				 = (2.5)
+ ng				 = (2)
+ lpe				 = (0)
+ sti_dummy			 = (0)
+ fem				 = (0)
+ soa				 = (1)
+ selfheat			 = (1)
+ mode_rthcth			 = (1)
+ dela_vth_relimo		 = (0)
+ dela_vth_relimo_mod		 = (0)
+ delr_u0_relimo		 = (1)
+ delr_rdsw_relimo		 = (1)
+ delr_a0_relimo		 = (1)
+ presto_device_active           = (1)
+ nbtidamage		         = (0.0)
+ nbtivthdegr		         = (0.0)
+ pbtidamage		         = (0.0)
+ pbtivthdegr		         = (0.0)
+ hcirondegrfac 	         = (0.0)
+ offrondegrfac 	         = (0.0)
+ hvgsvthdegr		         = (0.0)
+ hcidamage1		         = (0.0)
+ hcidamage2		         = (0.0)
+ offdamage1		         = (0.0)
+ offdamage2		         = (0.0)
+ hvgsdamage		         = (0.0)
+ presto_pld65_vthratio          = 1.0*(1.0/1.2052)
+ presto_pld65_ronratio          = 0.01/1.0/1.0636
+ l				 = (0.5)
+ tn                             = (27+273.15)
+ delt                           = (temp+273.15-tn)
+ nsmm_delr_tox_pld65_sphv_10hv    = tmp_nsmm_delr_tox_pld65_sphv_10hv
+ nsmm_dela_vfb_pld65_sphv_10hv    = tmp_nsmm_dela_vfb_pld65_sphv_10hv
+ nsmm_dela_vtw_pld65_sphv_10hv    = tmp_nsmm_dela_vtw_pld65_sphv_10hv
+ nsmm_delr_uch_pld65_sphv_10hv    = tmp_nsmm_delr_uch_pld65_sphv_10hv
+ nsmm_delr_res_pld65_sphv_10hv    = tmp_nsmm_delr_res_pld65_sphv_10hv
+ nsmm_dela_dwox_pld65_sphv_10hv   = tmp_nsmm_dela_dwox_pld65_sphv_10hv
+ nsmm_delr_nsub_pld65_sphv_10hv   = tmp_nsmm_delr_nsub_pld65_sphv_10hv


//process parameters
//+ delr_tox_pld65_sphv_10hv    = (nom_delr_tox_pld65_sphv_10hv*(1+sig_delr_tox_pld65_sphv_10hv*nsig_delr_tox_pld65_sphv_10hv+nsmm_delr_tox_pld65_sphv_10hv*smm_delr_tox_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_tox_pld65_sphv_10hv      = (nom_delr_tox_pld65_sphv_10hv*(1+sig_delr_tox_pld65_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld65_sphv_10hv*smm_delr_tox_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld65_sphv_10hv      = (nom_dela_vfb_pld65_sphv_10hv+(sig_dela_vfb_pld65_sphv_10hv*nsig_dela_vfb_pld65_sphv_10hv)+nsmm_dela_vfb_pld65_sphv_10hv*smm_dela_vfb_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld65_sphv_10hv      = (nom_dela_vtw_pld65_sphv_10hv+(sig_dela_vtw_pld65_sphv_10hv*nsig_dela_vtw_pld65_sphv_10hv)+nsmm_dela_vtw_pld65_sphv_10hv*smm_dela_vtw_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld65_sphv_10hv      = (nom_delr_uch_pld65_sphv_10hv*(1+sig_delr_uch_pld65_sphv_10hv*nsig_delr_uch_pld65_sphv_10hv+nsmm_delr_uch_pld65_sphv_10hv*smm_delr_uch_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld65_sphv_10hv      = (nom_delr_res_pld65_sphv_10hv*(1+sig_delr_res_pld65_sphv_10hv*nsig_delr_res_pld65_sphv_10hv+nsmm_delr_res_pld65_sphv_10hv*smm_delr_res_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld65_sphv_10hv     = (nom_dela_dwox_pld65_sphv_10hv+(sig_dela_dwox_pld65_sphv_10hv*nsig_dela_dwox_pld65_sphv_10hv)+nsmm_dela_dwox_pld65_sphv_10hv*smm_dela_dwox_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld65_sphv_10hv     = (1+nsmm_delr_nsub_pld65_sphv_10hv*smm_delr_nsub_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld65_sphv_10hv	= (nom_delr_cj_pld65_sphv_10hv*(1.0+nsig_delr_cj_pld65_sphv_10hv*sig_delr_cj_pld65_sphv_10hv))
+ delr_is_pld65_sphv_10hv	= (nom_delr_is_pld65_sphv_10hv*exp(nsig_delr_is_pld65_sphv_10hv*sig_delr_is_pld65_sphv_10hv))
+ delr_is2_pld65_sphv_10hv	= (nom_delr_is2_pld65_sphv_10hv*exp(nsig_delr_is2_pld65_sphv_10hv*sig_delr_is2_pld65_sphv_10hv))
+ delr_ir_pld65_sphv_10hv	= (nom_delr_ir_pld65_sphv_10hv*exp(nsig_delr_ir_pld65_sphv_10hv*sig_delr_ir_pld65_sphv_10hv))

parameters
//+ nde=(fmod(ng,2))
+ nde     = (0)
+ nse     = (2-nde)
+ nd      = ((ng+nde)/2)
+ ns      = (1-nde+nd)
+ ndi     = (nd-nde)
+ nsi     = (ns-nse)

//dummy parameters
+ ng_dmy  = (2*sti_dummy)
+ ng_eff  = (ng+ng_dmy)
+ ndi_eff = (ng_eff/2)
+ nsi_eff = ((ng_eff-2)/2)

+ wdrift  = (w)
+ ldrift  = (3.0)
+ ldr1    = (0.45)
+ lacts   = (0.3)
+ lactd   = (0.69)
+ lactg   = (0.35)

// junction calculation
+ as               = (w*lacts)*0
+ ps               = ((w+lacts)*2.0)*0
+ w2nhv            = (5.3)*(1-fem)
+ rnhv             = (1.44)
+ rnhv_p           = 2*rnhv*pi4models
+ rnhv_a           = rnhv*rnhv*pi4models
+ rnhv_daera       = (rnhv*rnhv-rnhv_a/4.0)*(1-fem)
+ ad               = ((ldr1+lactg+ldrift/2.0)*(w+2.0*w2nhv*(1-fem))-rnhv_daera*2.0*(1-fem))
+ pd               = ((ldr1+lactg+ldrift/2.0)*2.0*(1-fem)+(w+2.0*w2nhv*(1-fem))-4.0*rnhv*(1-fem)+rnhv_p/2.0*(1-fem))
+ ad2              = ((ldrift/2.0+lactd/2.0)*(w+2.0*w2nhv*(1-fem)))
+ pd2              = (ldrift+lactd)*(1-fem)

// nbl-oxide-sub box cap calculation
+ lb2b_d           = (8.29)
+ lp2p_s           = (0.99)
+ lp2dt_s          = (3.66)
+ w2dt             = (9.3)
+ xlnbl            = (lp2dt_s*nse+l*ng_eff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl            = (w+2.0*w2dt*(1-fem))
+ alnbl            = (xlnbl*ylnbl)
+ plnbl            = (2.0*(xlnbl*(1-fem)+ylnbl))

// heat region calculation
+ w_heat           = (w)
+ l_heat           = (lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ fac_rthNgT       = 1.8/(1.0+0.7/ng)*(1+0.00002*(temp-tnom)/(0.03+0.1/ng))
+ rth_f            = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld65_sphv_10hv*fac_rthNgT+(mode_rthcth==2)*rth*fac_rth_pld65_sphv_10hv*fac_rthNgT)*ng_eff
+ cth_f            = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff

+ djunc            = (2.5*1e-06)


//parasitic rgate calcultion
+ lflap 	   = (1.2)
+ length 	   = (l+ldr1+lflap)
+ w_ploycont2act   = (6.075)
+ rs_poly_gate     = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply             = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ r_gate           = (rply*((w+2*w_ploycont2act*(1-fem))/(length*3*ng)))

// calculation for poly over field parasitic capacitance, from pld90b
+ dwcgdfldmoscap   = (18)*(1-fem)
+ dwcgd_ply_fld    = (5)*(1-fem)
+ cgd_ply_fld      = (4.8e-17)*(w+dwcgd_ply_fld)*ng
+ cgs_ply_fld      = (3.375e-15)*(1-fem)*ng

// parasitic capacitnace caused by dummy gate, from pld90b
+ cgd_ply_fld_dmy  = (4.8e-17)*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld65_10hv    = (27)
+ dvp_pld65_10hv   = (6.2)
+ type_pld65_10hv  = (-1)

// calculation for parasitic Cgd & Cgs from routing, should be flagged off
// nom values are copied from V3M_1_FULL
// those nom's flagged off are used only for parasitic cap of dut routing
//+    nom_cpp_m2_ply_copied                 = (0.0269586592e-15)
//+    nom_cfr_m2_ply_copied                 = (0.0328181197349055e-15)
//+    nom_delr_cpp_m2_ply_copied            = (1)
//+    nom_delr_cfr_m2_ply_copied            = (1)
//+    nom_cpp_m2_m1_copied                  = (0.0672904e-15)
//+    nom_cfr_m2_m1_copied                  = (0.0412247297136575e-15)
//+    nom_delr_cpp_m2_m1_copied             = (1)
//+    nom_delr_cfr_m2_m1_copied             = (1)
+    nom_cpp_m3_ply_copied                 = (0.016515949268292e-15)
+    nom_cfr_m3_ply_copied                 = (0.0312438978945075e-15)
+    nom_delr_cpp_m3_ply_copied            = (1)
+    nom_delr_cfr_m3_ply_copied            = (1)
//+    nom_cpp_m3_m1_copied                  = (0.026105678461538e-15)
//+    nom_cfr_m3_m1_copied                  = (0.0347696665106795e-15)
//+    nom_delr_cpp_m3_m1_copied             = (1)
//+    nom_delr_cfr_m3_m1_copied             = (1)
//+    nom_cpp_ply_fld_copied                = (0.092229166666667e-15)
//+    nom_cfr_ply_fld_copied                = (0.042429385448008e-15)
//+    nom_delr_cpp_ply_fld_copied           = (1)
//+    nom_delr_cfr_ply_fld_copied           = (1)
//+    cpp_ply_fld                           = (nom_cpp_ply_fld_copied*nom_delr_cpp_ply_fld_copied)
//+    cfr_ply_fld                           = (nom_cfr_ply_fld_copied*nom_delr_cfr_ply_fld_copied)

//intrinsic cgs from pcell routing, should be kept
+    w2ply_inner                    = 2.175
+    w2ply_outer                    = 6.3
+    w_m1onpoly                     = 1.27
+    w_m1notonpoly                  = (w2ply_outer-w2ply_inner-w_m1onpoly)
+    w2m1_s                         = 0.555
+    a_m1_poly_cgs                  = 0.45*(w+w2m1_s*2*(1-fem))*ng
+    p_m1_poly_cgs                  = (w+w2m1_s*2*(1-fem))*ng
+    cgs1_m1_ply                    = a_m1_poly_cgs*nom_cpp_m3_ply_copied*nom_delr_cpp_m3_ply_copied+p_m1_poly_cgs*nom_cfr_m3_ply_copied*nom_delr_cfr_m3_ply_copied

//parasitic cgd from dut routing, should be flagged off
//+    a_m2_poly_cgd                  = 0.69*w_m1notonpoly/2*ng
//+    p_m2_poly_cgd                  = w_m1notonpoly*ng
//+    a_m2_m1_cgd                    = 0.69*w_m1onpoly/2*ng
//+    p_m2_m1_cgd                    = w_m1onpoly*ng
//+    cgd1_m2_ply                    = a_m2_poly_cgd*nom_cpp_m2_ply_copied*nom_delr_cpp_m2_ply_copied+p_m2_poly_cgd*nom_cfr_m2_ply_copied*nom_delr_cfr_m2_ply_copied
//+    cgd2_m2_m1                     = a_m2_m1_cgd*nom_cpp_m2_m1_copied*nom_delr_cpp_m2_m1_copied+p_m2_m1_cgd*nom_cfr_m2_m1_copied*nom_delr_cfr_m2_m1_copied

//parasitic cgs from dut routing, should be flagged off
//+    a_m3_ply_cgs                   = 0.45*(w2ply_inner-w2m1_s+w_m1notonpoly)*ng
//+    p_m3_ply_cgs                   = (w2ply_inner-w2m1_s+w_m1notonpoly)*ng
//+    a_m3_m1_cgs_nsi                = 0.45*w_m1onpoly*nsi
//+    p_m3_m1_cgs_nsi                = w_m1onpoly*nsi
//+    a_m3_ply_cgs_nse               = 0.45*w_m1onpoly*nse
//+    p_m3_ply_cgs_nse               = w_m1onpoly*nse
//+    cgs2_m3_ply                    = (a_m3_ply_cgs+a_m3_ply_cgs_nse)*nom_cpp_m3_ply_copied*nom_delr_cpp_m3_ply_copied+(p_m3_ply_cgs+p_m3_ply_cgs_nse)*nom_cfr_m3_ply_copied*nom_delr_cfr_m3_ply_copied
//+    cgs3_m3_m1                     = a_m3_m1_cgs_nsi*nom_cpp_m3_m1_copied*nom_delr_cpp_m3_m1_copied+p_m3_m1_cgs_nsi*nom_cfr_m3_m1_copied*nom_delr_cfr_m3_m1_copied


//intrinsic cgd & cgs from pcell, they are not used, they are replaced by moscap. They should be flagged off.
//even should considering parasitic cap of test dut routing, they should be flagged off.
//+    lp2p_d                         = 3.59
//+    l_plyhole                      = 0.7
// calculation for parasitic Cgd from layout, migrated from pld100
//+ aply_fld_cgd                      = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d-(w+2*w2ply_inner*(1-fem))*l_plyhole*2.0-4.0*rnhv_daera-w*ldr1*2)/2*ng
//+ pply_fld_cgd                      = ((w+2*w2ply_inner*(1-fem))*6+l_plyhole*4*(1-fem)+lp2p_d*2*(1-fem)-w*2)/2*ng
//+ cgd_ply_fld_orig                  = (aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld)                              //using psp moscap to replace it
// parasitic capacitnace Cgd caused by dummy gate, migrated from pld100
//+ aply_fld_cgd_dmy                  = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d-(w+2*w2ply_inner*(1-fem))*l_plyhole*2.0-4.0*rnhv_daera-w*ldr1*2)/2*ng_dmy
//+ pply_fld_cgd_dmy                  = ((w+2*w2ply_inner*(1-fem))*6+l_plyhole*4*(1-fem)+lp2p_d*2*(1-fem)-w*2)/2*ng_dmy
//+ cgd_ply_fld_dmy_orig              = (aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld)                          //using psp moscap to replace it
// calculation for parasitic Cgs from layout. For dummy gate, g and s are shorted, so no cgs, migrated from pld100
//+ aply_fld_cgs                      = ((w+2*w2ply_outer*(1-fem))*(2*l+lb2b_d)-(w+2*w2nhv*(1-fem))*lb2b_d+4*rnhv_daera-l*w*2)/2*ng
//+ pply_fld_cgs                      = (2*w2ply_outer+2*l+lb2b_d)*ng*(1-fem)
//+ cgs_ply_fld_orig                  = (aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld)

//if not for data-playback, should turn off parasitic cap from dut routing. That is, change 1 to 0 in the following two lines(cgs_all & cgd_all lines), in final model.
//+ cgs_all                           = (cgs1_m1_ply+cgs2_m3_ply*1+cgs3_m3_m1*1+cgs_ply_fld)
//+ cgd_all                           = (cgd1_m2_ply*1+cgd2_m2_m1*1+cgd_ply_fld)
+ cgs_all                           = (cgs1_m1_ply+cgs_ply_fld)
+ cgd_all                           = (cgd_ply_fld)




// simple model factor
+ swdrlin  = (2)  
+ fac_rshldd          = ((swdrlin==0)+(swdrlin==2)*0.9315)


// parameters for the BV diode
+ dcbv_pld65_10hv     = (90)

// multi-ng effect based on median
+ fac_a_ng_vfbo       = (ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*0.07364*(w/(w+1.55*(1-fem)))
+ fac_r_ng_rshldd     = (1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*0.18*(w/(w+1.9*(1-fem))))
+ fac_r_ng_thesato    = (1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*2.82*(w/(w+1.35*(1-fem))))
// multi-ng effect based on ng golden die
+ fac_r_ng_stvfbo     = (1)
+ fac_r_ng_stthesato  = 1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*0.3375*(w/(w+30*(1-fem))))
+ fac_r_ng_thesatgo   = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*3.5*(w/(w+8.4*(1-fem))))
+ fac_r_ng_ecrit      = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*0.195*(w/(w+5*(1-fem))))
+ fac_r_ng_ecorn      = (1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*4.1405*(w/(w+5*(1-fem)))))
+ fac_r_ng_tc1_ecrit  = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*3.85*(w/(w+1*(1-fem))))
+ fac_r_ng_tc1_ecorn  = 1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*15*(w/(w+5*(1-fem))))
+ tc1tc2_ecorn        = (1.0+70/w*(1-fem))
+ tfact_ecrit         = (1+(tc1_ecrit_pld65_sphv_10hv*fac_r_ng_tc1_ecrit+tc2_ecrit_pld65_sphv_10hv*(temp-tnom))*(temp-tnom))
+ tfact_ecorn         = (1+tc1tc2_ecorn*(tc1_ecorn_pld65_sphv_10hv*fac_r_ng_tc1_ecorn+tc2_ecorn_pld65_sphv_10hv*(temp-tnom))*(temp-tnom))
+ fact_r_w_temp_ikf   = 1

model dbodyBV diode
+ allow_scaling       = (yes)
+ jmax  	      = (1e12)
+ jmelt 	      = (1e12)
+ tnom  	      = (27)
+ is	              = (1e-30)
+ n		      = (1.0)
+ cj	              = (1e-30)
+ pta	              = (0)
+ tlevc 	      = (2)
+ tlev  	      = (2)
+ bv	              = (dcbv_pld65_10hv+bvdss_shift)
+ ibv	              = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (rd s) resistor r=0.01

// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w            = w
+ l            = l
+ ldrift       = ldrift
+ wdrift       = wdrift
+ ldr1         = ldr1
+ mult         = ng
+ ad           = ad
+ pd           = pd
+ as           = as
+ ps           = ps
+ ad2          = ad2
+ pd2          = pd2

model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi       = 1
+ swdrlin      = swdrlin
+ xvsat        = xvsat_pld65_sphv_10hv
+ qmc          = qmc_pld65_sphv_10hv
+ lvaro        = lvaro_pld65_sphv_10hv
+ lvarl        = lvarl_pld65_sphv_10hv
+ lvarw        = lvarw_pld65_sphv_10hv*(1-fem)
+ lap          = lap_pld65_sphv_10hv
+ wvaro        = wvaro_pld65_sphv_10hv*(1-fem)
+ wvarl        = wvarl_pld65_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld65_sphv_10hv*(1-fem)
+ wot          = wot_pld65_sphv_10hv*(1-fem)
+ dlq          = dlq_pld65_sphv_10hv
+ dwq          = dwq_pld65_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld65_sphv_10hv+dela_vfb_pld65_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld65_vthratio
+ vfbl         = vfbl_pld65_sphv_10hv
+ vfbw         = (vfbw_pld65_sphv_10hv+dela_vtw_pld65_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld65_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld65_sphv_10hv*fac_r_ng_stvfbo
+ stvfbl       = stvfbl_pld65_sphv_10hv
+ stvfbw       = stvfbw_pld65_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld65_sphv_10hv*(1-fem)
+ toxo         = toxo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ epsroxo      = epsroxo_pld65_sphv_10hv
+ nsubo        = nsubo_pld65_sphv_10hv*delr_nsub_pld65_sphv_10hv
+ nsubw        = nsubw_pld65_sphv_10hv*(1-fem)
+ wseg         = wseg_pld65_sphv_10hv
+ npck         = npck_pld65_sphv_10hv
+ npckw        = npckw_pld65_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld65_sphv_10hv
+ lpck         = lpck_pld65_sphv_10hv
+ lpckw        = lpckw_pld65_sphv_10hv*(1-fem)
+ fol1         = fol1_pld65_sphv_10hv
+ fol2         = fol2_pld65_sphv_10hv
+ facneffaco   = facneffaco_pld65_sphv_10hv
+ facneffacl   = facneffacl_pld65_sphv_10hv
+ facneffacw   = facneffacw_pld65_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld65_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld65_sphv_10hv
+ gfacnudl     = gfacnudl_pld65_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld65_sphv_10hv
+ gfacnudw     = gfacnudw_pld65_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld65_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld65_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld65_sphv_10hv
+ vnsubo       = vnsubo_pld65_sphv_10hv
+ nslpo        = nslpo_pld65_sphv_10hv
+ dnsubo       = dnsubo_pld65_sphv_10hv
+ dphibo       = dphibo_pld65_sphv_10hv
+ dphibl       = dphibl_pld65_sphv_10hv
+ dphiblexp    = dphiblexp_pld65_sphv_10hv
+ dphibw       = dphibw_pld65_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld65_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld65_sphv_10hv
+ delvtacl     = delvtacl_pld65_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld65_sphv_10hv
+ delvtacw     = delvtacw_pld65_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld65_sphv_10hv*(1-fem)
+ npo          = npo_pld65_sphv_10hv
+ npl          = npl_pld65_sphv_10hv
+ cto          = cto_pld65_sphv_10hv
+ ctl          = ctl_pld65_sphv_10hv
+ ctlexp       = ctlexp_pld65_sphv_10hv
+ ctw          = ctw_pld65_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld65_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld65_sphv_10hv
+ ctbo         = ctbo_pld65_sphv_10hv
+ stcto        = stcto_pld65_sphv_10hv
+ toxovo       = toxovo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ toxovdo      = toxovdo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ lov          = lov_pld65_sphv_10hv
+ dlovd        = dlovd_pld65_sphv_10hv
+ novo         = novo_pld65_sphv_10hv
+ novdo        = novdo_pld65_sphv_10hv
+ cfl          = cfl_pld65_sphv_10hv
+ cflexp       = cflexp_pld65_sphv_10hv
+ cfw          = cfw_pld65_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld65_sphv_10hv
+ uo           = uo_pld65_sphv_10hv*delr_uch_pld65_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld65_sphv_10hv
+ fbet1w       = fbet1w_pld65_sphv_10hv*(1-fem)
+ lp1          = lp1_pld65_sphv_10hv
+ lp1w         = lp1w_pld65_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld65_sphv_10hv
+ lp2          = lp2_pld65_sphv_10hv
+ betw1        = betw1_pld65_sphv_10hv*(1-fem)
+ betw2        = betw2_pld65_sphv_10hv*(1-fem)
+ wbet         = wbet_pld65_sphv_10hv
+ stbeto       = stbeto_pld65_sphv_10hv
+ stbetl       = stbetl_pld65_sphv_10hv
+ stbetw       = stbetw_pld65_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld65_sphv_10hv*(1-fem)
+ mueo         = mueo_pld65_sphv_10hv
+ muew         = muew_pld65_sphv_10hv*(1-fem)
+ stmueo       = stmueo_pld65_sphv_10hv
+ themuo       = themuo_pld65_sphv_10hv
+ stthemuo     = stthemuo_pld65_sphv_10hv
+ cso          = cso_pld65_sphv_10hv
+ csl          = csl_pld65_sphv_10hv
+ cslexp       = cslexp_pld65_sphv_10hv
+ csw          = csw_pld65_sphv_10hv*(1-fem)
+ cslw         = cslw_pld65_sphv_10hv*(1-fem)
+ stcso        = stcso_pld65_sphv_10hv
+ xcoro        = xcoro_pld65_sphv_10hv
+ xcorl        = xcorl_pld65_sphv_10hv
+ xcorw        = xcorw_pld65_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld65_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld65_sphv_10hv
+ fetao        = fetao_pld65_sphv_10hv
+ rsw1         = rsw1_pld65_sphv_10hv
+ rsw2         = rsw2_pld65_sphv_10hv*(1-fem)
+ strso        = strso_pld65_sphv_10hv
+ rsbo         = rsbo_pld65_sphv_10hv
+ rsgo         = rsgo_pld65_sphv_10hv
+ thesato      = thesato_pld65_sphv_10hv*fac_r_ng_thesato
+ thesatl      = thesatl_pld65_sphv_10hv
+ thesatlexp   = thesatlexp_pld65_sphv_10hv
+ thesatw      = thesatw_pld65_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld65_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld65_sphv_10hv*fac_r_ng_stthesato
+ stthesatl    = stthesatl_pld65_sphv_10hv
+ stthesatw    = stthesatw_pld65_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld65_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld65_sphv_10hv
+ thesatgo     = thesatgo_pld65_sphv_10hv/fac_r_ng_thesatgo
+ thesatgl     = thesatgl_pld65_sphv_10hv
+ thesatgw     = thesatgw_pld65_sphv_10hv/(1+thesatgw2_pld65_sphv_10hv/w)*(1-fem)
+ vdscale      = vdscale_pld65_sphv_10hv*(1.0+vdscalew_pld65_sphv_10hv*(1-fem)/w)
+ vdscaleb     = vdscaleb_pld65_sphv_10hv
+ stvdscale    = stvdscale_pld65_sphv_10hv
+ axo          = axo_pld65_sphv_10hv
+ axl          = axl_pld65_sphv_10hv
+ alpl         = alpl_pld65_sphv_10hv
+ alplexp      = alplexp_pld65_sphv_10hv
+ alpw         = alpw_pld65_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld65_sphv_10hv
+ alp1lexp     = alp1lexp_pld65_sphv_10hv
+ alp1l2       = alp1l2_pld65_sphv_10hv
+ alp1w        = alp1w_pld65_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld65_sphv_10hv
+ alp2lexp     = alp2lexp_pld65_sphv_10hv
+ alp2l2       = alp2l2_pld65_sphv_10hv
+ alp2w        = alp2w_pld65_sphv_10hv*(1-fem)
+ vpo          = vpo_pld65_sphv_10hv
+ a1o          = a1o_pld65_sphv_10hv
+ a1l          = a1l_pld65_sphv_10hv
+ a1w          = a1w_pld65_sphv_10hv*(1-fem)
+ a2o          = a2o_pld65_sphv_10hv
+ sta2o        = sta2o_pld65_sphv_10hv
+ a3o          = a3o_pld65_sphv_10hv
+ a3l          = a3l_pld65_sphv_10hv
+ a3w          = a3w_pld65_sphv_10hv*(1-fem)
+ a4o          = a4o_pld65_sphv_10hv
+ a4l          = a4l_pld65_sphv_10hv
+ a4w          = a4w_pld65_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld65_sphv_10hv
+ iginvlw      = iginvlw_pld65_sphv_10hv
+ igovw        = igovw_pld65_sphv_10hv
+ igovdw       = igovdw_pld65_sphv_10hv
+ stigo        = stigo_pld65_sphv_10hv
+ gc2o         = gc2o_pld65_sphv_10hv
+ gc3o         = gc3o_pld65_sphv_10hv
+ chibo        = chibo_pld65_sphv_10hv
+ agidlw       = agidlw_pld65_sphv_10hv
+ agidldw      = agidldw_pld65_sphv_10hv
+ bgidlo       = bgidlo_pld65_sphv_10hv
+ bgidldo      = bgidldo_pld65_sphv_10hv
+ stbgidlo     = stbgidlo_pld65_sphv_10hv
+ stbgidldo    = stbgidldo_pld65_sphv_10hv
+ cgidlo       = cgidlo_pld65_sphv_10hv
+ cgidldo      = cgidldo_pld65_sphv_10hv
+ cgbovl       = cgbovl_pld65_sphv_10hv
+ cfrw         = cfrw_pld65_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld65_sphv_10hv*(1-fem)
+ fnto         = fnto_pld65_sphv_10hv
+ nfalw        = nfalw_pld65_sphv_10hv
+ nfblw        = nfblw_pld65_sphv_10hv
+ nfclw        = nfclw_pld65_sphv_10hv
+ efo          = efo_pld65_sphv_10hv
+ lintnoi      = lintnoi_pld65_sphv_10hv
+ alpnoi       = alpnoi_pld65_sphv_10hv
+ kvthoweo     = kvthoweo_pld65_sphv_10hv
+ kvthowel     = kvthowel_pld65_sphv_10hv
+ kvthowew     = kvthowew_pld65_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld65_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld65_sphv_10hv
+ kuowel       = kuowel_pld65_sphv_10hv
+ kuowew       = kuowew_pld65_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld65_sphv_10hv*(1-fem)
+ rgo          = rgo_pld65_sphv_10hv
+ rsh          = rsh_pld65_sphv_10hv
+ rbulko       = rbulko_pld65_sphv_10hv
+ rwello       = rwello_pld65_sphv_10hv
+ rjunso       = rjunso_pld65_sphv_10hv/(w+dwrjunso_pld65_sphv_10hv*(1-fem))
+ rjundo       = rjundo_pld65_sphv_10hv/(w+dwrjundo_pld65_sphv_10hv*(1-fem))
+ rint         = rint_pld65_sphv_10hv
+ rvpoly       = rvpoly_pld65_sphv_10hv
+ rshg         = rshg_pld65_sphv_10hv
+ dlsil        = dlsil_pld65_sphv_10hv
+ saref        = saref_pld65_sphv_10hv
+ sbref        = sbref_pld65_sphv_10hv
+ wlod         = wlod_pld65_sphv_10hv
+ kuo          = kuo_pld65_sphv_10hv
+ kvsat        = kvsat_pld65_sphv_10hv
+ tkuo         = tkuo_pld65_sphv_10hv
+ lkuo         = lkuo_pld65_sphv_10hv
+ wkuo         = wkuo_pld65_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld65_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld65_sphv_10hv
+ wlodkuo      = wlodkuo_pld65_sphv_10hv
+ kvtho        = kvtho_pld65_sphv_10hv
+ lkvtho       = lkvtho_pld65_sphv_10hv
+ wkvtho       = wkvtho_pld65_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld65_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld65_sphv_10hv
+ wlodvth      = wlodvth_pld65_sphv_10hv
+ stetao       = stetao_pld65_sphv_10hv
+ lodetao      = lodetao_pld65_sphv_10hv
+ scref        = scref_pld65_sphv_10hv
+ web          = web_pld65_sphv_10hv
+ wec          = wec_pld65_sphv_10hv
+ adr1o        = adr1o_pld65_sphv_10hv
+ adr1l        = adr1l_pld65_sphv_10hv
+ adr1w        = adr1w_pld65_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld65_sphv_10hv
+ stadr2o      = stadr2o_pld65_sphv_10hv
+ adr3o        = adr3o_pld65_sphv_10hv
+ adr3l        = adr3l_pld65_sphv_10hv
+ adr3w        = adr3w_pld65_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld65_sphv_10hv
+ adr4l        = adr4l_pld65_sphv_10hv
+ adr4w        = adr4w_pld65_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld65_sphv_10hv
+ adr5l        = adr5l_pld65_sphv_10hv
+ adr5w        = adr5w_pld65_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld65_sphv_10hv
+ bidr1l       = bidr1l_pld65_sphv_10hv
+ bidr1w       = bidr1w_pld65_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld65_sphv_10hv
+ bidr2w       = bidr2w_pld65_sphv_10hv*(1-fem)
+ rtho         = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld65_sphv_10hv
+ strthao      = strthao_pld65_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld65_sphv_10hv*delr_res_pld65_sphv_10hv*fac_r_ng_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld65_ronratio)*fac_rshldd)
+ xw           = (xw_pld65_sphv_10hv+dela_dwox_pld65_sphv_10hv)*(1-fem)
+ nwxw         = (nwxw_pld65_sphv_10hv)*(1-fem)
+ xl           = xl_pld65_sphv_10hv
+ xlw          = xlw_pld65_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld65_sphv_10hv
+ nst          = nst_pld65_sphv_10hv
+ ats          = ats_pld65_sphv_10hv
+ dfinf        = dfinf_pld65_sphv_10hv
+ dfw          = dfw_pld65_sphv_10hv*(1-fem)
+ dfl          = dfl_pld65_sphv_10hv
+ dflw         = dflw_pld65_sphv_10hv*(1-fem)
+ dp           = dp_pld65_sphv_10hv
+ ecrit        = ecrit_pld65_sphv_10hv*tfact_ecrit/(1+ecritw_pld65_sphv_10hv*(1-fem)/w+ecritw2_pld65_sphv_10hv/w/w*(1-fem))/fac_r_ng_ecrit*(tc1_ecrit_pld65_sphv_10hv*0+tc2_ecrit_pld65_sphv_10hv*0+1)
+ ecorn        = ecorn_pld65_sphv_10hv*tfact_ecorn/(1+ecornw_pld65_sphv_10hv*(1-fem)/w**1.5)/fac_r_ng_ecorn*(tc1_ecorn_pld65_sphv_10hv*0+tc2_ecorn_pld65_sphv_10hv*0+1)
+ du           = du_pld65_sphv_10hv
+ tc1          = tc1_pld65_sphv_10hv
+ tc2          = tc2_pld65_sphv_10hv
+ tc1l         = tc1l_pld65_sphv_10hv
+ tc2l         = tc2l_pld65_sphv_10hv
+ tc1w         = tc1w_pld65_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld65_sphv_10hv*(1-fem)
+ theacc       = theacc_pld65_sphv_10hv
+ theacc2      = theacc2_pld65_sphv_10hv
+ rva          = rva_pld65_sphv_10hv
+ dta          = dta_pld65_sphv_10hv
+ trj          = trj_pld65_sphv_10hv
+ cjarea       = cjarea_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlsti       = cjlsti_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlgat       = cjarea_pld65_sphv_10hv*djunc*delr_cj_pld65_sphv_10hv
+ vbiarea      = vbiarea_pld65_sphv_10hv
+ vbisti       = vbisti_pld65_sphv_10hv
+ vbigat       = vbigat_pld65_sphv_10hv
+ parea        = parea_pld65_sphv_10hv
+ psti         = psti_pld65_sphv_10hv
+ pgat         = pgat_pld65_sphv_10hv
+ is1area      = is1area_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttarea       = ttarea_pld65_sphv_10hv
+ is2area      = is2area_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irarea       = irarea_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1area    = stis1area_pld65_sphv_10hv
+ stis2area    = stis2area_pld65_sphv_10hv
+ stirarea     = stirarea_pld65_sphv_10hv
+ n1area       = n1area_pld65_sphv_10hv
+ n2area       = n2area_pld65_sphv_10hv
+ nrarea       = nrarea_pld65_sphv_10hv
+ is1lsti      = is1lsti_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlsti       = ttlsti_pld65_sphv_10hv
+ is2lsti      = is2lsti_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlsti       = irlsti_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1sti     = stis1sti_pld65_sphv_10hv
+ stis2sti     = stis2sti_pld65_sphv_10hv
+ stirsti      = stirsti_pld65_sphv_10hv
+ n1sti        = n1sti_pld65_sphv_10hv
+ n2sti        = n2sti_pld65_sphv_10hv
+ nrsti        = nrsti_pld65_sphv_10hv
+ is1lgat      = is1area_pld65_sphv_10hv*djunc*delr_is_pld65_sphv_10hv
+ ttlgat       = ttlgat_pld65_sphv_10hv
+ is2lgat      = is2area_pld65_sphv_10hv*djunc*delr_is2_pld65_sphv_10hv
+ irlgat       = irarea_pld65_sphv_10hv*djunc*delr_ir_pld65_sphv_10hv
+ stis1gat     = stis1gat_pld65_sphv_10hv
+ stis2gat     = stis2gat_pld65_sphv_10hv
+ stirgat      = stirgat_pld65_sphv_10hv
+ n1gat        = n1gat_pld65_sphv_10hv
+ n2gat        = n2gat_pld65_sphv_10hv
+ nrgat        = nrgat_pld65_sphv_10hv
+ cjaread      = cjaread_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlstid      = cjlstid_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlgatd      = cjlgatd_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ vbiaread     = vbiaread_pld65_sphv_10hv
+ vbistid      = vbistid_pld65_sphv_10hv
+ vbigatd      = vbigatd_pld65_sphv_10hv
+ paread       = paread_pld65_sphv_10hv
+ pstid        = pstid_pld65_sphv_10hv
+ pgatd        = pgatd_pld65_sphv_10hv
+ is1aread     = is1aread_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttaread      = ttaread_pld65_sphv_10hv
+ is2aread     = is2aread_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ iraread      = iraread_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1aread   = stis1aread_pld65_sphv_10hv
+ stis2aread   = stis2aread_pld65_sphv_10hv
+ stiraread    = stiraread_pld65_sphv_10hv
+ n1aread      = n1aread_pld65_sphv_10hv
+ n2aread      = n2aread_pld65_sphv_10hv
+ nraread      = nraread_pld65_sphv_10hv
+ is1lstid     = is1lstid_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlstid      = ttlstid_pld65_sphv_10hv
+ is2lstid     = is2lstid_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlstid      = irlstid_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1stid    = stis1stid_pld65_sphv_10hv
+ stis2stid    = stis2stid_pld65_sphv_10hv
+ stirstid     = stirstid_pld65_sphv_10hv
+ n1stid       = n1stid_pld65_sphv_10hv
+ n2stid       = n2stid_pld65_sphv_10hv
+ nrstid       = nrstid_pld65_sphv_10hv
+ is1lgatd     = is1lgatd_pld65_sphv_10hv*djunc*delr_is_pld65_sphv_10hv
+ ttlgatd      = ttlgatd_pld65_sphv_10hv
+ is2lgatd     = is2lgatd_pld65_sphv_10hv*djunc*delr_is2_pld65_sphv_10hv
+ irlgatd      = irlgatd_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1gatd    = stis1gatd_pld65_sphv_10hv
+ stis2gatd    = stis2gatd_pld65_sphv_10hv
+ stirgatd     = stirgatd_pld65_sphv_10hv
+ n1gatd       = n1gatd_pld65_sphv_10hv
+ n2gatd       = n2gatd_pld65_sphv_10hv
+ nrgatd       = nrgatd_pld65_sphv_10hv
+ cjaread2     = cjaread2_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlstid2     = cjlstid2_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ vbiaread2    = vbiaread2_pld65_sphv_10hv
+ vbistid2     = vbistid2_pld65_sphv_10hv
+ paread2      = paread2_pld65_sphv_10hv
+ pstid2       = pstid2_pld65_sphv_10hv
+ is1aread2    = is1aread2_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttaread2     = ttaread2_pld65_sphv_10hv
+ is2aread2    = is2aread2_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ iraread2     = iraread2_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1aread2  = stis1aread2_pld65_sphv_10hv
+ stis2aread2  = stis2aread2_pld65_sphv_10hv
+ stiraread2   = stiraread2_pld65_sphv_10hv
+ n1aread2     = n1aread2_pld65_sphv_10hv
+ n2aread2     = n2aread2_pld65_sphv_10hv
+ nraread2     = nraread2_pld65_sphv_10hv
+ is1lstid2    = is1lstid2_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlstid2     = ttlstid2_pld65_sphv_10hv
+ is2lstid2    = is2lstid2_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlstid2     = irlstid2_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1stid2   = stis1stid2_pld65_sphv_10hv
+ stis2stid2   = stis2stid2_pld65_sphv_10hv
+ stirstid2    = stirstid2_pld65_sphv_10hv
+ n1stid2      = n1stid2_pld65_sphv_10hv
+ n2stid2      = n2stid2_pld65_sphv_10hv
+ nrstid2      = nrstid2_pld65_sphv_10hv
+ aacc         = aacc_pld65_sphv_10hv
+ eais1area    = eais1area_pld65_sphv_10hv
+ eais2area    = eais2area_pld65_sphv_10hv
+ eairarea     = eairarea_pld65_sphv_10hv
+ eais1sti     = eais1sti_pld65_sphv_10hv
+ eais2sti     = eais2sti_pld65_sphv_10hv
+ eairsti      = eairsti_pld65_sphv_10hv
+ eais1gat     = eais1gat_pld65_sphv_10hv
+ eais2gat     = eais2gat_pld65_sphv_10hv
+ eairgat      = eairgat_pld65_sphv_10hv
+ eais1aread   = eais1aread_pld65_sphv_10hv
+ eais2aread   = eais2aread_pld65_sphv_10hv
+ eairaread    = eairaread_pld65_sphv_10hv
+ eais1stid    = eais1stid_pld65_sphv_10hv
+ eais2stid    = eais2stid_pld65_sphv_10hv
+ eairstid     = eairstid_pld65_sphv_10hv
+ eais1gatd    = eais1gatd_pld65_sphv_10hv
+ eais2gatd    = eais2gatd_pld65_sphv_10hv
+ eairgatd     = eairgatd_pld65_sphv_10hv
+ eais1aread2  = eais1aread2_pld65_sphv_10hv
+ eais2aread2  = eais2aread2_pld65_sphv_10hv
+ eairaread2   = eairaread2_pld65_sphv_10hv
+ eais1stid2   = eais1stid2_pld65_sphv_10hv
+ eais2stid2   = eais2stid2_pld65_sphv_10hv
+ eairstid2    = eairstid2_pld65_sphv_10hv
+ mumb         = mumb_pld65_sphv_10hv
+ ikfaread     = ikfaread_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikfaread2    = ikfaread2_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflstid     = ikflstid_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflstid2    = ikflstid2_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflgatd     = ikflgatd_pld65_sphv_10hv/fact_r_w_temp_ikf

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr     = 27
+    toxo   = 3.20e-7
+    vfbo   = 3
+    stvfbo = stvfbo_pld65_sphv_10hv
+    nsubo  = 6.0e22
+    npck   = 1e22
+    lpck   = 1e-6
+    rtho   = 1e18
+    ctho   = 0
+    uo     = 0


//model pnpd_lateral bjt
//+ type           = (pnp)
//+ struct         = (lateral)
//+ tnom           = (27)
//+ imax           = (100)
//+ is             = (0.10e-18*(4.0+12.0)/(l+12.0)/(1.0+5e3*0.5/w))*50
//+ ikf            = 1e6*(4.0+12.0)/(l+12.0)*(1.0+0.5/w)
//+ ikr            = 1e6*(4.0+12.0)/(l+12.0)*(1.0+0.5/w)
//+ bf             = 1e8
//+ nf             = 1.04
//+ br             = 1e8
//+ nr             = 1.03
//+ xtb            = 0.0
//+ eg             = 1.11
//+ xti            = 4.5
//+ rb             = 0.0
//+ tf             = 54e-9
//+ tr             = 20e-9



//qsbd          (qsi qsi qdi)  pnpd_lateral  area=(w*2.5e-6*1e6) m=ng
//rs_qsbd       (s qsi)      resistor r=140e3/(1.0+1.2/w)/(1.0+50.0/sqrt(l))/(w*2.5e-6*1e6*ng)
//rd_qsbd       (d qdi)      resistor r=200e3/(1.0+1.2/w)/(1.0+28.0/sqrt(l))/(w*2.5e-6*1e6*ng)

cgd_fld (gi d) capacitor c=(cgd_all)
cgs_fld (gi s) capacitor c=(cgs_all)
rgate (g gi)   resistor  r=(r_gate)
xdsub (s sub)  cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)+1e-12) perim=(plnbl*(1-lpe)+1e-12) soa=1

if (ng_dmy>=2) {

amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
