acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(6.55e+16+(-9.67569e+15/w))
+ vfb=(0.049+dela_nld45_tlp_10hv_vfb)
+ f3=(7.71483)
+ phidel=(-0.127364)
+ em=(2.02381+(0.0172002/w))
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.000174569)
+ nd=(8.01048e+19)
+ u_init=((0.068764/delr_nld45_tlp_10hv_res)/delr_rdsw_relimo/(1+(hcirondegrfac+offrondegrfac)*presto_nld45_tlp_ronratio))
+ vsat=((97544.38+(2113.85/(w**(0.1))))*(1+(-0.00135577)*(temp-27)+(-6.61619e-07)*(temp-27)*(temp-27)))
+ fneff=(0.00202243)
+ alphafneff=(0.190879)
+ alphexp=(2.81106)
+ vfbtexp=(0.00982401)
+ udriftexpa=(-0.00548284+(0.00343/w)*(1-fem))
+ udriftexpb=(1.17567e-05+(-18.687e-06/w)*(1-fem))
+ betavds=(4.5)
+ betaexp=(0.85)
+ vfb0=(-6)
adsd_a (s intdx) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(chjs_junc_nld45_tlp_d_body*0.002)
+ n=(ajnd_junc_nld45_tlp_d_body*1.15)
+ rs=(0.0)
+ cj0=((acj0_junc_nld45_tlp_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld45_tlp_d_body)
+ tau=(28e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld45_tlp_d_body)
+ betaeg=(abetaeg_junc_nld45_tlp_d_body)
+ eg=(aeg_junc_nld45_tlp_d_body)
+ xti=(axti_junc_nld45_tlp_d_body+10)
+ bv=(69+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(4e-05)
adsd_p (s intdx) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(chjs_junc_nld45_tlp_d_body/sDOTmult*0.015*w)
+ n=(pjnd_junc_nld45_tlp_d_body*1.14)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld45_tlp_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld45_tlp_d_body)
+ tau=(20e-9)
+ trr=(1e-9)
+ alphaeg=(palphaeg_junc_nld45_tlp_d_body)
+ betaeg=(pbetaeg_junc_nld45_tlp_d_body)
+ eg=(peg_junc_nld45_tlp_d_body)
+ bv=(69+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(4)
+ ik=(0.75e-06*w)
adsd_pch (s intdx) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld45_tlp_d_body/sDOTmult*1.5)
+ n=(chjnd_junc_nld45_tlp_d_body)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld45_tlp_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld45_tlp_d_body)
+ tau=(24e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld45_tlp_d_body)
+ betaeg=(abetaeg_junc_nld45_tlp_d_body)
+ eg=(aeg_junc_nld45_tlp_d_body)
+ bv=(69+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(6)
+ ik=(maxa(10e-8,(4e-7)*(1+0.048*(temp-27)),4e-13))

include "./smos10hv_ade_dfrt.scs" section=nld45_tlp_10hv_dfrt
ends

subckt nld30_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld30_10hv_gox       = tmp_nsmm_delr_nld30_10hv_gox
+    nsmm_dela_nld30_10hv_vfb       = tmp_nsmm_dela_nld30_10hv_vfb
+    nsmm_delr_nld30_10hv_nsub      = tmp_nsmm_delr_nld30_10hv_nsub
+    nsmm_dela_nld30_10hv_vtl       = tmp_nsmm_dela_nld30_10hv_vtl
+    nsmm_dela_nld30_10hv_dwox      = tmp_nsmm_dela_nld30_10hv_dwox
+    nsmm_delr_nld30_10hv_ubref     = tmp_nsmm_delr_nld30_10hv_ubref
+    nsmm_delr_nld30_10hv_rsh       = tmp_nsmm_delr_nld30_10hv_rsh
+    nsmm_dela_nld30_10hv_vtw       = tmp_nsmm_dela_nld30_10hv_vtw
+    l                              = (0.35)
+    delr_nld30_10hv_tox            = (nom_delr_nld30_10hv_tox*(1+sig_delr_nld30_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld30_10hv_gox*smm_delr_nld30_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld30_10hv_uch            = (nom_delr_nld30_10hv_uch*(1+sig_delr_nld30_10hv_uch*nsig_delr_nld30_10hv_uch+nsmm_delr_nld30_10hv_ubref*smm_delr_nld30_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld30_10hv_res            = (nom_delr_nld30_10hv_res*(1+sig_delr_nld30_10hv_res*nsig_delr_nld30_10hv_res+nsmm_delr_nld30_10hv_rsh*smm_delr_nld30_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld30_10hv_vfb            = (nom_dela_nld30_10hv_vfb+(sig_dela_nld30_10hv_vfb*nsig_dela_nld30_10hv_vfb)+nsmm_dela_nld30_10hv_vfb*smm_dela_nld30_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld30_10hv_vtl*smm_dela_nld30_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld30_10hv_vtw*smm_dela_nld30_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld30_10hv_vtm            = (nom_dela_nld30_10hv_vtm+(sig_dela_nld30_10hv_vtm*nsig_dela_nld30_10hv_vtm))
+    dela_nld30_10hv_dw             = (nom_dela_nld30_10hv_dw+(sig_dela_nld30_10hv_dw*nsig_dela_nld30_10hv_dw)+(nsmm_dela_nld30_10hv_dwox*smm_dela_nld30_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld30_10hv_dr             = (nom_dela_nld30_10hv_dr+(sig_dela_nld30_10hv_dr*nsig_dela_nld30_10hv_dr))
+    delr_nld30_10hv_nsub           = (1+nsmm_delr_nld30_10hv_nsub*smm_delr_nld30_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld30_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.35)
+    lch                            = (0.32)
+    lacc_drawn                     = (0.7)
+    lacc                           = (0.669)
+    ld                             = (1.265)
+    wdel                           = (1.350)
+    lsc_ply                        = (0.215)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.25)
+    xiso                           = (1.27)
+    yiso                           = (2.23)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    dw_mos                         = (0.0)
+    dw_res                         = (4.03172+dela_nld30_10hv_dr)
+    lcheff                         = (0.32)
+    numbernplus                    = ((2+(w>=2.375)+(w>=3.18)+(w>=3.975)+(w>=4.775)+(w>=5.58)+(w>=6.38)+(w>=7.18)+(w>=7.98)+(w>=8.775)+(w>=9.58)+(w>=10.38)+(w>=11.175)+(w>=11.98)+(w>=12.775)+(w>=13.58)+(w>=14.38)+(w>=15.175)+(w>=15.98)+(w>=16.775)*(1+int_round((w-16.775)/0.8)))*(1-fem)+fem*int_round(w/0.8+1e-6))
+    w_mos                          = (numbernplus*0.4+dw_mos*(1-fem))
+    w_res                          = (w+((dw_res)+(-2.87886)/(w**1.40503e-05))*(1-fem))
+    xncom                          = (1.445+0.6)
+    yncom                          = (w+2*wdel)
+    ancom                          = (xncom*yncom*ng)
+    pncom                          = ((2*wdel+2*xncom)*ng)
+    chncom                         = (w*ng)
+    rsda                           = (129/(w-0.4))
+    rsdp                           = (205.8/(w+0.1))
+    rsdch                          = (10780/(w-0.2))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aholes                         = ((w+2*1.2)*(0.695+0.5)*ng)
+    aaccum                         = (lacc*w*ng)
+    aplyfld_d                      = (ancom-aholes-aaccum)
+    aplyfld_s                      = (2*((lch+lacc+ld)*0.145+lch*1.35)*ng)
+    area_accum                     = (lacc*w*ng)
+    lfring                         = (w*ng)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d                   = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    aphi_tnom                      = (aphi_junc_nld30_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld30_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld30_d_body)
+    pphi_tnom                      = (pphi_junc_nld30_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld30_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld30_d_body)
+    chphi_tnom                     = (chphi_junc_nld30_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld30_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld30_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld30_10hv_tox)
+ nch      = (4.63e+16*delr_nld30_10hv_nsub)
+ nsub     = (4e+16*delr_nld30_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-6.2487e-10+0.5e-6*dela_nld30_10hv_dw)*(1-fem))
+ wwl      = ((-1.9833e-20)*(1-fem))
+ wwn      = ((-1.99743)*(1-fem))
+ wln      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((1.35616+(1.45061/w))*(1+(0.0103398+(-0.00771991/w))*(temp-27)+(-5.87158e-05+(5.11549e-05/w))*(temp-27)*(temp-27)))
+ vfb      = (-0.619+dela_nld30_10hv_vfb)
+ a0       = (1.6)
+ a1       = (0)
+ a2       = (1)
+ b0       = (0.75e-7)
+ u0       = (269.494*delr_nld30_10hv_uch)
+ ua       = (1e-13)
+ ub       = (4.61232e-18)
+ vsat     = (300000)
+ drout    = (0.056)
+ pclm     = (0.2)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0)
+ wr       = (1)
+ prwg     = (0.0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voffcv   = (-0.5)
+ noff     = (4)
+ voff     = (-0.22)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((-0.00104309+dela_nld30_10hv_vtm)*(1-fem))
+ dvt1w    = (987687)
+ k3       = ((2.62517)*(1-fem))
+ k3b      = (0)
+ nlx      = (6.8e-7)
+ dsub     = (0.7)
+ alpha0   = (0e-5)
+ alpha1   = (28.54)
+ nfactor  = (1.5)
+ beta0    = (300)
+ kt1      = (-0.361828)
+ ua1      = (4.45438e-09)
+ ub1      = (-5.54417e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-0.751311)
+ dlc      = (0)
+ dwc      = ((-5.5e-7+(-5.05e-7/w))-(w-(int_round(w/0.8))*0.4)*0.5e-6)
+ wwlc     = (9e-19)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg_s (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring*sDOTmult2+1e-20)
cgd_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring*sDOTmult2+1e-20)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld30_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld30_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld30_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld30_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*1.495)/((lch+lacc+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(4.030391e+16+(8.94514e+16/w))
+ vfb=(-0.00512606+dela_nld30_10hv_vfb)
+ f3=(3.63325)
+ phidel=(-0.0503681)
+ em=(2.0)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.00597862)
+ nd=(2.83783e+19)
+ u_init=(0.0100186/delr_nld30_10hv_res)
+ vsat=(((w/((w**1.03212)+1.25605)))*(9632.32)*(1+-0.00155983*(temp-27)+1.8989e-06*(temp-27)*(temp-27)))
+ fneff=(0.151411+(0.190408/w)*(1-fem))
+ alphafneff=(0.0988521+(0.000932954/w)*(1-fem))
+ alphexp=(1.397416+(4.19015e-05/w)*(1-fem))
+ vfbtexp=(0.0106118)
+ udriftexpa=(-0.00585048+(-0.000262005/w)*(1-fem))
+ udriftexpb=(1.29442e-05+(-1.07208e-06/w)*(1-fem))
+ betavds=(0.05+(0.363811/w)*(1-fem))
+ betaexp=(0.65+(0.027967/w)*(1-fem))
+ vfb0=(0)
adsd_a (s intdxa) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(ajs_junc_nld30_d_body*0.00001)
+ n=(ajnd_junc_nld30_d_body*1.12)
+ rs=(0.0)
+ cj0=((acj0_junc_nld30_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld30_d_body)
+ tau=(10e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld30_d_body)
+ betaeg=(abetaeg_junc_nld30_d_body)
+ eg=(aeg_junc_nld30_d_body)
+ bv=(41.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(18)
+ ik=(5.5e-6)
adsd_p (s intdxp) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(pjs_junc_nld30_d_body/sDOTmult*50000*w)
+ n=(pjnd_junc_nld30_d_body*1.12)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld30_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld30_d_body)
+ tau=(1e-9)
+ trr=(1e-9)
+ alphaeg=(palphaeg_junc_nld30_d_body)
+ betaeg=(pbetaeg_junc_nld30_d_body)
+ eg=(peg_junc_nld30_d_body)
+ bv=(41.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(21)
+ ik=(0.3e-5*w)
adsd_pch (s intdxch) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld30_d_body/sDOTmult*1.5)
+ n=(chjnd_junc_nld30_d_body)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld30_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld30_d_body)
+ tau=(10e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld30_d_body)
+ betaeg=(abetaeg_junc_nld30_d_body)
+ eg=(aeg_junc_nld30_d_body)
+ bv=(41.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(4)
+ ik=(maxa(5e-8,(1e-7)*(1+0.27*(temp-27)),3e-13))

include "./smos10hv_ade_dfrt.scs" section=nld30_10hv_dfrt
ends

subckt nld45_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_10hv_gox       = tmp_nsmm_delr_nld45_10hv_gox
+    nsmm_dela_nld45_10hv_vfb       = tmp_nsmm_dela_nld45_10hv_vfb
+    nsmm_delr_nld45_10hv_nsub      = tmp_nsmm_delr_nld45_10hv_nsub
+    nsmm_dela_nld45_10hv_vtl       = tmp_nsmm_dela_nld45_10hv_vtl
+    nsmm_dela_nld45_10hv_dwox      = tmp_nsmm_dela_nld45_10hv_dwox
+    nsmm_delr_nld45_10hv_ubref     = tmp_nsmm_delr_nld45_10hv_ubref
+    nsmm_delr_nld45_10hv_rsh       = tmp_nsmm_delr_nld45_10hv_rsh
+    nsmm_dela_nld45_10hv_vtw       = tmp_nsmm_dela_nld45_10hv_vtw
+    nsmm_dela_nld45_10hv_cit       = tmp_nsmm_dela_nld45_10hv_cit
+    nsmm_delr_nld45_10hv_vsat      = tmp_nsmm_delr_nld45_10hv_vsat
+    l                              = (0.4)
+    tc_vth_mm                      = (1+(temp-27)*(-1.7e-3)/3)
+    vth_mm                         = tc_vth_mm*(nsmm_dela_nld45_10hv_vfb*smm_dela_nld45_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_10hv_vtl*smm_dela_nld45_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_10hv_vtw*smm_dela_nld45_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    delr_nld45_10hv_tox            = (nom_delr_nld45_10hv_tox*(1+sig_delr_nld45_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_10hv_gox*smm_delr_nld45_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_10hv_uch            = (nom_delr_nld45_10hv_uch*(1+sig_delr_nld45_10hv_uch*nsig_delr_nld45_10hv_uch+nsmm_delr_nld45_10hv_ubref*smm_delr_nld45_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_10hv_res            = (nom_delr_nld45_10hv_res*(1+sig_delr_nld45_10hv_res*nsig_delr_nld45_10hv_res+nsmm_delr_nld45_10hv_rsh*smm_delr_nld45_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_10hv_vfb            = (nom_dela_nld45_10hv_vfb+(sig_dela_nld45_10hv_vfb*nsig_dela_nld45_10hv_vfb)+vth_mm)
+    dela_nld45_10hv_dw             = (nom_dela_nld45_10hv_dw+(sig_dela_nld45_10hv_dw*nsig_dela_nld45_10hv_dw)+(nsmm_dela_nld45_10hv_dwox*smm_dela_nld45_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld45_10hv_vtm            = (nom_dela_nld45_10hv_vtm+(sig_dela_nld45_10hv_vtm*nsig_dela_nld45_10hv_vtm))
+    dela_nld45_10hv_dr             = (nom_dela_nld45_10hv_dr+(sig_dela_nld45_10hv_dr*nsig_dela_nld45_10hv_dr))
+    delr_nld45_10hv_nsub           = (1+nsmm_delr_nld45_10hv_nsub*smm_delr_nld45_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_10hv_cit            = (0+nsmm_dela_nld45_10hv_cit*smm_dela_nld45_10hv_cit(l,w)/sqrt(1*ng))
+    delr_nld45_10hv_vsat           = (1+nsmm_delr_nld45_10hv_vsat*smm_delr_nld45_10hv_vsat(l,w)/sqrt(1*ng))
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_vthratio          = 1.0
+    presto_nld45_ronratio          = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld45_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.4)
+    lch                            = (0.352)
+    lacc_drawn                     = (0.60)
+    lacc                           = (0.594)
+    ld                             = (1.895)
+    wdel                           = (0.255)
+    lsc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.55)
+    xiso                           = (1.275)
+    yiso                           = (4.26)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrd                           = (0)
+    lfrs                           = (0.0)
+    dw_mos                         = (0.0598426+dela_nld45_10hv_dw)
+    dw_res                         = (1.14033+dela_nld45_10hv_dr)
+    lcheff                         = (0.352)
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+(dw_res+(1.47132)/(w**1.80191))*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+0.45)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsda                           = (175/(w+0.1))
+    rsdp                           = (205.8/(w+2.5))
+    rsdch                          = (10780/(w-0.2))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (rpolyhole*(w-0.095*2)+0.5*pi4models*rpolyhole*rpolyhole)
+    apolyplushole                  = (rpoly*(w+0.225*2)+0.5*pi4models*rpoly*rpoly)
+    aplyfld_d                      = ((apolyplushole-ahole)*ng)
+    aplyfld_s                      = (2*(lch+lacc+ld)*0.5*ng)
+    area_accum                     = ((lacc*(w+2*0.255)+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*3.15)*ng)
+    lfring_d                       = ((w+2*0.255+pi4models*ld)*ng)
+    xmosend                        = (lch+lacc+ld)
+    ymosend                        = (w+2*3.15)
+    amosend                        = (((xmosend*ymosend)-(((w+2*0.255)*(ld+lacc))+0.5*pi4models*(ld+lacc)*(ld+lacc))-w*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round(w/(0.18+0.24))))
+    lfr_ct_ply_d                   = (ng*0.18*((int_round(w/(0.24+0.18))-1)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    aphi_tnom                      = (aphi_junc_nld45_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld45_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld45_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld45_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld45_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld45_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld45_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld45_10hv_tox)
+ nch      = (4.36e+16*delr_nld45_10hv_nsub)
+ nsub     = (4.0e+16*delr_nld45_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-2.09066e-08)*(1-fem))
+ wwl      = ((13.96817e-15)*(1-fem))
+ wln      = ((0)*(1-fem))
+ wwn      = ((1.065)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-0.185207+(4.8/w))*(1+(0.000987603+(-0.00138034/w))*(temp-27)+(-9.8517e-06+(-9.81902e-06/w))*(temp-27)*(temp-27)))
+ vfb      = (-0.549658+dela_nld45_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_vthratio)
+ a0       = (1.57729*delr_a0_relimo)
+ b0       = (6e-7)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (334.869*delr_nld45_10hv_uch*delr_u0_relimo)
+ ua       = (1.28662e-13)
+ ub       = (1.9626e-19)
+ vsat     = (148346*delr_nld45_10hv_vsat)
+ drout    = (0.056)
+ pclm     = (0.25)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.146377)
+ prt      = (2.6393)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voffcv   = (-0.45)
+ noff     = (4)
+ voff     = (-0.225)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.855777+dela_nld45_10hv_vtm)*(1-fem))
+ dvt1w    = (0.8e+06)
+ k3       = ((0)*(1-fem))
+ k3b      = (0)
+ nlx      = (7.59e-7)
+ dsub     = (0.7)
+ alpha0   = (0.0e-5)
+ alpha1   = (14.65)
+ nfactor  = (1.75)
+ beta0    = (325)
+ kt1      = (-0.359887)
+ ua1      = (1.00064e-11)
+ ub1      = (-3.99616e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.371)
+ dlc      = (0)
+ dwc      = ((-7.25e-7)-(w-(int_round(w/0.84))*0.42)*0.5e-6)
+ at       = (33000)
+ cit      = (0+dela_nld45_10hv_cit)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend+1e-20) m=(1)
cgs_frg (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring_s*sDOTmult2+1e-20)
cgd_frg (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2+1e-20)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.425)/((lch+lacc+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(5.939292e+16+(0e16/w))
+ vfb=(0.0348+dela_nld45_10hv_vfb)
+ f3=(3.733)
+ phidel=(-0.090495)
+ em=(2.005)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.00226033)
+ nd=(5.53774e+19)
+ u_init=((0.00732752/(delr_nld45_10hv_res))/delr_rdsw_relimo/(1+(hcirondegrfac+offrondegrfac)*presto_nld45_ronratio))
+ vsat=((w/(w+-0.469545))*(11464.1)*(1+0.7*(-0.0013506+(-0.001/w))*(temp-27)+0.7*(6.70137e-07+(-9.86544e-07/w))*(temp-27)*(temp-27)))
+ fneff=(0.01278624)
+ alphafneff=(0.153268)
+ alphexp=(2.092862)
+ vfbtexp=(0.0106118)
+ udriftexpa=((-0.00572981+(-0.000515482/w)*(1-fem))*0.97)
+ udriftexpb=(1.40324e-05*0.83+(4.20996e-06/w)*(1-fem)*0.38)
+ betavds=(0.02+(0.60/w)*(1-fem))
+ betaexp=(0.82+(1.5/w)*(1-fem))
+ vfb0=(-6)
adsd_a (s intdxa) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(3.19869e-20*0.00002)
+ n=(1.0016*1.123)
+ rs=(0.0)
+ cj0=((acj0_junc_nld45_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld45_d_body)
+ tau=(12e-9)*3.5*(1+1.8/w)
+ trr=(1e-9)*1.5
+ alphaeg=(aalphaeg_junc_nld45_d_body)
+ betaeg=(abetaeg_junc_nld45_d_body)
+ eg=(aeg_junc_nld45_d_body)
+ bv=(57+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(8)
+ ik=(5.5e-6)
adsd_p (s intdxp) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(1.00e-23/sDOTmult*110000*w)
+ n=(1.0016*1.16)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld45_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld45_d_body)
+ tau=(12e-9)*3.5*(1+1.8/w)
+ trr=(1e-9)*1.5
+ alphaeg=(palphaeg_junc_nld45_d_body)
+ betaeg=(pbetaeg_junc_nld45_d_body)
+ eg=(peg_junc_nld45_d_body)
+ bv=(57+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(12)
+ ik=(0.3e-5*w)
adsd_pch (s intdxch) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld45_d_body/sDOTmult*0.4)
+ n=(chjnd_junc_nld45_d_body*0.90)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld45_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld45_d_body)
+ tau=(12e-9)*3.5*(1+1.8/w)
+ trr=(1e-9)*1.5
+ alphaeg=(aalphaeg_junc_nld45_d_body)
+ betaeg=(abetaeg_junc_nld45_d_body)
+ eg=(aeg_junc_nld45_d_body)
+ bv=(57+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(4.8)
+ ik=(maxa(1e-8,(0.4e-7)*(1+0.025*(temp-27)),1.5e-15))

include "./smos10hv_ade_dfrt.scs" section=nld45_10hv_dfrt
ends

subckt nld45_he_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_he_10hv_gox    = tmp_nsmm_delr_nld45_he_10hv_gox
+    nsmm_dela_nld45_he_10hv_vfb    = tmp_nsmm_dela_nld45_he_10hv_vfb
+    nsmm_delr_nld45_he_10hv_nsub   = tmp_nsmm_delr_nld45_he_10hv_nsub
+    nsmm_dela_nld45_he_10hv_vtl    = tmp_nsmm_dela_nld45_he_10hv_vtl
+    nsmm_dela_nld45_he_10hv_dwox   = tmp_nsmm_dela_nld45_he_10hv_dwox
+    nsmm_delr_nld45_he_10hv_ubref  = tmp_nsmm_delr_nld45_he_10hv_ubref
+    nsmm_delr_nld45_he_10hv_rsh    = tmp_nsmm_delr_nld45_he_10hv_rsh
+    nsmm_dela_nld45_he_10hv_vtw    = tmp_nsmm_dela_nld45_he_10hv_vtw
+    l                              = (0.55)
+    delr_nld45_he_10hv_tox         = (nom_delr_nld45_he_10hv_tox*(1+sig_delr_nld45_he_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_he_10hv_gox*smm_delr_nld45_he_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_he_10hv_uch         = (nom_delr_nld45_he_10hv_uch*(1+sig_delr_nld45_he_10hv_uch*nsig_delr_nld45_he_10hv_uch+nsmm_delr_nld45_he_10hv_ubref*smm_delr_nld45_he_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_he_10hv_res         = (nom_delr_nld45_he_10hv_res*(1+sig_delr_nld45_he_10hv_res*nsig_delr_nld45_he_10hv_res+nsmm_delr_nld45_he_10hv_rsh*smm_delr_nld45_he_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_he_10hv_vfb         = (nom_dela_nld45_he_10hv_vfb+(sig_dela_nld45_he_10hv_vfb*nsig_dela_nld45_he_10hv_vfb)+nsmm_dela_nld45_he_10hv_vfb*smm_dela_nld45_he_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_he_10hv_vtl*smm_dela_nld45_he_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_he_10hv_vtw*smm_dela_nld45_he_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld45_he_10hv_dw          = (nom_dela_nld45_he_10hv_dw+(sig_dela_nld45_he_10hv_dw*nsig_dela_nld45_he_10hv_dw)+(nsmm_dela_nld45_he_10hv_dwox*smm_dela_nld45_he_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld45_he_10hv_vtm         = (nom_dela_nld45_he_10hv_vtm+(sig_dela_nld45_he_10hv_vtm*nsig_dela_nld45_he_10hv_vtm))
+    dela_nld45_he_10hv_dr          = (nom_dela_nld45_he_10hv_dr+(sig_dela_nld45_he_10hv_dr*nsig_dela_nld45_he_10hv_dr))
+    delr_nld45_he_10hv_nsub        = (1+nsmm_delr_nld45_he_10hv_nsub*smm_delr_nld45_he_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_he_10hv_a0          = (nom_dela_nld45_he_10hv_a0+nsig_dela_nld45_he_10hv_a0*sig_dela_nld45_he_10hv_a0)
+    dela_nld45_he_10hv_b0          = (nom_dela_nld45_he_10hv_b0+nsig_dela_nld45_he_10hv_b0*sig_dela_nld45_he_10hv_b0)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_he_vthratio       = 1.0
+    presto_nld45_he_ronratio       = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld45_he_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.55)
+    lch                            = (0.475)
+    lacc_drawn                     = (0.55)
+    lacc                           = (0.552)
+    ld                             = (1.995)
+    wdel                           = (0.305)
+    lsc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.7)
+    xiso                           = (1.275)
+    yiso                           = (4.51)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrd                           = (0.001069232)
+    lfrs                           = (0.001)
+    dw_mos                         = (0.0680494)
+    dw_res                         = (0.784289+dela_nld45_he_10hv_dr)
+    lcheff                         = (0.475)
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+(dw_res+(1.88638)/(w**0.997457))*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+lacc_drawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (112.8416638/(w+1.4))
+    rsd_t                          = (rsd*(1+0.0019*(temp-27)))
+    lsc2sc                         = (0.36)
+    xsub                           = (2*xiso+(lcell*ng)+lsc2sc*(ng/2.0-1.0))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.795)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (rpolyhole*(w-0.125*2)+0.5*pi4models*rpolyhole*rpolyhole)
+    apolyplushole                  = (rpoly*(w+0.305*2)+0.5*pi4models*rpoly*rpoly)
+    aplyfld_d                      = ((apolyplushole-ahole)*ng)
+    aplyfld_s                      = (2*(lch+lacc+ld)*0.5*ng)
+    area_accum                     = ((lacc*(w+2*0.045)+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*3.4)*ng)
+    lfring_d                       = ((w+2*0.305+pi4models*ld)*ng)
+    xmosend                        = (lch+lacc+ld)
+    ymosend                        = (w+2*3.4)
+    amosend                        = (((xmosend*ymosend)-(((w+2*0.35)*(ld+lacc))+0.5*pi4models*(ld+lacc)*(ld+lacc))-w*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round(w/(0.24+0.18))))
+    lfr_ct_ply_d                   = (ng*0.18*((int_round(w/(0.24+0.18))-1)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    aphi_tnom                      = (aphi_junc_nld45_he_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld45_he_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld45_he_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_he_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld45_he_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld45_he_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_he_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld45_he_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld45_he_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld45_he_10hv_tox)
+ nch      = (6.32e+16*delr_nld45_he_10hv_nsub)
+ nsub     = (6.0e+16*delr_nld45_he_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-5.48238e-08+0.5e-6*dela_nld45_he_10hv_dw)*(1-fem))
+ wwl      = ((4.4462e-15)*(1-fem))
+ wln      = ((0)*(1-fem))
+ wwn      = ((1.10491)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-0.573942+(0.150219/w))*(1+-0.0117571*(temp-27)+0.000123134*(temp-27)*(temp-27)))
+ vfb      = (-0.248912+dela_nld45_he_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_he_vthratio)
+ a0       = ((1.1769+dela_nld45_he_10hv_a0)*delr_a0_relimo)
+ b0       = (6e-7+1.0e-6*dela_nld45_he_10hv_b0)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (411.268*delr_nld45_he_10hv_uch*delr_u0_relimo)
+ ua       = (6.05676e-13)
+ ub       = (3.53713e-18)
+ vsat     = (300000)
+ drout    = (0.056)
+ pclm     = (0.25)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.146377)
+ prt      = (2.6393)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voffcv   = (-0.5)
+ noff     = (4)
+ voff     = (-0.225)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.0570501+dela_nld45_he_10hv_vtm)*(1-fem))
+ dvt1w    = (41396.5)
+ k3       = ((0.9)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.27e-7)
+ dsub     = (0.7)
+ alpha0   = (0.0e-5)
+ alpha1   = (11.65)
+ nfactor  = (1.15)
+ beta0    = (325)
+ kt1      = (-0.448923)
+ ua1      = (1.00071e-11)
+ ub1      = (-4.84324e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.58312)
+ dlc      = (0)
+ dwc      = ((-9.49e-7)-(w-(int_round(w/0.84))*0.42)*0.5e-6)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend+1e-20) m=(1)
cgs_frg (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring_s*sDOTmult2+1e-20)
cgd_frg (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2+1e-20)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_he_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_he_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_he_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_he_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.675)/((lch+lacc+lflap)*3*ng)))
rx (d intdx) resistor r=(rsd_t) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(8.41255e+16+(3.3246e+15/w))
+ vfb=(0.059039+dela_nld45_he_10hv_vfb)
+ f3=(4.5251)
+ phidel=(-0.12503601)
+ em=(2.01)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.00238627)
+ nd=(5.76331e+19)
+ u_init=((0.00756666/delr_nld45_he_10hv_res)/delr_rdsw_relimo/(1+(hcirondegrfac+offrondegrfac)*presto_nld45_he_ronratio))
+ vsat=(((w/(w+0.0115025)))*(9729.26)*(1+-0.00108338*(temp-27)+-9.20782e-07*(temp-27)*(temp-27)))
+ fneff=(0.00487865)
+ alphafneff=(0.143322)
+ alphexp=(2.70409)
+ vfbtexp=(0.0106118)
+ udriftexpa=(-0.00551801+(0.000328084/w)*(1-fem))
+ udriftexpb=(1.1604e-05+(-1.03936e-05/w)*(1-fem))
+ betavds=(0.02+(0.60/w)*(1-fem))
+ betaexp=(0.82+(1.5/w)*(1-fem))
+ vfb0=(-6)
adsd_a (s intdx) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(ajs_junc_nld45_he_d_body*0.3)
+ n=(ajnd_junc_nld45_he_d_body)
+ rs=(0.0)
+ cj0=((acj0_junc_nld45_he_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld45_he_d_body)
+ tau=(28e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld45_he_d_body)
+ betaeg=(abetaeg_junc_nld45_he_d_body)
+ eg=(aeg_junc_nld45_he_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(16)
+ ik=(0.2805e-6)
adsd_p (s intdx) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(pjs_junc_nld45_he_d_body/sDOTmult*4000*w)
+ n=(pjnd_junc_nld45_he_d_body*1.2)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld45_he_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld45_he_d_body)
+ tau=(20e-9)
+ trr=(1e-9)
+ alphaeg=(palphaeg_junc_nld45_he_d_body)
+ betaeg=(pbetaeg_junc_nld45_he_d_body)
+ eg=(peg_junc_nld45_he_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(17)
+ ik=(0.01e-3*w)
adsd_pch (s intdx) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld45_he_d_body/sDOTmult*1.5)
+ n=(chjnd_junc_nld45_he_d_body)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld45_he_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld45_he_d_body)
+ tau=(0e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld45_he_d_body)
+ betaeg=(abetaeg_junc_nld45_he_d_body)
+ eg=(aeg_junc_nld45_he_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(3.7)
+ ik=(maxa(3e-8,(0.8e-7)*(1+0.03*(temp-27)),1e-14))

include "./smos10hv_ade_dfrt.scs" section=nld45_he_10hv_dfrt
ends

subckt pld5_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 1
+    sti_dummy                      = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    ring                           = 1
+    sa                             = 0
+    sb                             = 0
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    fault_injection_pld5_leakage_outlier = fault_injection_pld5_leakage_outlier_global
+    nsmm_delr_pld5_10hv_gox        = tmp_nsmm_delr_pld5_10hv_gox
+    nsmm_dela_pld5_10hv_vfb        = tmp_nsmm_dela_pld5_10hv_vfb
+    nsmm_delr_pld5_10hv_nsub       = tmp_nsmm_delr_pld5_10hv_nsub
+    nsmm_dela_pld5_10hv_vtl        = tmp_nsmm_dela_pld5_10hv_vtl
+    nsmm_dela_pld5_10hv_dwox       = tmp_nsmm_dela_pld5_10hv_dwox
+    nsmm_delr_pld5_10hv_ubref      = tmp_nsmm_delr_pld5_10hv_ubref
+    nsmm_delr_pld5_10hv_rsh        = tmp_nsmm_delr_pld5_10hv_rsh
+    nsmm_dela_pld5_10hv_vtw        = tmp_nsmm_dela_pld5_10hv_vtw
+    l                              = (0.4)
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    delr_pld5_10hv_tox             = (nom_delr_pld5_10hv_tox*(1.0+nsig_delr_powermos_tox*sig_delr_pld5_10hv_tox+nsmm_delr_pld5_10hv_gox*smm_delr_pld5_10hv_gox(l,w)/sqrt(1*ng)))
+    tox                            = (132.438*1e-10*delr_pld5_10hv_tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.4)
+    lch                            = (0.329)
+    ld                             = (0.88)
+    lsc_ply                        = (0.21)
+    ldc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+ldc_ply)
+    xiso                           = (1.32)
+    yiso                           = (1.11)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    nde                            = (mod(ngeff,2))
+    nse                            = (2-nde)
+    nd                             = ((ngeff+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    lg2ct_s_pld5_10hv              = (0.12)
+    lg2ct_d_pld5_10hv              = (0.12)
+    lg2aa_d_pld5_10hv              = (0.42)
+    lg2g_d_pld5_10hv               = (0.42)
+    numbernplus                    = (int_round((w-1.69)/0.86+2))
+    w_mos                          = (w-numbernplus*0.43)
+    ad_i                           = ((ad/ngeff)+(ad==0)*(1-lpe)*((lg2aa_d_pld5_10hv*nde+lg2g_d_pld5_10hv*ndi)*w)+(lpe*1e-18))
+    pd_i                           = ((pd/ngeff)+(pd==0)*(1-lpe)*(2*(lg2aa_d_pld5_10hv*nde+lg2g_d_pld5_10hv*ndi)+2*nd*w)+(lpe*1e-18))
+    rsda                           = (40/(w))
+    rsdp                           = (396/(w-0.7))
+    nrs_i                          = (lg2ct_s_pld5_10hv/w)
+    nrd_i                          = (lg2ct_d_pld5_10hv/w)
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lch*0.6*2*ng)
+    lfrd                           = ((w+62/w**0.820375)*ngeff*1e-15)
+    rleak_pld5                     = (39936)
+    sa0                            = (0.42)
+    sb0                            = (0.42)
+    lg                             = (0.4)
+    pld5_astivfb                   = (0.001)
+    pld5_bstivfb                   = (0.0)
+    pld5_astinsub                  = (0.0)
+    pld5_astiubref                 = (0.02)
+    pld5_bstiubref                 = (0.13)
+    pld5_cstiubref                 = (0.6)
+    pld5_sapar0                    = (0.042+0.045*lg)
+    pld5_sapar1                    = (0.012+0.113*lg)
+    ng_i                           = (pld5_sapar0*(ngeff-1)+pld5_sapar1*(ngeff-1)*log(ngeff))
+    sa_i                           = (sa)
+    sb_i                           = (sb)
+    stress                         = (((sa_i==0)*(sb_i==0)*(1/(0.5*lg+sa0+ng_i)+1/(0.5*lg+sb0+ng_i))+(((-1)*((sa_i==0)-1))*((-1)*((sb_i==0)-1))*(1/(0.5*lg+sa_i)+1/(0.5*lg+sb_i))))*(fem==0))
+    stress0                        = ((1/(0.5*lg+sa0)+1/(0.5*lg+sb0))*(fem==0))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pld5_astivfb+pld5_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pld5_astinsub*stress)/(1+pld5_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti_final               = ((stimod_on)*(((1+(pld5_astiubref+l*pld5_bstiubref)*stress+(pld5_cstiubref/sqrt(w)))/(1+(pld5_astiubref+l*pld5_bstiubref)*stress0+(pld5_cstiubref/sqrt(w)))))+(1-stimod_on))
+    wscref                         = (1)
+    w2gdrain                       = (1.53)
+    w2gsource                      = (1.53)
+    w2gtop                         = (1.11)
+    w2gbottom                      = (1.11)
+    wsc1_i                         = ((wsc1)+(wsc1==0)*(w2gdrain))
+    wsc2_i                         = ((wsc2)+(wsc1==0)*(w2gbottom))
+    wsc3_i                         = ((wsc3)+(wsc1==0)*(w2gsource))
+    wsc4_i                         = ((wsc4)+(wsc1==0)*(w2gtop))
+    wsca                           = ((1/(l*w))*(w*wscref**2*(1/wsc1_i-(1/(wsc1_i+l)))+l*wscref**2*(1/wsc2_i-(1/(wsc2_i+w)))+w*wscref**2*(1/wsc3_i-(1/(wsc3_i+l)))+l*wscref**2*(1/wsc4_i-(1/(wsc4_i+w)))))
+    wscb                           = ((1/(l*w))*(w*wscref/100*((10*wsc1_i/wscref+1)*exp(-10*wsc1_i/wscref)-(10*(wsc1_i+l)/wscref+1)*exp(-10*(wsc1_i+l)/wscref))+l*wscref/100*((10*wsc2_i/wscref+1)*exp(-10*wsc2_i/wscref)-(10*(wsc2_i+w)/wscref+1)*exp(-10*(wsc2_i+w)/wscref))+w*wscref/100*((10*wsc3_i/wscref+1)*exp(-10*wsc3_i/wscref)-(10*(wsc3_i+l)/wscref+1)*exp(-10*(wsc3_i+l)/wscref))+l*wscref/100*((10*wsc4_i/wscref+1)*exp(-10*wsc4_i/wscref)-(10*(wsc4_i+w)/wscref+1)*exp(-10*(wsc4_i+w)/wscref))))
+    wscc                           = ((1/(l*w))*(w*wscref/400*((20*wsc1_i/wscref+1)*exp(-20*wsc1_i/wscref)-(20*(wsc1_i+l)/wscref+1)*exp(-20*(wsc1_i+l)/wscref))+l*wscref/400*((20*wsc2_i/wscref+1)*exp(-20*wsc2_i/wscref)-(20*(wsc2_i+w)/wscref+1)*exp(-20*(wsc2_i+w)/wscref))+w*wscref/400*((20*wsc3_i/wscref+1)*exp(-20*wsc3_i/wscref)-(20*(wsc3_i+l)/wscref+1)*exp(-20*(wsc3_i+l)/wscref))+l*wscref/400*((20*wsc4_i/wscref+1)*exp(-20*wsc4_i/wscref)-(20*(wsc4_i+w)/wscref+1)*exp(-20*(wsc4_i+w)/wscref))))
+    web                            = (1e+3)
+    wec                            = (1e+5)
+    kvfbwe                         = (-0.008521)
+    knsubwe                        = (0.01287)
+    kubrefwe                       = (0.01567)
+    wp_proxmod_on                  = (enable_wpe==1)
+    del_vfb_wpe                    = (kvfbwe*(wsca+web*wscb+wec*wscc))
+    fac_ub_wpe                     = (1+kubrefwe*(wsca+web*wscb+wec*wscc))
+    fac_nsub_wpe                   = (1+knsubwe*(wsca+web*wscb+wec*wscc))
+    wsc1_ref                       = (1.53)
+    wsc2_ref                       = (1.11)
+    wsc3_ref                       = (1.53)
+    wsc4_ref                       = (1.11)
+    wsca_ref                       = ((1/(l*w))*(w*wscref**2*(1/wsc1_ref-(1/(wsc1_ref+l)))+l*wscref**2*(1/wsc2_ref-(1/(wsc2_ref+w)))+w*wscref**2*(1/wsc3_ref-(1/(wsc3_ref+l)))+l*wscref**2*(1/wsc4_ref-(1/(wsc4_ref+w)))))
+    wscb_ref                       = ((1/(l*w))*(w*wscref/100*((10*wsc1_ref/wscref+1)*exp(-10*wsc1_ref/wscref)-(10*(wsc1_ref+l)/wscref+1)*exp(-10*(wsc1_ref+l)/wscref))+l*wscref/100*((10*wsc2_ref/wscref+1)*exp(-10*wsc2_ref/wscref)-(10*(wsc2_ref+w)/wscref+1)*exp(-10*(wsc2_ref+w)/wscref))+w*wscref/100*((10*wsc3_ref/wscref+1)*exp(-10*wsc3_ref/wscref)-(10*(wsc3_ref+l)/wscref+1)*exp(-10*(wsc3_ref+l)/wscref))+l*wscref/100*((10*wsc4_ref/wscref+1)*exp(-10*wsc4_ref/wscref)-(10*(wsc4_ref+w)/wscref+1)*exp(-10*(wsc4_ref+w)/wscref))))
+    wscc_ref                       = ((1/(l*w))*(w*wscref/400*((20*wsc1_ref/wscref+1)*exp(-20*wsc1_ref/wscref)-(20*(wsc1_ref+l)/wscref+1)*exp(-20*(wsc1_ref+l)/wscref))+l*wscref/400*((20*wsc2_ref/wscref+1)*exp(-20*wsc2_ref/wscref)-(20*(wsc2_ref+w)/wscref+1)*exp(-20*(wsc2_ref+w)/wscref))+w*wscref/400*((20*wsc3_ref/wscref+1)*exp(-20*wsc3_ref/wscref)-(20*(wsc3_ref+l)/wscref+1)*exp(-20*(wsc3_ref+l)/wscref))+l*wscref/400*((20*wsc4_ref/wscref+1)*exp(-20*wsc4_ref/wscref)-(20*(wsc4_ref+w)/wscref+1)*exp(-20*(wsc4_ref+w)/wscref))))
+    del_vfb_wpe_ref                = (kvfbwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_ub_wpe_ref                 = (1+kubrefwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_nsub_wpe_ref               = (1+knsubwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    del_vfb_wpe_final              = ((del_vfb_wpe-del_vfb_wpe_ref)*wp_proxmod_on)
+    fac_ub_wpe_final               = (fac_ub_wpe/fac_ub_wpe_ref*wp_proxmod_on+(1-wp_proxmod_on))
+    fac_nsub_wpe_final             = (fac_nsub_wpe/fac_nsub_wpe_ref*wp_proxmod_on+(1-wp_proxmod_on))
+    dt2gdrain                      = (1.53)
+    dt2gsource                     = (1.53)
+    dt2gtop                        = (1.11)
+    dt2gbottom                     = (1.11)
+    tsc1_i                         = ((tsc1)+(tsc1==0)*(dt2gdrain))
+    tsc2_i                         = ((tsc2)+(tsc1==0)*(dt2gbottom))
+    tsc3_i                         = ((tsc3)+(tsc1==0)*(dt2gsource))
+    tsc4_i                         = ((tsc4)+(tsc1==0)*(dt2gtop))
+    adtnsub                        = (0.29)
+    adtvfb                         = (2.344)
+    bdtvfb                         = (2.253)
+    adtubref                       = (2.25)
+    bdtubref                       = (2.113)
+    cdtubref                       = (2.31)
+    consub                         = (0.0005)
+    covfb                          = (0.0005)
+    coubref                        = (0.0005)
+    dtpara1                        = (6)
+    dtpara2                        = (6)
+    dtpara3                        = (6)
+    dtpara4                        = (6)
+    dtstress                       = (dtpara1*1/(tsc1_i+0.5*l)+dtpara2*1/(tsc2_i+0.5*w)+dtpara3*1/(tsc3_i+0.5*l)+dtpara4*1/(tsc4_i+0.5*w))
+    dtstressref                    = (dtpara1*1/(dt2gdrain+0.5*l)+dtpara2*1/(dt2gbottom+0.5*w)+dtpara3*1/(dt2gsource+0.5*l)+dtpara4*1/(dt2gtop+0.5*w))
+    dt_proxmod_on                  = (enable_dte==1)
+    del_vfb_dte                    = (covfb*((adtvfb+bdtvfb/sqrt(w))*(dtstress-dtstressref)))
+    fac_nsub_dte_ref               = (1+consub)
+    fac_ub_dte_ref                 = (1+coubref)
+    fac_nsub_dte_final             = (dt_proxmod_on)*(1+consub*((1+adtnsub*dtstress*sqrt(l))/(1+adtnsub*dtstressref*sqrt(l))))/fac_nsub_dte_ref+(1-dt_proxmod_on)
+    del_vfb_dte_final              = (dt_proxmod_on*del_vfb_dte)
+    fac_ub_dte_final               = ((dt_proxmod_on)*(1+coubref*((1+(adtubref+l*bdtubref)*dtstress+(cdtubref/sqrt(w)))/(1+(adtubref+l*bdtubref)*dtstressref+(cdtubref/sqrt(w))))))/fac_ub_dte_ref+(1-dt_proxmod_on)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld5_vthratio           = 1.0
+    presto_pld5_betaratio          = 1.16
+    relimo_ratio1_a_hci_pld5_10hv  = (0.234436051)
+    relimo_ratio1_b_hci_pld5_10hv  = (-1.024442563)
+    cox                            = (epsox/tox)
+    dela_pld5_10hv_dw              = (nom_dela_pld5_10hv_dw+nsig_dela_pld5_10hv_dw*sig_dela_pld5_10hv_dw+nsmm_dela_pld5_10hv_dwox*smm_dela_pld5_10hv_dwox(l,w)/sqrt(1*ng))
+    dela_pld5_10hv_vfb             = (nom_dela_pld5_10hv_vfb+del_vfb_sti_final+del_vfb_wpe_final+del_vfb_dte_final+nsig_dela_pld5_10hv_vfb*sig_dela_pld5_10hv_vfb+nsmm_dela_pld5_10hv_vfb*smm_dela_pld5_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld5_10hv_vtl*smm_dela_pld5_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld5_10hv_vtw*smm_dela_pld5_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    delr_pld5_10hv_uch             = (nom_delr_pld5_10hv_uch*fac_ub_sti_final*fac_ub_wpe_final*fac_ub_dte_final*(1+nsig_delr_pld5_10hv_uch*sig_delr_pld5_10hv_uch+nsmm_delr_pld5_10hv_ubref*smm_delr_pld5_10hv_ubref(l,w)/sqrt(1*ng)))
+    dela_pld5_10hv_vtm             = (nom_dela_pld5_10hv_vtm+nsig_dela_pld5_10hv_vtm*sig_dela_pld5_10hv_vtm)
+    delr_pld5_10hv_res             = (1+nsmm_delr_pld5_10hv_rsh*smm_delr_pld5_10hv_rsh(l,w)/sqrt(1*ng))
+    delr_pld5_10hv_nsub            = (fac_nsub_sti_final*fac_nsub_wpe_final*fac_nsub_dte_final*(1+nsmm_delr_pld5_10hv_nsub*smm_delr_pld5_10hv_nsub(l,w)/sqrt(1*ng)))
+    aphi_tnom                      = (aphi_junc_pld5_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_pld5_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_pld5_d_body)
+    pphi_tnom                      = (pphi_junc_pld5_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_pld5_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_pld5_d_body)

model pld5_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ capmod   = (3)
+ noimod   = (2)
+ cgbo     = (0)
+ cgso     = (5.3e-8*cox+0.5*cfr_pld5_s_ply_m1ct*1e6+(1-lpe)*cfr_pld5_s_ply_met*1e6-0.5*cfr_pld5_s_ply_met*1e6)
+ cgdo     = (4.635e-8*cox+0.5*cfr_pld5_d_ply_m1ct*1e6+(1-lpe)*cfr_pld5_d_ply_met*1e6-0.5*cfr_pld5_d_ply_met*1e6)
+ cf       = ((0.0+(62/w**0.820375)*(1-fem))*1e-12)
+ dlc      = (3.5e-8)
+ dwc      = ((-1.01195e-08)*(1-fem)-((int_round(w/0.86))*0.43)*0.5e-6)
+ acde     = (1.0)
+ moin     = (10)
+ noff     = (3.2)
+ voffcv   = (0.08)
+ cgsl     = (0.0e-11)
+ cgdl     = (6.80967912e-11)
+ cj       = (0)
+ cjsw     = (0)
+ js       = (0)
+ jsw      = (0)
+ ckappa   = (0.7898487)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = ((-3.9159e-20)*(1-fem))
+ mobmod   = (1)
+ rsh      = (8.4)
+ tox      = (132.438*1e-10*delr_pld5_10hv_tox)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (1.775e-08)
+ wint     = ((1.713038e-08-0.5e-06*dela_pld5_10hv_dw)*(1-fem))
+ ww       = (((0)*1e-14)*(1-fem))
+ u0       = (326.671*delr_pld5_10hv_uch*delr_u0_relimo)
+ rdsw     = (290.411*delr_pld5_10hv_res*delr_rdsw_relimo)
+ wr       = (1)
+ nsub     = (1.00e17*delr_pld5_10hv_nsub)
+ nch      = (7.04e16*delr_pld5_10hv_nsub)
+ vfb      = (-0.425+dela_pld5_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld5_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pld5_10hv-relimo_ratio1_b_hci_pld5_10hv))
+ nfactor  = (1.30)
+ vbm      = (-2.86)
+ xt       = (2.00189783373556e-07)
+ alpha1   = (2.6)
+ alpha0   = (3.88e-07)
+ a0       = (1.6*delr_a0_relimo)
+ ags      = ((-0.379+(1.0006927/w**1.14727)*(1-fem))*(1+(-0.00970674+(0.0522004/w)*(1-fem))*(temp-27)+(1.11914e-05+(-5.86479e-05/w)*(1-fem))*(temp-27)*(temp-27)))
+ keta     = (-0.00619931)
+ ua       = (6.414738e-11)
+ ub       = (2.181408975e-18)
+ uc       = (-6.50121e-11)
+ eta0     = (0.6+0.2)
+ etab     = (-0.5)
+ drout    = (0.869588)
+ nlx      = (2.5786e-07)
+ dvt0     = (1.55187)
+ dvt1     = (0.22012)
+ dvt2     = (0.08)
+ dvt0w    = ((0.00128983)*(1-fem))
+ dvt1w    = (0.4e+05)
+ dvt2w    = (0)
+ k3       = ((0.13518+dela_pld5_10hv_vtm)*(1-fem))
+ k3b      = ((0.554951)*(1-fem))
+ w0       = (0)
+ dwg      = ((0)*(1-fem))
+ dwb      = ((-9.45513e-09)*(1-fem))
+ b0       = (4.24614e-07)
+ b1       = (0)
+ prwg     = (0.0)
+ prwb     = (-0.174744)
+ pclm     = (1.27263)
+ pdiblc1  = (0.0390017)
+ pdiblc2  = (0.0478204)
+ pdiblcb  = (0.0160105)
+ delta    = (0.0453491)
+ vsat     = (207490)
+ ll       = (-2.78832e-13)
+ voff     = (-0.095-0.05)
+ wwl      = ((1.80798e-20)*(1-fem))
+ lwl      = (3.17082e-20)
+ lwn      = (0.974466)
+ wln      = ((0.963632)*(1-fem))
+ wl       = ((8.8917e-15)*(1-fem))
+ lw       = (-3.9100708e-16)
+ lln      = (0.885)
+ wwn      = ((1.0006)*(1-fem))
+ kt1      = (-0.423)
+ ute      = ((-0.73045)+(0/w)*(1-fem))
+ ua1      = ((3.16938e-09)+(-8.28563e-10/w)*(1-fem))
+ ub1      = ((-4.85954e-18)+(8.53449e-19/w)*(1-fem))
+ uc1      = (-5.6e-11)
+ prt      = ((-0)+(-0/w)*(1-fem))
+ kt1l     = (0.0e-08)
+ at       = (3.3e+04)
+ kt2      = (-0.0286)
+ noia     = (5.503e+19)
+ noib     = (75257)
+ noic     = (1.437e-12)
+ ef       = (1.0)

if (ng_dmy>=2) {
mpowermos_dmy (d s s s) pld5_10hv l=lch w=w_mos m=ng_dmy ad=(1e-18) pd=(1e-18)
}
bileak (d s) bsource i=((fault_injection_pld5_leakage_outlier==1)*v(d,s)/(rleak_pld5)) tc1=-2e-05 tc2=0
adsd_a (intdxa s) powerdiode
+ areafactor=(ad_i)
+ num=(1)
+ is=(ajs_junc_pld5_d_body*130000)
+ n=(ajnd_junc_pld5_d_body*1.26)
+ rs=(0.0)
+ cj0=((acj0_junc_pld5_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_pld5_d_body)
+ tau=(1e-9)
+ trr=(2e-9)
+ alphaeg=(aalphaeg_junc_pld5_d_body)
+ betaeg=(abetaeg_junc_pld5_d_body)
+ eg=(aeg_junc_pld5_d_body)
+ bv=(7.3+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(40e-4)
+ xti=(19)
adsd_p (intdxp s) powerdiode
+ areafactor=(pd_i)
+ num=(1)
+ is=(pjs_junc_pld5_d_body/sDOTmult*0.5)
+ n=(pjnd_junc_pld5_d_body*0.98)
+ rs=(0.0)
+ cj0=((pcj0_junc_pld5_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_pld5_d_body)
+ tau=(1e-9)
+ trr=(2e-9)
+ alphaeg=(palphaeg_junc_pld5_d_body)
+ betaeg=(pbetaeg_junc_pld5_d_body)
+ eg=(peg_junc_pld5_d_body)
+ bv=(7.3+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(3e-08)
+ xti=(pxti_junc_pld5_d_body-1)
mpld5_10hv (d g s s) pld5_10hv w=w_mos l=lch nrd=nrd_i nrs=nrs_i m=ngtotal ad=(1e-18) pd=(1e-18)
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
cgs_fld_s (g s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
xcdgoptub_sub (s sub) cnwtub_box_sub_10hv area=(((asub*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((psub*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=1
aprint_function print_function
+ device="pld5_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_injection_pld5_leakage_outlier

include "./smos10hv_ade_dfrt.scs" section=pld5_10hv_dfrt
ends

subckt nld5_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld5_10hv_gox        = tmp_nsmm_delr_nld5_10hv_gox
+    nsmm_dela_nld5_10hv_vfb        = tmp_nsmm_dela_nld5_10hv_vfb
+    nsmm_delr_nld5_10hv_nsub       = tmp_nsmm_delr_nld5_10hv_nsub
+    nsmm_dela_nld5_10hv_vtl        = tmp_nsmm_dela_nld5_10hv_vtl
+    nsmm_dela_nld5_10hv_dwox       = tmp_nsmm_dela_nld5_10hv_dwox
+    nsmm_delr_nld5_10hv_ubref      = tmp_nsmm_delr_nld5_10hv_ubref
+    nsmm_delr_nld5_10hv_rsh        = tmp_nsmm_delr_nld5_10hv_rsh
+    nsmm_dela_nld5_10hv_vtw        = tmp_nsmm_dela_nld5_10hv_vtw
+    l                              = (0.4)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nld5_vthratio           = 1.0
+    presto_nld5_betaratio          = 1.24
+    relimo_ratio1_a_hci_nld5_10hv  = (0.163151796)
+    relimo_ratio1_b_hci_nld5_10hv  = (-0.461262665)
+    lg                             = (0.4)
+    stimod_on                      = (enable_sti==1)
+    ngeff                          = ng+2*sti_dummy
+    nld5_10hv_del_vfb_sti_final    = ((stimod_on)*((ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-0.65))*(w/(w+0.4*(1-fem))))
+    nld5_10hv_fac_nsub_sti_final   = (1)
+    nld5_10hv_fac_uch_sti_final    = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*0.73))
+    nld5_10hv_fac_res_sti_final    = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-1.3)))
+    tc_vth_mm                      = (1+(temp-27)*(-1.0e-3))
+    delr_nld5_10hv_tox             = (nom_delr_nld5_10hv_tox*(1+sig_delr_nld5_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld5_10hv_gox*smm_delr_nld5_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld5_10hv_uch             = (nom_delr_nld5_10hv_uch*nld5_10hv_fac_uch_sti_final*(1+sig_delr_nld5_10hv_uch*nsig_delr_nld5_10hv_uch+nsmm_delr_nld5_10hv_ubref*smm_delr_nld5_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld5_10hv_res             = (nom_delr_nld5_10hv_res*nld5_10hv_fac_res_sti_final*(1+sig_delr_nld5_10hv_res*nsig_delr_nld5_10hv_res+nsmm_delr_nld5_10hv_rsh*smm_delr_nld5_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld5_10hv_vfb             = (nom_dela_nld5_10hv_vfb+nld5_10hv_del_vfb_sti_final+(sig_dela_nld5_10hv_vfb*nsig_dela_nld5_10hv_vfb)+tc_vth_mm*nsmm_dela_nld5_10hv_vfb*smm_dela_nld5_10hv_vfb(l,w)/sqrt(1*ng)+tc_vth_mm*nsmm_dela_nld5_10hv_vtl*smm_dela_nld5_10hv_vtl(l,w)/sqrt(1*ng)/l+tc_vth_mm*nsmm_dela_nld5_10hv_vtw*smm_dela_nld5_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld5_10hv_vxb             = (nom_dela_nld5_10hv_vfb+(sig_dela_nld5_10hv_vfb*nsig_dela_nld5_10hv_vfb)+nsmm_dela_nld5_10hv_vfb*smm_dela_nld5_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld5_10hv_vtl*smm_dela_nld5_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld5_10hv_vtw*smm_dela_nld5_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld5_10hv_dwmos           = (nom_dela_nld5_10hv_dwmos+(sig_dela_nld5_10hv_dwmos*nsig_dela_nld5_10hv_dwmos)+(nsmm_dela_nld5_10hv_dwox*smm_dela_nld5_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld5_10hv_vtw             = (nom_dela_nld5_10hv_vtw+(sig_dela_nld5_10hv_vtw*nsig_dela_nld5_10hv_vtw))
+    delr_nld5_10hv_vsat            = (nom_delr_nld5_10hv_vsat*(1+sig_delr_nld5_10hv_vsat*nsig_delr_nld5_10hv_vsat))
+    delr_nld5_10hv_nsub            = (nld5_10hv_fac_nsub_sti_final*(1+nsmm_delr_nld5_10hv_nsub*smm_delr_nld5_10hv_nsub(l,w)/sqrt(1*ng)))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.01*1e-10*delr_nld5_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.4)
+    lchtcad                        = (0.293)
+    lacc                           = (0.058)
+    wdel                           = (0.3)
+    lch                            = (0.293)
+    lsovl                          = (lchdrawn-lchtcad-lacc)
+    ld                             = (0.255)
+    lsrc                           = (0.29)
+    lcell                          = (lsrc+lchdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.20)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    d_cfr                          = (6.84647e-17)
+    lfr                            = (0.090191174+(0.11/w**2))
+    dw_mos                         = (0)
+    dw_res                         = (-5.12098)
+    lcheff                         = (0.293)
+    numbernplus                    = (int_round(w/0.8))
+    w_mos                          = (numbernplus*0.4+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(6.79401)/(w**1.00015))*(1-fem))
+    ansd                           = ((w+2*wdel)*(ld)*ngeff)
+    pnsd                           = ((2*ld+2*wdel)*ngeff)
+    chnsd                          = (w*ngeff)
+    rsda                           = ((44/(w-0.61))*(1+0.01*(temp-27)))
+    rsdp                           = (136/(w-1.2))
+    rsdch                          = (57/(w-0.5))
+    xsub                           = ((2*xiso)+(lcell*ngeff))
+    ysub                           = (w+2*yiso)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lchdrawn*0.585*ng)
+    area_accum                     = ((lacc+0.15824)*w*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = ((int_round((w-0.135*2)/(0.18+0.22)/2))*2+1)
+    nb_ct_ply_d                    = (int_round(w/(0.18+0.24)+0.2))
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*w-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*w-lfr_ct_ply_d)
+    lm1s                           = (0.6*2*n_src)
+    lm1d                           = (0.6*2*n_drn)
+    ng_dmy                         = (2*sti_dummy)
+    area_accum_dmy                 = ((lacc+0.15824)*w*ng_dmy)
+    lfring_dmy                     = (w*ng_dmy)
+    lfr_ct_ply_d_dmy               = (nb_ct_ply_d*0.18*ng_dmy)
+    lfr_m1_ply_d_dmy               = (ng_dmy*w-lfr_ct_ply_d_dmy)
+    n_drn_dmy                      = (ng_dmy/2)
+    lm1d_dmy                       = (0.6*2*n_drn_dmy)
+    sdotmult                       = (1)
+    sdotmult2                      = (1)
+    aphi_tnom                      = (aphi_junc_nld5_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld5_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld5_d_body)
+    pphi_tnom                      = (pphi_junc_nld5_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld5_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld5_d_body)
+    chphi_tnom                     = (chphi_junc_nld5_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld5_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/pphi)
+    chexm                          = (chexm_junc_nld5_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_10hv_tox)
+ nch      = (3.10e16*delr_nld5_10hv_nsub)
+ nsub     = (4.75e16*delr_nld5_10hv_nsub)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-1.36807e-07+0.5e-6*dela_nld5_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((6.44544e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((7.45381e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-10.5045+6.5/w)*(1+-0.00251007*(temp-27)+3.99712e-06*(temp-27)*(temp-27)))
+ vfb      = (0.2048228+dela_nld5_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nld5_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nld5_10hv-relimo_ratio1_b_hci_nld5_10hv))
+ a0       = (1.37362*delr_a0_relimo)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (768.188*delr_nld5_10hv_uch*delr_u0_relimo)
+ ua       = (1e-17)
+ ub       = (6.28673e-19)
+ vsat     = (459379*delr_nld5_10hv_vsat)
+ drout    = (0.56)
+ pclm     = (0.37)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.0785775)
+ rdsw     = (14.6748*delr_nld5_10hv_res*delr_rdsw_relimo)
+ wr       = (1.00)
+ prwg     = (2.85)
+ prt      = (18.0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1.0)
+ moin     = (10)
+ cgsl     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0+dela_nld5_10hv_vtw)*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = (4.8)
+ voff     = (-0.38)
+ beta0    = (50)
+ kt1      = (-0.55851)
+ ua1      = (1.31648e-10)
+ ub1      = (-9.04058e-20)
+ uc1      = (-5.6e-11)
+ ute      = (-1.25783)
+ dlc      = (0.140e-6)
+ dwc      = (0)
+ at       = (33000)
+ noia     = (1.0e21)
+ noib     = (5.0e4*5.0)
+ noic     = (0.0)
+ em       = (4.1e7)
+ af       = (1)
+ ef       = (1)
+ kf       = (0)

if (ng_dmy>=2) {
mpowermos_dmy (intd_dmy s s s) nmosmodel l=lcheff w=(w_mos) m=(ng_dmy) ad=(1e-18) pd=(1e-18)
cgd_frg_dmy (s d) capacitor c=(d_cfr*lfring_dmy*sdotmult)
cgd_m1_dmy (s d) capacitor c=(lfr_m1_ply_d_dmy*cfr_nld5_d_ply_met*sdotmult+lfr_ct_ply_d_dmy*cfr_nld5_d_ply_m1ct*sdotmult+lm1d_dmy*3.06679e-16*sdotmult)
acapmos1_dmy (intd_dmy s s) accumcap
+ aream=(area_accum_dmy*sdotmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(1.28493e+17+(0/w))
+ vfb=(1.07938+dela_nld5_10hv_vxb)
+ f3=(1.5122)
+ phidel=(0.275864)
+ em=(1.98)
ares_dmy (d intd_dmy s) drifty
+ wm=(w_res*sdotmult*1e-6)
+ lm=(1*sdotmult*1e-6)
+ num=(ng_dmy)
+ xj=(0.005)
+ nd=(8.07053e+18)
+ u_init=(0.800201/delr_nld5_10hv_res)
+ vsat=((119803)*(1+0*(temp-27)+3.30717e-05*(temp-27)*(temp-27)))
+ fneff=(2.4)
+ alphafneff=(3.79989)
+ alphexp=(1.2)
+ vfbtexp=(0)
+ udriftexpa=(0+(0/w)*(1-fem))
+ udriftexpb=(0+(0/w)*(1-fem))
+ betavds=(0)
+ betaexp=(0.149911)
+ vfb0=(-3)
}
mpowermos (intd intg s s) nmosmodel l=lcheff w=(w_mos) m=(ng) ad=(1e-18) pd=(1e-18)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_frg (intg s) capacitor c=(cox*(lsovl+lfr)*lfring*sDOTmult2)
cgd_frg (intg d) capacitor c=(d_cfr*lfring*sDOTmult)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply_s*cfr_nld5_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld5_s_ply_m1ct*sDOTmult+lm1s*3.06679e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld5_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld5_d_ply_m1ct*sDOTmult+lm1d*3.06679e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.36)/(lchdrawn*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ngeff)
rxp (intdxp d) resistor r=(rsdp) m=(ngeff)
rxch (intdxch d) resistor r=(rsdch) m=(ngeff)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(1.28493e+17+(0/w))
+ vfb=(1.07938+dela_nld5_10hv_vxb)
+ f3=(1.5122)
+ phidel=(0.275864)
+ em=(1.98)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.005)
+ nd=(8.07053e+18)
+ u_init=(0.800201/delr_nld5_10hv_res)
+ vsat=((119803)*(1+0*(temp-27)+3.30717e-05*(temp-27)*(temp-27)))
+ fneff=(2.4)
+ alphafneff=(3.79989)
+ alphexp=(1.2)
+ vfbtexp=(0)
+ udriftexpa=(0+(0/w)*(1-fem))
+ udriftexpb=(0+(0/w)*(1-fem))
+ betavds=(0)
+ betaexp=(0.149911)
+ vfb0=(-3)
adsd_a (s intdxa) powerdiode
+ areafactor=(ansd)
+ num=(1)
+ is=(ajs_junc_nld5_d_body/sDOTmult)
+ n=(ajnd_junc_nld5_d_body*0.9)
+ rs=(0.0)
+ cj0=((acj0_junc_nld5_d_body/sDOTmult)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld5_d_body)
+ tau=(4e-9*0.25)
+ trr=(7.5e-9*0.62)
+ alphaeg=(aalphaeg_junc_nld5_d_body)
+ betaeg=(abetaeg_junc_nld5_d_body)
+ eg=(aeg_junc_nld5_d_body)
+ bv=(8.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(40e-4)
+ xti=(6)
adsd_p (s intdxp) powerdiode
+ areafactor=(pnsd)
+ num=(1)
+ is=(pjs_junc_nld5_d_body/sDOTmult*4500*w)
+ n=(pjnd_junc_nld5_d_body*0.9)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld5_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld5_d_body)
+ tau=(4e-9*0.25)
+ trr=(7.5e-9*0.62)
+ alphaeg=(palphaeg_junc_nld5_d_body)
+ betaeg=(pbetaeg_junc_nld5_d_body)
+ eg=(peg_junc_nld5_d_body)
+ bv=(8.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(6.00e-06*w)
+ xti=(5)
adsd_ch (s intdxch) powerdiode
+ areafactor=(chnsd)
+ num=(1)
+ is=(chjs_junc_nld5_d_body/sDOTmult)
+ n=(chjnd_junc_nld5_d_body)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld5_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld5_d_body)
+ tau=(4e-9*0.25)
+ trr=(7.5e-9*0.62)
+ alphaeg=(aalphaeg_junc_nld5_d_body)
+ betaeg=(abetaeg_junc_nld5_d_body)
+ eg=(aeg_junc_nld5_d_body)
+ bv=(8.5+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(6)
+ ik=(maxa(2e-8,(2.7e-6)*(1+0.13*(temp-27)),1e-13))

include "./smos10hv_ade_dfrt.scs" section=nld5_10hv_dfrt
ends

subckt pld10_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld10_10hv_gox       = tmp_nsmm_delr_pld10_10hv_gox
+    nsmm_dela_pld10_10hv_vfb       = tmp_nsmm_dela_pld10_10hv_vfb
+    nsmm_delr_pld10_10hv_nsub      = tmp_nsmm_delr_pld10_10hv_nsub
+    nsmm_dela_pld10_10hv_vtl       = tmp_nsmm_dela_pld10_10hv_vtl
+    nsmm_dela_pld10_10hv_dwox      = tmp_nsmm_dela_pld10_10hv_dwox
+    nsmm_delr_pld10_10hv_ubref     = tmp_nsmm_delr_pld10_10hv_ubref
+    nsmm_delr_pld10_10hv_rsh       = tmp_nsmm_delr_pld10_10hv_rsh
+    nsmm_dela_pld10_10hv_vtw       = tmp_nsmm_dela_pld10_10hv_vtw
+    l                              = (0.2)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld10_vthratio          = 1.0
+    presto_pld10_betaratio         = 1
+    delr_pld10_10hv_tox            = (nom_delr_pld10_10hv_tox*(1+sig_delr_pld10_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld10_10hv_gox*smm_delr_pld10_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld10_10hv_uch            = (nom_delr_pld10_10hv_uch*(1+sig_delr_pld10_10hv_uch*nsig_delr_pld10_10hv_uch+nsmm_delr_pld10_10hv_ubref*smm_delr_pld10_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld10_10hv_res            = (nom_delr_pld10_10hv_res*(1+sig_delr_pld10_10hv_res*nsig_delr_pld10_10hv_res+nsmm_delr_pld10_10hv_rsh*smm_delr_pld10_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld10_10hv_vfb            = (nom_dela_pld10_10hv_vfb+(sig_dela_pld10_10hv_vfb*nsig_dela_pld10_10hv_vfb)+nsmm_dela_pld10_10hv_vfb*smm_dela_pld10_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld10_10hv_vtl*smm_dela_pld10_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld10_10hv_vtw*smm_dela_pld10_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld10_10hv_dwres          = (nom_dela_pld10_10hv_dwres+(sig_dela_pld10_10hv_dwres*nsig_dela_pld10_10hv_dwres))
+    dela_pld10_10hv_dwmos          = (nom_dela_pld10_10hv_dwmos+(sig_dela_pld10_10hv_dwmos*nsig_dela_pld10_10hv_dwmos)+(nsmm_dela_pld10_10hv_dwox*smm_dela_pld10_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_pld10_10hv_vtw            = (nom_dela_pld10_10hv_vtw+(sig_dela_pld10_10hv_vtw*nsig_dela_pld10_10hv_vtw))
+    delr_pld10_10hv_nsub           = (1+nsmm_delr_pld10_10hv_nsub*smm_delr_pld10_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld10_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.2)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.369)
+    lacc                           = (0.324)
+    w_delta                        = (0.60)
+    lch                            = (0.369)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (0.525)
+    lsrc                           = (0.495)
+    lflap                          = (0.225)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.35)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr_s                          = (0.00693216)
+    dw_mos                         = (0)
+    dw_res                         = (-0.502252+dela_pld10_10hv_dwres)
+    lcheff                         = (0.369)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(0.861359)/(w**(1.14813)))*(1-fem))
+    xnhvhole                       = (ld+laccdrawn)
+    ynhvhole                       = (w+2*w_delta)
+    anhvhole                       = (xnhvhole*ynhvhole*ng)
+    pnhvhole                       = ((2*w_delta+2*xnhvhole)*ng)
+    chnhvhole                      = (w*ng)
+    rsda                           = ((180/(w+1))*(1+0.0032*(temp-27)))
+    rsdp                           = (396/(w+1))
+    rsdch                          = (10780/(w+0))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (0.54*(lsovl+lch)*2*ng)
+    aplyfld_d                      = ((0.54*(lacc+lflap)*2+w*lflap)*ng)
+    area_accum                     = ((lacc+0.08424)*w*ng)
+    lfring_s                       = (w*ng)
+    nb_ct_ply                      = (int_round((w-(0.18+0.08*2))/(0.18*2))+1)
+    lfr_ct_ply                     = (nb_ct_ply*0.18*ng)
+    lfr_m1_ply                     = (ng*w-lfr_ct_ply)
+    lm1s                           = (0.96*2*n_src)
+    lm1d                           = (0.96*2*n_drn)
+    aphi_tnom                      = (aphi_junc_pld10_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_pld10_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_pld10_d_body)
+    pphi_tnom                      = (pphi_junc_pld10_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_pld10_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_pld10_d_body)
+    chphi_tnom                     = (chphi_junc_pld10_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_pld10_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/pphi)
+    chexm                          = (chexm_junc_pld10_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld10_10hv_tox)
+ nch      = (7.19e16*delr_pld10_10hv_nsub)
+ nsub     = (8.77e16*delr_pld10_10hv_nsub)
+ xt       = (2.002e-7)
+ capmod   = (3)
+ wint     = ((-3.88988e-07+0.5e-6*dela_pld10_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-13)*(1-fem))
+ wwn      = (1.14665)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-4.89381)*(1+-0.00791271*(temp-27)+4.05173e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.385944+dela_pld10_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld10_vthratio)
+ a0       = (0.399319*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = (579.236*delr_pld10_10hv_uch*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld10_betaratio))
+ ua       = (7.95632e-09)
+ ub       = (1.77696e-18)
+ vsat     = (2.44887e+06)
+ drout    = (0.892638)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (0.003918138)
+ pdiblc2  = (0.00478204)
+ delta    = (0.12)
+ rdsw     = (771.216*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.3)
+ prt      = (0.126802)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.0019111)
+ etab     = (0)
+ voffcv   = (0)
+ noff     = (4.0)
+ voff     = (-0.35)
+ w0       = (0)
+ dvt0     = (2.2)
+ dvt1     = (0.53)
+ dvt0w    = ((0.261316+dela_pld10_10hv_vtw)*(1-fem))
+ dvt1w    = (210481)
+ k3       = ((10.8148)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.42e-6)
+ dsub     = (1.89)
+ alpha0   = (5e-5)
+ alpha1   = (0.387818)
+ nfactor  = (2.75)
+ beta0    = (1000)
+ kt1      = (-0.587409)
+ ua1      = (1.00223e-12)
+ ub1      = (-2.06824e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.38925)
+ dlc      = (0.1725e-6)
+ dwc      = (0)
+ at       = (33000)

model nmcapmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld10_10hv_tox)
+ nch      = (1.05e16)
+ nsub     = (8.77e15)
+ xt       = (2.002e-7)
+ capmod   = (3)
+ wint     = ((-3.88988e-07)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-13)*(1-fem))
+ wwn      = (1.14665)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-4.89381)*(1+-0.00791271*(temp-27)+4.05173e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.385944)
+ a0       = (0.399319)
+ a1       = (0)
+ a2       = (1)
+ u0       = (579.236)
+ ua       = (7.95632e-09)
+ ub       = (1.77696e-18)
+ vsat     = (2.44887e+06)
+ drout    = (0.892638)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (0.003918138)
+ pdiblc2  = (0.00478204)
+ delta    = (0.12)
+ rdsw     = (771.216)
+ wr       = (1)
+ prwg     = (0.3)
+ prt      = (0.126802)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.0019111)
+ etab     = (0)
+ voffcv   = (0)
+ noff     = (4.0)
+ voff     = (-0.35)
+ w0       = (0)
+ dvt0     = (2.2)
+ dvt1     = (0.53)
+ dvt0w    = ((0.261316)*(1-fem))
+ dvt1w    = (210481)
+ k3       = ((10.8148)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.42e-6)
+ dsub     = (1.89)
+ alpha0   = (5e-5)
+ alpha1   = (0.387818)
+ nfactor  = (2.75)
+ beta0    = (1000)
+ kt1      = (-0.587409)
+ ua1      = (1.00223e-12)
+ ub1      = (-2.06824e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.38925)
+ dlc      = (0.08424*0.5e-6)
+ dwc      = (-5.09577e-07)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=w_mos m=(ng)
cgs_frg (intg s) capacitor c=(cox*(lfr_s+lsovl)*lfring_s*sDOTmult2)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply*cfr_pld10_s_ply_met*sDOTmult+lfr_ct_ply*cfr_pld10_s_ply_m1ct*sDOTmult+lm1s*1.846448e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply*cfr_pld10_d_ply_met*sDOTmult+lfr_ct_ply*cfr_pld10_d_ply_m1ct*sDOTmult+lm1d*1.846448e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.3)/((lchdrawn+laccdrawn+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ kind=(-1)
+ num=(1)
+ tox=(tox)
+ nb=(9.8624e+16+(1.1e17/w))
+ vfb=(-0.1205864+dela_pld10_10hv_vfb)
+ f3=(2.62597)
+ phidel=(-0.228701)
+ em=(2.0)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ kind=(-1)
+ num=(ng)
+ xj=(0.00072989)
+ nd=(2.0267e+19)
+ u_init=(0.0033013/delr_pld10_10hv_res)
+ vsat=((8128.21)*(1+-0.0011604*(temp-27)+9.21543e-06*(temp-27)*(temp-27)))
+ fneff=(1.6453)
+ alphafneff=(1.28952)
+ alphexp=(1.36203)
+ vfbtexp=(0)
+ udriftexpa=(-0.00440614+(5e-4/w)*(1-fem))
+ udriftexpb=(9.38241e-06+(0/w)*(1-fem))
+ betavds=(4.03283+(5.0/w)*(1-fem))
+ betaexp=(0.165581+(1.0/w)*(1-fem))
+ vfb0=(-7)
adsd_a (intdxa s) powerdiode
+ areafactor=(anhvhole)
+ num=(1)
+ is=(ajs_junc_pld10_d_body*0.5)
+ n=(ajnd_junc_pld10_d_body*1.1)
+ rs=(0.0)
+ cj0=((acj0_junc_pld10_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_pld10_d_body)
+ tau=(5e-9)
+ trr=(2e-9)
+ alphaeg=(aalphaeg_junc_pld10_d_body)
+ betaeg=(abetaeg_junc_pld10_d_body)
+ eg=(aeg_junc_pld10_d_body)
+ bv=(16+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(25e-05)
+ xti=(19)
adsd_p (intdxp s) powerdiode
+ areafactor=(pnhvhole)
+ num=(1)
+ is=(pjs_junc_pld10_d_body/sDOTmult*4000*w)
+ n=(pjnd_junc_pld10_d_body*1.03)
+ rs=(0.0)
+ cj0=((pcj0_junc_pld10_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_pld10_d_body)
+ tau=(5e-9)
+ trr=(2e-9)
+ alphaeg=(palphaeg_junc_pld10_d_body)
+ betaeg=(pbetaeg_junc_pld10_d_body)
+ eg=(peg_junc_pld10_d_body)
+ bv=(16+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(0.5e-04*w)
+ xti=(pxti_junc_pld10_d_body+15)
adsd_ch (intdxch s) powerdiode
+ areafactor=(chnhvhole)
+ num=(1)
+ is=(chjs_junc_pld10_d_body/sDOTmult*0.4)
+ n=(chjnd_junc_pld10_d_body*0.935)
+ rs=(0.0)
+ cj0=((chcj0_junc_pld10_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_pld10_d_body)
+ tau=(5e-9)
+ trr=(2e-9)
+ alphaeg=(aalphaeg_junc_pld10_d_body)
+ betaeg=(abetaeg_junc_pld10_d_body)
+ eg=(aeg_junc_pld10_d_body)
+ bv=(16+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(axti_junc_pld10_d_body+0.5)
+ ik=(maxa(4e-8,(1e-07)*(1+0.075*(temp-27)),1e-13))

include "./smos10hv_ade_dfrt.scs" section=pld10_10hv_dfrt
ends

subckt pld10b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    sti_dummy                      = 0
+    gt_90v                         = 0
+    nsmm_delr_gox_pld10b_sphv_10hv = tmp_nsmm_delr_gox_pld10b_sphv_10hv
+    nsmm_dela_dw_pld10b_sphv_10hv  = tmp_nsmm_dela_dw_pld10b_sphv_10hv
+    nsmm_dela_vfb_pld10b_sphv_10hv = tmp_nsmm_dela_vfb_pld10b_sphv_10hv
+    nsmm_delr_mobref_pld10b_sphv_10hv = tmp_nsmm_delr_mobref_pld10b_sphv_10hv
+    nsmm_delr_rshl_pld10b_sphv_10hv = tmp_nsmm_delr_rshl_pld10b_sphv_10hv
+    nsmm_delr_nsub_pld10b_sphv_10hv = tmp_nsmm_delr_nsub_pld10b_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld10b_vthratio         = 1.0
+    presto_pld10b_ronratio         = 0.01/0.6336
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    fscale                         = (1)
+    l                              = (0.25)
+    wum                            = (w*fscale)
+    lum                            = (l*fscale)
+    wdrift_um                      = (w*fscale)
+    ldrift_um                      = (0.36*fscale)
+    ldr1_um                        = (0.5*fscale)
+    lacts                          = (0.66)
+    lactd                          = (0.33)
+    ldr1                           = (0.5)
+    ldrift                         = (0.36)
+    wg2nhv                         = (0.6)
+    as_xdr                         = (1e-18)
+    ps_xdr                         = (1e-18)
+    ad_xdr                         = ((ldr1-0.2)*(w+2*wg2nhv))
+    pd_xdr                         = (2*((ldr1-0.2)+(w+2*wg2nhv)))
+    ad2_xdr                        = ((lactd/2+ldr1+0.2)*(w+2*wg2nhv))
+    pd2_xdr                        = (2*(lactd/2+ldr1+0.2))
+    as_um                          = (as_xdr*fscale*fscale)
+    ps_um                          = (ps_xdr*fscale)
+    ad_um                          = (ad_xdr*fscale*fscale)
+    pd_um                          = (pd_xdr*fscale)
+    ad2_um                         = (ad2_xdr*fscale*fscale)
+    pd2_um                         = (pd2_xdr*fscale)
+    lg2dt                          = (1.77)
+    wg2dt                          = (1.35)
+    lg2g_d                         = (2*(ldr1+ldrift+lactd/2))
+    lg2g_s                         = (0.99)
+    xnbl_xdr                       = (lg2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (w+2*wg2dt)
+    dt_upsize                      = (0.75*2*gt_90v)
+    anbl_xdr                       = (xnbl_xdr*(ynbl_xdr+dt_upsize))
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr+dt_upsize))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_pld10b_sphv_10hv+tc2_ecrit_pld10b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    perimeter__1__                 = ((((xnbl_xdr+t_dt))+((ynbl_xdr+t_dt)))*2)
+    w__1__                         = ((perimeter__1__)*1e-6)
+    l__1__                         = ((d_dt)*1e-6)
+    t_dielectric__1__              = ((t_ox_dt)*1e-6)
+    fac_cdt__1__                   = (1.820)
+    e0__1__                        = (8.854214871e-12)
+    df__1__                        = (t_dielectric__1__*(1+e0__1__*1e11*log(w__1__*l__1__*1e4+1))/3.14159265358979323846)
+    ctot__1__                      = (fac_cdt__1__*(w__1__+df__1__)*(l__1__+df__1__)*(e_toxrel_10hv)*e0__1__/t_dielectric__1__)
+    w_heat                         = (w)
+    l_heat                         = (lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+    dtemp__1__                     = (temp-tnom)
+    tcr__1__                       = (1.0+dtemp__1__*((0)+dtemp__1__*(0)))
+    tcc__1__                       = (1.0+dtemp__1__*((0)+dtemp__1__*(0)))
+    area__1__                      = ((w_heat)*(l_heat))
+    aspr__1__                      = (max((w_heat),(l_heat))/min((w_heat),(l_heat)))
+    rth0__1__                      = (2150.6240)
+    c1__1__                        = (-0.5385)
+    c2__1__                        = (-0.2000)
+    rth                            = (rth0__1__*pow(area__1__,c1__1__)*pow(aspr__1__,c2__1__)*tcr__1__)
+    cth0__1__                      = (1.264e-11)
+    c11__2__                       = (0.8994)
+    c12__2__                       = (0.0482)
+    term_area_1__2__               = (c11__2__*log10(area__1__))
+    term_area_2__2__               = (c12__2__*pow(log10(area__1__),2))
+    cth                            = (cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__)
+    rth_f                          = (((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld10b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld10b_sphv_10hv)*ngeff)
+    cth_f                          = (((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    delr_tox_pld10b_sphv_10hv      = (nom_delr_tox_pld10b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld10b_sphv_10hv+nsmm_delr_gox_pld10b_sphv_10hv*smm_delr_gox_pld10b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_pld10b_sphv_10hv       = (nom_dela_dw_pld10b_sphv_10hv+nsig_dela_dw_pld10b_sphv_10hv*sig_dela_dw_pld10b_sphv_10hv+nsmm_dela_dw_pld10b_sphv_10hv*smm_dela_dw_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_pld10b_sphv_10hv      = (nom_dela_vfb_pld10b_sphv_10hv+nsig_dela_vfb_pld10b_sphv_10hv*sig_dela_vfb_pld10b_sphv_10hv+nsmm_dela_vfb_pld10b_sphv_10hv*smm_dela_vfb_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_pld10b_sphv_10hv     = (nom_dela_vtwl_pld10b_sphv_10hv+nsig_dela_vtwl_pld10b_sphv_10hv*sig_dela_vtwl_pld10b_sphv_10hv)
+    delr_mobref_pld10b_sphv_10hv   = (nom_delr_mobref_pld10b_sphv_10hv*(1.0+nsig_delr_mobref_pld10b_sphv_10hv*sig_delr_mobref_pld10b_sphv_10hv+nsmm_delr_mobref_pld10b_sphv_10hv*smm_delr_mobref_pld10b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_pld10b_sphv_10hv     = (nom_delr_rshl_pld10b_sphv_10hv*(1.0+nsig_delr_rshl_pld10b_sphv_10hv*sig_delr_rshl_pld10b_sphv_10hv)+nsmm_delr_rshl_pld10b_sphv_10hv*smm_delr_rshl_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_pld10b_sphv_10hv     = (1+nsmm_delr_nsub_pld10b_sphv_10hv*smm_delr_nsub_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dcbv_pld10b_10hv               = (16)
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lchdrawn                       = (0.2)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.369)
+    lacc                           = (0.324)
+    lflap                          = (0.225)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    swdrlin                        = (0)
+    fac_rshldd                     = ((swdrlin==0)+(swdrlin==2)*0.8529)
+    fac_a_ng_vfbo                  = -((ngeff/(ngeff+0.2)-2/(2+0.2))*0.48*(1-fem))
+    fac_r_ng_rshldd                = (1+(ngeff/(ngeff+1)-2/(2+1))*0.06*(1-fem))
+    fac_r_ng_uo                    = (1-(ngeff/(ngeff+1)-2/(2+1))*0.155*(1-fem))
+    fac_a_ng_thesato               = ((ngeff/(ngeff+2)-2/(2+2))*0.027*(1-fem)*0.7*w/(w+1.5*(1-fem)))

if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=wum l=lum ldrift=ldrift_um wdrift=wdrift_um ldr1=ldr1_um mult=ng_dmy ad=ad_um pd=pd_um as=as_um ps=ps_um ad2=ad2_um pd2=pd2_um
}

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (0)
+ swdrlin  = (0)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swgedi   = (1)
+ qmc      = (qmc_pld10b_sphv_10hv)
+ lvaro    = (lvaro_pld10b_sphv_10hv)
+ lvarl    = (lvarl_pld10b_sphv_10hv)
+ lvarw    = (lvarw_pld10b_sphv_10hv*(1-fem))
+ lap      = (lap_pld10b_sphv_10hv)
+ wvaro    = (wvaro_pld10b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld10b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld10b_sphv_10hv*(1-fem))
+ wot      = ((wot_pld10b_sphv_10hv+0.5e-6*dela_dw_pld10b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_pld10b_sphv_10hv)
+ dwq      = (dwq_pld10b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld10b_sphv_10hv+dela_vfb_pld10b_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld10b_vthratio)
+ vfbl     = (vfbl_pld10b_sphv_10hv)
+ vfbw     = (vfbw_pld10b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_pld10b_sphv_10hv+dela_vtwl_pld10b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_pld10b_sphv_10hv)
+ stvfbl   = (stvfbl_pld10b_sphv_10hv)
+ stvfbw   = (stvfbw_pld10b_sphv_10hv)
+ stvfblw  = (stvfblw_pld10b_sphv_10hv)
+ toxo     = (toxo_pld10b_sphv_10hv*delr_tox_pld10b_sphv_10hv)
+ epsroxo  = (epsroxo_pld10b_sphv_10hv)
+ nsubo    = (nsubo_pld10b_sphv_10hv*delr_nsub_pld10b_sphv_10hv)
+ nsubw    = (nsubw_pld10b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld10b_sphv_10hv)
+ npck     = (npck_pld10b_sphv_10hv)
+ npckw    = (npckw_pld10b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld10b_sphv_10hv)
+ lpck     = (lpck_pld10b_sphv_10hv)
+ lpckw    = (lpckw_pld10b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld10b_sphv_10hv)
+ fol2     = (fol2_pld10b_sphv_10hv)
+ facneffaco = (facneffaco_pld10b_sphv_10hv)
+ facneffacl = (facneffacl_pld10b_sphv_10hv)
+ facneffacw = (facneffacw_pld10b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld10b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld10b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld10b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld10b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld10b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld10b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld10b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld10b_sphv_10hv)
+ vnsubo   = (vnsubo_pld10b_sphv_10hv)
+ nslpo    = (nslpo_pld10b_sphv_10hv)
+ dnsubo   = (dnsubo_pld10b_sphv_10hv)
+ dphibo   = (dphibo_pld10b_sphv_10hv)
+ dphibl   = (dphibl_pld10b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld10b_sphv_10hv)
+ dphibw   = (dphibw_pld10b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld10b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld10b_sphv_10hv)
+ delvtacl = (delvtacl_pld10b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld10b_sphv_10hv)
+ delvtacw = (delvtacw_pld10b_sphv_10hv)
+ delvtaclw = (delvtaclw_pld10b_sphv_10hv)
+ npo      = (npo_pld10b_sphv_10hv)
+ npl      = (npl_pld10b_sphv_10hv)
+ cto      = (cto_pld10b_sphv_10hv)
+ ctl      = (ctl_pld10b_sphv_10hv)
+ ctlexp   = (ctlexp_pld10b_sphv_10hv)
+ ctw      = (ctw_pld10b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld10b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld10b_sphv_10hv)
+ toxovdo  = (toxovdo_pld10b_sphv_10hv)
+ lov      = (lov_pld10b_sphv_10hv)
+ dlovd    = (dlovd_pld10b_sphv_10hv)
+ novo     = (novo_pld10b_sphv_10hv)
+ novdo    = (novdo_pld10b_sphv_10hv)
+ cfl      = (cfl_pld10b_sphv_10hv)
+ cflexp   = (cflexp_pld10b_sphv_10hv)
+ cfw      = (cfw_pld10b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld10b_sphv_10hv)
+ uo       = (uo_pld10b_sphv_10hv*delr_mobref_pld10b_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_pld10b_sphv_10hv)
+ fbet1w   = (fbet1w_pld10b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld10b_sphv_10hv)
+ lp1w     = (lp1w_pld10b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld10b_sphv_10hv)
+ lp2      = (lp2_pld10b_sphv_10hv)
+ betw1    = (betw1_pld10b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld10b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld10b_sphv_10hv)
+ stbeto   = (stbeto_pld10b_sphv_10hv)
+ stbetl   = (stbetl_pld10b_sphv_10hv)
+ stbetw   = (stbetw_pld10b_sphv_10hv)
+ stbetlw  = (stbetlw_pld10b_sphv_10hv)
+ mueo     = (mueo_pld10b_sphv_10hv)
+ muew     = (muew_pld10b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld10b_sphv_10hv)
+ themuo   = (themuo_pld10b_sphv_10hv)
+ stthemuo = (stthemuo_pld10b_sphv_10hv)
+ cso      = (cso_pld10b_sphv_10hv)
+ csl      = (csl_pld10b_sphv_10hv)
+ cslexp   = (cslexp_pld10b_sphv_10hv)
+ csw      = (csw_pld10b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld10b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld10b_sphv_10hv)
+ xcoro    = (xcoro_pld10b_sphv_10hv)
+ xcorl    = (xcorl_pld10b_sphv_10hv)
+ xcorw    = (xcorw_pld10b_sphv_10hv)
+ xcorlw   = (xcorlw_pld10b_sphv_10hv)
+ stxcoro  = (stxcoro_pld10b_sphv_10hv)
+ fetao    = (fetao_pld10b_sphv_10hv)
+ rsw1     = (rsw1_pld10b_sphv_10hv)
+ rsw2     = (rsw2_pld10b_sphv_10hv)
+ strso    = (strso_pld10b_sphv_10hv)
+ rsbo     = (rsbo_pld10b_sphv_10hv)
+ rsgo     = (rsgo_pld10b_sphv_10hv)
+ thesato  = (thesato_pld10b_sphv_10hv*0.958+fac_a_ng_thesato)
+ thesatl  = (thesatl_pld10b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld10b_sphv_10hv)
+ thesatw  = (thesatw_pld10b_sphv_10hv*0.972*(1-fem))
+ thesatlw = (thesatlw_pld10b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld10b_sphv_10hv)
+ stthesatl = (stthesatl_pld10b_sphv_10hv)
+ stthesatw = (stthesatw_pld10b_sphv_10hv)
+ stthesatlw = (stthesatlw_pld10b_sphv_10hv)
+ thesatbo = (thesatbo_pld10b_sphv_10hv)
+ thesatgo = (thesatgo_pld10b_sphv_10hv)
+ thesatgl = (thesatgl_pld10b_sphv_10hv)
+ thesatgw = (thesatgw_pld10b_sphv_10hv*(1-fem))
+ axo      = (axo_pld10b_sphv_10hv)
+ axl      = (axl_pld10b_sphv_10hv)
+ alpl     = (alpl_pld10b_sphv_10hv)
+ alplexp  = (alplexp_pld10b_sphv_10hv)
+ alpw     = (alpw_pld10b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld10b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld10b_sphv_10hv)
+ alp1l2   = (alp1l2_pld10b_sphv_10hv)
+ alp1w    = (alp1w_pld10b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld10b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld10b_sphv_10hv)
+ alp2l2   = (alp2l2_pld10b_sphv_10hv)
+ alp2w    = (alp2w_pld10b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld10b_sphv_10hv)
+ a1o      = (a1o_pld10b_sphv_10hv)
+ a1l      = (a1l_pld10b_sphv_10hv)
+ a1w      = (a1w_pld10b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld10b_sphv_10hv)
+ sta2o    = (sta2o_pld10b_sphv_10hv)
+ a3o      = (a3o_pld10b_sphv_10hv)
+ a3l      = (a3l_pld10b_sphv_10hv)
+ a3w      = (a3w_pld10b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld10b_sphv_10hv)
+ a4l      = (a4l_pld10b_sphv_10hv)
+ a4w      = (a4w_pld10b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld10b_sphv_10hv)
+ iginvlw  = (iginvlw_pld10b_sphv_10hv)
+ igovw    = (igovw_pld10b_sphv_10hv)
+ igovdw   = (igovdw_pld10b_sphv_10hv)
+ stigo    = (stigo_pld10b_sphv_10hv)
+ gc2o     = (gc2o_pld10b_sphv_10hv)
+ gc3o     = (gc3o_pld10b_sphv_10hv)
+ chibo    = (chibo_pld10b_sphv_10hv)
+ agidlw   = (agidlw_pld10b_sphv_10hv)
+ agidldw  = (agidldw_pld10b_sphv_10hv)
+ bgidlo   = (bgidlo_pld10b_sphv_10hv)
+ bgidldo  = (bgidldo_pld10b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld10b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld10b_sphv_10hv)
+ cgidlo   = (cgidlo_pld10b_sphv_10hv)
+ cgidldo  = (cgidldo_pld10b_sphv_10hv)
+ cgbovl   = (cgbovl_pld10b_sphv_10hv)
+ cfrw     = (cfrw_pld10b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_pld10b_sphv_10hv*(1-fem))
+ fnto     = (fnto_pld10b_sphv_10hv)
+ nfalw    = (nfalw_pld10b_sphv_10hv)
+ nfblw    = (nfblw_pld10b_sphv_10hv)
+ nfclw    = (nfclw_pld10b_sphv_10hv)
+ efo      = (efo_pld10b_sphv_10hv)
+ lintnoi  = (lintnoi_pld10b_sphv_10hv)
+ alpnoi   = (alpnoi_pld10b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld10b_sphv_10hv)
+ kvthowel = (kvthowel_pld10b_sphv_10hv)
+ kvthowew = (kvthowew_pld10b_sphv_10hv)
+ kvthowelw = (kvthowelw_pld10b_sphv_10hv)
+ kuoweo   = (kuoweo_pld10b_sphv_10hv)
+ kuowel   = (kuowel_pld10b_sphv_10hv)
+ kuowew   = (kuowew_pld10b_sphv_10hv)
+ kuowelw  = (kuowelw_pld10b_sphv_10hv)
+ rgo      = (rgo_pld10b_sphv_10hv)
+ rsh      = (rsh_pld10b_sphv_10hv)
+ rbulko   = (rbulko_pld10b_sphv_10hv)
+ rwello   = (rwello_pld10b_sphv_10hv)
+ rjunso   = (rjunso_pld10b_sphv_10hv/(wum+dwrjunso_pld10b_sphv_10hv))
+ rjundo   = (rjundo_pld10b_sphv_10hv/(wum+dwrjundo_pld10b_sphv_10hv))
+ rint     = (rint_pld10b_sphv_10hv)
+ rvpoly   = (rvpoly_pld10b_sphv_10hv)
+ rshg     = (rshg_pld10b_sphv_10hv)
+ dlsil    = (dlsil_pld10b_sphv_10hv)
+ saref    = (saref_pld10b_sphv_10hv)
+ sbref    = (sbref_pld10b_sphv_10hv)
+ wlod     = (wlod_pld10b_sphv_10hv)
+ kuo      = (kuo_pld10b_sphv_10hv)
+ kvsat    = (kvsat_pld10b_sphv_10hv)
+ tkuo     = (tkuo_pld10b_sphv_10hv)
+ lkuo     = (lkuo_pld10b_sphv_10hv)
+ wkuo     = (wkuo_pld10b_sphv_10hv)
+ pkuo     = (pkuo_pld10b_sphv_10hv)
+ llodkuo  = (llodkuo_pld10b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld10b_sphv_10hv)
+ kvtho    = (kvtho_pld10b_sphv_10hv)
+ lkvtho   = (lkvtho_pld10b_sphv_10hv)
+ wkvtho   = (wkvtho_pld10b_sphv_10hv)
+ pkvtho   = (pkvtho_pld10b_sphv_10hv)
+ llodvth  = (llodvth_pld10b_sphv_10hv)
+ wlodvth  = (wlodvth_pld10b_sphv_10hv)
+ stetao   = (stetao_pld10b_sphv_10hv)
+ lodetao  = (lodetao_pld10b_sphv_10hv)
+ scref    = (scref_pld10b_sphv_10hv)
+ web      = (web_pld10b_sphv_10hv)
+ wec      = (wec_pld10b_sphv_10hv)
+ adr1o    = (adr1o_pld10b_sphv_10hv)
+ adr1l    = (adr1l_pld10b_sphv_10hv)
+ adr1w    = (adr1w_pld10b_sphv_10hv)
+ adr2o    = (adr2o_pld10b_sphv_10hv)
+ stadr2o  = (stadr2o_pld10b_sphv_10hv)
+ adr3o    = (adr3o_pld10b_sphv_10hv)
+ adr3l    = (adr3l_pld10b_sphv_10hv)
+ adr3w    = (adr3w_pld10b_sphv_10hv)
+ adr4o    = (adr4o_pld10b_sphv_10hv)
+ adr4l    = (adr4l_pld10b_sphv_10hv)
+ adr4w    = (adr4w_pld10b_sphv_10hv)
+ adr5o    = (adr5o_pld10b_sphv_10hv)
+ adr5l    = (adr5l_pld10b_sphv_10hv)
+ adr5w    = (adr5w_pld10b_sphv_10hv)
+ bidr1o   = (bidr1o_pld10b_sphv_10hv)
+ bidr1l   = (bidr1l_pld10b_sphv_10hv)
+ bidr1w   = (bidr1w_pld10b_sphv_10hv)
+ bidr2o   = (bidr2o_pld10b_sphv_10hv)
+ bidr2w   = (bidr2w_pld10b_sphv_10hv)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_pld10b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_pld10b_sphv_10hv*delr_rshl_pld10b_sphv_10hv*fac_r_ng_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld10b_ronratio))*fac_rshldd)
+ xw       = (xw_pld10b_sphv_10hv*(1-fem))
+ nwxw     = (nwxw_pld10b_sphv_10hv*(1-fem))
+ xl       = (xl_pld10b_sphv_10hv)
+ xlw      = (xlw_pld10b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld10b_sphv_10hv)
+ nst      = (nst_pld10b_sphv_10hv)
+ ats      = (ats_pld10b_sphv_10hv)
+ dfinf    = (dfinf_pld10b_sphv_10hv)
+ dfw      = (dfw_pld10b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld10b_sphv_10hv)
+ dflw     = (dflw_pld10b_sphv_10hv*(1-fem))
+ dp       = (dp_pld10b_sphv_10hv)
+ ecrit    = (ecrit_pld10b_sphv_10hv*tfact_ecrit)
+ ecorn    = (ecorn_pld10b_sphv_10hv*tfact_ecrit)
+ du       = (du_pld10b_sphv_10hv)
+ tc1      = (tc1_pld10b_sphv_10hv)
+ tc2      = (tc2_pld10b_sphv_10hv)
+ tc1l     = (tc1l_pld10b_sphv_10hv)
+ tc2l     = (tc2l_pld10b_sphv_10hv)
+ tc1w     = (tc1w_pld10b_sphv_10hv)
+ tc2w     = (tc2w_pld10b_sphv_10hv)
+ theacc   = (theacc_pld10b_sphv_10hv)
+ theacc2  = (theacc2_pld10b_sphv_10hv)
+ aacc     = (aacc_pld10b_sphv_10hv)
+ rva      = (rva_pld10b_sphv_10hv)
+ dta      = (dta_pld10b_sphv_10hv)
+ trj      = (trj_pld10b_sphv_10hv)
+ cjarea   = (cjarea_pld10b_sphv_10hv)
+ cjlsti   = (cjlsti_pld10b_sphv_10hv)
+ cjlgat   = (cjlgat_pld10b_sphv_10hv)
+ vbiarea  = (vbiarea_pld10b_sphv_10hv)
+ vbisti   = (vbisti_pld10b_sphv_10hv)
+ vbigat   = (vbigat_pld10b_sphv_10hv)
+ parea    = (parea_pld10b_sphv_10hv)
+ psti     = (psti_pld10b_sphv_10hv)
+ pgat     = (pgat_pld10b_sphv_10hv)
+ is1area  = (is1area_pld10b_sphv_10hv)
+ ttarea   = (ttarea_pld10b_sphv_10hv)
+ is2area  = (is2area_pld10b_sphv_10hv)
+ irarea   = (irarea_pld10b_sphv_10hv)
+ stis1area = (stis1area_pld10b_sphv_10hv)
+ stis2area = (stis2area_pld10b_sphv_10hv)
+ stirarea = (stirarea_pld10b_sphv_10hv)
+ n1area   = (n1area_pld10b_sphv_10hv)
+ n2area   = (n2area_pld10b_sphv_10hv)
+ nrarea   = (nrarea_pld10b_sphv_10hv)
+ is1lsti  = (is1lsti_pld10b_sphv_10hv)
+ ttlsti   = (ttlsti_pld10b_sphv_10hv)
+ is2lsti  = (is2lsti_pld10b_sphv_10hv)
+ irlsti   = (irlsti_pld10b_sphv_10hv)
+ stis1sti = (stis1sti_pld10b_sphv_10hv)
+ stis2sti = (stis2sti_pld10b_sphv_10hv)
+ stirsti  = (stirsti_pld10b_sphv_10hv)
+ n1sti    = (n1sti_pld10b_sphv_10hv)
+ n2sti    = (n2sti_pld10b_sphv_10hv)
+ nrsti    = (nrsti_pld10b_sphv_10hv)
+ is1lgat  = (is1lgat_pld10b_sphv_10hv)
+ ttlgat   = (ttlgat_pld10b_sphv_10hv)
+ is2lgat  = (is2lgat_pld10b_sphv_10hv)
+ irlgat   = (irlgat_pld10b_sphv_10hv)
+ stis1gat = (stis1gat_pld10b_sphv_10hv)
+ stis2gat = (stis2gat_pld10b_sphv_10hv)
+ stirgat  = (stirgat_pld10b_sphv_10hv)
+ n1gat    = (n1gat_pld10b_sphv_10hv)
+ n2gat    = (n2gat_pld10b_sphv_10hv)
+ nrgat    = (nrgat_pld10b_sphv_10hv)
+ cjaread  = (cjaread_pld10b_sphv_10hv*cj0_junc_pld10b_d_body)
+ cjlstid  = (cjaread_pld10b_sphv_10hv*djunc*cj0_junc_pld10b_d_body)
+ cjlgatd  = (cjaread_pld10b_sphv_10hv*djunc*cj0_junc_pld10b_d_body)
+ vbiaread = (vbiaread_pld10b_sphv_10hv)
+ vbistid  = (vbistid_pld10b_sphv_10hv)
+ vbigatd  = (vbigatd_pld10b_sphv_10hv)
+ paread   = (paread_pld10b_sphv_10hv)
+ pstid    = (pstid_pld10b_sphv_10hv)
+ pgatd    = (pgatd_pld10b_sphv_10hv)
+ is1aread = (is1aread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ ttaread  = (ttaread_pld10b_sphv_10hv)
+ is2aread = (is2aread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ iraread  = (iraread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1aread = (stis1aread_pld10b_sphv_10hv)
+ stis2aread = (stis2aread_pld10b_sphv_10hv)
+ stiraread = (stiraread_pld10b_sphv_10hv)
+ n1aread  = (n1aread_pld10b_sphv_10hv)
+ n2aread  = (n2aread_pld10b_sphv_10hv)
+ nraread  = (nraread_pld10b_sphv_10hv)
+ is1lstid = (is1lstid_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ ttlstid  = (ttlstid_pld10b_sphv_10hv)
+ is2lstid = (is2aread_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ irlstid  = (irlstid_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1stid = (stis1stid_pld10b_sphv_10hv)
+ stis2stid = (stis2stid_pld10b_sphv_10hv)
+ stirstid = (stirstid_pld10b_sphv_10hv)
+ n1stid   = (n1stid_pld10b_sphv_10hv)
+ n2stid   = (n2stid_pld10b_sphv_10hv)
+ nrstid   = (nrstid_pld10b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ ttlgatd  = (ttlgatd_pld10b_sphv_10hv)
+ is2lgatd = (is2aread_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ irlgatd  = (irlgatd_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1gatd = (stis1gatd_pld10b_sphv_10hv)
+ stis2gatd = (stis2gatd_pld10b_sphv_10hv)
+ stirgatd = (stirgatd_pld10b_sphv_10hv)
+ n1gatd   = (n1gatd_pld10b_sphv_10hv)
+ n2gatd   = (n2gatd_pld10b_sphv_10hv)
+ nrgatd   = (nrgatd_pld10b_sphv_10hv)
+ cjaread2 = (cjaread_pld10b_sphv_10hv)
+ cjlstid2 = (cjaread_pld10b_sphv_10hv*djunc)
+ vbiaread2 = (vbiaread2_pld10b_sphv_10hv)
+ vbistid2 = (vbistid2_pld10b_sphv_10hv)
+ paread2  = (paread2_pld10b_sphv_10hv)
+ pstid2   = (pstid2_pld10b_sphv_10hv)
+ is1aread2 = (is1aread_pld10b_sphv_10hv)
+ ttaread2 = (ttaread2_pld10b_sphv_10hv)
+ is2aread2 = (is2aread_pld10b_sphv_10hv)
+ iraread2 = (iraread2_pld10b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld10b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld10b_sphv_10hv)
+ stiraread2 = (stiraread2_pld10b_sphv_10hv)
+ n1aread2 = (n1aread2_pld10b_sphv_10hv)
+ n2aread2 = (n2aread2_pld10b_sphv_10hv)
+ nraread2 = (nraread2_pld10b_sphv_10hv)
+ is1lstid2 = (is1aread_pld10b_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_pld10b_sphv_10hv)
+ is2lstid2 = (is2aread_pld10b_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_pld10b_sphv_10hv)
+ stis1stid2 = (stis1stid2_pld10b_sphv_10hv)
+ stis2stid2 = (stis2stid2_pld10b_sphv_10hv)
+ stirstid2 = (stirstid2_pld10b_sphv_10hv)
+ n1stid2  = (n1stid2_pld10b_sphv_10hv)
+ n2stid2  = (n2stid2_pld10b_sphv_10hv)
+ nrstid2  = (nrstid2_pld10b_sphv_10hv)
+ eais1area = (eais1area_pld10b_sphv_10hv)
+ eais2area = (eais2area_pld10b_sphv_10hv)
+ eairarea = (eairarea_pld10b_sphv_10hv)
+ eais1sti = (eais1sti_pld10b_sphv_10hv)
+ eais2sti = (eais2sti_pld10b_sphv_10hv)
+ eairsti  = (eairsti_pld10b_sphv_10hv)
+ eais1gat = (eais1gat_pld10b_sphv_10hv)
+ eais2gat = (eais2gat_pld10b_sphv_10hv)
+ eairgat  = (eairgat_pld10b_sphv_10hv)
+ eais1aread = (eais1aread_pld10b_sphv_10hv)
+ eais2aread = (eais2aread_pld10b_sphv_10hv)
+ eairaread = (eairaread_pld10b_sphv_10hv)
+ eais1stid = (eais1stid_pld10b_sphv_10hv)
+ eais2stid = (eais2stid_pld10b_sphv_10hv)
+ eairstid = (eairstid_pld10b_sphv_10hv)
+ eais1gatd = (eais1gatd_pld10b_sphv_10hv)
+ eais2gatd = (eais2gatd_pld10b_sphv_10hv)
+ eairgatd = (eairgatd_pld10b_sphv_10hv)
+ eais1aread2 = (eais1aread2_pld10b_sphv_10hv)
+ eais2aread2 = (eais2aread2_pld10b_sphv_10hv)
+ eairaread2 = (eairaread2_pld10b_sphv_10hv)
+ eais1stid2 = (eais1stid2_pld10b_sphv_10hv)
+ eais2stid2 = (eais2stid2_pld10b_sphv_10hv)
+ eairstid2 = (eairstid2_pld10b_sphv_10hv)
+ ikfarea  = (ikfarea_pld10b_sphv_10hv)
+ ikflsti  = (ikfarea_pld10b_sphv_10hv*djunc)
+ ikflgat  = (ikfarea_pld10b_sphv_10hv*djunc)
+ stikfarea = (stikfarea_pld10b_sphv_10hv)
+ stikfsti = (stikfarea_pld10b_sphv_10hv)
+ stikfgat = (stikfarea_pld10b_sphv_10hv)
+ ikfaread = (ikfaread_pld10b_sphv_10hv*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflstid = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflgatd = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikfaread2 = (ikfaread_pld10b_sphv_10hv*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflstid2 = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ stikfaread = (stikfaread_pld10b_sphv_10hv)
+ stikfstid = (stikfaread_pld10b_sphv_10hv)
+ stikfgatd = (stikfaread_pld10b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld10b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld10b_sphv_10hv)

model dbodybv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (dcbv_pld10b_10hv+bvdss_shift)
+ ibv      = (1e-5/1e-12)
xdsub (s sub) cdgoptub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
mamost (d intg s s dtemp) sphvt_simkit w=wum l=lum ldrift=ldrift_um wdrift=wdrift_um ldr1=ldr1_um mult=ng ad=ad_um pd=pd_um as=as_um ps=ps_um ad2=ad2_um pd2=pd2_um
rgate (g intg) resistor r=(rply*((w+2*0.3)/((lchdrawn+laccdrawn+lflap)*3*ng)))
dbodybv (d rd) dbodybv area=((ad_um+ad2_um)*ngeff)
rlimit (rd s) resistor r=0.01

include "./smos10hv_ade_dfrt.scs" section=pld10b_10hv_dfrt
ends

subckt pld30_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld30_10hv_gox       = tmp_nsmm_delr_pld30_10hv_gox
+    nsmm_dela_pld30_10hv_vfb       = tmp_nsmm_dela_pld30_10hv_vfb
+    nsmm_delr_pld30_10hv_nsub      = tmp_nsmm_delr_pld30_10hv_nsub
+    nsmm_dela_pld30_10hv_vtl       = tmp_nsmm_dela_pld30_10hv_vtl
+    nsmm_dela_pld30_10hv_dwox      = tmp_nsmm_dela_pld30_10hv_dwox
+    nsmm_delr_pld30_10hv_ubref     = tmp_nsmm_delr_pld30_10hv_ubref
+    nsmm_delr_pld30_10hv_rsh       = tmp_nsmm_delr_pld30_10hv_rsh
+    nsmm_dela_pld30_10hv_vtw       = tmp_nsmm_dela_pld30_10hv_vtw
+    l                              = (0.5)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld30_vthratio          = 1.0
+    presto_pld30_betaratio         = 1
+    delr_pld30_10hv_tox            = (nom_delr_pld30_10hv_tox*(1+sig_delr_pld30_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld30_10hv_gox*smm_delr_pld30_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld30_10hv_uch            = (nom_delr_pld30_10hv_uch*(1+sig_delr_pld30_10hv_uch*nsig_delr_pld30_10hv_uch+nsmm_delr_pld30_10hv_ubref*smm_delr_pld30_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld30_10hv_res            = (nom_delr_pld30_10hv_res*(1+sig_delr_pld30_10hv_res*nsig_delr_pld30_10hv_res+nsmm_delr_pld30_10hv_rsh*smm_delr_pld30_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld30_10hv_vfb            = (nom_dela_pld30_10hv_vfb+(sig_dela_pld30_10hv_vfb*nsig_dela_pld30_10hv_vfb)+nsmm_dela_pld30_10hv_vfb*smm_dela_pld30_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld30_10hv_vtl*smm_dela_pld30_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld30_10hv_vtw*smm_dela_pld30_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld30_10hv_dwmos          = (nom_dela_pld30_10hv_dwmos+(sig_dela_pld30_10hv_dwmos*nsig_dela_pld30_10hv_dwmos)+(nsmm_dela_pld30_10hv_dwox*smm_dela_pld30_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_pld30_10hv_vtw            = (nom_dela_pld30_10hv_vtw+(sig_dela_pld30_10hv_vtw*nsig_dela_pld30_10hv_vtw))
+    dela_pld30_10hv_dwres          = (nom_dela_pld30_10hv_dwres+(sig_dela_pld30_10hv_dwres*nsig_dela_pld30_10hv_dwres))
+    delr_pld30_10hv_nsub           = (1+nsmm_delr_pld30_10hv_nsub*smm_delr_pld30_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld30_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    coxfieldfr                     = (cfr_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.5)
+    lchtcad                        = (0.645)
+    lch                            = (0.645)
+    laccdrawn                      = (0.6)
+    w_delta                        = (1.55)
+    lacc                           = (0.398)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (0.88)
+    lsrc                           = (0.495)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (0.275)
+    xiso                           = (1.275)
+    yiso                           = (2.85)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr_s                          = (0.112161+(0.0644068/(w**1.58152)))
+    dw_mos                         = (0)
+    dw_res                         = (0.226705+dela_pld30_10hv_dwres)
+    lcheff                         = (0.645)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(1.021037e-1/(w**2)))*(1-fem))
+    xnhvhole                       = (ld+laccdrawn)
+    ynhvhole                       = (w+2*w_delta)
+    anhvhole                       = (xnhvhole*ynhvhole*ng)
+    pnhvhole                       = ((2*w_delta+2*xnhvhole)*ng)
+    chnhvhole                      = (w*ng)
+    rsda                           = ((165/(w+0.2))*(1+0.0025*(temp-27)))
+    rsdp                           = (296/(w+0.5))
+    rsdch                          = (70780/(w-0.2))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = ((1.55*(lsovl+lch)+0.55*(ld+lacc))*2*ng)
+    aplyfld_d                      = (((1.55*lacc)*2+(w+2*1.55)*lflap+0.95*1.21)*ng)
+    area_accum                     = (lacc*w*ng)
+    lfring_s                       = (w*ng)
+    lfring_d                       = ((w+2*0.6+(ld-lflap)*2)*ng)
+    nb_ct_ply                      = (int_round((w-(0.18+0.08*2))/(0.18*2))+1)
+    lfr_ct_ply                     = (nb_ct_ply*0.18*ng)
+    lfr_m1_ply                     = (ng*w-lfr_ct_ply)
+    aphi_tnom                      = (aphi_junc_pld30_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_pld30_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_pld30_d_body)
+    pphi_tnom                      = (pphi_junc_pld30_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_pld30_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_pld30_d_body)
+    chphi_tnom                     = (chphi_junc_pld30_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_pld30_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/pphi)
+    chexm                          = (chexm_junc_pld30_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld30_10hv_tox)
+ nch      = (5.66e16*delr_pld30_10hv_nsub)
+ nsub     = (5.23e16*delr_pld30_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((1.91508e-07+0.5e-6*dela_pld30_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = ((0.800112)*(1-fem))
+ ww       = ((-5.935754e-14)*(1-fem))
+ wwn      = ((0.99276)*(1-fem))
+ wwl      = ((3.37425e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((3.14194+(1.728067/(w+-0.55))*(1-fem))*(1+0.00441443*(temp-27)+-2.88816e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.548859+dela_pld30_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld30_vthratio)
+ a0       = (0.403104*delr_a0_relimo)
+ b0       = (8.93124e-11)
+ b1       = (0.0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (199.996*delr_pld30_10hv_uch*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld30_betaratio))
+ ua       = (6.47551e-10)
+ ub       = (8.97971e-18)
+ vsat     = (41441.7)
+ drout    = (0.6)
+ pclm     = (0.55)
+ pvag     = (0)
+ pdiblc1  = (0.000039)
+ pdiblc2  = (0.00086)
+ delta    = (0.0164987)
+ rdsw     = (0*delr_rdsw_relimo)
+ wr       = (1)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.00048)
+ etab     = (0)
+ voffcv   = (-0.125)
+ noff     = (4)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.14633+dela_pld30_10hv_vtw)*(1-fem))
+ dvt1w    = (75770)
+ k3       = ((1.5)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (2.4)
+ alpha0   = (0.9e-5)
+ alpha1   = (0.52)
+ nfactor  = (1.35)
+ voff     = (-0.12)
+ beta0    = (410)
+ kt1      = (-0.46871)
+ ua1      = (2.52048e-11)
+ ub1      = (-4.48256e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.69286)
+ dlc      = (4.15445e-08)
+ dwc      = (-2.7402e-07)
+ wwlc     = (-12.60385e-21)
+ at       = (33000)
+ noia     = (9.9e18)*4.5
+ noib     = (2.4e3)*90
+ noic     = (1.4e-12)*4
+ em       = (4.1e7)
+ af       = (1.0)
+ ef       = (1.0)
+ kf       = (0.0)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg (intg s) capacitor c=(cox*(lfr_s+lsovl)*lfring_s*sDOTmult2)
cgd_frg (intg d) capacitor c=(coxfieldfr*(0.1)*lfring_d*sDOTmult)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply*cfr_pld30_s_ply_met*sDOTmult+lfr_ct_ply*cfr_pld30_s_ply_m1ct*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply*cfr_pld30_d_ply_met*sDOTmult+lfr_ct_ply*cfr_pld30_d_ply_m1ct*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*1.875)/((lchdrawn+laccdrawn+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ kind=(-1)
+ num=(1)
+ tox=(tox)
+ nb=(6.154e+16+(8.5e16/w))
+ vfb=(-0.31267+dela_pld30_10hv_vfb)
+ f3=(4.88424)
+ phidel=(-0.223008)
+ em=(2.0186)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ kind=(-1)
+ num=(ng)
+ xj=(0.000339417)
+ nd=(2.54866e+20)
+ u_init=(0.00204992/delr_pld30_10hv_res)
+ vsat=((6693.31+(1673.3275/(w+-0.25))*(1-fem))*(1+-0.000893996*(temp-27)+-1.00246e-06*(temp-27)*(temp-27)))
+ fneff=(0.786311)
+ alphafneff=(0.404597)
+ alphexp=(1.06059)
+ vfbtexp=(0)
+ udriftexpa=(-0.0049126+(0.000866593/w)*(1-fem))
+ udriftexpb=(1.14433e-05+(-4.5451e-06/w)*(1-fem))
+ betavds=(0.767327)
+ betaexp=(0.3)
+ vfb0=(-5)
adsd_a (intdxa s) powerdiode
+ areafactor=(anhvhole)
+ num=(1)
+ is=(ajs_junc_pld30_d_body*0.000002)
+ n=(ajnd_junc_pld30_d_body*1.22)
+ rs=(0.0)
+ cj0=((acj0_junc_pld30_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_pld30_d_body)
+ tau=(7.5e-9)
+ trr=(2.0e-9)
+ alphaeg=(aalphaeg_junc_pld30_d_body)
+ betaeg=(abetaeg_junc_pld30_d_body)
+ eg=(aeg_junc_pld30_d_body)
+ bv=(40+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(9.00e-06)
+ xti=(24)
adsd_p (intdxp s) powerdiode
+ areafactor=(pnhvhole)
+ num=(1)
+ is=(pjs_junc_pld30_d_body/sDOTmult*355000*(w))
+ n=(pjnd_junc_pld30_d_body*1.18)
+ rs=(0.0)
+ cj0=((pcj0_junc_pld30_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_pld30_d_body)
+ tau=(7.5e-9)
+ trr=(2.0e-9)
+ alphaeg=(palphaeg_junc_pld30_d_body)
+ betaeg=(pbetaeg_junc_pld30_d_body)
+ eg=(peg_junc_pld30_d_body)
+ bv=(40+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(6.00e-06*(w))
+ xti=(17)
adsd_ch (intdxch s) powerdiode
+ areafactor=(chnhvhole)
+ num=(1)
+ is=(chjs_junc_pld30_d_body/sDOTmult*0.4)
+ n=(chjnd_junc_pld30_d_body*0.94)
+ rs=(0.0)
+ cj0=((chcj0_junc_pld30_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_pld30_d_body)
+ tau=(7.5e-9)
+ trr=(2.0e-9)
+ alphaeg=(aalphaeg_junc_pld30_d_body)
+ betaeg=(abetaeg_junc_pld30_d_body)
+ eg=(aeg_junc_pld30_d_body)
+ xti=(axti_junc_pld30_d_body)
+ bv=(40+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(3e-7)

include "./smos10hv_ade_dfrt.scs" section=pld30_10hv_dfrt
ends

subckt pld45_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld45_10hv_gox       = tmp_nsmm_delr_pld45_10hv_gox
+    nsmm_dela_pld45_10hv_vfb       = tmp_nsmm_dela_pld45_10hv_vfb
+    nsmm_delr_pld45_10hv_nsub      = tmp_nsmm_delr_pld45_10hv_nsub
+    nsmm_dela_pld45_10hv_dwox      = tmp_nsmm_dela_pld45_10hv_dwox
+    nsmm_delr_pld45_10hv_ubref     = tmp_nsmm_delr_pld45_10hv_ubref
+    nsmm_delr_pld45_10hv_rsh       = tmp_nsmm_delr_pld45_10hv_rsh
+    l                              = (0.05)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld45_vthratio          = 1.0
+    presto_pld45_betaratio         = 1
+    delr_pld45_10hv_tox            = (nom_delr_pld45_10hv_tox*(1+sig_delr_pld45_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld45_10hv_gox*smm_delr_pld45_10hv_gox(l,w,ng)))
+    delr_pld45_10hv_uch            = (nom_delr_pld45_10hv_uch*(1+sig_delr_pld45_10hv_uch*nsig_delr_pld45_10hv_uch+nsmm_delr_pld45_10hv_ubref*smm_delr_pld45_10hv_ubref(l,w,ng)))
+    delr_pld45_10hv_res            = (nom_delr_pld45_10hv_res*(1+sig_delr_pld45_10hv_res*nsig_delr_pld45_10hv_res+nsmm_delr_pld45_10hv_rsh*smm_delr_pld45_10hv_rsh(l,w,ng)))
+    dela_pld45_10hv_vfb            = (nom_dela_pld45_10hv_vfb+(sig_dela_pld45_10hv_vfb*nsig_dela_pld45_10hv_vfb)+nsmm_dela_pld45_10hv_vfb*smm_dela_pld45_10hv_vfb(l,w,ng))
+    dela_pld45_10hv_dwmos          = (nom_dela_pld45_10hv_dwmos+(sig_dela_pld45_10hv_dwmos*nsig_dela_pld45_10hv_dwmos)+(nsmm_dela_pld45_10hv_dwox*smm_dela_pld45_10hv_dwox(l,w,ng)))
+    dela_pld45_10hv_dwres          = (nom_dela_pld45_10hv_dwres+(sig_dela_pld45_10hv_dwres*nsig_dela_pld45_10hv_dwres))
+    dela_pld45_10hv_vtw            = (nom_dela_pld45_10hv_vtw+(sig_dela_pld45_10hv_vtw*nsig_dela_pld45_10hv_vtw))
+    delr_pld45_10hv_nsub           = (1+nsmm_delr_pld45_10hv_nsub*smm_delr_pld45_10hv_nsub(l,w,ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld45_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.05)
+    laccdrawn                      = (1.0)
+    lacc_drawn                     = (1.0)
+    lchtcad                        = (0.432)
+    lacc                           = (0.559)
+    dlacc                          = (0.310)
+    w_delta                        = (3.10)
+    lch                            = (0.432)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (1.745)
+    lsrc                           = (0.55)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (0.85)
+    xiso                           = (1.275)
+    yiso                           = (4.10)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr                            = (0.0306142+(0.2/(w**1.0)))
+    dw_mos                         = (0)
+    dw_accum                       = (0.08)
+    dw_res                         = (0.293631+dela_pld45_10hv_dwres)
+    lcheff                         = (0.432)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(-0.101176)/(w**0.7889))*(1-fem))
+    rnhv                           = (1.36)
+    xnhvhole                       = (ld+lacc_drawn)
+    ynhvhole                       = (w+2*(w_delta-rnhv))
+    anhvhole                       = (((xnhvhole*ynhvhole)+(xnhvhole-rnhv)*rnhv*2+0.5*pi4models*rnhv*rnhv)*ng)
+    pnhvhole                       = ((2*(w_delta-rnhv)+(xnhvhole-rnhv)*2+pi4models*rnhv)*ng)
+    chnhvhole                      = (w*ng)
+    rsda                           = ((148.5/(w+0.85))*(1+0.0035*(temp-27)))
+    rsdp                           = (286/(w-0.1))
+    rsdch                          = (30780/(w+1.52))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    lpoly                          = (lchdrawn+laccdrawn+lflap)
+    latdiff                        = (lch-lchdrawn)
+    rnhvdiff                       = (1.36-latdiff)
+    aplyfld_d_tab                  = ((0.5*pi4models*(rnhvdiff*rnhvdiff)+2*(lacc+ld-rnhvdiff)*rnhvdiff+2*(lacc+ld)*0.915+2*(lacc+lflap)*0.825)*ng)
+    aplyfld_d                      = (aplyfld_d_tab+lflap*w*ng)
+    aplytab                        = ((2.275*1.79+lpoly*3.55*2)*ng)
+    aplyfld_s                      = (aplytab-aplyfld_d_tab)
+    area_accum                     = ((lacc+dlacc)*(w+dw_accum*(1-fem))*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = (int_round((w-(0.18+0.16*2))/(0.18*2))+1)
+    nb_ct_ply_d                    = (int_round((w-(0.18+0.08*2))/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.555)-lfr_ct_ply_d)
+    aphi_tnom                      = (aphi_junc_pld45_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_pld45_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_pld45_d_body)
+    pphi_tnom                      = (pphi_junc_pld45_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_pld45_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_pld45_d_body)
+    chphi_tnom                     = (chphi_junc_pld45_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_pld45_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_pld45_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld45_10hv_tox)
+ nch      = (2.2e16*delr_pld45_10hv_nsub)
+ nsub     = (2.47e16*delr_pld45_10hv_nsub)
+ nlx      = (4.41636e-6)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((3.9209e-8+0.5e-6*dela_pld45_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1.0)
+ ww       = ((0)*(1-fem))
+ wwn      = (1.0)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((4)*(1+-0.0242475*(temp-27)+-0.000151733*(temp-27)*(temp-27)))
+ vfb      = (0.20814+dela_pld45_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld45_vthratio)
+ a0       = (0.2*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = (406.988*delr_pld45_10hv_uch*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld45_betaratio))
+ ua       = (6.1892e-10)
+ ub       = (1.07097e-18)
+ vsat     = (47786.1)
+ drout    = (5.6)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.15)
+ rdsw     = (50*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.048)
+ etab     = (0)
+ noff     = (4.0)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0.01983+dela_pld45_10hv_vtw)
+ dvt1w    = (2.9e+05)
+ k3       = (12.6)
+ k3b      = (0)
+ dsub     = (1.4)
+ alpha0   = (0)
+ alpha1   = (0.00)
+ nfactor  = (7.2)
+ voff     = (-0.45)
+ beta0    = (0)
+ kt1      = (-0.628195)
+ ua1      = (2.83064e-10)
+ ub1      = (-8.99476e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.1891)
+ dlc      = (0.210e-6)
+ dwc      = (0)
+ at       = (33000)
+ noia     = (1.249e+20)
+ noib     = (726308)
+ noic     = (4.724e-11)
+ ef       = (1.0)

model nmcapmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld45_10hv_tox)
+ nch      = (1.0e16)
+ nsub     = (2.47e14)
+ nlx      = (0)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((3.9209e-8+0.5e-6*dela_pld45_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1.0)
+ ww       = ((0)*(1-fem))
+ wwn      = (1.0)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((4)*(1+-0.0242475*(temp-27)+-0.000151733*(temp-27)*(temp-27)))
+ vfb      = (-0.35+dela_pld45_10hv_vfb)
+ a0       = (0.2)
+ a1       = (0)
+ a2       = (1)
+ u0       = (406.988*delr_pld45_10hv_uch)
+ ua       = (6.1892e-10)
+ ub       = (1.07097e-18)
+ vsat     = (47786.1)
+ drout    = (5.6)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.15)
+ rdsw     = (50)
+ wr       = (1)
+ prwg     = (0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.048)
+ etab     = (0)
+ noff     = (4.0)
+ voffcv   = (0.1)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0.01983+dela_pld45_10hv_vtw)
+ dvt1w    = (2.9e+05)
+ k3       = (12.6)
+ k3b      = (0)
+ dsub     = (1.4)
+ alpha0   = (0)
+ alpha1   = (0.00)
+ nfactor  = (7.2)
+ voff     = (0)
+ beta0    = (0)
+ kt1      = (-0.628195)
+ ua1      = (2.83064e-10)
+ ub1      = (-8.99476e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.1891)
+ dlc      = (1.5e-7)
+ dwc      = (0)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=w_mos m=(ng)
cgs_frg (intg s) capacitor c=(cox*(lfr+lsovl)*lfring*sDOTmult2)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_pld45_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_pld45_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_pld45_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_pld45_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.325)/((lchdrawn+laccdrawn+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ kind=(-1)
+ num=(1)
+ tox=(132.44*1e-10*delr_pld45_10hv_tox)
+ nb=(2.805e+16)
+ vfb=(0.1122+dela_pld45_10hv_vfb)
+ f3=(5.0)
+ phidel=(-0.05)
+ em=(2.0225)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ kind=(-1)
+ num=(ng)
+ xj=(0.000274177)
+ nd=(1.01458e+20)
+ u_init=(0.00163975/delr_pld45_10hv_res)
+ vsat=((9694.97+(3277.92753/(w+-0.338106)))*(1+-0.0012334*(temp-27)+-6.0499e-07*(temp-27)*(temp-27)))
+ fneff=(1.06313)
+ alphafneff=(1.24759)
+ alphexp=(0.837585)
+ vfbtexp=(0)
+ udriftexpa=(-0.00551081*0.939+(2.4e-4/w)*(1-fem))
+ udriftexpb=(1.50497e-05*0.740+(-1.5e-7/w)*(1-fem))
+ betavds=(4.52566)
+ betaexp=(0.0224409)
+ vfb0=(-5)
adsd_a (intdxa s) powerdiode
+ areafactor=(anhvhole)
+ num=(1)
+ is=(8.07e-16*0.000002)
+ n=(1.01849*1.22)
+ rs=(0.0)
+ cj0=((acj0_junc_pld45_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_pld45_d_body)
+ tau=(7.0e-9)
+ trr=(1.0e-9)
+ alphaeg=(aalphaeg_junc_pld45_d_body)
+ betaeg=(abetaeg_junc_pld45_d_body)
+ eg=(aeg_junc_pld45_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(9.00e-06)
+ xti=(18)
adsd_p (intdxp s) powerdiode
+ areafactor=(pnhvhole)
+ num=(1)
+ is=(1e-23/sDOTmult*355000*(w))
+ n=(1.01849*1.18)
+ rs=(0.0)
+ cj0=((pcj0_junc_pld45_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_pld45_d_body)
+ tau=(7.0e-9)
+ trr=(1.0e-9)
+ alphaeg=(aalphaeg_junc_pld45_d_body)
+ betaeg=(abetaeg_junc_pld45_d_body)
+ eg=(aeg_junc_pld45_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(6.00e-06*(w))
+ xti=(9)
adsd_ch (intdxch s) powerdiode
+ areafactor=(chnhvhole)
+ num=(1)
+ is=(6.64e-15/sDOTmult*0.005)
+ n=(1.01849*1.1)
+ rs=(0.0)
+ cj0=((chcj0_junc_pld45_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_pld45_d_body)
+ tau=(7.0e-9)
+ trr=(1.0e-9)
+ alphaeg=(aalphaeg_junc_pld45_d_body)
+ betaeg=(abetaeg_junc_pld45_d_body)
+ eg=(aeg_junc_pld45_d_body)
+ bv=(59+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ xti=(0)
+ ik=(7.20e-5)

include "./smos10hv_ade_dfrt.scs" section=pld45_10hv_dfrt
ends

subckt nld5_lvt_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld5_lvt_10hv_gox    = tmp_nsmm_delr_nld5_lvt_10hv_gox
+    nsmm_dela_nld5_lvt_10hv_vfb    = tmp_nsmm_dela_nld5_lvt_10hv_vfb
+    nsmm_delr_nld5_lvt_10hv_nsub   = tmp_nsmm_delr_nld5_lvt_10hv_nsub
+    nsmm_dela_nld5_lvt_10hv_vtl    = tmp_nsmm_dela_nld5_lvt_10hv_vtl
+    nsmm_dela_nld5_lvt_10hv_dwox   = tmp_nsmm_dela_nld5_lvt_10hv_dwox
+    nsmm_delr_nld5_lvt_10hv_ubref  = tmp_nsmm_delr_nld5_lvt_10hv_ubref
+    nsmm_delr_nld5_lvt_10hv_rsh    = tmp_nsmm_delr_nld5_lvt_10hv_rsh
+    nsmm_dela_nld5_lvt_10hv_vtw    = tmp_nsmm_dela_nld5_lvt_10hv_vtw
+    l                              = (0.4)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nld5_lvt_vthratio       = 1.0
+    presto_nld5_lvt_betaratio      = 1.286
+    relimo_ratio1_a_hci_nld5_lvt_10hv = (0.12244898)
+    relimo_ratio1_b_hci_nld5_lvt_10hv = (-1.02735102)
+    lg                             = (0.4)
+    stimod_on                      = (enable_sti==1)
+    nld5_lvt_10hv_del_vfb_sti_final = (0)
+    nld5_lvt_10hv_fac_nsub_sti_final = (1)
+    ngeff                          = ng+2*sti_dummy
+    nld5_lvt_10hv_fac_uch_sti_final = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*1.25))
+    nld5_lvt_10hv_fac_res_sti_final = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-0.5)))
+    delr_nld5_lvt_10hv_tox         = (nom_delr_nld5_lvt_10hv_tox*(1+sig_delr_nld5_lvt_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld5_lvt_10hv_gox*smm_delr_nld5_lvt_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_uch         = (nom_delr_nld5_lvt_10hv_uch*nld5_lvt_10hv_fac_uch_sti_final*(1+sig_delr_nld5_lvt_10hv_uch*nsig_delr_nld5_lvt_10hv_uch+nsmm_delr_nld5_lvt_10hv_ubref*smm_delr_nld5_lvt_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_res         = (nom_delr_nld5_lvt_10hv_res*nld5_lvt_10hv_fac_res_sti_final*(1+sig_delr_nld5_lvt_10hv_res*nsig_delr_nld5_lvt_10hv_res+nsmm_delr_nld5_lvt_10hv_rsh*smm_delr_nld5_lvt_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld5_lvt_10hv_vfb         = (nom_dela_nld5_lvt_10hv_vfb+nld5_lvt_10hv_del_vfb_sti_final+(sig_dela_nld5_lvt_10hv_vfb*nsig_dela_nld5_lvt_10hv_vfb)+nsmm_dela_nld5_lvt_10hv_vfb*smm_dela_nld5_lvt_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld5_lvt_10hv_vtl*smm_dela_nld5_lvt_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld5_lvt_10hv_vtw*smm_dela_nld5_lvt_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld5_lvt_10hv_vxb         = (nom_dela_nld5_lvt_10hv_vfb+(sig_dela_nld5_lvt_10hv_vfb*nsig_dela_nld5_lvt_10hv_vfb)+nsmm_dela_nld5_lvt_10hv_vfb*smm_dela_nld5_lvt_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld5_lvt_10hv_vtl*smm_dela_nld5_lvt_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld5_lvt_10hv_vtw*smm_dela_nld5_lvt_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld5_lvt_10hv_dwmos       = (nom_dela_nld5_lvt_10hv_dwmos+(sig_dela_nld5_lvt_10hv_dwmos*nsig_dela_nld5_lvt_10hv_dwmos)+(nsmm_dela_nld5_lvt_10hv_dwox*smm_dela_nld5_lvt_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld5_lvt_10hv_vtw         = (nom_dela_nld5_lvt_10hv_vtw+(sig_dela_nld5_lvt_10hv_vtw*nsig_dela_nld5_lvt_10hv_vtw))
+    delr_nld5_lvt_10hv_vsat        = (nom_delr_nld5_lvt_10hv_vsat*(1+sig_delr_nld5_lvt_10hv_vsat*nsig_delr_nld5_lvt_10hv_vsat))
+    delr_nld5_lvt_10hv_nsub        = (nld5_lvt_10hv_fac_nsub_sti_final*(1+nsmm_delr_nld5_lvt_10hv_nsub*smm_delr_nld5_lvt_10hv_nsub(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_ub          = (nom_delr_nld5_lvt_10hv_ub*(1+sig_delr_nld5_lvt_10hv_ub*nsig_delr_nld5_lvt_10hv_ub))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.01*1e-10*delr_nld5_lvt_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.4)
+    lchtcad                        = (0.343)
+    lacc                           = (0.058)
+    wdel                           = (0.3)
+    lch                            = (0.343)
+    lsovl                          = (0.025)
+    ld                             = (0.405)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.20)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    d_cfr                          = (4.6556e-17)
+    lfr                            = (0.090191174)
+    dw_mos                         = (0)
+    dw_res                         = (-0.333834)
+    lcheff                         = (0.343)
+    numbernplus                    = (int_round((w+0.02*(1-fem))/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(1.8)/(w**1.0))*(1-fem))
+    ansd                           = ((w+2*wdel)*(ld)*ngeff)
+    pnsd                           = ((2*ld+2*wdel)*ngeff)
+    chnsd                          = (w*ngeff)
+    rsda                           = ((50/(w+1))*(1+0.001*(temp-27)))
+    rsdp                           = (90/(w-0.4))
+    rsdch                          = (6780/(w))
+    xsub                           = ((2*xiso)+(lcell*ngeff))
+    ysub                           = (w+2*yiso)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lchdrawn*0.585*ng)
+    area_accum                     = ((lacc+0.15824)*w*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = (24)
+    nb_ct_ply_d                    = (int_round(w/(0.18+0.24)+0.2))
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*w-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*w-lfr_ct_ply_s)
+    lm1s                           = (0.6*2*n_src)
+    lm1d                           = (0.6*2*n_drn)
+    ng_dmy                         = (2*sti_dummy)
+    area_accum_dmy                 = ((lacc+0.15824)*w*ng_dmy)
+    lfring_dmy                     = (w*ng_dmy)
+    lfr_ct_ply_d_dmy               = (nb_ct_ply_d*0.18*ng_dmy)
+    lfr_m1_ply_d_dmy               = (ng_dmy*w-lfr_ct_ply_d_dmy)
+    n_drn_dmy                      = (ng_dmy/2)
+    lm1d_dmy                       = (0.6*2*n_drn_dmy)
+    sdotmult                       = (1)
+    sdotmult2                      = (1)
+    aphi_tnom                      = (aphi_junc_nld5_lvt_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld5_lvt_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld5_lvt_d_body)
+    pphi_tnom                      = (pphi_junc_nld5_lvt_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld5_lvt_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld5_lvt_d_body)
+    chphi_tnom                     = (chphi_junc_nld5_lvt_d_body)
+    chphi_calc                     = (chphi_tnom-pta_junc_nld5_lvt_d_body*(temp-tnom))
+    chphi_temp                     = (maxmodels(0.1,chphi_calc))
+    chphi_tf                       = (chphi_tnom/pphi_temp)
+    chexm                          = (chexm_junc_nld5_lvt_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_lvt_10hv_tox)
+ nch      = 0.5*(3.10e16*delr_nld5_lvt_10hv_nsub)
+ nsub     = 15.0*(4.75e16*delr_nld5_lvt_10hv_nsub)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((2.4e-08+0.5e-6*dela_nld5_lvt_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = (0)
+ vfb      = (-0.944+dela_nld5_lvt_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nld5_lvt_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nld5_lvt_10hv-relimo_ratio1_b_hci_nld5_lvt_10hv))
+ a0       = (4.5*delr_a0_relimo)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (390*delr_nld5_lvt_10hv_uch*delr_u0_relimo)
+ ua       = (-2.02e-09)
+ ub       = (1.352e-18*delr_nld5_lvt_10hv_ub)
+ vsat     = (150400*1.14*delr_nld5_lvt_10hv_vsat)
+ wvsat    = (50000*1.6)
+ drout    = (0.56)
+ pclm     = (0.3)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1e-02)
+ delta    = (0.0785775)
+ rdsw     = (28.15*delr_nld5_lvt_10hv_res*delr_rdsw_relimo)
+ wr       = (1.00)
+ prwg     = (2)
+ prt      = (24.9511)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1.0)
+ moin     = (10)
+ cgsl     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0)
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0+80*dela_nld5_lvt_10hv_vtw)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = 1.3*(2.4)
+ voff     = (-0.18)
+ beta0    = (50)
+ kt1      = (-0.5)
+ ua1      = (-2.6e-10)
+ wua1     = (-1.9e-10)
+ ub1      = (1.1e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.5)
+ dlc      = (0.140e-6)
+ dwc      = (2e-7)
+ at       = (6000*0)
+ wat      = (-8000*0)
+ noia     = (1e20*10)
+ noib     = (5e4*8.0)
+ noic     = (0.0)
+ em       = (4.1e7)
+ af       = (1)
+ ef       = (1)
+ kf       = (0)

if (ng_dmy>=2) {
mpowermos_dmy (intd_dmy s s s) nmosmodel l=lcheff w=(w_mos) m=(ng_dmy) ad=(1e-18) pd=(1e-18)
cgd_frg_dmy (s d) capacitor c=(d_cfr*lfring_dmy*sdotmult)
cgd_m1_dmy (s d) capacitor c=(lfr_m1_ply_d_dmy*cfr_nld5_lvt_d_ply_met*sdotmult+lfr_ct_ply_d_dmy*cfr_nld5_lvt_d_ply_m1ct*sdotmult+lm1d_dmy*3.06679e-16*sdotmult)
acapmos1_dmy (intd_dmy s s) accumcap
+ aream=(area_accum_dmy*sdotmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(1.28493e+17+(0/w))
+ vfb=(1.07938+dela_nld5_lvt_10hv_vxb)
+ f3=(1.5122)
+ phidel=(0.275864)
+ em=(1.98)
ares_dmy (d intd_dmy s) drifty
+ wm=(w_res*sdotmult*1e-6)
+ lm=(1*sdotmult*1e-6)
+ num=(ng_dmy)
+ xj=(0.0079934)
+ nd=(1.05175e+19)
+ u_init=(0.21681/delr_nld5_lvt_10hv_res)
+ vsat=((11929.7)*(1+0.000710715*(temp-27)+-9.84528e-06*(temp-27)*(temp-27)))
+ fneff=(0.6604)
+ alphafneff=(3.79973)
+ alphexp=(0.0561983)
+ vfbtexp=(0.003)
+ udriftexpa=(0.00590887+(0/w)*(1-fem))
+ udriftexpb=(-9.77669e-06+(0/w)*(1-fem))
+ betavds=(0.432594)
+ betaexp=(0.142259)
+ vfb0=(-3)
}
mpowermos (intd intg s s) nmosmodel l=lcheff w=(w_mos) m=(ng) ad=(1e-18) pd=(1e-18)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_frg (intg s) capacitor c=(cox*(lsovl+lfr)*lfring*sDOTmult2)
cgd_frg (intg d) capacitor c=(d_cfr*lfring*sDOTmult)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply_s*cfr_nld5_lvt_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld5_lvt_s_ply_m1ct*sDOTmult+lm1s*3.06679e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld5_lvt_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld5_lvt_d_ply_m1ct*sDOTmult+lm1d*3.06679e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.36)/(lchdrawn*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ngeff)
rxp (intdxp d) resistor r=(rsdp) m=(ngeff)
rxch (intdxch d) resistor r=(rsdch) m=(ngeff)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(1.28493e+17+(0/w))
+ vfb=(1.07938+dela_nld5_lvt_10hv_vxb)
+ f3=(1.5122)
+ phidel=(0.275864)
+ em=(1.98)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.0079934)
+ nd=(1.05175e+19)
+ u_init=(0.21681/delr_nld5_lvt_10hv_res)
+ vsat=((11929.7)*(1+0.000710715*(temp-27)+-9.84528e-06*(temp-27)*(temp-27)))
+ fneff=(0.6604)
+ alphafneff=(3.79973)
+ alphexp=(0.0561983)
+ vfbtexp=(0.003)
+ udriftexpa=(0.00590887+(0/w)*(1-fem))
+ udriftexpb=(-9.77669e-06+(0/w)*(1-fem))
+ betavds=(0.432594)
+ betaexp=(0.142259)
+ vfb0=(-3)
adsd_a (s intdxa) powerdiode
+ areafactor=(ansd)
+ num=(1)
+ is=(1.0e-23*0.5)
+ n=(1.01347*0.98)
+ rs=(0.0)
+ cj0=((acj0_junc_nld5_lvt_d_body/sDOTmult)*(aphi_tf**aexm))
+ vj=(aphi_temp)
+ em=(aexm_junc_nld5_lvt_d_body)
+ tau=(7e-9*0.15)
+ trr=(2e-9*2.5)
+ bv=(8+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(10e-5)
+ xti=(3)
adsd_p (s intdxp) powerdiode
+ areafactor=(pnsd)
+ num=(1)
+ is=(1.00e-23/sDOTmult*70000*w)
+ n=(1.01347*1.03)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld5_lvt_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi_temp)
+ em=(pexm_junc_nld5_lvt_d_body)
+ tau=(7e-9*0.15)
+ trr=(2e-9*2.5)
+ bv=(8+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(0.5e-03*w)
+ xti=(3)
adsd_ch (s intdxch) powerdiode
+ areafactor=(chnsd)
+ num=(1)
+ is=(0.001*12.017e-16/sDOTmult*0.6)
+ n=(1.01347*0.935*1.06)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld5_lvt_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi_temp)
+ em=(chexm_junc_nld5_lvt_d_body)
+ tau=(7e-9*0.15)
+ trr=(2e-9*2.5)
+ bv=(8+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(maxa(4e-8,(2e-7)*(1+0.005*(temp-27)),0))
+ xti=(3)

include "./smos10hv_ade_dfrt.scs" section=nld5_lvt_10hv_dfrt
ends



//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld30b_10hv (d g s sub)
parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
+    fem                            = 0
+    soa                            = 1
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld30b_vthratio     = 1.0
+    presto_nld30b_ronratio     = 0.01/0.74

parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.35)
//
+    dw_mos                         = (0)
+    numbernplus                    = ((2+(w>=2.375)+(w>=3.18)+(w>=3.975)+(w>=4.775)+(w>=5.58)+(w>=6.38)+(w>=7.18)+(w>=7.98)+(w>=8.775)+(w>=9.58)+(w>=10.38)+(w>=11.175)+(w>=11.98)+(w>=12.775)+(w>=13.58)+(w>=14.38)+(w>=15.175)+(w>=15.98)+(w>=16.775)*(1+int_round((w-16.775)/0.8)))*(1-fem)+fem*int_round(w/0.8+1e-6))
+    w_um                           = (numbernplus*0.4+dw_mos*(1-fem))
+    l_um                           = (l)
+    wdrift                         = (w)
+    ldrift                         = (1.15)
+    ldr1                           = (0.65)
+    lacts                          = (0.375)
+    lactd                          = (0.69)
+    wg2nhv                         = (1.35)
+    aplyfld_d                      = (((ldr1+ldrift+lactd*0.5)*2*wg2nhv-(0.6*2+1.39)*1.2)*(1-fem)+0.2*wdrift)*ng
+    aplyfld_d_dmy                  = (((ldr1+ldrift+lactd*0.5)*2*wg2nhv-(0.6*2+1.39)*1.2)*(1-fem)+0.2*wdrift)*ng_dmy
+    aplyfld_s                      = ((ldr1+ldrift+lactd*0.5+0.35)*2*1.72-(ldr1+ldrift+lactd*0.5)*2*wg2nhv)*ng*(1-fem)
+    as_xdr                         = (lacts*w_um)
+    ps_xdr                         = ((2*(lacts+0.4))*numbernplus)
+    ad_xdr                         = ((ldr1+ldrift*0.5)*(w+2*wg2nhv*(1-fem)))
+    pd_xdr                         = ((2*((ldr1+ldrift*0.5)*(1-fem)+(w+2*wg2nhv*(1-fem)))))
+    ad2_xdr                        = ((lactd+ldrift)*0.5*(w+2*wg2nhv*(1-fem)))
+    pd2_xdr                        = ((lactd+ldrift))
+    as_i                           = (as_xdr)
+    ps_i                           = (ps_xdr)
+    ad_i                           = (ad_xdr)
+    pd_i                           = (pd_xdr)
+    ad2_i                          = (ad2_xdr)
+    pd2_i                          = (pd2_xdr)
+    lg2dt                          = (1.485)
+    wg2dt                          = (2.23*(1-fem))
+    lg2g_d                         = ((ldr1+ldrift+lactd*0.5)*2)
+    lg2g_s                         = (0.42)
+    lg2w                           = (l)
+    xnbl_xdr                       = (lg2dt*nse+lg2w*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (2*wg2dt+w)
+    anbl_xdr                       = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_nld30b_sphv_10hv+tc2_ecrit_nld30b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    wfact_ecrit                    = (1+ecritw_nld30b_sphv_10hv/w*(1-fem))
+    w_heat=w
+    l_heat=(lg2w*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld30b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld30b_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff
+    nsmm_delr_gox_nld30b_sphv_10hv  = 0
+    nsmm_dela_dw_nld30b_sphv_10hv   = tmp_nsmm_dela_dw_nld30b_sphv_10hv
+    nsmm_dela_vfb_nld30b_sphv_10hv  = tmp_nsmm_dela_vfb_nld30b_sphv_10hv
+    nsmm_delr_mobref_nld30b_sphv_10hv = 0
+    nsmm_delr_rshl_nld30b_sphv_10hv = 0
+    nsmm_delr_nsub_nld30b_sphv_10hv = tmp_nsmm_delr_nsub_nld30b_sphv_10hv

//+    delr_tox_nld30b_sphv_10hv      = (nom_delr_tox_nld30b_sphv_10hv*(1.0+nsig_delr_tox_nld30b_sphv_10hv*sig_delr_tox_nld30b_sphv_10hv+nsmm_delr_gox_nld30b_sphv_10hv*smm_delr_gox_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_tox_nld30b_sphv_10hv      = (nom_delr_tox_nld30b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld30b_sphv_10hv+nsmm_delr_gox_nld30b_sphv_10hv*smm_delr_gox_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld30b_sphv_10hv       = (nom_dela_dw_nld30b_sphv_10hv+nsig_dela_dw_nld30b_sphv_10hv*sig_dela_dw_nld30b_sphv_10hv+nsmm_dela_dw_nld30b_sphv_10hv*smm_dela_dw_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld30b_sphv_10hv       = (nom_dela_xw_nld30b_sphv_10hv+nsig_dela_xw_nld30b_sphv_10hv*sig_dela_xw_nld30b_sphv_10hv)
+    dela_vfb_nld30b_sphv_10hv      = (nom_dela_vfb_nld30b_sphv_10hv+nsig_dela_vfb_nld30b_sphv_10hv*sig_dela_vfb_nld30b_sphv_10hv+nsmm_dela_vfb_nld30b_sphv_10hv*smm_dela_vfb_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_nld30b_sphv_10hv     = (nom_dela_vtwl_nld30b_sphv_10hv+nsig_dela_vtwl_nld30b_sphv_10hv*sig_dela_vtwl_nld30b_sphv_10hv)
+    delr_mobref_nld30b_sphv_10hv   = (nom_delr_mobref_nld30b_sphv_10hv*(1.0+nsig_delr_mobref_nld30b_sphv_10hv*sig_delr_mobref_nld30b_sphv_10hv+nsmm_delr_mobref_nld30b_sphv_10hv*smm_delr_mobref_nld30b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_nld30b_sphv_10hv     = (nom_delr_rshl_nld30b_sphv_10hv*(1.0+nsig_delr_rshl_nld30b_sphv_10hv*sig_delr_rshl_nld30b_sphv_10hv)+nsmm_delr_rshl_nld30b_sphv_10hv*smm_delr_rshl_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_nld30b_sphv_10hv     = (1+nsmm_delr_nsub_nld30b_sphv_10hv*smm_delr_nsub_nld30b_sphv_10hv(l,w)/sqrt(ng/2))
//+    cj0_junc_nld30b_d_body         = ((nom_delr_cj0_junc_nld30b_d_body*(1+nsig_delr_cj0_junc_nld30b_d_body*sig_delr_cj0_junc_nld30b_d_body)))
//+    js_junc_nld30b_d_body          = ((nom_delr_js_junc_nld30b_d_body*(1+nsig_delr_js_junc_nld30b_d_body*sig_delr_js_junc_nld30b_d_body)))
+    delr_cj_nld30b_sphv_10hv = (nom_delr_cj_nld30b_sphv_10hv*(1+sig_delr_cj_nld30b_sphv_10hv*nsig_delr_cj_nld30b_sphv_10hv))
+    delr_is_nld30b_sphv_10hv = (nom_delr_is_nld30b_sphv_10hv*exp(sig_delr_is_nld30b_sphv_10hv*nsig_delr_is_nld30b_sphv_10hv))
+    delr_is2_nld30b_sphv_10hv = (nom_delr_is2_nld30b_sphv_10hv*exp(sig_delr_is2_nld30b_sphv_10hv*nsig_delr_is2_nld30b_sphv_10hv))
+    delr_ir_nld30b_sphv_10hv = (nom_delr_ir_nld30b_sphv_10hv*exp(sig_delr_ir_nld30b_sphv_10hv*nsig_delr_ir_nld30b_sphv_10hv))


//+    cpp_ply_fld                    = (nom_cpp_ply_fld)
//+    nom_cpp_ply_fld                = (0.092229166666667e-15)
//+    cpp_ply_sdt                    = (nom_cpp_ply_sdt)
//+    nom_cpp_ply_sdt                = (2.6460229885057e-15)

+    lfr_ct_ply_s                   = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d                   = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d                   = ((w+2*0.555*(1-fem))*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555*(1-fem))*ng-lfr_ct_ply_s)

// for dummy
+    lfr_ct_ply_d_dmy                   = (ng_dmy*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d_dmy                   = ((w+2*0.555*(1-fem))*ng_dmy-lfr_ct_ply_d_dmy)

//**parameters for multi ng
+ fac_r_ng_rshldd= (1-(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.01)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+0.8*(1-fem))-2/(2+0.8))*0.04*1.5*2*(w/(w+0.8)))
+ fac_a_ng_uo= (1+(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.016*2.5)


//+    cfr_nld30b_d_ply_m1ct       = (4.90e-17)

//+    cfr_nld30b_s_ply_m1ct       = (1.59e-16)

//+    cfr_nld30b_s_ply_met        = (7.65e-17)

//+    cfr_nld30b_d_ply_met        = (4.17e-17)

+    lfring                         = (w*ng)
+    lch_drawn                      = (0.35)
+    lch                            = (0.32)
+    lacc_drawn                     = (0.7)
+    lacc                           = (0.669)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    lflap                          = (0.25)

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))


+ swdrlin  = (0)
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8)

if (ng_dmy>=2) {

cgd_fld_d_dmy (s d) capacitor c=(cpp_ply_fld*aplyfld_d_dmy)

cgd_m1_dmy (s d) capacitor c=((lfr_m1_ply_d_dmy*cfr_nld30b_d_ply_met+lfr_ct_ply_d_dmy*cfr_nld30b_d_ply_m1ct))

mpowermos_dmy  (d s s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
}

model sphvt_simkit sphvt
+ type     =(n)
+ vdscale  = (vdscale_nld30b_sphv_10hv*(1-0.06*(1-fem)/w))
+ ctgo     = (0.1)
+ stcto    = (0.2)
+ stvdscale= (-0.27)
+ strthao  = (0.8)
+ tr       = (27)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec    = (1)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ xvsat = (xvsat_nld30b_sphv_10hv*(1+xvsatw_nld30b_sphv_10hv/w*(1-fem)))
+ qmc      = (qmc_nld30b_sphv_10hv)
+ lvaro    = (lvaro_nld30b_sphv_10hv)
+ lvarl    = (lvarl_nld30b_sphv_10hv)
+ lvarw    = (lvarw_nld30b_sphv_10hv*(1-fem))
+ lap      = (lap_nld30b_sphv_10hv)
+ wvaro    = (wvaro_nld30b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld30b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld30b_sphv_10hv*(1-fem))
+ wot      = ((wot_nld30b_sphv_10hv+0.5e-6*dela_dw_nld30b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld30b_sphv_10hv)
+ dwq      = (dwq_nld30b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld30b_sphv_10hv+fac_a_ng_vfbo+dela_vfb_nld30b_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld30b_vthratio)
+ vfbl     = (vfbl_nld30b_sphv_10hv)
+ vfbw     = (vfbw_nld30b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld30b_sphv_10hv+dela_vtwl_nld30b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld30b_sphv_10hv)
+ stvfbl   = (stvfbl_nld30b_sphv_10hv)
+ stvfbw   = (stvfbw_nld30b_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld30b_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ epsroxo  = (epsroxo_nld30b_sphv_10hv)
+ nsubo    = (nsubo_nld30b_sphv_10hv*delr_nsub_nld30b_sphv_10hv)
+ nsubw    = (nsubw_nld30b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld30b_sphv_10hv)
+ npck     = (npck_nld30b_sphv_10hv)
+ npckw    = (npckw_nld30b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld30b_sphv_10hv)
+ lpck     = (lpck_nld30b_sphv_10hv)
+ lpckw    = (lpckw_nld30b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld30b_sphv_10hv)
+ fol2     = (fol2_nld30b_sphv_10hv)
+ facneffaco = (facneffaco_nld30b_sphv_10hv)
+ facneffacl = (facneffacl_nld30b_sphv_10hv)
+ facneffacw = (facneffacw_nld30b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld30b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld30b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld30b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld30b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld30b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld30b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld30b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld30b_sphv_10hv)
+ vnsubo   = (vnsubo_nld30b_sphv_10hv)
+ nslpo    = (nslpo_nld30b_sphv_10hv)
+ dnsubo   = (dnsubo_nld30b_sphv_10hv)
+ dphibo   = (dphibo_nld30b_sphv_10hv)
+ dphibl   = (dphibl_nld30b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld30b_sphv_10hv)
+ dphibw   = (dphibw_nld30b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld30b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld30b_sphv_10hv)
+ delvtacl = (delvtacl_nld30b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld30b_sphv_10hv)
+ delvtacw = (delvtacw_nld30b_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld30b_sphv_10hv)*(1-fem)
+ npo      = (npo_nld30b_sphv_10hv)
+ npl      = (npl_nld30b_sphv_10hv)
+ cto      = (cto_nld30b_sphv_10hv)
+ ctl      = (ctl_nld30b_sphv_10hv)
+ ctlexp   = (ctlexp_nld30b_sphv_10hv)
+ ctw      = (ctw_nld30b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld30b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ toxovdo  = (toxovdo_nld30b_sphv_10hv*delr_tox_nld30b_sphv_10hv)
+ lov      = (lov_nld30b_sphv_10hv)
+ dlovd    = (dlovd_nld30b_sphv_10hv)
+ novo     = (novo_nld30b_sphv_10hv)
+ novdo    = (novdo_nld30b_sphv_10hv)
+ cfl      = (cfl_nld30b_sphv_10hv)
+ cflexp   = (cflexp_nld30b_sphv_10hv)
+ cfw      = (cfw_nld30b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld30b_sphv_10hv)
+ uo       = (uo_nld30b_sphv_10hv*fac_a_ng_uo*delr_mobref_nld30b_sphv_10hv*delr_u0_relimo)*w_um/wdrift
+ fbet1    = (fbet1_nld30b_sphv_10hv)
+ fbet1w   = (fbet1w_nld30b_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld30b_sphv_10hv)
+ lp1w     = (lp1w_nld30b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld30b_sphv_10hv)
+ lp2      = (lp2_nld30b_sphv_10hv)
+ betw1    = (betw1_nld30b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld30b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld30b_sphv_10hv)
+ stbeto   = (stbeto_nld30b_sphv_10hv)
+ stbetl   = (stbetl_nld30b_sphv_10hv)
+ stbetw   = (stbetw_nld30b_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld30b_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld30b_sphv_10hv)
+ muew     = (muew_nld30b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld30b_sphv_10hv)
+ themuo   = (themuo_nld30b_sphv_10hv)
+ stthemuo = (stthemuo_nld30b_sphv_10hv)
+ cso      = (cso_nld30b_sphv_10hv)
+ csl      = (csl_nld30b_sphv_10hv)
+ cslexp   = (cslexp_nld30b_sphv_10hv)
+ csw      = (csw_nld30b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld30b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld30b_sphv_10hv)
+ xcoro    = (xcoro_nld30b_sphv_10hv)
+ xcorl    = (xcorl_nld30b_sphv_10hv)
+ xcorw    = (xcorw_nld30b_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld30b_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld30b_sphv_10hv)
+ fetao    = (fetao_nld30b_sphv_10hv)
+ rsw1     = (rsw1_nld30b_sphv_10hv)
+ rsw2     = (rsw2_nld30b_sphv_10hv)*(1-fem)
+ strso    = (strso_nld30b_sphv_10hv)
+ rsbo     = (rsbo_nld30b_sphv_10hv)
+ rsgo     = (rsgo_nld30b_sphv_10hv)
+ thesato  = (thesato_nld30b_sphv_10hv)
+ thesatl  = (thesatl_nld30b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld30b_sphv_10hv)
+ thesatw  = (thesatw_nld30b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld30b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld30b_sphv_10hv)
+ stthesatl = (stthesatl_nld30b_sphv_10hv)
+ stthesatw = (stthesatw_nld30b_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld30b_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld30b_sphv_10hv)
+ thesatgo = (thesatgo_nld30b_sphv_10hv)
+ thesatgl = (thesatgl_nld30b_sphv_10hv)
+ thesatgw = (thesatgw_nld30b_sphv_10hv*(1-fem))
+ axo      = (axo_nld30b_sphv_10hv)
+ axl      = (axl_nld30b_sphv_10hv)
+ alpl     = (alpl_nld30b_sphv_10hv)
+ alplexp  = (alplexp_nld30b_sphv_10hv)
+ alpw     = (alpw_nld30b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld30b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld30b_sphv_10hv)
+ alp1l2   = (alp1l2_nld30b_sphv_10hv)
+ alp1w    = (alp1w_nld30b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld30b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld30b_sphv_10hv)
+ alp2l2   = (alp2l2_nld30b_sphv_10hv)
+ alp2w    = (alp2w_nld30b_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld30b_sphv_10hv)
+ a1o      = (a1o_nld30b_sphv_10hv)
+ a1l      = (a1l_nld30b_sphv_10hv)
+ a1w      = (a1w_nld30b_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld30b_sphv_10hv)
+ sta2o    = (sta2o_nld30b_sphv_10hv)
+ a3o      = (a3o_nld30b_sphv_10hv)
+ a3l      = (a3l_nld30b_sphv_10hv)
+ a3w      = (a3w_nld30b_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld30b_sphv_10hv)
+ a4l      = (a4l_nld30b_sphv_10hv)
+ a4w      = (a4w_nld30b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld30b_sphv_10hv)
+ iginvlw  = (iginvlw_nld30b_sphv_10hv)
+ igovw    = (igovw_nld30b_sphv_10hv)
+ igovdw   = (igovdw_nld30b_sphv_10hv)
+ stigo    = (stigo_nld30b_sphv_10hv)
+ gc2o     = (gc2o_nld30b_sphv_10hv)
+ gc3o     = (gc3o_nld30b_sphv_10hv)
+ chibo    = (chibo_nld30b_sphv_10hv)
+ agidlw   = (agidlw_nld30b_sphv_10hv)
+ agidldw  = (agidldw_nld30b_sphv_10hv)
+ bgidlo   = (bgidlo_nld30b_sphv_10hv)
+ bgidldo  = (bgidldo_nld30b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld30b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld30b_sphv_10hv)
+ cgidlo   = (cgidlo_nld30b_sphv_10hv)
+ cgidldo  = (cgidldo_nld30b_sphv_10hv)
+ cgbovl   = (cgbovl_nld30b_sphv_10hv)
+ cfrw     = (cfrw_nld30b_sphv_10hv)
+ cfrdw    = (cfrdw_nld30b_sphv_10hv)
+ fnto     = (fnto_nld30b_sphv_10hv)
+ nfalw    = (nfalw_nld30b_sphv_10hv)
+ nfblw    = (nfblw_nld30b_sphv_10hv)
+ nfclw    = (nfclw_nld30b_sphv_10hv)
+ efo      = (efo_nld30b_sphv_10hv)
+ lintnoi  = (lintnoi_nld30b_sphv_10hv)
+ alpnoi   = (alpnoi_nld30b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld30b_sphv_10hv)
+ kvthowel = (kvthowel_nld30b_sphv_10hv)
+ kvthowew = (kvthowew_nld30b_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld30b_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld30b_sphv_10hv)
+ kuowel   = (kuowel_nld30b_sphv_10hv)
+ kuowew   = (kuowew_nld30b_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld30b_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld30b_sphv_10hv)
+ rsh      = (rsh_nld30b_sphv_10hv)
+ rbulko   = (rbulko_nld30b_sphv_10hv)
+ rwello   = (rwello_nld30b_sphv_10hv)
+ rjunso   = (rjunso_nld30b_sphv_10hv/(w_um+dwrjunso_nld30b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld30b_sphv_10hv/(wdrift+dwrjundo_nld30b_sphv_10hv*(1-fem)))
+ rint     = (rint_nld30b_sphv_10hv)
+ rvpoly   = (rvpoly_nld30b_sphv_10hv)
+ rshg     = (rshg_nld30b_sphv_10hv)
+ dlsil    = (dlsil_nld30b_sphv_10hv)
+ saref    = (saref_nld30b_sphv_10hv)
+ sbref    = (sbref_nld30b_sphv_10hv)
+ wlod     = (wlod_nld30b_sphv_10hv)
+ kuo      = (kuo_nld30b_sphv_10hv)
+ kvsat    = (kvsat_nld30b_sphv_10hv)
+ tkuo     = (tkuo_nld30b_sphv_10hv)
+ lkuo     = (lkuo_nld30b_sphv_10hv)
+ wkuo     = (wkuo_nld30b_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld30b_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld30b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld30b_sphv_10hv)
+ kvtho    = (kvtho_nld30b_sphv_10hv)
+ lkvtho   = (lkvtho_nld30b_sphv_10hv)
+ wkvtho   = (wkvtho_nld30b_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld30b_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld30b_sphv_10hv)
+ wlodvth  = (wlodvth_nld30b_sphv_10hv)
+ stetao   = (stetao_nld30b_sphv_10hv)
+ lodetao  = (lodetao_nld30b_sphv_10hv)
+ scref    = (scref_nld30b_sphv_10hv)
+ web      = (web_nld30b_sphv_10hv)
+ wec      = (wec_nld30b_sphv_10hv)
+ adr1o    = (adr1o_nld30b_sphv_10hv)
+ adr1l    = (adr1l_nld30b_sphv_10hv)
+ adr1w    = (adr1w_nld30b_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld30b_sphv_10hv)
+ stadr2o  = (stadr2o_nld30b_sphv_10hv)
+ adr3o    = (adr3o_nld30b_sphv_10hv)
+ adr3l    = (adr3l_nld30b_sphv_10hv)
+ adr3w    = (adr3w_nld30b_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld30b_sphv_10hv)
+ adr4l    = (adr4l_nld30b_sphv_10hv)
+ adr4w    = (adr4w_nld30b_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld30b_sphv_10hv)
+ adr5l    = (adr5l_nld30b_sphv_10hv)
+ adr5w    = (adr5w_nld30b_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld30b_sphv_10hv)
+ bidr1l   = (bidr1l_nld30b_sphv_10hv)
+ bidr1w   = (bidr1w_nld30b_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld30b_sphv_10hv)
+ bidr2w   = (bidr2w_nld30b_sphv_10hv)*(1-fem)
//+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld30b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld30b_sphv_10hv*fac_r_ng_rshldd*delr_rshl_nld30b_sphv_10hv*delr_rdsw_relimo)*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld30b_ronratio))
+ xw       = ((xw_nld30b_sphv_10hv+0.5e-6*dela_xw_nld30b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld30b_sphv_10hv*(1-fem))
+ xl       = (xl_nld30b_sphv_10hv)
+ xlw      = (xlw_nld30b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld30b_sphv_10hv)
+ nst      = (nst_nld30b_sphv_10hv)
+ ats      = (ats_nld30b_sphv_10hv)
+ dfinf    = (dfinf_nld30b_sphv_10hv)
+ dfw      = (dfw_nld30b_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld30b_sphv_10hv)
+ dflw     = (dflw_nld30b_sphv_10hv*(1-fem))
+ dp       = (dp_nld30b_sphv_10hv)
+ ecrit    = (ecrit_nld30b_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ ecorn    = (ecorn_nld30b_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ du       = (du_nld30b_sphv_10hv)
+ tc1      = (tc1_nld30b_sphv_10hv)
+ tc2      = (tc2_nld30b_sphv_10hv)
+ tc1l     = (tc1l_nld30b_sphv_10hv)
+ tc2l     = (tc2l_nld30b_sphv_10hv)
+ tc1w     = (tc1w_nld30b_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld30b_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld30b_sphv_10hv)
+ theacc2  = (theacc2_nld30b_sphv_10hv)
+ aacc     = (aacc_nld30b_sphv_10hv)
+ rva      = (rva_nld30b_sphv_10hv)*(1+2.5/w*(1-fem))
+ dta      = (dta_nld30b_sphv_10hv)
+ trj      = (trj_nld30b_sphv_10hv)
+ cjarea   = (cjarea_nld30b_sphv_10hv)*delr_cj_nld30b_sphv_10hv
+ cjlsti   = (cjlsti_nld30b_sphv_10hv)*djunc*delr_cj_nld30b_sphv_10hv
+ cjlgat   = (cjlgat_nld30b_sphv_10hv)*djunc*delr_cj_nld30b_sphv_10hv
+ vbiarea  = (vbiarea_nld30b_sphv_10hv)
+ vbisti   = (vbisti_nld30b_sphv_10hv)
+ vbigat   = (vbigat_nld30b_sphv_10hv)
+ parea    = (parea_nld30b_sphv_10hv)
+ psti     = (psti_nld30b_sphv_10hv)
+ pgat     = (pgat_nld30b_sphv_10hv)
+ is1area  = (is1area_nld30b_sphv_10hv)
+ ttarea   = (ttarea_nld30b_sphv_10hv)
+ is2area  = (is2area_nld30b_sphv_10hv)
+ irarea   = (irarea_nld30b_sphv_10hv)
+ stis1area = (stis1area_nld30b_sphv_10hv)
+ stis2area = (stis2area_nld30b_sphv_10hv)
+ stirarea = (stirarea_nld30b_sphv_10hv)
+ n1area   = (n1area_nld30b_sphv_10hv)
+ n2area   = (n2area_nld30b_sphv_10hv)
+ nrarea   = (nrarea_nld30b_sphv_10hv)
+ is1lsti  = (is1lsti_nld30b_sphv_10hv)
+ ttlsti   = (ttlsti_nld30b_sphv_10hv)
+ is2lsti  = (is2lsti_nld30b_sphv_10hv)
+ irlsti   = (irlsti_nld30b_sphv_10hv)
+ stis1sti = (stis1sti_nld30b_sphv_10hv)
+ stis2sti = (stis2sti_nld30b_sphv_10hv)
+ stirsti  = (stirsti_nld30b_sphv_10hv)
+ n1sti    = (n1sti_nld30b_sphv_10hv)
+ n2sti    = (n2sti_nld30b_sphv_10hv)
+ nrsti    = (nrsti_nld30b_sphv_10hv)
+ is1lgat  = (is1lgat_nld30b_sphv_10hv)
+ ttlgat   = (ttlgat_nld30b_sphv_10hv)
+ is2lgat  = (is2lgat_nld30b_sphv_10hv)
+ irlgat   = (irlgat_nld30b_sphv_10hv)
+ stis1gat = (stis1gat_nld30b_sphv_10hv)
+ stis2gat = (stis2gat_nld30b_sphv_10hv)
+ stirgat  = (stirgat_nld30b_sphv_10hv)
+ n1gat    = (n1gat_nld30b_sphv_10hv)
+ n2gat    = (n2gat_nld30b_sphv_10hv)
+ nrgat    = (nrgat_nld30b_sphv_10hv)
+ cjaread  = (cjaread_nld30b_sphv_10hv*delr_cj_nld30b_sphv_10hv)
+ cjlstid  = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ cjlgatd  = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ vbiaread = (vbiaread_nld30b_sphv_10hv)
+ vbistid  = (vbistid_nld30b_sphv_10hv)
+ vbigatd  = (vbigatd_nld30b_sphv_10hv)
+ paread   = (paread_nld30b_sphv_10hv)
+ pstid    = (pstid_nld30b_sphv_10hv)
+ pgatd    = (pgatd_nld30b_sphv_10hv)
+ is1aread = (is1aread_nld30b_sphv_10hv*delr_is_nld30b_sphv_10hv)
+ ttaread  = (ttaread_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread = (is2aread_nld30b_sphv_10hv*delr_is2_nld30b_sphv_10hv)
+ iraread  = (iraread_nld30b_sphv_10hv*delr_ir_nld30b_sphv_10hv)
+ stis1aread = (stis1aread_nld30b_sphv_10hv)
+ stis2aread = (stis2aread_nld30b_sphv_10hv)
+ stiraread = (stiraread_nld30b_sphv_10hv)
+ n1aread  = (n1aread_nld30b_sphv_10hv)
+ n2aread  = (n2aread_nld30b_sphv_10hv)
+ nraread  = (nraread_nld30b_sphv_10hv)
+ is1lstid = (is1aread_nld30b_sphv_10hv*djunc*delr_is_nld30b_sphv_10hv*0)
+ ttlstid  = (ttlstid_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid = (is2aread_nld30b_sphv_10hv*djunc*delr_is2_nld30b_sphv_10hv)
+ irlstid  = (irlstid_nld30b_sphv_10hv*djunc*delr_ir_nld30b_sphv_10hv)
+ stis1stid = (stis1stid_nld30b_sphv_10hv)
+ stis2stid = (stis2stid_nld30b_sphv_10hv)
+ stirstid = (stirstid_nld30b_sphv_10hv)
+ n1stid   = (n1stid_nld30b_sphv_10hv)
+ n2stid   = (n2stid_nld30b_sphv_10hv)
+ nrstid   = (nrstid_nld30b_sphv_10hv)
+ is1lgatd = (is1aread_nld30b_sphv_10hv*djunc*delr_is_nld30b_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lgatd = (is2aread_nld30b_sphv_10hv*djunc*delr_is2_nld30b_sphv_10hv)
+ irlgatd  = (irlgatd_nld30b_sphv_10hv*djunc*delr_ir_nld30b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld30b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld30b_sphv_10hv)
+ stirgatd = (stirgatd_nld30b_sphv_10hv)
+ n1gatd   = (n1gatd_nld30b_sphv_10hv)
+ n2gatd   = (n2gatd_nld30b_sphv_10hv)
+ nrgatd   = (nrgatd_nld30b_sphv_10hv)
+ cjaread2 = (cjaread_nld30b_sphv_10hv*delr_cj_nld30b_sphv_10hv)
+ cjlstid2 = (cjaread_nld30b_sphv_10hv*djunc*delr_cj_nld30b_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld30b_sphv_10hv)
+ vbistid2 = (vbistid2_nld30b_sphv_10hv)
+ paread2  = (paread2_nld30b_sphv_10hv)
+ pstid2   = (pstid2_nld30b_sphv_10hv)
+ is1aread2 = (is1aread_nld30b_sphv_10hv)*delr_is_nld30b_sphv_10hv
+ ttaread2 = (ttaread2_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread2 = (is2aread_nld30b_sphv_10hv)*delr_is2_nld30b_sphv_10hv
+ iraread2 = (iraread2_nld30b_sphv_10hv)*delr_ir_nld30b_sphv_10hv
+ stis1aread2 = (stis1aread_nld30b_sphv_10hv)
+ stis2aread2 = (stis2aread_nld30b_sphv_10hv)
+ stiraread2 = (stiraread2_nld30b_sphv_10hv)
+ n1aread2 = (n1aread2_nld30b_sphv_10hv)
+ n2aread2 = (n2aread2_nld30b_sphv_10hv)
+ nraread2 = (nraread2_nld30b_sphv_10hv)
+ is1lstid2 = (is1aread_nld30b_sphv_10hv*djunc*0)
+ ttlstid2 = (ttlstid2_nld30b_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid2 = (is2aread_nld30b_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_nld30b_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld30b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld30b_sphv_10hv)
+ stirstid2 = (stirstid2_nld30b_sphv_10hv)
+ n1stid2  = (n1stid2_nld30b_sphv_10hv)
+ n2stid2  = (n2stid2_nld30b_sphv_10hv)
+ nrstid2  = (nrstid2_nld30b_sphv_10hv)

+ eais1area = (eais1area_nld30b_sphv_10hv)
+ eais2area = (eais2area_nld30b_sphv_10hv)
+ eairarea = (eairarea_nld30b_sphv_10hv)
+ eais1sti = (eais1sti_nld30b_sphv_10hv)
+ eais2sti = (eais2sti_nld30b_sphv_10hv)
+ eairsti = (eairsti_nld30b_sphv_10hv)
+ eais1gat = (eais1gat_nld30b_sphv_10hv)
+ eais2gat = (eais2gat_nld30b_sphv_10hv)
+ eairgat = (eairgat_nld30b_sphv_10hv)

+ eais1aread = (eais1aread_nld30b_sphv_10hv)
+ eais2aread = (eais2aread_nld30b_sphv_10hv)
+ eairaread = (eairaread_nld30b_sphv_10hv)
+ eais1stid = (eais1stid_nld30b_sphv_10hv)
+ eais2stid = (eais2stid_nld30b_sphv_10hv)
+ eairstid = (eairstid_nld30b_sphv_10hv)
+ eais1gatd = (eais1gatd_nld30b_sphv_10hv)
+ eais2gatd = (eais2gatd_nld30b_sphv_10hv)
+ eairgatd = (eairgatd_nld30b_sphv_10hv)

+ eais1aread2 = (eais1aread2_nld30b_sphv_10hv)
+ eais2aread2 = (eais2aread2_nld30b_sphv_10hv)
+ eairaread2 = (eairaread2_nld30b_sphv_10hv)
+ eais1stid2 = (eais1stid2_nld30b_sphv_10hv)
+ eais2stid2 = (eais2stid2_nld30b_sphv_10hv)
+ eairstid2 = (eairstid2_nld30b_sphv_10hv)

+ ikfarea               = ikfarea_nld30b_sphv_10hv
+ ikflsti               = ikfarea_nld30b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld30b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld30b_sphv_10hv
+ stikfsti              = stikfarea_nld30b_sphv_10hv
+ stikfgat              = stikfarea_nld30b_sphv_10hv
+ ikfaread              = ikfaread_nld30b_sphv_10hv*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflstid              = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflgatd              = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikfaread2             = ikfaread_nld30b_sphv_10hv*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ ikflstid2             = ikfaread_nld30b_sphv_10hv*djunc*(w/(w+dwikfaread_nld30b_sphv_10hv))
+ stikfaread             = stikfaread_nld30b_sphv_10hv
+ stikfstid             = stikfaread_nld30b_sphv_10hv
+ stikfgatd             = stikfaread_nld30b_sphv_10hv
+ stikfaread2            = stikfaread_nld30b_sphv_10hv
+ stikfstid2            = stikfaread_nld30b_sphv_10hv

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt    = (1e12)
+ tnom    = (27)
+ is           = (1e-30)
+ n           = (1.0)
+ cj          = (1e-30)
+ pta        = (0)
+ tlevc     = (2)
+ tlev       = (2)
+ bv         = (41.5+bvdss_shift)
+ ibv         = (1e-5/1e-12)


xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
//cgs_frg_s (intg s) capacitor c=(cpp_ply_sdt*(lovlap+lfrs)*lfring)
//cgd_frg_d (intg d) capacitor c=(cpp_ply_sdt*(lfrd)*lfring)
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld30b_s_ply_met+lfr_ct_ply_s*cfr_nld30b_s_ply_m1ct))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld30b_d_ply_met+lfr_ct_ply_d*cfr_nld30b_d_ply_m1ct))
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
dbodyBV (s rd)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rd d)   resistor r=0.01

rgate (g intg) resistor r=(rply*((w+2*1.495*(1-fem))/((lch+lacc+lflap)*3*ng)))

include "./smos10hv_ade_dfrt.scs" section=nld30b_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = 1
+    selfheat                       = 1
+    fscale			    = 1
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_sphv_10hv
+    nsmm_dela_vfb_nld45b_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_sphv_10hv
+    nsmm_dela_vtw_nld45b_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_sphv_10hv
+    nsmm_delr_mobref_nld45b_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_sphv_10hv
+    nsmm_delr_rsh_nld45b_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_sphv_10hv
+    nsmm_delr_vdscale_nld45b_sphv_10hv = tmp_nsmm_delr_vdscale_nld45b_sphv_10hv
+    nsmm_delr_nsub_nld45b_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_vthratio     = 1.0/1.075
+    presto_nld45b_ronratio     = 0.01/0.58
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.4)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.2)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.5)
+    ldr1 			    = (0.6)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.255)
+    wd2g			    = (0.75)*(1-fem)
+    wg1			    = (0.7)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.4)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lch                            = (0.352)
+    lacc                           = (0.594)
+    lflap                          = (0.55)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.42)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w)+0.5*pi4models*(wd2g+wg1)*(wd2g+wg1))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_sphv_10hv+tc2_ecrit_nld45b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1.2)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-5e-4))

+    delr_tox_nld45b_sphv_10hv      = (nom_delr_tox_nld45b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_sphv_10hv+nsmm_delr_gox_nld45b_sphv_10hv*smm_delr_gox_nld45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_xw_nld45b_sphv_10hv       = (nom_dela_xw_nld45b_sphv_10hv+nsig_dela_xw_nld45b_sphv_10hv*sig_dela_xw_nld45b_sphv_10hv+nsmm_dela_xw_nld45b_sphv_10hv*smm_dela_xw_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_nld45b_sphv_10hv      = (nom_dela_vfb_nld45b_sphv_10hv+nsig_dela_vfb_nld45b_sphv_10hv*sig_dela_vfb_nld45b_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_sphv_10hv*smm_dela_vfb_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtw_nld45b_sphv_10hv     = (nom_dela_vtw_nld45b_sphv_10hv+nsig_dela_vtw_nld45b_sphv_10hv*sig_dela_vtw_nld45b_sphv_10hv+nsmm_dela_vtw_nld45b_sphv_10hv*smm_dela_vtw_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_mobref_nld45b_sphv_10hv   = (nom_delr_mobref_nld45b_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_sphv_10hv*sig_delr_mobref_nld45b_sphv_10hv+nsmm_delr_mobref_nld45b_sphv_10hv*smm_delr_mobref_nld45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rsh_nld45b_sphv_10hv     = (nom_delr_rsh_nld45b_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_sphv_10hv*sig_delr_rsh_nld45b_sphv_10hv)+nsmm_delr_rsh_nld45b_sphv_10hv*smm_delr_rsh_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_vdscale_nld45b_sphv_10hv     = (nom_delr_vdscale_nld45b_sphv_10hv*(1.0+nsig_delr_vdscale_nld45b_sphv_10hv*sig_delr_vdscale_nld45b_sphv_10hv)+nsmm_delr_vdscale_nld45b_sphv_10hv*smm_delr_vdscale_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_nld45b_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_sphv_10hv*smm_delr_nsub_nld45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_cj_nld45b_sphv_10hv        = ((nom_delr_cj_nld45b_sphv_10hv*(1+nsig_delr_cj_nld45b_sphv_10hv*sig_delr_cj_nld45b_sphv_10hv)))
+    delr_is_nld45b_sphv_10hv = (nom_delr_is_nld45b_sphv_10hv*exp(sig_delr_is_nld45b_sphv_10hv*nsig_delr_is_nld45b_sphv_10hv))
+    delr_is2_nld45b_sphv_10hv = (nom_delr_is2_nld45b_sphv_10hv*exp(sig_delr_is2_nld45b_sphv_10hv*nsig_delr_is2_nld45b_sphv_10hv))
+    delr_ir_nld45b_sphv_10hv = (nom_delr_ir_nld45b_sphv_10hv*exp(sig_delr_ir_nld45b_sphv_10hv*nsig_delr_ir_nld45b_sphv_10hv))
// bin parameters
+    dwvdscale =(dwvdscale_nld45b_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(0)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ uo_ng_del =	      (weff/(weff+2))*(0.15)
+ uo_ng_fac =	      (ngeff/(ngeff+uo_ng_del))/(2/(2+uo_ng_del))
+ dvth_ng=weff/(weff+0.25)*(0.03)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ rshldd_ng_del =   (weff/(weff+2))*(0.12)
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(rshldd_ng_del)*(1-fem)
//simple model
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.85)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}


// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (57+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rply*((w+2*3.425*(1-fem))/((lch+lacc+lflap)*3*ng)))
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+     dphibo=(dphibo_nld45b_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_pspmoscap_10hv+dela_vfb_nld45b_sphv_10hv)
+     nsubo=(nsubo_nld45b_sphv_10hv)
+     nsubw=(nsubw_nld45b_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =amoscap/l*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_mosb_10hv)
+ wdrift     =(w_nld45b_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_mosb_10hv)+(stdelvto_nld45b_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)
+ factuo     =(factuo_nld45b_mosb_10hv)*(1+(stfactuo_nld45b_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))


model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=(vdscale_nld45b_sphv_10hv)*(1+dwvdscale/w+dwvdscalew/(w*w))*(((temp+273.5)/(tnom+273.5))**(stvdscale1_nld45b_sphv_10hv))*(delr_vdscale_nld45b_sphv_10hv)
+ stvdscale=(stvdscale_nld45b_sphv_10hv)
+ ctgo=(ctgo_nld45b_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (1)
+ swexp    = (1)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_sphv_10hv)
+ qmc      = (qmc_nld45b_sphv_10hv)
+ lvaro    = (lvaro_nld45b_sphv_10hv)
+ lvarl    = (lvarl_nld45b_sphv_10hv)
+ lvarw    = (lvarw_nld45b_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_sphv_10hv)
+ wvaro    = (wvaro_nld45b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_sphv_10hv+0.5e-6*dela_dw_nld45b_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_sphv_10hv)
+ dwq      = (dwq_nld45b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_sphv_10hv+dela_vfb_nld45b_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_sphv_10hv+dela_vtw_nld45b_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_sphv_10hv)
+ nsubo    = (nsubo_nld45b_sphv_10hv*delr_nsub_nld45b_sphv_10hv)
+ nsubw    = (nsubw_nld45b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_sphv_10hv)
+ npck     = (npck_nld45b_sphv_10hv)
+ npckw    = (npckw_nld45b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_sphv_10hv)
+ lpck     = (lpck_nld45b_sphv_10hv)
+ lpckw    = (lpckw_nld45b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_sphv_10hv)
+ fol2     = (fol2_nld45b_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_sphv_10hv)
+ nslpo    = (nslpo_nld45b_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_sphv_10hv)
+ dphibo   = (dphibo_nld45b_sphv_10hv)
+ dphibl   = (dphibl_nld45b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_sphv_10hv)
+ dphibw   = (dphibw_nld45b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_sphv_10hv)
+ npl      = (npl_nld45b_sphv_10hv)
+ cto      = (cto_nld45b_sphv_10hv)
+ ctl      = (ctl_nld45b_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_sphv_10hv)
+ ctw      = (ctw_nld45b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_sphv_10hv*delr_tox_nld45b_sphv_10hv)
+ lov      = (lov_nld45b_sphv_10hv)
+ dlovd    = (dlovd_nld45b_sphv_10hv)
+ novo     = (novo_nld45b_sphv_10hv)
+ novdo    = (novdo_nld45b_sphv_10hv)
+ cfl      = (cfl_nld45b_sphv_10hv)
+ cflexp   = (cflexp_nld45b_sphv_10hv)
+ cfw      = (cfw_nld45b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_sphv_10hv)
+ uo       = (uo_nld45b_sphv_10hv*delr_mobref_nld45b_sphv_10hv*delr_u0_relimo)*(weff/w)*(uo_ng_fac)
+ fbet1    = (fbet1_nld45b_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_sphv_10hv)
+ lp1w     = (lp1w_nld45b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_sphv_10hv)
+ lp2      = (lp2_nld45b_sphv_10hv)
+ betw1    = (betw1_nld45b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_sphv_10hv)
+ stbeto   = (stbeto_nld45b_sphv_10hv)
+ stbetl   = (stbetl_nld45b_sphv_10hv)
+ stbetw   = (stbetw_nld45b_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_sphv_10hv)
+ muew     = (muew_nld45b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_sphv_10hv)
+ themuo   = (themuo_nld45b_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_sphv_10hv)
+ cso      = (cso_nld45b_sphv_10hv)
+ csl      = (csl_nld45b_sphv_10hv)
+ cslexp   = (cslexp_nld45b_sphv_10hv)
+ csw      = (csw_nld45b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_sphv_10hv)
+ xcoro    = (xcoro_nld45b_sphv_10hv)
+ xcorl    = (xcorl_nld45b_sphv_10hv)
+ xcorw    = (xcorw_nld45b_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_sphv_10hv)
+ fetao    = (fetao_nld45b_sphv_10hv)
+ rsw1     = (rsw1_nld45b_sphv_10hv)
+ rsw2     = (rsw2_nld45b_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_sphv_10hv)
+ rsbo     = (rsbo_nld45b_sphv_10hv)
+ rsgo     = (rsgo_nld45b_sphv_10hv)
+ thesato  = (thesato_nld45b_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_sphv_10hv)
+ thesatw  = (thesatw_nld45b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_sphv_10hv)
+ axl      = (axl_nld45b_sphv_10hv)
+ alpl     = (alpl_nld45b_sphv_10hv)
+ alplexp  = (alplexp_nld45b_sphv_10hv)
+ alpw     = (alpw_nld45b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_sphv_10hv)
+ alp1w    = (alp1w_nld45b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_sphv_10hv)
+ alp2w    = (alp2w_nld45b_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_sphv_10hv)
+ a1o      = (a1o_nld45b_sphv_10hv)
+ a1l      = (a1l_nld45b_sphv_10hv)
+ a1w      = (a1w_nld45b_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_sphv_10hv)
+ sta2o    = (sta2o_nld45b_sphv_10hv)
+ a3o      = (a3o_nld45b_sphv_10hv)
+ a3l      = (a3l_nld45b_sphv_10hv)
+ a3w      = (a3w_nld45b_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_sphv_10hv)
+ a4l      = (a4l_nld45b_sphv_10hv)
+ a4w      = (a4w_nld45b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_sphv_10hv)
+ igovw    = (igovw_nld45b_sphv_10hv)
+ igovdw   = (igovdw_nld45b_sphv_10hv)
+ stigo    = (stigo_nld45b_sphv_10hv)
+ gc2o     = (gc2o_nld45b_sphv_10hv)
+ gc3o     = (gc3o_nld45b_sphv_10hv)
+ chibo    = (chibo_nld45b_sphv_10hv)
+ agidlw   = (agidlw_nld45b_sphv_10hv)
+ agidldw  = (agidldw_nld45b_sphv_10hv)
+ bgidlo   = (bgidlo_nld45b_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_sphv_10hv)
+ cfrw     = (cfrw_nld45b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_sphv_10hv)
+ nfalw    = (nfalw_nld45b_sphv_10hv)
+ nfblw    = (nfblw_nld45b_sphv_10hv)
+ nfclw    = (nfclw_nld45b_sphv_10hv)
+ efo      = (efo_nld45b_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_sphv_10hv)
+ kuowel   = (kuowel_nld45b_sphv_10hv)
+ kuowew   = (kuowew_nld45b_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_sphv_10hv)
+ rsh      = (rsh_nld45b_sphv_10hv)
+ rbulko   = (rbulko_nld45b_sphv_10hv)
+ rwello   = (rwello_nld45b_sphv_10hv)
+ rjunso   = (rjunso_nld45b_sphv_10hv/(weff+dwrjunso_nld45b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_sphv_10hv/(weff+dwrjundo_nld45b_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_sphv_10hv)
+ rshg     = (rshg_nld45b_sphv_10hv)
+ dlsil    = (dlsil_nld45b_sphv_10hv)
+ saref    = (saref_nld45b_sphv_10hv)
+ sbref    = (sbref_nld45b_sphv_10hv)
+ wlod     = (wlod_nld45b_sphv_10hv)
+ kuo      = (kuo_nld45b_sphv_10hv)
+ kvsat    = (kvsat_nld45b_sphv_10hv)
+ tkuo     = (tkuo_nld45b_sphv_10hv)
+ lkuo     = (lkuo_nld45b_sphv_10hv)
+ wkuo     = (wkuo_nld45b_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_sphv_10hv)
+ kvtho    = (kvtho_nld45b_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_sphv_10hv)
+ stetao   = (stetao_nld45b_sphv_10hv)
+ lodetao  = (lodetao_nld45b_sphv_10hv)
+ scref    = (scref_nld45b_sphv_10hv)
+ web      = (web_nld45b_sphv_10hv)
+ wec      = (wec_nld45b_sphv_10hv)
+ adr1o    = (adr1o_nld45b_sphv_10hv)
+ adr1l    = (adr1l_nld45b_sphv_10hv)
+ adr1w    = ((adr1w_nld45b_sphv_10hv)/exp(w))*(1-fem)
+ adr2o    = (adr2o_nld45b_sphv_10hv)*((temp+273.5)/(tnom+273.5))**(stadr2o1_nld45b_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_sphv_10hv)
+ adr3o    = (adr3o_nld45b_sphv_10hv)
+ adr3l    = (adr3l_nld45b_sphv_10hv)
+ adr3w    = (adr3w_nld45b_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_sphv_10hv)
+ adr4l    = (adr4l_nld45b_sphv_10hv)
+ adr4w    = (adr4w_nld45b_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_sphv_10hv)
+ adr5l    = (adr5l_nld45b_sphv_10hv)
+ adr5w    = (adr5w_nld45b_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_sphv_10hv)
+ strthao   = (strthao_nld45b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
//+ rshldd   = (rshldd_nld45b_sphv_10hv*(1+(ng/(ng+6)-2/(2+6))*0.08*(1-fem))*delr_rsh_nld45b_sphv_10hv*delr_rdsw_relimo)
+ rshldd   = ((rshldd_nld45b_sphv_10hv*delr_rsh_nld45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_ronratio))*fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_sphv_10hv+(1e-6)*dela_xw_nld45b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_sphv_10hv)
+ xlw      = (xlw_nld45b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_sphv_10hv)
+ nst      = (nst_nld45b_sphv_10hv)
+ ats      = (ats_nld45b_sphv_10hv)
+ dfinf    = (dfinf_nld45b_sphv_10hv)
+ dfw      = (dfw_nld45b_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_sphv_10hv)
+ dflw     = (dflw_nld45b_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_sphv_10hv)
+ ecrit    = (ecrit_nld45b_sphv_10hv*tfact_ecrit)*(1+dwecrit/w+dwecritw/(w*w))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_sphv_10hv*tfact_ecrit)*(1+dwecrit/w+dwecritw/(w*w))*(ecrit_ng_fac)
+ du       = (du_nld45b_sphv_10hv)
+ tc1      = (tc1_nld45b_sphv_10hv)
+ tc2      = (tc2_nld45b_sphv_10hv)
+ tc1l     = (tc1l_nld45b_sphv_10hv)
+ tc2l     = (tc2l_nld45b_sphv_10hv)
+ tc1w     = (tc1w_nld45b_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_sphv_10hv)
+ theacc2  = (theacc2_nld45b_sphv_10hv)
+ aacc     = (aacc_nld45b_sphv_10hv)
+ rva      = (rva_nld45b_sphv_10hv)
+ dta      = (dta_nld45b_sphv_10hv)
+ trj      = (trj_nld45b_sphv_10hv)
+ cjarea   = (cjarea_nld45b_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_sphv_10hv)
+ vbisti   = (vbisti_nld45b_sphv_10hv)
+ vbigat   = (vbigat_nld45b_sphv_10hv)
+ parea    = (parea_nld45b_sphv_10hv)
+ psti     = (psti_nld45b_sphv_10hv)
+ pgat     = (pgat_nld45b_sphv_10hv)
+ is1area  = (is1area_nld45b_sphv_10hv)
+ ttarea   = (ttarea_nld45b_sphv_10hv)
+ is2area  = (is2area_nld45b_sphv_10hv)
+ irarea   = (irarea_nld45b_sphv_10hv)
+ stis1area = (stis1area_nld45b_sphv_10hv)
+ stis2area = (stis2area_nld45b_sphv_10hv)
+ stirarea = (stirarea_nld45b_sphv_10hv)
+ n1area   = (n1area_nld45b_sphv_10hv)
+ n2area   = (n2area_nld45b_sphv_10hv)
+ nrarea   = (nrarea_nld45b_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_sphv_10hv)
+ irlsti   = (irlsti_nld45b_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_sphv_10hv)
+ stirsti  = (stirsti_nld45b_sphv_10hv)
+ n1sti    = (n1sti_nld45b_sphv_10hv)
+ n2sti    = (n2sti_nld45b_sphv_10hv)
+ nrsti    = (nrsti_nld45b_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_sphv_10hv)
+ irlgat   = (irlgat_nld45b_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_sphv_10hv)
+ stirgat  = (stirgat_nld45b_sphv_10hv)
+ n1gat    = (n1gat_nld45b_sphv_10hv)
+ n2gat    = (n2gat_nld45b_sphv_10hv)
+ nrgat    = (nrgat_nld45b_sphv_10hv)
+ cjaread  = (cjaread_nld45b_sphv_10hv*delr_cj_nld45b_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_sphv_10hv)
+ vbistid  = (vbistid_nld45b_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_sphv_10hv)
+ paread   = (paread_nld45b_sphv_10hv)
+ pstid    = (pstid_nld45b_sphv_10hv)
+ pgatd    = (pgatd_nld45b_sphv_10hv)
+ is1aread = (is1aread_nld45b_sphv_10hv*delr_is_nld45b_sphv_10hv)
+ ttaread  = (ttaread_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2aread = (is2aread_nld45b_sphv_10hv*delr_is2_nld45b_sphv_10hv)
+ iraread  = (iraread_nld45b_sphv_10hv*delr_ir_nld45b_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_sphv_10hv)
+ stiraread = (stiraread_nld45b_sphv_10hv)
+ n1aread  = (n1aread_nld45b_sphv_10hv)
+ n2aread  = (n2aread_nld45b_sphv_10hv)
+ nraread  = (nraread_nld45b_sphv_10hv)
+ is1lstid = (is1aread_nld45b_sphv_10hv*djunc*delr_is_nld45b_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lstid = (is2aread_nld45b_sphv_10hv*djunc*delr_is2_nld45b_sphv_10hv)
+ irlstid  = (iraread_nld45b_sphv_10hv*djunc*delr_ir_nld45b_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_sphv_10hv)
+ stirstid = (stirstid_nld45b_sphv_10hv)
+ n1stid   = (n1stid_nld45b_sphv_10hv)
+ n2stid   = (n2stid_nld45b_sphv_10hv)
+ nrstid   = (nrstid_nld45b_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_sphv_10hv*djunc*delr_is_nld45b_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lgatd = (is2aread_nld45b_sphv_10hv*djunc*delr_is2_nld45b_sphv_10hv)
+ irlgatd  = (iraread_nld45b_sphv_10hv*djunc*delr_ir_nld45b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_sphv_10hv*delr_cj_nld45b_sphv_10hv)
+ cjlstid2 = (0*cjaread_nld45b_sphv_10hv*djunc*delr_cj_nld45b_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_sphv_10hv)
+ paread2  = (paread2_nld45b_sphv_10hv)
+ pstid2   = (pstid2_nld45b_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2aread2 = (is2aread_nld45b_sphv_10hv)
+ iraread2 = (iraread2_nld45b_sphv_10hv*delr_ir_nld45b_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_sphv_10hv)
+ nraread2 = (nraread2_nld45b_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_sphv_10hv)*(1+dwtt/w)
+ is2lstid2 = (is2aread_nld45b_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_sphv_10hv*djunc)
+ stis1stid2 = (stis1stid2_nld45b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_sphv_10hv)
+ eais1area		= eais1area_nld45b_sphv_10hv
+ eais2area		= eais2area_nld45b_sphv_10hv
+ eairarea		= eairarea_nld45b_sphv_10hv
+ eais1sti		= eais1sti_nld45b_sphv_10hv
+ eais2sti		= eais2sti_nld45b_sphv_10hv
+ eairsti	  = eairsti_nld45b_sphv_10hv
+ eais1gat		= eais1gat_nld45b_sphv_10hv
+ eais2gat		= eais2gat_nld45b_sphv_10hv
+ eairgat	  = eairgat_nld45b_sphv_10hv
+ eais1aread		= eais1aread_nld45b_sphv_10hv
+ eais2aread		= eais2aread_nld45b_sphv_10hv
+ eairaread		= eairaread_nld45b_sphv_10hv
+ eais1stid		= eais1stid_nld45b_sphv_10hv
+ eais2stid		= eais2stid_nld45b_sphv_10hv
+ eairstid		= eairstid_nld45b_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_sphv_10hv
+ eairgatd		= eairgatd_nld45b_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_sphv_10hv
+ eairaread2		= eairaread2_nld45b_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_sphv_10hv
+ eairstid2		= eairstid2_nld45b_sphv_10hv
+ ikfarea               = ikfarea_nld45b_sphv_10hv
+ ikflsti               = ikfarea_nld45b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_sphv_10hv
+ stikfsti              = stikfarea_nld45b_sphv_10hv
+ stikfgat              = stikfarea_nld45b_sphv_10hv
+ ikfaread              = ikfaread_nld45b_sphv_10hv*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_sphv_10hv*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_sphv_10hv
+ stikfstid             = stikfaread_nld45b_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_sphv_10hv



include "./smos10hv_ade_dfrt.scs" section=nld45b_10hv_dfrt
ends


//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld65b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    sti_dummy                      = 0


//*support mismatch
//*******************************************************************************************************
+ tc_vth_mm                      = (1+(temp-27)*(-2.5e-3))
+ nsmm_delr_gox_nld65b_sphv_10hv = tmp_nsmm_delr_gox_nld65b_sphv_10hv
+ nsmm_delr_uch_nld65b_sphv_10hv  = tmp_nsmm_delr_uch_nld65b_sphv_10hv
+ nsmm_delr_res_nld65b_sphv_10hv  = tmp_nsmm_delr_res_nld65b_sphv_10hv
+ nsmm_dela_vfb_nld65b_sphv_10hv  = tmp_nsmm_dela_vfb_nld65b_sphv_10hv
+ nsmm_dela_vtw_nld65b_sphv_10hv  = tmp_nsmm_dela_vtw_nld65b_sphv_10hv
+ nsmm_delr_nsub_nld65b_sphv_10hv = tmp_nsmm_delr_nsub_nld65b_sphv_10hv
+ nsmm_dela_dxw_nld65b_sphv_10hv = tmp_nsmm_dela_dxw_nld65b_sphv_10hv

//*relimo model
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld65b_vthratio     = 1.0
+    presto_nld65b_ronratio     = 0.01/1.25

//**parameters for multi ng
+ fac_ng_rshldd=(1+(ngeff/(ngeff-0.3*(1-fem))-2/(2-0.3))*(0.1))
+ fac_ng_vfbo= ((ngeff/(ngeff+0.6*(1-fem))-2/(2+0.6))*(0.14))
+ fac_ng_thesato= (1+(ngeff/(ngeff+0.1*(1-fem))-2/(2+0.1))*(0))

//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+ delr_tox_nld65b_sphv_10hv=(nom_delr_tox_nld65b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld65b_sphv_10hv+nsmm_delr_gox_nld65b_sphv_10hv*smm_delr_gox_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_uch_nld65b_sphv_10hv = (nom_delr_uch_nld65b_sphv_10hv*(1+sig_delr_uch_nld65b_sphv_10hv*nsig_delr_uch_nld65b_sphv_10hv+nsmm_delr_uch_nld65b_sphv_10hv*smm_delr_uch_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_nld65b_sphv_10hv = (nom_delr_res_nld65b_sphv_10hv*(1+sig_delr_res_nld65b_sphv_10hv*nsig_delr_res_nld65b_sphv_10hv+nsmm_delr_res_nld65b_sphv_10hv*smm_delr_res_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_nld65b_sphv_10hv = (nom_dela_vfb_nld65b_sphv_10hv+(sig_dela_vfb_nld65b_sphv_10hv*nsig_dela_vfb_nld65b_sphv_10hv)+tc_vth_mm*nsmm_dela_vfb_nld65b_sphv_10hv*smm_dela_vfb_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_nld65b_sphv_10hv = (nom_dela_vtw_nld65b_sphv_10hv+(sig_dela_vtw_nld65b_sphv_10hv*nsig_dela_vtw_nld65b_sphv_10hv)+nsmm_dela_vtw_nld65b_sphv_10hv*smm_dela_vtw_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_xw_nld65b_sphv_10hv = (nom_dela_xw_nld65b_sphv_10hv+(sig_dela_xw_nld65b_sphv_10hv*nsig_dela_xw_nld65b_sphv_10hv)+(nsmm_dela_dxw_nld65b_sphv_10hv*smm_dela_dxw_nld65b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_nsub_nld65b_sphv_10hv = (1+nsmm_delr_nsub_nld65b_sphv_10hv*smm_delr_nsub_nld65b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_thesatw_nld65b_sphv_10hv = (nom_dela_thesatw_nld65b_sphv_10hv+(sig_dela_thesatw_nld65b_sphv_10hv*nsig_dela_thesatw_nld65b_sphv_10hv))
+ delr_cj_nld65b_sphv_10hv = (nom_delr_cj_nld65b_sphv_10hv*(1+sig_delr_cj_nld65b_sphv_10hv*nsig_delr_cj_nld65b_sphv_10hv))
+ delr_is_nld65b_sphv_10hv = (nom_delr_is_nld65b_sphv_10hv*exp(sig_delr_is_nld65b_sphv_10hv*nsig_delr_is_nld65b_sphv_10hv))
+ delr_is2_nld65b_sphv_10hv = (nom_delr_is2_nld65b_sphv_10hv*exp(sig_delr_is2_nld65b_sphv_10hv*nsig_delr_is2_nld65b_sphv_10hv))
+ delr_ir_nld65b_sphv_10hv = (nom_delr_ir_nld65b_sphv_10hv*exp(sig_delr_ir_nld65b_sphv_10hv*nsig_delr_ir_nld65b_sphv_10hv))
//****************************************************************************************************
// *will remove in final assemble
//****************************************************************************************************
//+    cpp_ply_fld		    = (0.092229166666667e-15)
//+    cpp_ply_sdt		    = (2.6460229885057e-15)
//+    cpp_m1_sd 		            = (0.054083183333333e-15)
//

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))


+    fscale			    = (1)
+    nde			    = (0)
+    nse			    = (2)
+    ns 		    = ((ng+nse)/2)
+    nd 		    = (ng/2)
+    ndi			    = (nd-nde)
+    nsi			    = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv		    = (3.9)
+    l                              = (0.55)
+    numbernplus		    = (int_round((w-0.09*(1-fem))/0.84))
+    weff		    = (numbernplus*0.42*fscale)
+    ldrift_dr  	    = (2.75*fscale)
+    wdrift_dr  	    = (w*fscale)
+    ldr1		    = (0.6*fscale)
+    lacts			    = (0.375)
+    lactd			    = (0.69/2)
+    ldrift			    = (2.75)
+    wd2g		    = (1.3)*(1-fem)
+    wg1		    = (1.95)*(1-fem)
+    wg2		    = (1.85)*(1-fem)
+    wnc		    = (0.95)*(1-fem)
+    wgd			    = (0.6)*(1-fem)
+    wdcfply                        = (0.7)*(1-fem)

// for the moscap
+    rect_area  		    = (wd2g+wg1+wg2)*(l+ldr1+ldrift+lactd)*2
+    rect_cutout		    = (ldr1+ldrift+lactd)*(wd2g)*2
+    semi_cutout		    =  pi4models*(wdcfply+wgd+wg1)*(wdcfply+wgd+wg1)/2
+    amoscap			    = ((rect_area-rect_cutout-semi_cutout)*fscale*fscale)
// for the parastic cap
+    ld2g			    = 0.8
+    as_xdr			    = (lacts*(weff))
+    ps_xdr			    = (2*(lacts+(weff)))
+    ad_xdr			    = (((ldrift*2+ldr1*2+lactd*2)*(w+2*wd2g)+pi4models*(wg1+wdcfply+wgd)*(wg1+wdcfply+wgd))/2)
+    pd_xdr			    = (((2*pi4models*(wg1+wdcfply+wgd))+2*(w+2*wd2g))/2)
+    ad2_xdr			    = (((lactd*2+ldrift)*(w)+pi4models*wd2g*wd2g)/2)
+    as_dr			    = (as_xdr*fscale*fscale)
+    ps_dr			    = (ps_xdr*fscale)
+    ad_dr			    = ((ad_xdr-ad2_xdr)*fscale*fscale)
+    pd_dr			    = (pd_xdr*fscale)
+    ad2_dr			    = (ad2_xdr*fscale*fscale)
+    pd2_dr			    = (0)
+    la2dt			    = (1.485)
+    wa2dt			    = (1.11)*(1-fem)
+    lg2g_d			    = (2*(ldr1+ldrift+lactd))
+    lg2g_s			    = (0.78)
+    xnbl_xdr			    = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			    = (w+(wd2g+wg1+wg2+wa2dt)*2)
+    anbl_xdr			    = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			    = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			    = 2.0*1e-6
+    aplyfld_d  		    = (((ldrift_dr-ld2g-0.7)*(w+wd2g*2)+(pi4models*(wg1)*(wg1))/2)*ngeff*fscale*fscale)
+    aplyact_d  		    = ((ldr1*wd2g*2+pi4models*(wg1+wdcfply+wgd)*(wg1+wdcfply+wgd)/2-pi4models*(wg1+wdcfply)*(wg1+wdcfply)/2)*fscale*fscale)
+    ldr1_eff		            = (ldr1+1.0*aplyact_d/(w))
+    lacc			    = (0.6)
+    lch			    = (0.55)
+    lflap                          = (1.25)
+    aplyfld_d_rgate                = (aplyfld_d/ngeff)
+    rgateout			    = (rply*(w+2*5.375*(1-fem))/((lch+lacc)*3))
+    rgatein			    = (rply*aplyfld_d_rgate/((lflap)*(lflap)*3))
+    rgatetot			    = (rgatein*rgateout/(rgatein+rgateout))
+    tfact_ecrit		    = 1+(tc1_ecrit_nld65b_sphv_10hv+tc2_ecrit_nld65b_sphv_10hv*(temp-tnom))*(temp-tnom)
+    w_heat			    = w
+    l_heat			    = (lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=(((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld65b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld65b_sphv_10hv)*ngeff/she_fit)
+    cth_f=(((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8668)


+    xcoord			    = (0)
+    ycoord			    = (0)


if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift_dr wdrift=wdrift_dr ldr1=ldr1_eff mult=ng_dmy ad=ad_dr pd=pd_dr as=as_dr ps=ps_dr ad2=ad2_dr pd2=pd2_dr
}

model pspmoscap psp103t type=n
+     tr		 = 27
+     toxo=toxo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+     dphibo=dphibo_nld65b_sphv_10hv
+     vfbo=vfbo_nld65b_sphv_10hv+dela_vfb_nld65b_sphv_10hv+fac_ng_vfbo-0.85
+     nsubo=nsubo_nld65b_sphv_10hv
+     nsubw=nsubw_nld65b_sphv_10hv*(1-fem)*0
+     rtho=1e18
+     ctho=0


mmoscap (s intg s s dtemp) pspmoscap
+ l	     =0.64
+ w	     =amoscap/l*(1-fem)+fem*1e-3
+ mult       =ng

// BV diode model card:
model dbodydrainbv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (84+bvdss_shift)
+ ibv      = (1e-5/1e-12)



amost (d intg s s dtemp) sphvt_simkit
+ w	     =w
+ l	     =l
+ ldrift     =ldrift_dr
+ wdrift     =wdrift_dr
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad	     =ad_dr
+ pd	     =pd_dr
+ as	     =as_dr
+ ps	     =ps_dr
+ ad2	     =ad2_dr
+ pd2	     =pd2_dr

model sphvt_simkit sphvt
+ type         = n
+ vdscale      = 1.23
+ tr	       = 27
+ swgeo        = 1
+ swgedi       = 1
+ swigate      = 0
+ swimpact     = 1
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = 1
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 0
+ swnud        = 0
+ swptest      = 0
+ swdrlin      = swdrlin
+ xvsat	       = xvsat_nld65b_sphv_10hv
+ qmc	       = qmc_nld65b_sphv_10hv
+ lvaro    = lvaro_nld65b_sphv_10hv
+ lvarl    = lvarl_nld65b_sphv_10hv
+ lvarw    = (lvarw_nld65b_sphv_10hv*(1-fem))
+ lap		     = lap_nld65b_sphv_10hv
+ wvaro     = (wvaro_nld65b_sphv_10hv*(1-fem))
+ wvarl     = (wvarl_nld65b_sphv_10hv*(1-fem))
+ wvarw     = (wvarw_nld65b_sphv_10hv*(1-fem))
+ wot		     = (wot_nld65b_sphv_10hv*(1-fem))
+ dlq		     = dlq_nld65b_sphv_10hv
+ dwq		     = (dwq_nld65b_sphv_10hv*(1-fem))
+ vfbo     = vfbo_nld65b_sphv_10hv+dela_vfb_nld65b_sphv_10hv+fac_ng_vfbo+dela_vth_relimo+hvgsvthdegr*presto_nld65b_vthratio
+ vfbl     = vfbl_nld65b_sphv_10hv
+ vfbw     = (vfbw_nld65b_sphv_10hv+dela_vtw_nld65b_sphv_10hv*(1-fem))
+ vfblw     = (vfblw_nld65b_sphv_10hv*(1-fem))
+ stvfbo     = stvfbo_nld65b_sphv_10hv
+ stvfbl     = stvfbl_nld65b_sphv_10hv
+ stvfbw     = (stvfbw_nld65b_sphv_10hv*(1-fem))
+ stvfblw     = (stvfblw_nld65b_sphv_10hv*(1-fem))
+ toxo     = toxo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ epsroxo     = epsroxo_nld65b_sphv_10hv
+ nsubo     = nsubo_nld65b_sphv_10hv*delr_nsub_nld65b_sphv_10hv
+ nsubw     = (nsubw_nld65b_sphv_10hv*(1-fem))
+ wseg     = wseg_nld65b_sphv_10hv
+ npck     = npck_nld65b_sphv_10hv
+ npckw     = (npckw_nld65b_sphv_10hv*(1-fem))
+ wsegp     = wsegp_nld65b_sphv_10hv
+ lpck     = lpck_nld65b_sphv_10hv
+ lpckw     = (lpckw_nld65b_sphv_10hv*(1-fem))
+ fol1     = fol1_nld65b_sphv_10hv
+ fol2     = fol2_nld65b_sphv_10hv
+ facneffaco		   = facneffaco_nld65b_sphv_10hv
+ facneffacl		   = facneffacl_nld65b_sphv_10hv
+ facneffacw		   = (facneffacw_nld65b_sphv_10hv*(1-fem))
+ facneffaclw		    = (facneffaclw_nld65b_sphv_10hv*(1-fem))
+ gfacnudo		 = gfacnudo_nld65b_sphv_10hv
+ gfacnudl		 = gfacnudl_nld65b_sphv_10hv
+ gfacnudlexp		    = gfacnudlexp_nld65b_sphv_10hv
+ gfacnudw		 = (gfacnudw_nld65b_sphv_10hv*(1-fem))
+ gfacnudlw		  = (gfacnudlw_nld65b_sphv_10hv*(1-fem))
+ vsbnudo     = vsbnudo_nld65b_sphv_10hv
+ dvsbnudo		 = dvsbnudo_nld65b_sphv_10hv
+ vnsubo     = vnsubo_nld65b_sphv_10hv
+ nslpo     = nslpo_nld65b_sphv_10hv
+ dnsubo     = dnsubo_nld65b_sphv_10hv
+ dphibo     = dphibo_nld65b_sphv_10hv
+ dphibl     = dphibl_nld65b_sphv_10hv
+ dphiblexp		  = dphiblexp_nld65b_sphv_10hv
+ dphibw     = (dphibw_nld65b_sphv_10hv*(1-fem))
+ dphiblw     = (dphiblw_nld65b_sphv_10hv*(1-fem))
+ delvtaco		 = delvtaco_nld65b_sphv_10hv
+ delvtacl		 = delvtacl_nld65b_sphv_10hv
+ delvtaclexp		    = delvtaclexp_nld65b_sphv_10hv
+ delvtacw		 = delvtacw_nld65b_sphv_10hv*(1-fem)
+ delvtaclw		  = delvtaclw_nld65b_sphv_10hv*(1-fem)
+ npo		    = npo_nld65b_sphv_10hv
+ npl		    = npl_nld65b_sphv_10hv
+ cto		    = cto_nld65b_sphv_10hv
+ ctl		    = ctl_nld65b_sphv_10hv
+ ctlexp     = ctlexp_nld65b_sphv_10hv
+ ctw		    = (ctw_nld65b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld65b_sphv_10hv*(1-fem))
+ toxovo     = toxovo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ toxovdo    = toxovdo_nld65b_sphv_10hv*delr_tox_nld65b_sphv_10hv
+ lov		    = lov_nld65b_sphv_10hv
+ dlovd     = dlovd_nld65b_sphv_10hv
+ novo     = novo_nld65b_sphv_10hv
+ novdo     = novdo_nld65b_sphv_10hv
+ cfl		    = cfl_nld65b_sphv_10hv
+ cflexp     = cflexp_nld65b_sphv_10hv
+ cfw		    = (cfw_nld65b_sphv_10hv*(1-fem))
+ cfbo     = cfbo_nld65b_sphv_10hv
+ uo		   = uo_nld65b_sphv_10hv*(weff/w)*delr_uch_nld65b_sphv_10hv*delr_u0_relimo
+ fbet1     = fbet1_nld65b_sphv_10hv
+ fbet1w     = (fbet1w_nld65b_sphv_10hv*(1-fem))
+ lp1		    = lp1_nld65b_sphv_10hv
+ lp1w     = (lp1w_nld65b_sphv_10hv*(1-fem))
+ fbet2     = fbet2_nld65b_sphv_10hv
+ lp2		    = lp2_nld65b_sphv_10hv
+ betw1     = (betw1_nld65b_sphv_10hv*(1-fem))
+ betw2     = (betw2_nld65b_sphv_10hv*(1-fem))
+ wbet     = wbet_nld65b_sphv_10hv
+ stbeto     = stbeto_nld65b_sphv_10hv
+ stbetl     = stbetl_nld65b_sphv_10hv
+ stbetw     = (stbetw_nld65b_sphv_10hv*(1-fem))
+ stbetlw     = (stbetlw_nld65b_sphv_10hv*(1-fem))
+ mueo     = mueo_nld65b_sphv_10hv
+ muew     = (muew_nld65b_sphv_10hv*(1-fem))
+ stmueo     = stmueo_nld65b_sphv_10hv
+ themuo     = themuo_nld65b_sphv_10hv
+ stthemuo		 = stthemuo_nld65b_sphv_10hv
+ cso		    = cso_nld65b_sphv_10hv
+ csl		    = csl_nld65b_sphv_10hv
+ cslexp     = cslexp_nld65b_sphv_10hv
+ csw		    = (csw_nld65b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld65b_sphv_10hv*(1-fem))
+ stcso     = stcso_nld65b_sphv_10hv
+ xcoro     = xcoro_nld65b_sphv_10hv
+ xcorl     = xcorl_nld65b_sphv_10hv
+ xcorw     = (xcorw_nld65b_sphv_10hv*(1-fem))
+ xcorlw     = (xcorlw_nld65b_sphv_10hv*(1-fem))
+ stxcoro     = stxcoro_nld65b_sphv_10hv
+ fetao     = fetao_nld65b_sphv_10hv
+ rsw1     = rsw1_nld65b_sphv_10hv
+ rsw2     = rsw2_nld65b_sphv_10hv*(1-fem)
+ strso     = strso_nld65b_sphv_10hv
+ rsbo     = rsbo_nld65b_sphv_10hv
+ rsgo     = rsgo_nld65b_sphv_10hv
+ thesato     = (thesato_nld65b_sphv_10hv)*fac_ng_thesato
+ thesatl     = (thesatl_nld65b_sphv_10hv)
+ thesatlexp		 = thesatlexp_nld65b_sphv_10hv
+ thesatw     = ((thesatw_nld65b_sphv_10hv+dela_thesatw_nld65b_sphv_10hv)*(1-fem))
+ thesatlw	       = (thesatlw_nld65b_sphv_10hv*(1-fem))
+ stthesato		  = stthesato_nld65b_sphv_10hv
+ stthesatl		  = stthesatl_nld65b_sphv_10hv
+ stthesatw		  = (stthesatw_nld65b_sphv_10hv*(1-fem))
+ stthesatlw		   = (stthesatlw_nld65b_sphv_10hv*(1-fem))
+ thesatbo		 = thesatbo_nld65b_sphv_10hv
+ thesatgo		 = thesatgo_nld65b_sphv_10hv
+ thesatgl		 = thesatgl_nld65b_sphv_10hv
+ thesatgw		 = (thesatgw_nld65b_sphv_10hv*(1-fem))
+ axo		    = axo_nld65b_sphv_10hv
+ axl		    = axl_nld65b_sphv_10hv
+ alpl     = alpl_nld65b_sphv_10hv
+ alplexp     = alplexp_nld65b_sphv_10hv
+ alpw     = (alpw_nld65b_sphv_10hv*(1-fem))
+ alp1l1     = alp1l1_nld65b_sphv_10hv
+ alp1lexp		 = alp1lexp_nld65b_sphv_10hv
+ alp1l2     = alp1l2_nld65b_sphv_10hv
+ alp1w     = (alp1w_nld65b_sphv_10hv*(1-fem))
+ alp2l1     = alp2l1_nld65b_sphv_10hv
+ alp2lexp		 = alp2lexp_nld65b_sphv_10hv
+ alp2l2     = alp2l2_nld65b_sphv_10hv
+ alp2w     = (alp2w_nld65b_sphv_10hv*(1-fem))
+ vpo		    = vpo_nld65b_sphv_10hv
+ a1o		    = a1o_nld65b_sphv_10hv
+ a1l		    = a1l_nld65b_sphv_10hv
+ a1w		    = (a1w_nld65b_sphv_10hv*(1-fem))
+ a2o		    = a2o_nld65b_sphv_10hv
+ sta2o     = sta2o_nld65b_sphv_10hv
+ a3o		    = a3o_nld65b_sphv_10hv
+ a3l		    = a3l_nld65b_sphv_10hv
+ a3w		    = (a3w_nld65b_sphv_10hv*(1-fem))
+ a4o		    = a4o_nld65b_sphv_10hv
+ a4l		    = a4l_nld65b_sphv_10hv
+ a4w		    = (a4w_nld65b_sphv_10hv*(1-fem))
+ gcoo     = gcoo_nld65b_sphv_10hv
+ iginvlw     = iginvlw_nld65b_sphv_10hv
+ igovw     = igovw_nld65b_sphv_10hv
+ igovdw     = igovdw_nld65b_sphv_10hv
+ stigo     = stigo_nld65b_sphv_10hv
+ gc2o     = gc2o_nld65b_sphv_10hv
+ gc3o     = gc3o_nld65b_sphv_10hv
+ chibo     = chibo_nld65b_sphv_10hv
+ agidlw     = (agidlw_nld65b_sphv_10hv)
+ agidldw     = (agidldw_nld65b_sphv_10hv)
+ bgidlo     = bgidlo_nld65b_sphv_10hv
+ bgidldo     = bgidldo_nld65b_sphv_10hv
+ stbgidlo		 = stbgidlo_nld65b_sphv_10hv
+ stbgidldo		  = stbgidldo_nld65b_sphv_10hv
+ cgidlo     = cgidlo_nld65b_sphv_10hv
+ cgidldo     = cgidldo_nld65b_sphv_10hv
+ cgbovl     = cgbovl_nld65b_sphv_10hv
+ cfrw     = (cfrw_nld65b_sphv_10hv)*(1-fem)
+ cfrdw     = (cfrdw_nld65b_sphv_10hv*(1-fem))
+ fnto     = fnto_nld65b_sphv_10hv
+ nfalw     = nfalw_nld65b_sphv_10hv
+ nfblw     = nfblw_nld65b_sphv_10hv
+ nfclw     = nfclw_nld65b_sphv_10hv
+ efo		    = efo_nld65b_sphv_10hv
+ lintnoi     = lintnoi_nld65b_sphv_10hv
+ alpnoi     = alpnoi_nld65b_sphv_10hv
+ kvthoweo		 = kvthoweo_nld65b_sphv_10hv
+ kvthowel		 = kvthowel_nld65b_sphv_10hv
+ kvthowew		 = kvthowew_nld65b_sphv_10hv*(1-fem)
+ kvthowelw		  = kvthowelw_nld65b_sphv_10hv*(1-fem)
+ kuoweo     = kuoweo_nld65b_sphv_10hv
+ kuowel     = kuowel_nld65b_sphv_10hv
+ kuowew     = kuowew_nld65b_sphv_10hv*(1-fem)
+ kuowelw     = kuowelw_nld65b_sphv_10hv*(1-fem)
+ rgo		    = rgo_nld65b_sphv_10hv
+ rsh		    = rsh_nld65b_sphv_10hv
+ rbulko     = rbulko_nld65b_sphv_10hv
+ rwello     = rwello_nld65b_sphv_10hv
+ rjunso     = rjunso_nld65b_sphv_10hv/(w+dwrjunso_nld65b_sphv_10hv*(1-fem))
+ rjundo     = rjundo_nld65b_sphv_10hv/(w+dwrjundo_nld65b_sphv_10hv*(1-fem))
+ rint     = rint_nld65b_sphv_10hv
+ rvpoly     = rvpoly_nld65b_sphv_10hv
+ rshg     = rshg_nld65b_sphv_10hv
+ dlsil     = dlsil_nld65b_sphv_10hv
+ saref     = saref_nld65b_sphv_10hv
+ sbref     = sbref_nld65b_sphv_10hv
+ wlod     = wlod_nld65b_sphv_10hv
+ kuo		    = kuo_nld65b_sphv_10hv
+ kvsat     = kvsat_nld65b_sphv_10hv
+ tkuo     = tkuo_nld65b_sphv_10hv
+ lkuo     = lkuo_nld65b_sphv_10hv
+ wkuo     = wkuo_nld65b_sphv_10hv*(1-fem)
+ pkuo     = pkuo_nld65b_sphv_10hv*(1-fem)
+ llodkuo     = llodkuo_nld65b_sphv_10hv
+ wlodkuo     = wlodkuo_nld65b_sphv_10hv
+ kvtho     = kvtho_nld65b_sphv_10hv
+ lkvtho     = lkvtho_nld65b_sphv_10hv
+ wkvtho     = wkvtho_nld65b_sphv_10hv*(1-fem)
+ pkvtho     = pkvtho_nld65b_sphv_10hv*(1-fem)
+ llodvth     = llodvth_nld65b_sphv_10hv
+ wlodvth     = wlodvth_nld65b_sphv_10hv
+ stetao     = stetao_nld65b_sphv_10hv
+ lodetao     = lodetao_nld65b_sphv_10hv
+ scref     = scref_nld65b_sphv_10hv
+ web		    = web_nld65b_sphv_10hv
+ wec		    = wec_nld65b_sphv_10hv
+ adr1o     = adr1o_nld65b_sphv_10hv
+ adr1l     = adr1l_nld65b_sphv_10hv
+ adr1w     = adr1w_nld65b_sphv_10hv*(1-fem)
+ adr2o     = adr2o_nld65b_sphv_10hv
+ stadr2o     = stadr2o_nld65b_sphv_10hv
+ adr3o     = adr3o_nld65b_sphv_10hv
+ adr3l     = adr3l_nld65b_sphv_10hv
+ adr3w     = adr3w_nld65b_sphv_10hv*(1-fem)
+ adr4o     = adr4o_nld65b_sphv_10hv
+ adr4l     = adr4l_nld65b_sphv_10hv
+ adr4w     = adr4w_nld65b_sphv_10hv*(1-fem)
+ adr5o     = adr5o_nld65b_sphv_10hv
+ adr5l     = adr5l_nld65b_sphv_10hv
+ adr5w     = adr5w_nld65b_sphv_10hv*(1-fem)
+ bidr1o     = bidr1o_nld65b_sphv_10hv
+ bidr1l     = bidr1l_nld65b_sphv_10hv
+ bidr1w     = bidr1w_nld65b_sphv_10hv*(1-fem)
+ bidr2o     = bidr2o_nld65b_sphv_10hv
+ bidr2w     = bidr2w_nld65b_sphv_10hv*(1-fem)
+ rtho     = (selfheat*enable_selfheat>0)?rth_f:0.0
+ //rtho     = rth_f
+ rthl     = 0
+ rthw     = 0
+ rthlw     = 0
+ strtho     = strtho_nld65b_sphv_10hv
+ strthao     = strthao_nld65b_sphv_10hv
+ ctho     = cth_f
+ cthl     = 0
+ cthw     = 0
+ cthlw     = 0
+ rshldd     = (rshldd_nld65b_sphv_10hv*fac_ng_rshldd*delr_res_nld65b_sphv_10hv*delr_rdsw_relimo*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld65b_ronratio))
+ xw		   = ((xw_nld65b_sphv_10hv+1e-6*dela_xw_nld65b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld65b_sphv_10hv*(1-fem))
+ xl		   = xl_nld65b_sphv_10hv
+ xlw		    = (xlw_nld65b_sphv_10hv*(1-fem))
+ dxlsat     = dxlsat_nld65b_sphv_10hv
+ nst		    = nst_nld65b_sphv_10hv
+ ats		    = ats_nld65b_sphv_10hv
+ dfinf     = dfinf_nld65b_sphv_10hv
+ dfw		    = (dfw_nld65b_sphv_10hv*(1-fem))
+ dfl		    = dfl_nld65b_sphv_10hv
+ dflw     = (dflw_nld65b_sphv_10hv*(1-fem))
+ dp		   = dp_nld65b_sphv_10hv
+ ecrit     = ecrit_nld65b_sphv_10hv*tfact_ecrit
+ ecorn     = ecorn_nld65b_sphv_10hv*tfact_ecrit
+ du		   = du_nld65b_sphv_10hv
+ tc1		    = tc1_nld65b_sphv_10hv
+ tc2		    = tc2_nld65b_sphv_10hv
+ tc1l     = tc1l_nld65b_sphv_10hv
+ tc2l     = tc2l_nld65b_sphv_10hv
+ tc1w     = (tc1w_nld65b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld65b_sphv_10hv*(1-fem))
+ theacc     = theacc_nld65b_sphv_10hv
+ theacc2     = theacc2_nld65b_sphv_10hv
+ aacc        = aacc_nld65b_sphv_10hv
+ rva		    = rva_nld65b_sphv_10hv
+ dta		    = dta_nld65b_sphv_10hv
+ trj		    = trj_nld65b_sphv_10hv
+ cjarea     = cjarea_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlsti     = cjarea_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ cjlgat     = cjarea_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiarea     = vbiarea_nld65b_sphv_10hv
+ vbisti     = vbisti_nld65b_sphv_10hv
+ vbigat     = vbigat_nld65b_sphv_10hv
+ parea     = parea_nld65b_sphv_10hv
+ psti     = psti_nld65b_sphv_10hv
+ pgat     = pgat_nld65b_sphv_10hv
+ is1area     = is1area_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttarea     = ttarea_nld65b_sphv_10hv
+ is2area     = is2area_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ irarea     = irarea_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1area		  = stis1area_nld65b_sphv_10hv
+ stis2area		  = stis2area_nld65b_sphv_10hv
+ stirarea		 = stirarea_nld65b_sphv_10hv
+ n1area     = n1area_nld65b_sphv_10hv
+ n2area     = n2area_nld65b_sphv_10hv
+ nrarea     = nrarea_nld65b_sphv_10hv
+ is1lsti     = is1area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlsti     = ttlsti_nld65b_sphv_10hv
+ is2lsti     = is2area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ irlsti     = irarea_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1sti		 = stis1sti_nld65b_sphv_10hv
+ stis2sti		 = stis2sti_nld65b_sphv_10hv
+ stirsti     = stirsti_nld65b_sphv_10hv
+ n1sti     = n1sti_nld65b_sphv_10hv
+ n2sti     = n2sti_nld65b_sphv_10hv
+ nrsti     = nrsti_nld65b_sphv_10hv
+ is1lgat     = is1area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlgat     = ttlgat_nld65b_sphv_10hv
+ is2lgat     = is2area_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ irlgat     = irarea_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1gat		 = stis1gat_nld65b_sphv_10hv
+ stis2gat		 = stis2gat_nld65b_sphv_10hv
+ stirgat     = stirgat_nld65b_sphv_10hv
+ n1gat     = n1gat_nld65b_sphv_10hv
+ n2gat     = n2gat_nld65b_sphv_10hv
+ nrgat     = nrgat_nld65b_sphv_10hv
+ cjaread     = cjaread_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlstid     = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ cjlgatd     = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiaread		 = vbiaread_nld65b_sphv_10hv
+ vbistid     = vbistid_nld65b_sphv_10hv
+ vbigatd     = vbigatd_nld65b_sphv_10hv
+ paread     = paread_nld65b_sphv_10hv
+ pstid     = pstid_nld65b_sphv_10hv
+ pgatd     = pgatd_nld65b_sphv_10hv
+ is1aread		 = is1aread_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttaread     = ttaread_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2aread		 = is2aread_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ iraread     = iraread_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1aread		   = stis1aread_nld65b_sphv_10hv
+ stis2aread		   = stis2aread_nld65b_sphv_10hv
+ stiraread		  = stiraread_nld65b_sphv_10hv
+ n1aread     = n1aread_nld65b_sphv_10hv
+ n2aread     = n2aread_nld65b_sphv_10hv
+ nraread     = nraread_nld65b_sphv_10hv
+ is1lstid		 = 0
+ ttlstid     = ttlstid_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lstid		 = 0
+ irlstid     = 0
+ stis1stid		  = stis1stid_nld65b_sphv_10hv
+ stis2stid		  = stis2stid_nld65b_sphv_10hv
+ stirstid		 = stirstid_nld65b_sphv_10hv
+ n1stid     = n1stid_nld65b_sphv_10hv
+ n2stid     = n2stid_nld65b_sphv_10hv
+ nrstid     = nrstid_nld65b_sphv_10hv
+ is1lgatd		 = is1aread_nld65b_sphv_10hv*djunc*delr_is_nld65b_sphv_10hv
+ ttlgatd     = ttlgatd_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lgatd		 = is2aread_nld65b_sphv_10hv*djunc*delr_is2_nld65b_sphv_10hv
+ irlgatd     = iraread_nld65b_sphv_10hv*djunc*delr_ir_nld65b_sphv_10hv
+ stis1gatd		  = stis1gatd_nld65b_sphv_10hv
+ stis2gatd		  = stis2gatd_nld65b_sphv_10hv
+ stirgatd		 = stirgatd_nld65b_sphv_10hv
+ n1gatd     = n1gatd_nld65b_sphv_10hv
+ n2gatd     = n2gatd_nld65b_sphv_10hv
+ nrgatd     = nrgatd_nld65b_sphv_10hv
+ cjaread2		 = cjaread_nld65b_sphv_10hv*delr_cj_nld65b_sphv_10hv
+ cjlstid2		 = cjaread_nld65b_sphv_10hv*djunc*delr_cj_nld65b_sphv_10hv
+ vbiaread2		  = vbiaread2_nld65b_sphv_10hv
+ vbistid2		 = vbistid2_nld65b_sphv_10hv
+ paread2     = paread2_nld65b_sphv_10hv
+ pstid2     = pstid2_nld65b_sphv_10hv
+ is1aread2		  = is1aread_nld65b_sphv_10hv*delr_is_nld65b_sphv_10hv
+ ttaread2		 = ttaread2_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2aread2		  = is2aread_nld65b_sphv_10hv*delr_is2_nld65b_sphv_10hv
+ iraread2		 = iraread_nld65b_sphv_10hv*delr_ir_nld65b_sphv_10hv
+ stis1aread2		    = stis1aread2_nld65b_sphv_10hv
+ stis2aread2		    = stis2aread2_nld65b_sphv_10hv
+ stiraread2		   = stiraread2_nld65b_sphv_10hv
+ n1aread2		 = n1aread2_nld65b_sphv_10hv
+ n2aread2		 = n2aread2_nld65b_sphv_10hv
+ nraread2		 = nraread2_nld65b_sphv_10hv
+ is1lstid2		  = 0
+ ttlstid2		 = ttlstid2_nld65b_sphv_10hv*(1+(3.22/w)*(1-fem))
+ is2lstid2		  = 0
+ irlstid2		 = 0
+ stis1stid2		   = stis1stid2_nld65b_sphv_10hv
+ stis2stid2		   = stis2stid2_nld65b_sphv_10hv
+ stirstid2		  = stirstid2_nld65b_sphv_10hv
+ n1stid2     = n1stid2_nld65b_sphv_10hv
+ n2stid2     = n2stid2_nld65b_sphv_10hv
+ nrstid2     = nrstid2_nld65b_sphv_10hv
+ eais1area		= eais1area_nld65b_sphv_10hv
+ eais2area		= eais2area_nld65b_sphv_10hv
+ eairarea		= eairarea_nld65b_sphv_10hv
+ eais1sti		= eais1sti_nld65b_sphv_10hv
+ eais2sti		= eais2sti_nld65b_sphv_10hv
+ eairsti	  = eairsti_nld65b_sphv_10hv
+ eais1gat		= eais1gat_nld65b_sphv_10hv
+ eais2gat		= eais2gat_nld65b_sphv_10hv
+ eairgat	  = eairgat_nld65b_sphv_10hv
+ eais1aread		= eais1aread_nld65b_sphv_10hv
+ eais2aread		= eais2aread_nld65b_sphv_10hv
+ eairaread		= eairaread_nld65b_sphv_10hv
+ eais1stid		= eais1stid_nld65b_sphv_10hv
+ eais2stid		= eais2stid_nld65b_sphv_10hv
+ eairstid		= eairstid_nld65b_sphv_10hv
+ eais1gatd		= eais1gatd_nld65b_sphv_10hv
+ eais2gatd		= eais2gatd_nld65b_sphv_10hv
+ eairgatd		= eairgatd_nld65b_sphv_10hv
+ eais1aread2		= eais1aread2_nld65b_sphv_10hv
+ eais2aread2		= eais2aread2_nld65b_sphv_10hv
+ eairaread2		= eairaread2_nld65b_sphv_10hv
+ eais1stid2		= eais1stid2_nld65b_sphv_10hv
+ eais2stid2		= eais2stid2_nld65b_sphv_10hv
+ eairstid2		= eairstid2_nld65b_sphv_10hv
+ ikfarea               = ikfarea_nld65b_sphv_10hv
+ ikflsti               = ikfarea_nld65b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld65b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld65b_sphv_10hv
+ stikfsti              = stikfarea_nld65b_sphv_10hv
+ stikfgat              = stikfarea_nld65b_sphv_10hv
+ ikfaread              = ikfaread_nld65b_sphv_10hv*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflstid              = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflgatd              = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikfaread2             = ikfaread_nld65b_sphv_10hv*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ ikflstid2             = ikfaread_nld65b_sphv_10hv*djunc*(w/(w+dwikfaread_nld65b_sphv_10hv*(1-fem)))
+ stikfaread             = stikfaread_nld65b_sphv_10hv
+ stikfstid             = stikfaread_nld65b_sphv_10hv
+ stikfgatd             = stikfaread_nld65b_sphv_10hv
+ stikfaread2            = stikfaread_nld65b_sphv_10hv
+ stikfstid2            = stikfaread_nld65b_sphv_10hv

// ****** ckt elements:
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
dbdbv	  (s d) dbodydrainbv area=(ad_xdr) m=(ng)
rgate     (g intg) resistor r=rgatetot m=ng
xdsub	  (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
//cgd_m1_d (intg d) capacitor c=(cpp_m1_sd*aplyfld_d)
//cgd_act_d (intg d) capacitor c=(cpp_ply_sdt*aplyact_d)

include "./smos10hv_ade_dfrt.scs" section=nld65b_10hv_dfrt
ends

subckt pld45b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    l                              = 0.05
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    selfheat                       = 1
+    mode_rthcth                    = 1

+    nsmm_delr_gox_pld45b_sphv_10hv  = tmp_nsmm_delr_gox_pld45b_sphv_10hv
+    nsmm_dela_dw_pld45b_sphv_10hv   = tmp_nsmm_dela_dw_pld45b_sphv_10hv
+    nsmm_dela_vfb_pld45b_sphv_10hv  = tmp_nsmm_dela_vfb_pld45b_sphv_10hv
+    nsmm_delr_uch_pld45b_sphv_10hv  = tmp_nsmm_delr_uch_pld45b_sphv_10hv
+    nsmm_delr_rshl_pld45b_sphv_10hv = tmp_nsmm_delr_rshl_pld45b_sphv_10hv
+    nsmm_delr_nsub_pld45b_sphv_10hv = tmp_nsmm_delr_nsub_pld45b_sphv_10hv

parameters
+ nde=(0)
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+    ng_dmy         = 2*sti_dummy
+    ngeff          = ng+ng_dmy
+    ndi_eff        = (ngeff/2)
+    nsi_eff        = ((ngeff-2)/2)

// check these values against layout
+    leff                           = (0.432)   // effective channel length from TCAD
+    rnhv_pld45b_10hv               = (1.360*(1-fem))   // radius of the inner nhv corner
+    w2nhv_pld45b_10hv              = (3.100*(1-fem))   // top edge of the active to the top edge of the inner nhv
+    lg2aa_s_pld45b_10hv            = (0.550)   // lateral dimension from the center of the LHS of the source/drain contact to the LHS of the POLY
+    lg2aa_d_pld45b_10hv            = (0.000)
+    lg2g_s_pld45b_10hv             = (1.100)   // use ng=4 on pcell to measure this variable
+    lg2g_d_pld45b_10hv             = (5.490)   // dimension from the inner LHS NHV to the inner RHS NHV
+    wg2aa_se_pld45b_10hv           = (0.000)
+    wg2aa_si_pld45b_10hv           = (0.000)
+    wg2aa_di_pld45b_10hv           = (6.200*(1-fem))   // 2 times of the dimension from the top edge of the active to the inner edge of the NHV
+    wg2trench_pld45b_10hv          = (8.200*(1-fem))   // 2 times of the dimension from the top edge of the active to the inner edge fo the DTI
+    wg2m1_pld45b_10hv              = (1.110*(1-fem))   // 2 times of the dimension from the top edge of the active to the edge fo the M1
+    trench2se_body_pld45b_10hv     = (0.000)
+    trench2se_nobody_pld45b_10hv   = (1.110)   // for devices w/o body, the dimension from external source to DTI
+    trench2de_pld45b_10hv          = (0.000)
+    s2s_inside_pld45b_10hv         = (0.000)   // shared active for sources
+    djunc                          = (2e-6)    // scale does not impact vertically, unit should be in meter
+    lactd                          = (0.690)   // lateral dimension of the drain active region
+    lpoly                          = (0.650)   // drawn poly dimension
+    ldr1                           = (lpoly-leff)   // first drift region or the RHS edge of the NHV to the RHS of the poly edge (i.e., the first part of the split gate)
+    ldr1drawn                      = (lpoly-l)   // drawn first drift region or the rhs edge of the NHV to the RHS of the poly edge (i.e., the first part of the split gate)
+    ldrift                         = (1.500)   // dirft region or the width of the STI or the RHS of the first active to the LHS of the second active
+    lgply2sti                      = (0.300)   // lateral dimension from RHS poly edge to the RHS of the active edge
+    wg2plye_pld45b_10hv            = (6.400*(1-fem))   // 2 times distance of channel top edge to poly top edge
+    lsebc                          = (0.2075)  // length of source edge to body center
+    lsti_g_pld45b_10hv             = (0.650)   // lateral dimension of the side hole in the split gate structure
+    lsti_d_pld45b_10hv             = (2.390)   // lateral dimension of the middle hole in the split gate structure
+    wae2plye_isti_g_pld45b_10hv    = (2.550*(1-fem))   // vertical dimension of the LHS hole in POLY subtract the width of the channcel or w
+    wae2plye_isti_d_pld45b_10hv    = (2.550*(1-fem))   // vertical dimension of the middle hole in POLY subtract the width of the channcel or w
+    lcc2aa_pld45b_10hv             = (0.165)   // lateral dimension from the center of the cont to the source/drain active edge
+    lpoly2m1_pld45b_10hv           = (1.025)   // lateral dimension from the edge of the poly to the edge of the m1 for parasitic cgs due to frindge cap between m1 and m2


//**** calculation for d/b junction:JD and JD2 ********
+    as                             = ((lg2aa_s_pld45b_10hv*(wg2aa_se_pld45b_10hv+w)*nse+lg2g_s_pld45b_10hv*(wg2aa_si_pld45b_10hv+w)*nsi)/ng)
+    ps                             = ((2*((lg2aa_s_pld45b_10hv+wg2aa_se_pld45b_10hv+w)*nse+(lg2g_s_pld45b_10hv+wg2aa_si_pld45b_10hv+w)*nsi))/ng)
+    ad2                            = (w+wg2aa_di_pld45b_10hv)*(ldrift/2+lactd/2)
+    pd2                            = (lactd+ldrift)
+    ad                             = (w+wg2aa_di_pld45b_10hv)*(ldr1+lgply2sti+ldrift/2)
+    pd                             = (2*(ldr1+lgply2sti+ldrift/2)+w+wg2aa_di_pld45b_10hv)
// L and W for trench box calculation wg2trench_pld45b_10hv should be 2*each side; length2 is the LHS edge of the active to the edge of active on the RHS
+    length1                        = (trench2se_nobody_pld45b_10hv*nse+trench2de_pld45b_10hv*nde)
+    length2                        = (l*ngeff+lcc2aa_pld45b_10hv*2+lg2aa_s_pld45b_10hv*nse+lg2g_s_pld45b_10hv*nsi_eff+lg2aa_d_pld45b_10hv*nde+lg2g_d_pld45b_10hv*ndi_eff)
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_pld45b_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
+    fac_c_lstid                    = (0.4)
+    fac_i_lstid                    = (0.0)
+    fac_tt                         = ((w+3.0*(1-fem))/w)

//**** parameters for bv diode  ********
+    dcbv_pld45b_10hv               = (59)

//**** parameters for rgate copied from pld45  ********
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.05)
+    laccdrawn                      = (1.0)
+    lflap                          = (0.85)

//**** multi-ng scaling ****
+    dela_vth_ng		    = (ngeff/(ngeff+0.05)-2/(2+0.05))*1.78*(1-fem)
+    delr_thesato_ng		    = (1+(ngeff/(ngeff+0.05)-2/(2+0.05))*2.0*(1-fem))
+    delr_rshldd_ng		    = (1+(ngeff/(ngeff+0.1)-2/(2+0.1))*0.10*(1-fem))
+    delr_u0_ng 		    = (1+(ngeff/(ngeff+0.1)-2/(2+0.1))*(-0.50)*(1-fem))

//**** geometry input for vfunctions: rthch_think_wafer()********
//**** vfunction:   (rth, cth)=rthcth_thin_wafer(weff, leff, rtc1, rtc2, ctc1, ctc2)
//**** description: calculate thermal resistance rth. inputs in micrometer. outputs in K/W.
//**** weff: effective width in micrometer for thermal injection.
//**** leff: effective length in micrometer for thermal injection.
+ w_heat_um	 =	w				// in unit of micrometer
+ l_heat_um	 =	(l*ng+lcc2aa_pld45b_10hv*2+lg2aa_s_pld45b_10hv*nse+lg2g_s_pld45b_10hv*nsi+lg2aa_d_pld45b_10hv*nde+lg2g_d_pld45b_10hv*ndi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat_um)*(l_heat_um)
+ aspr__1__=max((w_heat_um),(l_heat_um))/min((w_heat_um),(l_heat_um))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f          =      ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld45b_sphv_10hv)*ngeff
+ cth_f          =      ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

+ swshe = selfheat*enable_selfheat
+ rth_f_sw = (swshe>0)*rth_f
+ swdrlin  = (0)
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.8)
+ dw_ecrit = 0.250*(1-fem)

+ tfact_ecrit	=	1+(tc1_ecrit_pld45b_sphv_10hv+tc2_ecrit_pld45b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ tfact_rth_power = 0.0
+ tfact_rth=pow((temp+273.15)/(27+273.15),tfact_rth_power)

//**** calculation for poly over field parasitic cap: cgd_ply_fld ********

+ aply_fld_cgd=(0.5* lg2g_d_pld45b_10hv *(wg2aa_di_pld45b_10hv+w)-(wae2plye_isti_g_pld45b_10hv+w)*lsti_g_pld45b_10hv-0.5*(wae2plye_isti_d_pld45b_10hv+w )*lsti_d_pld45b_10hv-w*ldr1drawn-(2-0.5*pi4models)*rnhv_pld45b_10hv*rnhv_pld45b_10hv)*ng
+ pply_fld_cgd= 0
+ cgd_ply_fld=aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld

+ aply_fld_cgd_dmy=(0.5* lg2g_d_pld45b_10hv *(wg2aa_di_pld45b_10hv+w)-(wae2plye_isti_g_pld45b_10hv+w)*lsti_g_pld45b_10hv-0.5*(wae2plye_isti_d_pld45b_10hv+w )*lsti_d_pld45b_10hv-w*ldr1drawn-(2-0.5*pi4models)*rnhv_pld45b_10hv*rnhv_pld45b_10hv)*ng_dmy
+ pply_fld_cgd_dmy= 0
+ cgd_ply_fld_dmy=aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld


//**** calculation for poly over field parasitic cap: cgs_ply_fld ********
+ aply_fld_cgs=((wg2plye_pld45b_10hv*l)+(0.5*wg2plye_pld45b_10hv-0.5*wg2aa_di_pld45b_10hv)* lg2g_d_pld45b_10hv+2*(rnhv_pld45b_10hv*rnhv_pld45b_10hv*(1.0-0.25*pi4models)))*ng
+ pply_fld_cgs= (wg2plye_pld45b_10hv+lg2g_d_pld45b_10hv)*ng
+ cgs_ply_fld=aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld

//**** calculation for m1 to poly gate capacitance, unit is micron ********
+ cfr_ply_m1_s         = (w+wg2m1_pld45b_10hv)*nom_cfr_m1_ply*ng*(1-lpe)+lpe*1e-19

// metal par cap
+    cgs_pld45b_10hv_m2m1_par      = ((1-lpe)*((l+0.5*lg2g_d_pld45b_10hv-lpoly2m1_pld45b_10hv*2)*ng*cfr_m2_m1)+lpe*1e-20)

// mismatch
//*******************************************************************************************************

//*******************************************************************************************************
// casing
//*******************************************************************************************************
+    delr_tox_pld45b_sphv_10hv      = (nom_delr_tox_pld45b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld45b_sphv_10hv+nsmm_delr_gox_pld45b_sphv_10hv*smm_delr_gox_pld45b_sphv_10hv(leff,w,ng)))
+    dela_dw_pld45b_sphv_10hv       = (nom_dela_dw_pld45b_sphv_10hv+nsig_dela_dw_pld45b_sphv_10hv*sig_dela_dw_pld45b_sphv_10hv+nsmm_dela_dw_pld45b_sphv_10hv*smm_dela_dw_pld45b_sphv_10hv(leff,w,ng))
+    dela_vfb_pld45b_sphv_10hv      = (nom_dela_vfb_pld45b_sphv_10hv+nsig_dela_vfb_pld45b_sphv_10hv*sig_dela_vfb_pld45b_sphv_10hv+nsmm_dela_vfb_pld45b_sphv_10hv*smm_dela_vfb_pld45b_sphv_10hv(leff,w,ng))
+    dela_vtwl_pld45b_sphv_10hv     = (nom_dela_vtwl_pld45b_sphv_10hv+nsig_dela_vtwl_pld45b_sphv_10hv*sig_dela_vtwl_pld45b_sphv_10hv)
+    delr_uch_pld45b_sphv_10hv      = (nom_delr_uch_pld45b_sphv_10hv*(1.0+nsig_delr_uch_pld45b_sphv_10hv*sig_delr_uch_pld45b_sphv_10hv+nsmm_delr_uch_pld45b_sphv_10hv*smm_delr_uch_pld45b_sphv_10hv(leff,w,ng)))
+    delr_rshl_pld45b_sphv_10hv     = (nom_delr_rshl_pld45b_sphv_10hv*(1.0+nsig_delr_rshl_pld45b_sphv_10hv*sig_delr_rshl_pld45b_sphv_10hv)+nsmm_delr_rshl_pld45b_sphv_10hv*smm_delr_rshl_pld45b_sphv_10hv(leff,w,ng))
+    delr_nsub_pld45b_sphv_10hv     = (1+nsmm_delr_nsub_pld45b_sphv_10hv*smm_delr_nsub_pld45b_sphv_10hv(leff,w,ng))
+    delr_cj_pld45b_sphv_10hv       = (nom_delr_cj_pld45b_sphv_10hv*(1.0+nsig_delr_cj_pld45b_sphv_10hv*sig_delr_cj_pld45b_sphv_10hv))
+    delr_is_pld45b_sphv_10hv       = (nom_delr_is_pld45b_sphv_10hv*(1.0+nsig_delr_is_pld45b_sphv_10hv*sig_delr_is_pld45b_sphv_10hv))
+    delr_is2_pld45b_sphv_10hv      = (nom_delr_is2_pld45b_sphv_10hv*(1.0+nsig_delr_is2_pld45b_sphv_10hv*sig_delr_is2_pld45b_sphv_10hv))
+    delr_ir_pld45b_sphv_10hv 	    = (nom_delr_ir_pld45b_sphv_10hv*exp(nsig_delr_ir_pld45b_sphv_10hv*sig_delr_ir_pld45b_sphv_10hv))
+    dela_nwxw_pld45b_sphv_10hv     = (nom_dela_nwxw_pld45b_sphv_10hv+nsig_dela_nwxw_pld45b_sphv_10hv*sig_dela_nwxw_pld45b_sphv_10hv)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld45b_vthratio     = 1.0
+    presto_pld45b_ronratio     = 0.01

//*******************************************************************************************************
// to add one more parasitic poly to m2 Cgs cap (scale with ng)

+ fac_cgd_ply_fld = 0.9
+ delta_cgd_ply_fld = 1e-16
+ delta_cfr_ply_m1_s = 1e-16

cgs_fld (intg s) capacitor c=(cgs_ply_fld)
cgd_fld (intg d) capacitor c=(cgd_ply_fld*fac_cgd_ply_fld+delta_cgd_ply_fld*ng*w)

cgs_ply_m1_s (intg s) capacitor c=(cfr_ply_m1_s+delta_cfr_ply_m1_s*ng)

ccgs_pld45b_10hv_m2m1_par (intg s) capacitor c=cgs_pld45b_10hv_m2m1_par

xdsub (s sub) cdgoptub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=1

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swtcec   = (1)
+ swgedi   = (1)
+ qmc      = (qmc_pld45b_sphv_10hv)
+ lvaro    = (lvaro_pld45b_sphv_10hv)
+ lvarl    = (lvarl_pld45b_sphv_10hv)
+ lvarw    = (lvarw_pld45b_sphv_10hv*(1-fem))
+ lap      = (lap_pld45b_sphv_10hv)
+ wvaro    = (wvaro_pld45b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld45b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld45b_sphv_10hv*(1-fem))
+ wot      = ((wot_pld45b_sphv_10hv+0.5e-6*dela_dw_pld45b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_pld45b_sphv_10hv)
+ dwq      = (dwq_pld45b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld45b_sphv_10hv+dela_vfb_pld45b_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld45b_vthratio+dela_vth_ng)
+ vfbl     = (vfbl_pld45b_sphv_10hv)
+ vfbw     = (vfbw_pld45b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_pld45b_sphv_10hv+dela_vtwl_pld45b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_pld45b_sphv_10hv)
+ stvfbl   = (stvfbl_pld45b_sphv_10hv)
+ stvfbw   = (stvfbw_pld45b_sphv_10hv*(1-fem))
+ stvfblw  = (stvfblw_pld45b_sphv_10hv*(1-fem))
+ toxo     = (toxo_pld45b_sphv_10hv*delr_tox_pld45b_sphv_10hv)
+ epsroxo  = (epsroxo_pld45b_sphv_10hv)
+ nsubo    = (nsubo_pld45b_sphv_10hv*delr_nsub_pld45b_sphv_10hv)
+ nsubw    = (nsubw_pld45b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld45b_sphv_10hv)
+ npck     = (npck_pld45b_sphv_10hv)
+ npckw    = (npckw_pld45b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld45b_sphv_10hv)
+ lpck     = (lpck_pld45b_sphv_10hv)
+ lpckw    = (lpckw_pld45b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld45b_sphv_10hv)
+ fol2     = (fol2_pld45b_sphv_10hv)
+ facneffaco = (facneffaco_pld45b_sphv_10hv)
+ facneffacl = (facneffacl_pld45b_sphv_10hv)
+ facneffacw = (facneffacw_pld45b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld45b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld45b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld45b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld45b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld45b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld45b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld45b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld45b_sphv_10hv)
+ vnsubo   = (vnsubo_pld45b_sphv_10hv)
+ nslpo    = (nslpo_pld45b_sphv_10hv)
+ dnsubo   = (dnsubo_pld45b_sphv_10hv)
+ dphibo   = (dphibo_pld45b_sphv_10hv)
+ dphibl   = (dphibl_pld45b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld45b_sphv_10hv)
+ dphibw   = (dphibw_pld45b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld45b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld45b_sphv_10hv)
+ delvtacl = (delvtacl_pld45b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld45b_sphv_10hv)
+ delvtacw = (delvtacw_pld45b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_pld45b_sphv_10hv*(1-fem))
+ npo      = (npo_pld45b_sphv_10hv)
+ npl      = (npl_pld45b_sphv_10hv)
+ cto      = (cto_pld45b_sphv_10hv)
+ ctl      = (ctl_pld45b_sphv_10hv)
+ ctlexp   = (ctlexp_pld45b_sphv_10hv)
+ ctw      = (ctw_pld45b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld45b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld45b_sphv_10hv)
+ toxovdo  = (toxovdo_pld45b_sphv_10hv)
+ lov      = (lov_pld45b_sphv_10hv)
+ dlovd    = (dlovd_pld45b_sphv_10hv)
+ novo     = (novo_pld45b_sphv_10hv)
+ novdo    = (novdo_pld45b_sphv_10hv)
+ cfl      = (cfl_pld45b_sphv_10hv)
+ cflexp   = (cflexp_pld45b_sphv_10hv)
+ cfw      = (cfw_pld45b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld45b_sphv_10hv)
+ uo       = (uo_pld45b_sphv_10hv*delr_uch_pld45b_sphv_10hv*delr_u0_relimo*delr_u0_ng)
+ fbet1    = (fbet1_pld45b_sphv_10hv)
+ fbet1w   = (fbet1w_pld45b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld45b_sphv_10hv)
+ lp1w     = (lp1w_pld45b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld45b_sphv_10hv)
+ lp2      = (lp2_pld45b_sphv_10hv)
+ betw1    = (betw1_pld45b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld45b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld45b_sphv_10hv)
+ stbeto   = (stbeto_pld45b_sphv_10hv)
+ stbetl   = (stbetl_pld45b_sphv_10hv)
+ stbetw   = (stbetw_pld45b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_pld45b_sphv_10hv*(1-fem))
+ mueo     = (mueo_pld45b_sphv_10hv)
+ muew     = (muew_pld45b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld45b_sphv_10hv)
+ themuo   = (themuo_pld45b_sphv_10hv)
+ stthemuo = (stthemuo_pld45b_sphv_10hv)
+ cso      = (cso_pld45b_sphv_10hv)
+ csl      = (csl_pld45b_sphv_10hv)
+ cslexp   = (cslexp_pld45b_sphv_10hv)
+ csw      = (csw_pld45b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld45b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld45b_sphv_10hv)
+ xcoro    = (xcoro_pld45b_sphv_10hv)
+ xcorl    = (xcorl_pld45b_sphv_10hv)
+ xcorw    = (xcorw_pld45b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_pld45b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_pld45b_sphv_10hv)
+ fetao    = (fetao_pld45b_sphv_10hv)
+ rsw1     = (rsw1_pld45b_sphv_10hv)
+ rsw2     = (rsw2_pld45b_sphv_10hv*(1-fem))
+ strso    = (strso_pld45b_sphv_10hv)
+ rsbo     = (rsbo_pld45b_sphv_10hv)
+ rsgo     = (rsgo_pld45b_sphv_10hv)
+ thesato  = (thesato_pld45b_sphv_10hv*delr_thesato_ng)
+ thesatl  = (thesatl_pld45b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld45b_sphv_10hv)
+ thesatw  = (thesatw_pld45b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_pld45b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld45b_sphv_10hv)
+ stthesatl = (stthesatl_pld45b_sphv_10hv)
+ stthesatw = (stthesatw_pld45b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_pld45b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_pld45b_sphv_10hv)
+ thesatgo = (thesatgo_pld45b_sphv_10hv)
+ thesatgl = (thesatgl_pld45b_sphv_10hv)
+ thesatgw = (thesatgw_pld45b_sphv_10hv*(1-fem))
+ vdscale  = (vdscale_pld45b_sphv_10hv)
+ vdscaleb = (vdscaleb_pld45b_sphv_10hv)
+ stvdscale = (stvdscale_pld45b_sphv_10hv)
+ axo      = (axo_pld45b_sphv_10hv)
+ axl      = (axl_pld45b_sphv_10hv)
+ alpl     = (alpl_pld45b_sphv_10hv)
+ alplexp  = (alplexp_pld45b_sphv_10hv)
+ alpw     = (alpw_pld45b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld45b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld45b_sphv_10hv)
+ alp1l2   = (alp1l2_pld45b_sphv_10hv)
+ alp1w    = (alp1w_pld45b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld45b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld45b_sphv_10hv)
+ alp2l2   = (alp2l2_pld45b_sphv_10hv)
+ alp2w    = (alp2w_pld45b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld45b_sphv_10hv)
+ a1o      = (a1o_pld45b_sphv_10hv)
+ a1l      = (a1l_pld45b_sphv_10hv)
+ a1w      = (a1w_pld45b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld45b_sphv_10hv)
+ sta2o    = (sta2o_pld45b_sphv_10hv)
+ a3o      = (a3o_pld45b_sphv_10hv)
+ a3l      = (a3l_pld45b_sphv_10hv)
+ a3w      = (a3w_pld45b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld45b_sphv_10hv)
+ a4l      = (a4l_pld45b_sphv_10hv)
+ a4w      = (a4w_pld45b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld45b_sphv_10hv)
+ iginvlw  = (iginvlw_pld45b_sphv_10hv)
+ igovw    = (igovw_pld45b_sphv_10hv)
+ igovdw   = (igovdw_pld45b_sphv_10hv)
+ stigo    = (stigo_pld45b_sphv_10hv)
+ gc2o     = (gc2o_pld45b_sphv_10hv)
+ gc3o     = (gc3o_pld45b_sphv_10hv)
+ chibo    = (chibo_pld45b_sphv_10hv)
+ agidlw   = (agidlw_pld45b_sphv_10hv)
+ agidldw  = (agidldw_pld45b_sphv_10hv)
+ bgidlo   = (bgidlo_pld45b_sphv_10hv)
+ bgidldo  = (bgidldo_pld45b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld45b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld45b_sphv_10hv)
+ cgidlo   = (cgidlo_pld45b_sphv_10hv)
+ cgidldo  = (cgidldo_pld45b_sphv_10hv)
+ cgbovl   = (cgbovl_pld45b_sphv_10hv)
+ cfrw     = (cfrw_pld45b_sphv_10hv)
+ cfrdw    = (cfrdw_pld45b_sphv_10hv)
+ fnto     = (fnto_pld45b_sphv_10hv)
+ nfalw    = (nfalw_pld45b_sphv_10hv)
+ nfblw    = (nfblw_pld45b_sphv_10hv)
+ nfclw    = (nfclw_pld45b_sphv_10hv)
+ efo      = (efo_pld45b_sphv_10hv)
+ lintnoi  = (lintnoi_pld45b_sphv_10hv)
+ alpnoi   = (alpnoi_pld45b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld45b_sphv_10hv)
+ kvthowel = (kvthowel_pld45b_sphv_10hv)
+ kvthowew = (kvthowew_pld45b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_pld45b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_pld45b_sphv_10hv)
+ kuowel   = (kuowel_pld45b_sphv_10hv)
+ kuowew   = (kuowew_pld45b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_pld45b_sphv_10hv*(1-fem))
+ rgo      = (rgo_pld45b_sphv_10hv)
+ rsh      = (rsh_pld45b_sphv_10hv)
+ rbulko   = (rbulko_pld45b_sphv_10hv)
+ rwello   = (rwello_pld45b_sphv_10hv)
+ rjunso   = (rjunso_pld45b_sphv_10hv/(w+dwrjunso_pld45b_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_pld45b_sphv_10hv/(w+dwrjundo_pld45b_sphv_10hv*(1-fem)))
+ rint     = (rint_pld45b_sphv_10hv)
+ rvpoly   = (rvpoly_pld45b_sphv_10hv)
+ rshg     = (rshg_pld45b_sphv_10hv)
+ dlsil    = (dlsil_pld45b_sphv_10hv)
+ saref    = (saref_pld45b_sphv_10hv)
+ sbref    = (sbref_pld45b_sphv_10hv)
+ wlod     = (wlod_pld45b_sphv_10hv*(1-fem))
+ kuo      = (kuo_pld45b_sphv_10hv)
+ kvsat    = (kvsat_pld45b_sphv_10hv)
+ tkuo     = (tkuo_pld45b_sphv_10hv)
+ lkuo     = (lkuo_pld45b_sphv_10hv)
+ wkuo     = (wkuo_pld45b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_pld45b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_pld45b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld45b_sphv_10hv)
+ kvtho    = (kvtho_pld45b_sphv_10hv)
+ lkvtho   = (lkvtho_pld45b_sphv_10hv)
+ wkvtho   = (wkvtho_pld45b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_pld45b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_pld45b_sphv_10hv)
+ wlodvth  = (wlodvth_pld45b_sphv_10hv)
+ stetao   = (stetao_pld45b_sphv_10hv)
+ lodetao  = (lodetao_pld45b_sphv_10hv)
+ scref    = (scref_pld45b_sphv_10hv)
+ web      = (web_pld45b_sphv_10hv)
+ wec      = (wec_pld45b_sphv_10hv)
+ adr1o    = (adr1o_pld45b_sphv_10hv)
+ adr1l    = (adr1l_pld45b_sphv_10hv)
+ adr1w    = (adr1w_pld45b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_pld45b_sphv_10hv)
+ stadr2o  = (stadr2o_pld45b_sphv_10hv)
+ adr3o    = (adr3o_pld45b_sphv_10hv)
+ adr3l    = (adr3l_pld45b_sphv_10hv)
+ adr3w    = (adr3w_pld45b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_pld45b_sphv_10hv)
+ adr4l    = (adr4l_pld45b_sphv_10hv)
+ adr4w    = (adr4w_pld45b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_pld45b_sphv_10hv)
+ adr5l    = (adr5l_pld45b_sphv_10hv)
+ adr5w    = (adr5w_pld45b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_pld45b_sphv_10hv)
+ bidr1l   = (bidr1l_pld45b_sphv_10hv)
+ bidr1w   = (bidr1w_pld45b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_pld45b_sphv_10hv)
+ bidr2w   = (bidr2w_pld45b_sphv_10hv*(1-fem))
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_pld45b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_pld45b_sphv_10hv*delr_rshldd_ng*delr_rshl_pld45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld45b_ronratio))*fac_rshldd)
+ xw       = (xw_pld45b_sphv_10hv*(1-fem))
+ nwxw     = ((nwxw_pld45b_sphv_10hv+1e-12*dela_nwxw_pld45b_sphv_10hv)*(1-fem))
+ xl       = (xl_pld45b_sphv_10hv)
+ xlw      = (xlw_pld45b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld45b_sphv_10hv)
+ nst      = (nst_pld45b_sphv_10hv)
+ ats      = (ats_pld45b_sphv_10hv)
+ dfinf    = (dfinf_pld45b_sphv_10hv)
+ dfw      = (dfw_pld45b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld45b_sphv_10hv)
+ dflw     = (dflw_pld45b_sphv_10hv*(1-fem))
+ dp       = (dp_pld45b_sphv_10hv)
+ ecrit    = (ecrit_pld45b_sphv_10hv*tfact_ecrit)*(w+dw_ecrit)/w
+ ecorn    = (ecorn_pld45b_sphv_10hv*tfact_ecrit)*(w+dw_ecrit)/w
+ du       = (du_pld45b_sphv_10hv)
+ tc1      = (tc1_pld45b_sphv_10hv)
+ tc2      = (tc2_pld45b_sphv_10hv)
+ tc1l     = (tc1l_pld45b_sphv_10hv)
+ tc2l     = (tc2l_pld45b_sphv_10hv)
+ tc1w     = (tc1w_pld45b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_pld45b_sphv_10hv*(1-fem))
+ theacc   = (theacc_pld45b_sphv_10hv)
+ theacc2  = (theacc2_pld45b_sphv_10hv)
+ aacc     = (aacc_pld45b_sphv_10hv)
+ rva      = (rva_pld45b_sphv_10hv)
+ dta      = (dta_pld45b_sphv_10hv)
+ trj      = (trj_pld45b_sphv_10hv)
+ cjarea   = (cjarea_pld45b_sphv_10hv)
+ cjlsti   = (cjlsti_pld45b_sphv_10hv)
+ cjlgat   = (cjlgat_pld45b_sphv_10hv)
+ vbiarea  = (vbiarea_pld45b_sphv_10hv)
+ vbisti   = (vbisti_pld45b_sphv_10hv)
+ vbigat   = (vbigat_pld45b_sphv_10hv)
+ parea    = (parea_pld45b_sphv_10hv)
+ psti     = (psti_pld45b_sphv_10hv)
+ pgat     = (pgat_pld45b_sphv_10hv)
+ is1area  = (is1area_pld45b_sphv_10hv)
+ ttarea   = (ttarea_pld45b_sphv_10hv)
+ is2area  = (is2area_pld45b_sphv_10hv)
+ irarea   = (irarea_pld45b_sphv_10hv)
+ stis1area = (stis1area_pld45b_sphv_10hv)
+ stis2area = (stis2area_pld45b_sphv_10hv)
+ stirarea = (stirarea_pld45b_sphv_10hv)
+ n1area   = (n1area_pld45b_sphv_10hv)
+ n2area   = (n2area_pld45b_sphv_10hv)
+ nrarea   = (nrarea_pld45b_sphv_10hv)
+ is1lsti  = (is1lsti_pld45b_sphv_10hv)
+ ttlsti   = (ttlsti_pld45b_sphv_10hv)
+ is2lsti  = (is2lsti_pld45b_sphv_10hv)
+ irlsti   = (irlsti_pld45b_sphv_10hv)
+ stis1sti = (stis1sti_pld45b_sphv_10hv)
+ stis2sti = (stis2sti_pld45b_sphv_10hv)
+ stirsti  = (stirsti_pld45b_sphv_10hv)
+ n1sti    = (n1sti_pld45b_sphv_10hv)
+ n2sti    = (n2sti_pld45b_sphv_10hv)
+ nrsti    = (nrsti_pld45b_sphv_10hv)
+ is1lgat  = (is1lgat_pld45b_sphv_10hv)
+ ttlgat   = (ttlgat_pld45b_sphv_10hv)
+ is2lgat  = (is2lgat_pld45b_sphv_10hv)
+ irlgat   = (irlgat_pld45b_sphv_10hv)
+ stis1gat = (stis1gat_pld45b_sphv_10hv)
+ stis2gat = (stis2gat_pld45b_sphv_10hv)
+ stirgat  = (stirgat_pld45b_sphv_10hv)
+ n1gat    = (n1gat_pld45b_sphv_10hv)
+ n2gat    = (n2gat_pld45b_sphv_10hv)
+ nrgat    = (nrgat_pld45b_sphv_10hv)
+ cjaread  = (cjaread_pld45b_sphv_10hv*delr_cj_pld45b_sphv_10hv)
+ cjlstid  = (cjaread_pld45b_sphv_10hv*djunc*delr_cj_pld45b_sphv_10hv*fac_c_lstid)
+ cjlgatd  = (cjaread_pld45b_sphv_10hv*djunc*delr_cj_pld45b_sphv_10hv)
+ vbiaread = (vbiaread_pld45b_sphv_10hv)
+ vbistid  = (vbistid_pld45b_sphv_10hv)
+ vbigatd  = (vbigatd_pld45b_sphv_10hv)
+ paread   = (paread_pld45b_sphv_10hv)
+ pstid    = (pstid_pld45b_sphv_10hv)
+ pgatd    = (pgatd_pld45b_sphv_10hv)
+ is1aread = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttaread  = (ttaread_pld45b_sphv_10hv*fac_tt)
+ is2aread = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ iraread  = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1aread = (stis1aread_pld45b_sphv_10hv)
+ stis2aread = (stis2aread_pld45b_sphv_10hv)
+ stiraread = (stiraread_pld45b_sphv_10hv)
+ n1aread  = (n1aread_pld45b_sphv_10hv)
+ n2aread  = (n2aread_pld45b_sphv_10hv)
+ nraread  = (nraread_pld45b_sphv_10hv)
+ is1lstid = (is1aread_pld45b_sphv_10hv*djunc*delr_is_pld45b_sphv_10hv*fac_i_lstid)
+ ttlstid  = (ttlstid_pld45b_sphv_10hv*fac_tt)
+ is2lstid = (is2aread_pld45b_sphv_10hv*djunc*delr_is2_pld45b_sphv_10hv*fac_i_lstid)
+ irlstid  = (iraread_pld45b_sphv_10hv*djunc*delr_ir_pld45b_sphv_10hv*fac_i_lstid)
+ stis1stid = (stis1stid_pld45b_sphv_10hv)
+ stis2stid = (stis2stid_pld45b_sphv_10hv)
+ stirstid = (stirstid_pld45b_sphv_10hv)
+ n1stid   = (n1stid_pld45b_sphv_10hv)
+ n2stid   = (n2stid_pld45b_sphv_10hv)
+ nrstid   = (nrstid_pld45b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttlgatd  = (ttlgatd_pld45b_sphv_10hv*fac_tt)
+ is2lgatd = (is2lgatd_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ irlgatd  = (irlgatd_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1gatd = (stis1gatd_pld45b_sphv_10hv)
+ stis2gatd = (stis2gatd_pld45b_sphv_10hv)
+ stirgatd = (stirgatd_pld45b_sphv_10hv)
+ n1gatd   = (n1gatd_pld45b_sphv_10hv)
+ n2gatd   = (n2gatd_pld45b_sphv_10hv)
+ nrgatd   = (nrgatd_pld45b_sphv_10hv)
+ cjaread2 = (cjaread_pld45b_sphv_10hv)
+ cjlstid2 = (cjaread_pld45b_sphv_10hv*djunc*fac_c_lstid)
+ vbiaread2 = (vbiaread2_pld45b_sphv_10hv)
+ vbistid2 = (vbistid2_pld45b_sphv_10hv)
+ paread2  = (paread2_pld45b_sphv_10hv)
+ pstid2   = (pstid2_pld45b_sphv_10hv)
+ is1aread2 = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv)
+ ttaread2 = (ttaread2_pld45b_sphv_10hv*fac_tt)
+ is2aread2 = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv)
+ iraread2 = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld45b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld45b_sphv_10hv)
+ stiraread2 = (stiraread2_pld45b_sphv_10hv)
+ n1aread2 = (n1aread2_pld45b_sphv_10hv)
+ n2aread2 = (n2aread2_pld45b_sphv_10hv)
+ nraread2 = (nraread2_pld45b_sphv_10hv)
+ is1lstid2 = (is1aread_pld45b_sphv_10hv*delr_is_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ ttlstid2 = (ttlstid2_pld45b_sphv_10hv*fac_tt)
+ is2lstid2 = (is2aread_pld45b_sphv_10hv*delr_is2_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ irlstid2 = (iraread_pld45b_sphv_10hv*delr_ir_pld45b_sphv_10hv*djunc*fac_i_lstid)
+ stis1stid2 = (stis1stid2_pld45b_sphv_10hv)
+ stis2stid2 = (stis2stid2_pld45b_sphv_10hv)
+ stirstid2 = (stirstid2_pld45b_sphv_10hv)
+ n1stid2  = (n1stid2_pld45b_sphv_10hv)
+ n2stid2  = (n2stid2_pld45b_sphv_10hv)
+ nrstid2  = (nrstid2_pld45b_sphv_10hv)
+ eais1area  = (eais1area_pld45b_sphv_10hv)
+ eais2area  = (eais2area_pld45b_sphv_10hv)
+ eairarea   = (eairarea_pld45b_sphv_10hv)
+ eais1sti   = (eais1sti_pld45b_sphv_10hv)
+ eais2sti   = (eais2sti_pld45b_sphv_10hv)
+ eairsti    = (eairsti_pld45b_sphv_10hv)
+ eais1gat   = (eais1gat_pld45b_sphv_10hv)
+ eais2gat   = (eais2gat_pld45b_sphv_10hv)
+ eairgat    = (eairgat_pld45b_sphv_10hv)
+ eais1aread = (eais1aread_pld45b_sphv_10hv)
+ eais2aread = (eais2aread_pld45b_sphv_10hv)
+ eairaread  = (eairaread_pld45b_sphv_10hv)
+ eais1stid  = (eais1stid_pld45b_sphv_10hv)
+ eais2stid  = (eais2stid_pld45b_sphv_10hv)
+ eairstid   = (eairstid_pld45b_sphv_10hv)
+ eais1gatd  = (eais1gatd_pld45b_sphv_10hv)
+ eais2gatd  = (eais2gatd_pld45b_sphv_10hv)
+ eairgatd    = (eairgat_pld45b_sphv_10hv)
+ eais1aread2 = (eais1aread_pld45b_sphv_10hv)
+ eais2aread2 = (eais2aread_pld45b_sphv_10hv)
+ eairaread2  = (eairaread_pld45b_sphv_10hv)
+ eais1stid2  = (eais1stid_pld45b_sphv_10hv)
+ eais2stid2  = (eais2stid_pld45b_sphv_10hv)
+ eairstid2   = (eairstid_pld45b_sphv_10hv)
+ ctgo        = (ctgo_pld45b_sphv_10hv)
+ xvsat       = (xvsat_pld45b_sphv_10hv)
+ ikfarea     = (ikfarea_pld45b_sphv_10hv)
+ ikflsti     = (ikfarea_pld45b_sphv_10hv*djunc)
+ ikflgat     = (ikfarea_pld45b_sphv_10hv*djunc)
+ stikfarea   = (stikfarea_pld45b_sphv_10hv)
+ stikfsti   = (stikfarea_pld45b_sphv_10hv)
+ stikfgat   = (stikfarea_pld45b_sphv_10hv)
+ ikfaread    = (ikfaread_pld45b_sphv_10hv*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflstid    = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflgatd    = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikfaread2   = (ikfaread_pld45b_sphv_10hv*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ ikflstid2   = (ikfaread_pld45b_sphv_10hv*djunc*(w/(w+dwikfaread_pld45b_sphv_10hv*(1-fem))))
+ stikfaread  = (stikfaread_pld45b_sphv_10hv)
+ stikfstid  = (stikfaread_pld45b_sphv_10hv)
+ stikfgatd  = (stikfaread_pld45b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld45b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld45b_sphv_10hv)

model dbodybv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (dcbv_pld45b_10hv+bvdss_shift)
+ ibv      = (1e-5/1e-12)

mpowermos (d intg s s dtemp) sphvt_simkit w=w l=leff ldrift=ldrift wdrift=w ldr1=ldr1 mult=ng ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2
rgate (g intg) resistor r=(rply*((w+2*3.325)/((lchdrawn+laccdrawn+lflap)*3*ng)))
dbodybv (d rd) dbodybv area=((ad+ad2)*ngeff)
rlimit (rd s) resistor r=0.01

if (ng_dmy >= 2) {

cgd_fld_dmy (s d) capacitor c=(cgd_ply_fld_dmy*fac_cgd_ply_fld+delta_cgd_ply_fld*ng_dmy*w)
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=leff ldrift=ldrift wdrift=w ldr1=ldr1 mult=ng_dmy ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2

}



include "./smos10hv_ade_dfrt.scs" section=pld45b_10hv_dfrt
ends

subckt pld30b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy			    = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1

parameters
//* parameters to control self-heating model
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
//* switch for simple model
+    swdrlin  = (0)
+    fac_rshldd                     = ((swdrlin==0)+(swdrlin==2)*0.848)
//* geometry parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2.0)
+    nd                             = (ng/2.0)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
//* dummy parameters
+    ng_dmy                         = (2*sti_dummy)
+    ng_eff                         = (ng+ng_dmy)
+    ndi_eff                        = (ng_eff/2)
+    nsi_eff                        = ((ng_eff-2)/2)
//* geometry parameters
+    l                              = (0.5)
+    lacts                          = (0.66)
+    lactd                          = (0.36)
+    ldr1                           = (0.25)
+    ldrift                         = (0.85)
+    lgply2act                      = (0.2)
+    lg2pepi_s                      = (1.77)
+    lg2pepi_d                      = (0)
+    lp2p_d                         = (2.96)
+    lp2p_s                         = (0.99)
+    wnwx                           = (1.4)
+    wdrift                         = (w)
+    wd2g                           = (0.6)
+    wd2pepi                        = (2.85)
+    wplyend                        = (1.5)
+    djunc                          = (2.5e-06)      // vertical, not scalable
//* junction
+    as                             = (lacts*w)
+    ps                             = ((lacts+w)*2)
+    ad                             = (((ldr1+lgply2act)+ldrift*0.5)*(w+2*wnwx*(1-fem)))
+    pd                             = ((2*((ldr1+lgply2act)+ldrift*0.5)+(w+2*wnwx*(1-fem))))
+    ad2                            = ((lactd+ldrift)*0.5*(w+2*wnwx*(1-fem)))
+    pd2                            = ((lactd+ldrift))
//* box cap
+    xiso                           = (lg2pepi_s*nse+lg2pepi_d*nde+l*ng_eff+lp2p_d*ndi_eff+lp2p_s*nsi_eff)
+    yiso                           = (w+2*wd2pepi*(1-fem))
+    aiso                           = (xiso*yiso)
+    piso                           = (2*(xiso+yiso))
//* parasitic cgd_ply_fld and cgs_ply_fld
+    ca_ply_fld                     = (cpp_ply_fld)
+    ahole_nhv_d                    = (lp2p_d*(w+2*wnwx*(1-fem)))
+    ahole_noply_d                  = ((w+2*wd2g*(1-fem))*(0.5+1.06+0.5))
+    aldr1_d                        = ((ldr1*w)*2)
+    aplyfld_d                      = ((ahole_nhv_d-ahole_noply_d-aldr1_d)/2.0)
+    aply_s                         = ((lp2p_d+2*l)*(w+2*wd2g*(1-fem)+2*wplyend*(1-fem)))
+    ach_s                          = ((l*w)*2)
+    aplyfld_s                      = ((aply_s-ahole_nhv_d-ach_s)/2.0*(1-fem)+1e-18*fem)
+    cgd_ply_fld                    = (ca_ply_fld*aplyfld_d)
+    cgs_ply_fld                    = (ca_ply_fld*aplyfld_s)
//* gate resistance, copy from pld30.
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rgate                          = ((rply*((w+2*1.875*(1-fem))/((l+ldr1)*3*ng))))
//* BV diode
+    dcbv_pld30b_sphv_10hv          = (40)
//* multi-ng
+    dela_vth_ng                    = (ng_eff/(ng_eff+1.2*(1-fem))-2/(2+1.2))*0.025
+    delr_thesato_ng                = (1+(ng_eff/(ng_eff+0.1*(1-fem))-2/(2+0.1))*4.5)
+    delr_thesatw_ng                = (1+(ng_eff/(ng_eff+0.1*(1-fem))-2/(2+0.1))*3)
//* self_heating
+    w_heat                         = w
+    l_heat                         = (l*ng+lp2p_d*ndi+lp2p_s*nsi+lacts*nse)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f                          = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld30b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld30b_sphv_10hv)*ng_eff
+    cth_f                          = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff
+    tfact_ecrit                    = (1+(tc1_ecrit_pld30b_sphv_10hv+tc2_ecrit_pld30b_sphv_10hv*delt)*delt)
//* reliability parameters
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld30b_vthratio     = 1.0
+    presto_pld30b_ronratio     = 0.01
//* mismatch
+    nsmm_dela_vfbo_pld30b_sphv_10hv   = tmp_nsmm_dela_vfbo_pld30b_sphv_10hv
+    nsmm_delr_uo_pld30b_sphv_10hv     = tmp_nsmm_delr_uo_pld30b_sphv_10hv
+    nsmm_delr_rshldd_pld30b_sphv_10hv = tmp_nsmm_delr_rshldd_pld30b_sphv_10hv
+    tc_rshldd_mm                      = (1+(temp-27)*(-1.3e-3))
+    tc_uo_mm                          = (1+(temp-27)*(5e-3))
//* casing
+    delr_tox_pld30b_sphv_10hv      = (nom_delr_tox_pld30b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld30b_sphv_10hv))
+    dela_vfbo_pld30b_sphv_10hv     = (nom_dela_vfbo_pld30b_sphv_10hv+nsig_dela_vfbo_pld30b_sphv_10hv*sig_dela_vfbo_pld30b_sphv_10hv+nsmm_dela_vfbo_pld30b_sphv_10hv*smm_dela_vfbo_pld30b_sphv_10hv(l,w,ng))
+    dela_vfbw_pld30b_sphv_10hv     = (nom_dela_vfbw_pld30b_sphv_10hv+nsig_dela_vfbw_pld30b_sphv_10hv*sig_dela_vfbw_pld30b_sphv_10hv)
+    delr_rshldd_pld30b_sphv_10hv   = (nom_delr_rshldd_pld30b_sphv_10hv*(1.0+nsig_delr_rshldd_pld30b_sphv_10hv*sig_delr_rshldd_pld30b_sphv_10hv)+tc_rshldd_mm*nsmm_delr_rshldd_pld30b_sphv_10hv*smm_delr_rshldd_pld30b_sphv_10hv(l,w,ng))
+    dela_nwxw_pld30b_sphv_10hv     = (nom_dela_nwxw_pld30b_sphv_10hv+nsig_dela_nwxw_pld30b_sphv_10hv*sig_dela_nwxw_pld30b_sphv_10hv)
+    dela_vdscale_pld30b_sphv_10hv  = (nom_dela_vdscale_pld30b_sphv_10hv+nsig_dela_vdscale_pld30b_sphv_10hv*sig_dela_vdscale_pld30b_sphv_10hv)
+    dela_vdscalew_pld30b_sphv_10hv = (nom_dela_vdscalew_pld30b_sphv_10hv+nsig_dela_vdscalew_pld30b_sphv_10hv*sig_dela_vdscalew_pld30b_sphv_10hv)
+    delr_uo_pld30b_sphv_10hv       = (1.0+tc_uo_mm*nsmm_delr_uo_pld30b_sphv_10hv*smm_delr_uo_pld30b_sphv_10hv(l,w,ng))
+    delr_cj_pld30b_sphv_10hv	    = (nom_delr_cj_pld30b_sphv_10hv*(1.0+nsig_delr_cj_pld30b_sphv_10hv*sig_delr_cj_pld30b_sphv_10hv))
+    delr_is_pld30b_sphv_10hv	    = (nom_delr_is_pld30b_sphv_10hv*exp(nsig_delr_is_pld30b_sphv_10hv*sig_delr_is_pld30b_sphv_10hv))
+    delr_is2_pld30b_sphv_10hv	    = (nom_delr_is2_pld30b_sphv_10hv*exp(nsig_delr_is2_pld30b_sphv_10hv*sig_delr_is2_pld30b_sphv_10hv))
+    delr_ir_pld30b_sphv_10hv	    = (nom_delr_ir_pld30b_sphv_10hv*exp(nsig_delr_ir_pld30b_sphv_10hv*sig_delr_ir_pld30b_sphv_10hv))

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ vdscale  = ((vdscale_pld30b_sphv_10hv+dela_vdscale_pld30b_sphv_10hv)+(vdscalew_pld30b_sphv_10hv+dela_vdscalew_pld30b_sphv_10hv)/w*(1-fem))
+ vdscaleb = (vdscaleb_pld30b_sphv_10hv)
+ stvdscale= (stvdscale_pld30b_sphv_10hv)
+ ctgo     = (0)
+ ctbo     = (0)
+ stcto    = (0)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swgedi   = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec   = (1)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ xvsat    = (xvsat_pld30b_sphv_10hv)
+ qmc      = (qmc_pld30b_sphv_10hv)
+ lvaro    = (lvaro_pld30b_sphv_10hv)
+ lvarl    = (lvarl_pld30b_sphv_10hv)
+ lvarw    = (lvarw_pld30b_sphv_10hv*(1-fem))
+ lap      = (lap_pld30b_sphv_10hv)
+ wvaro    = (wvaro_pld30b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld30b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld30b_sphv_10hv*(1-fem))
+ wot      = (wot_pld30b_sphv_10hv*(1-fem))
+ dlq      = (dlq_pld30b_sphv_10hv)
+ dwq      = (dwq_pld30b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld30b_sphv_10hv+dela_vfbo_pld30b_sphv_10hv+dela_vth_ng+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld30b_vthratio)
+ vfbl     = (vfbl_pld30b_sphv_10hv)
+ vfbw     = ((vfbw_pld30b_sphv_10hv+dela_vfbw_pld30b_sphv_10hv)*(1-fem))
+ vfblw    = (vfblw_pld30b_sphv_10hv*(1-fem))
+ stvfbo   = (stvfbo_pld30b_sphv_10hv)
+ stvfbl   = (stvfbl_pld30b_sphv_10hv)
+ stvfbw   = (stvfbw_pld30b_sphv_10hv*(1-fem))
+ stvfblw  = (stvfblw_pld30b_sphv_10hv*(1-fem))
+ toxo     = (toxo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ epsroxo  = (epsroxo_pld30b_sphv_10hv)
+ nsubo    = (nsubo_pld30b_sphv_10hv)
+ nsubw    = (nsubw_pld30b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld30b_sphv_10hv)
+ npck     = (npck_pld30b_sphv_10hv)
+ npckw    = (npckw_pld30b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld30b_sphv_10hv)
+ lpck     = (lpck_pld30b_sphv_10hv)
+ lpckw    = (lpckw_pld30b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld30b_sphv_10hv)
+ fol2     = (fol2_pld30b_sphv_10hv)
+ facneffaco = (facneffaco_pld30b_sphv_10hv)
+ facneffacl = (facneffacl_pld30b_sphv_10hv)
+ facneffacw = (facneffacw_pld30b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld30b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld30b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld30b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld30b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld30b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld30b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld30b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld30b_sphv_10hv)
+ vnsubo   = (vnsubo_pld30b_sphv_10hv)
+ nslpo    = (nslpo_pld30b_sphv_10hv)
+ dnsubo   = (dnsubo_pld30b_sphv_10hv)
+ dphibo   = (dphibo_pld30b_sphv_10hv)
+ dphibl   = (dphibl_pld30b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld30b_sphv_10hv)
+ dphibw   = (dphibw_pld30b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld30b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld30b_sphv_10hv)
+ delvtacl = (delvtacl_pld30b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld30b_sphv_10hv)
+ delvtacw = (delvtacw_pld30b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_pld30b_sphv_10hv*(1-fem))
+ npo      = (npo_pld30b_sphv_10hv)
+ npl      = (npl_pld30b_sphv_10hv)
+ cto      = (cto_pld30b_sphv_10hv)
+ ctl      = (ctl_pld30b_sphv_10hv)
+ ctlexp   = (ctlexp_pld30b_sphv_10hv)
+ ctw      = (ctw_pld30b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld30b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ toxovdo  = (toxovdo_pld30b_sphv_10hv*delr_tox_pld30b_sphv_10hv)
+ lov      = (lov_pld30b_sphv_10hv)
+ dlovd    = (dlovd_pld30b_sphv_10hv)
+ novo     = (novo_pld30b_sphv_10hv)
+ novdo    = (novdo_pld30b_sphv_10hv)
+ cfl      = (cfl_pld30b_sphv_10hv)
+ cflexp   = (cflexp_pld30b_sphv_10hv)
+ cfw      = (cfw_pld30b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld30b_sphv_10hv)
+ uo       = (uo_pld30b_sphv_10hv*delr_uo_pld30b_sphv_10hv*delr_u0_relimo)
+ fbet1    = (fbet1_pld30b_sphv_10hv)
+ fbet1w   = (fbet1w_pld30b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld30b_sphv_10hv)
+ lp1w     = (lp1w_pld30b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld30b_sphv_10hv)
+ lp2      = (lp2_pld30b_sphv_10hv)
+ betw1    = (betw1_pld30b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld30b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld30b_sphv_10hv)
+ stbeto   = (stbeto_pld30b_sphv_10hv)
+ stbetl   = (stbetl_pld30b_sphv_10hv)
+ stbetw   = (stbetw_pld30b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_pld30b_sphv_10hv*(1-fem))
+ mueo     = (mueo_pld30b_sphv_10hv)
+ muew     = (muew_pld30b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld30b_sphv_10hv)
+ themuo   = (themuo_pld30b_sphv_10hv)
+ stthemuo = (stthemuo_pld30b_sphv_10hv)
+ cso      = (cso_pld30b_sphv_10hv)
+ csl      = (csl_pld30b_sphv_10hv)
+ cslexp   = (cslexp_pld30b_sphv_10hv)
+ csw      = (csw_pld30b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld30b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld30b_sphv_10hv)
+ xcoro    = (xcoro_pld30b_sphv_10hv)
+ xcorl    = (xcorl_pld30b_sphv_10hv)
+ xcorw    = (xcorw_pld30b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_pld30b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_pld30b_sphv_10hv)
+ fetao    = (fetao_pld30b_sphv_10hv)
+ rsw1     = (rsw1_pld30b_sphv_10hv*(1-fem))
+ rsw2     = (rsw2_pld30b_sphv_10hv*(1-fem))
+ strso    = (strso_pld30b_sphv_10hv)
+ rsbo     = (rsbo_pld30b_sphv_10hv)
+ rsgo     = (rsgo_pld30b_sphv_10hv)
+ thesato  = (thesato_pld30b_sphv_10hv*delr_thesato_ng)
+ thesatl  = (thesatl_pld30b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld30b_sphv_10hv)
+ thesatw  = (thesatw_pld30b_sphv_10hv*delr_thesatw_ng*(1-fem))
+ thesatlw = (thesatlw_pld30b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld30b_sphv_10hv)
+ stthesatl = (stthesatl_pld30b_sphv_10hv)
+ stthesatw = (stthesatw_pld30b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_pld30b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_pld30b_sphv_10hv)
+ thesatgo = (thesatgo_pld30b_sphv_10hv)
+ thesatgl = (thesatgl_pld30b_sphv_10hv)
+ thesatgw = (thesatgw_pld30b_sphv_10hv*(1-fem))
+ axo      = (axo_pld30b_sphv_10hv)
+ axl      = (axl_pld30b_sphv_10hv)
+ alpl     = (alpl_pld30b_sphv_10hv)
+ alplexp  = (alplexp_pld30b_sphv_10hv)
+ alpw     = (alpw_pld30b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld30b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld30b_sphv_10hv)
+ alp1l2   = (alp1l2_pld30b_sphv_10hv)
+ alp1w    = (alp1w_pld30b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld30b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld30b_sphv_10hv)
+ alp2l2   = (alp2l2_pld30b_sphv_10hv)
+ alp2w    = (alp2w_pld30b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld30b_sphv_10hv)
+ a1o      = (a1o_pld30b_sphv_10hv)
+ a1l      = (a1l_pld30b_sphv_10hv)
+ a1w      = (a1w_pld30b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld30b_sphv_10hv)
+ sta2o    = (sta2o_pld30b_sphv_10hv)
+ a3o      = (a3o_pld30b_sphv_10hv)
+ a3l      = (a3l_pld30b_sphv_10hv)
+ a3w      = (a3w_pld30b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld30b_sphv_10hv)
+ a4l      = (a4l_pld30b_sphv_10hv)
+ a4w      = (a4w_pld30b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld30b_sphv_10hv)
+ iginvlw  = (iginvlw_pld30b_sphv_10hv)
+ igovw    = (igovw_pld30b_sphv_10hv)
+ igovdw   = (igovdw_pld30b_sphv_10hv)
+ stigo    = (stigo_pld30b_sphv_10hv)
+ gc2o     = (gc2o_pld30b_sphv_10hv)
+ gc3o     = (gc3o_pld30b_sphv_10hv)
+ chibo    = (chibo_pld30b_sphv_10hv)
+ agidlw   = (agidlw_pld30b_sphv_10hv)
+ agidldw  = (agidldw_pld30b_sphv_10hv)
+ bgidlo   = (bgidlo_pld30b_sphv_10hv)
+ bgidldo  = (bgidldo_pld30b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld30b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld30b_sphv_10hv)
+ cgidlo   = (cgidlo_pld30b_sphv_10hv)
+ cgidldo  = (cgidldo_pld30b_sphv_10hv)
+ cgbovl   = (cgbovl_pld30b_sphv_10hv)
+ cfrw     = (cfrw_pld30b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_pld30b_sphv_10hv*(1-fem))
+ fnto     = (fnto_pld30b_sphv_10hv)
+ nfalw    = (nfalw_pld30b_sphv_10hv)
+ nfblw    = (nfblw_pld30b_sphv_10hv)
+ nfclw    = (nfclw_pld30b_sphv_10hv)
+ efo      = (efo_pld30b_sphv_10hv)
+ lintnoi  = (lintnoi_pld30b_sphv_10hv)
+ alpnoi   = (alpnoi_pld30b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld30b_sphv_10hv)
+ kvthowel = (kvthowel_pld30b_sphv_10hv)
+ kvthowew = (kvthowew_pld30b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_pld30b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_pld30b_sphv_10hv)
+ kuowel   = (kuowel_pld30b_sphv_10hv)
+ kuowew   = (kuowew_pld30b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_pld30b_sphv_10hv*(1-fem))
+ rgo      = (rgo_pld30b_sphv_10hv)
+ rsh      = (rsh_pld30b_sphv_10hv)
+ rbulko   = (rbulko_pld30b_sphv_10hv)
+ rwello   = (rwello_pld30b_sphv_10hv)
+ rjunso   = (rjunso_pld30b_sphv_10hv)
+ rjundo   = ((rjundo_pld30b_sphv_10hv/(w+(1-fem)*dwrjundo_pld30b_sphv_10hv))*(1-0.0002*(temp-27)))
+ rint     = (rint_pld30b_sphv_10hv)
+ rvpoly   = (rvpoly_pld30b_sphv_10hv)
+ rshg     = (rshg_pld30b_sphv_10hv)
+ dlsil    = (dlsil_pld30b_sphv_10hv)
+ saref    = (saref_pld30b_sphv_10hv)
+ sbref    = (sbref_pld30b_sphv_10hv)
+ wlod     = (wlod_pld30b_sphv_10hv)
+ kuo      = (kuo_pld30b_sphv_10hv)
+ kvsat    = (kvsat_pld30b_sphv_10hv)
+ tkuo     = (tkuo_pld30b_sphv_10hv)
+ lkuo     = (lkuo_pld30b_sphv_10hv)
+ wkuo     = (wkuo_pld30b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_pld30b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_pld30b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld30b_sphv_10hv*(1-fem))
+ kvtho    = (kvtho_pld30b_sphv_10hv)
+ lkvtho   = (lkvtho_pld30b_sphv_10hv)
+ wkvtho   = (wkvtho_pld30b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_pld30b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_pld30b_sphv_10hv)
+ wlodvth  = (wlodvth_pld30b_sphv_10hv*(1-fem))
+ stetao   = (stetao_pld30b_sphv_10hv)
+ lodetao  = (lodetao_pld30b_sphv_10hv)
+ scref    = (scref_pld30b_sphv_10hv)
+ web      = (web_pld30b_sphv_10hv)
+ wec      = (wec_pld30b_sphv_10hv)
+ adr1o    = (adr1o_pld30b_sphv_10hv)
+ adr1l    = (adr1l_pld30b_sphv_10hv)
+ adr1w    = (adr1w_pld30b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_pld30b_sphv_10hv)
+ stadr2o  = (stadr2o_pld30b_sphv_10hv)
+ adr3o    = (adr3o_pld30b_sphv_10hv)
+ adr3l    = (adr3l_pld30b_sphv_10hv)
+ adr3w    = (adr3w_pld30b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_pld30b_sphv_10hv)
+ adr4l    = (adr4l_pld30b_sphv_10hv)
+ adr4w    = (adr4w_pld30b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_pld30b_sphv_10hv)
+ adr5l    = (adr5l_pld30b_sphv_10hv)
+ adr5w    = (adr5w_pld30b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_pld30b_sphv_10hv)
+ bidr1l   = (bidr1l_pld30b_sphv_10hv)
+ bidr1w   = (bidr1w_pld30b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_pld30b_sphv_10hv)
+ bidr2w   = (bidr2w_pld30b_sphv_10hv*(1-fem))
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0*(1-fem))
+ rthlw    = (0*(1-fem))
+ strtho   = (strtho_pld30b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0*(1-fem))
+ cthlw    = (0*(1-fem))
+ rshldd   = (rshldd_pld30b_sphv_10hv*delr_rshldd_pld30b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld30b_ronratio))*fac_rshldd
+ xw       = (xw_pld30b_sphv_10hv*(1-fem))
+ nwxw     = ((nwxw_pld30b_sphv_10hv+1.0e-12*dela_nwxw_pld30b_sphv_10hv)*(1-fem))
+ xl       = (xl_pld30b_sphv_10hv)
+ xlw      = (xlw_pld30b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld30b_sphv_10hv)
+ nst      = (nst_pld30b_sphv_10hv)
+ ats      = (ats_pld30b_sphv_10hv)
+ dfinf    = (dfinf_pld30b_sphv_10hv)
+ dfw      = (dfw_pld30b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld30b_sphv_10hv)
+ dflw     = (dflw_pld30b_sphv_10hv*(1-fem))
+ dp       = (dp_pld30b_sphv_10hv)
+ ecrit    = (ecrit_pld30b_sphv_10hv*tfact_ecrit)*(1+ecritw_pld30b_sphv_10hv/w*(1-fem))
+ ecorn    = (ecorn_pld30b_sphv_10hv*tfact_ecrit)*(1+ecritw_pld30b_sphv_10hv/w*(1-fem))
+ du       = (du_pld30b_sphv_10hv)
+ tc1      = (tc1_pld30b_sphv_10hv)
+ tc2      = (tc2_pld30b_sphv_10hv)
+ tc1l     = (tc1l_pld30b_sphv_10hv)
+ tc2l     = (tc2l_pld30b_sphv_10hv)
+ tc1w     = (tc1w_pld30b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_pld30b_sphv_10hv*(1-fem))
+ theacc   = (theacc_pld30b_sphv_10hv)
+ theacc2  = (theacc2_pld30b_sphv_10hv)
+ aacc     = (aacc_pld30b_sphv_10hv)
+ rva      = (rva_pld30b_sphv_10hv)
+ dta      = (dta_pld30b_sphv_10hv)
+ trj      = (trj_pld30b_sphv_10hv)
+ cjarea   = (cjarea_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlsti   = (cjlsti_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlgat   = (cjlgat_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiarea  = (vbiarea_pld30b_sphv_10hv)
+ vbisti   = (vbisti_pld30b_sphv_10hv)
+ vbigat   = (vbigat_pld30b_sphv_10hv)
+ parea    = (parea_pld30b_sphv_10hv)
+ psti     = (psti_pld30b_sphv_10hv)
+ pgat     = (pgat_pld30b_sphv_10hv)
+ is1area  = (is1area_pld30b_sphv_10hv)
+ ttarea   = (ttarea_pld30b_sphv_10hv)
+ is2area  = (is2area_pld30b_sphv_10hv)
+ irarea   = (irarea_pld30b_sphv_10hv)
+ stis1area = (stis1area_pld30b_sphv_10hv)
+ stis2area = (stis2area_pld30b_sphv_10hv)
+ stirarea = (stirarea_pld30b_sphv_10hv)
+ n1area   = (n1area_pld30b_sphv_10hv)
+ n2area   = (n2area_pld30b_sphv_10hv)
+ nrarea   = (nrarea_pld30b_sphv_10hv)
+ is1lsti  = (is1lsti_pld30b_sphv_10hv)
+ ttlsti   = (ttlsti_pld30b_sphv_10hv)
+ is2lsti  = (is2lsti_pld30b_sphv_10hv)
+ irlsti   = (irlsti_pld30b_sphv_10hv)
+ stis1sti = (stis1area_pld30b_sphv_10hv)
+ stis2sti = (stis2area_pld30b_sphv_10hv)
+ stirsti  = (stirarea_pld30b_sphv_10hv)
+ n1sti    = (n1sti_pld30b_sphv_10hv)
+ n2sti    = (n2sti_pld30b_sphv_10hv)
+ nrsti    = (nrsti_pld30b_sphv_10hv)
+ is1lgat  = (is1lgat_pld30b_sphv_10hv)
+ ttlgat   = (ttlgat_pld30b_sphv_10hv)
+ is2lgat  = (is2lgat_pld30b_sphv_10hv)
+ irlgat   = (irlgat_pld30b_sphv_10hv)
+ stis1gat = (stis1area_pld30b_sphv_10hv)
+ stis2gat = (stis2area_pld30b_sphv_10hv)
+ stirgat  = (stirarea_pld30b_sphv_10hv)
+ n1gat    = (n1gat_pld30b_sphv_10hv)
+ n2gat    = (n2gat_pld30b_sphv_10hv)
+ nrgat    = (nrgat_pld30b_sphv_10hv)
+ cjaread  = (cjaread_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlstid  = (cjlstid_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlgatd  = (cjlgatd_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiaread = (vbiaread_pld30b_sphv_10hv)
+ vbistid  = (vbistid_pld30b_sphv_10hv)
+ vbigatd  = (vbigatd_pld30b_sphv_10hv)
+ paread   = (paread_pld30b_sphv_10hv)
+ pstid    = (pstid_pld30b_sphv_10hv)
+ pgatd    = (pgatd_pld30b_sphv_10hv)
+ is1aread = (is1aread_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttaread  = (ttaread_pld30b_sphv_10hv)
+ is2aread = (is2aread_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ iraread  = (iraread_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1aread = (stis1aread_pld30b_sphv_10hv)
+ stis2aread = (stis2aread_pld30b_sphv_10hv)
+ stiraread = (stiraread_pld30b_sphv_10hv)
+ n1aread  = (n1aread_pld30b_sphv_10hv)
+ n2aread  = (n2aread_pld30b_sphv_10hv)
+ nraread  = (nraread_pld30b_sphv_10hv)
+ is1lstid = (is1lstid_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlstid  = (ttlstid_pld30b_sphv_10hv)
+ is2lstid = (is2lstid_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlstid  = (irlstid_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1stid = (stis1aread_pld30b_sphv_10hv)
+ stis2stid = (stis2aread_pld30b_sphv_10hv)
+ stirstid = (stiraread_pld30b_sphv_10hv)
+ n1stid   = (n1stid_pld30b_sphv_10hv)
+ n2stid   = (n2stid_pld30b_sphv_10hv)
+ nrstid   = (nrstid_pld30b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlgatd  = (ttlgatd_pld30b_sphv_10hv)
+ is2lgatd = (is2lgatd_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlgatd  = (irlgatd_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1gatd = (stis1aread_pld30b_sphv_10hv)
+ stis2gatd = (stis2aread_pld30b_sphv_10hv)
+ stirgatd = (stiraread_pld30b_sphv_10hv)
+ n1gatd   = (n1gatd_pld30b_sphv_10hv)
+ n2gatd   = (n2gatd_pld30b_sphv_10hv)
+ nrgatd   = (nrgatd_pld30b_sphv_10hv)
+ cjaread2 = (cjaread_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ cjlstid2 = (cjlstid_pld30b_sphv_10hv*delr_cj_pld30b_sphv_10hv)
+ vbiaread2 = (vbiaread_pld30b_sphv_10hv)
+ vbistid2 = (vbistid_pld30b_sphv_10hv)
+ paread2  = (paread_pld30b_sphv_10hv)
+ pstid2   = (pstid_pld30b_sphv_10hv)
+ is1aread2 = (is1aread2_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttaread2 = (ttaread2_pld30b_sphv_10hv)
+ is2aread2 = (is2aread2_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ iraread2 = (iraread2_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld30b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld30b_sphv_10hv)
+ stiraread2 = (stiraread_pld30b_sphv_10hv)
+ n1aread2 = (n1aread2_pld30b_sphv_10hv)
+ n2aread2 = (n2aread2_pld30b_sphv_10hv)
+ nraread2 = (nraread2_pld30b_sphv_10hv)
+ is1lstid2 = (is1lstid2_pld30b_sphv_10hv*delr_is_pld30b_sphv_10hv)
+ ttlstid2 = (ttlstid2_pld30b_sphv_10hv)
+ is2lstid2 = (is2lstid2_pld30b_sphv_10hv*delr_is2_pld30b_sphv_10hv)
+ irlstid2 = (irlstid2_pld30b_sphv_10hv*delr_ir_pld30b_sphv_10hv)
+ stis1stid2 = (stis1aread_pld30b_sphv_10hv)
+ stis2stid2 = (stis2aread_pld30b_sphv_10hv)
+ stirstid2 = (stiraread_pld30b_sphv_10hv)
+ n1stid2  = (n1stid2_pld30b_sphv_10hv)
+ n2stid2  = (n2stid2_pld30b_sphv_10hv)
+ nrstid2  = (nrstid2_pld30b_sphv_10hv)
+ eais1area = (eais1area_pld30b_sphv_10hv)
+ eais2area = (eais2area_pld30b_sphv_10hv)
+ eairarea = (eairarea_pld30b_sphv_10hv)
+ eais1sti = (eais1sti_pld30b_sphv_10hv)
+ eais2sti = (eais2sti_pld30b_sphv_10hv)
+ eairsti = (eairsti_pld30b_sphv_10hv)
+ eais1gat = (eais1gat_pld30b_sphv_10hv)
+ eais2gat = (eais2gat_pld30b_sphv_10hv)
+ eairgat = (eairgat_pld30b_sphv_10hv)
+ eais1aread = (eais1aread_pld30b_sphv_10hv)
+ eais2aread = (eais2aread_pld30b_sphv_10hv)
+ eairaread = (eairaread_pld30b_sphv_10hv)
+ eais1stid = (eais1stid_pld30b_sphv_10hv)
+ eais2stid = (eais2stid_pld30b_sphv_10hv)
+ eairstid = (eairstid_pld30b_sphv_10hv)
+ eais1gatd = (eais1gatd_pld30b_sphv_10hv)
+ eais2gatd = (eais2gatd_pld30b_sphv_10hv)
+ eairgatd = (eairgatd_pld30b_sphv_10hv)
+ eais1aread2 = (eais1aread2_pld30b_sphv_10hv)
+ eais2aread2 = (eais2aread2_pld30b_sphv_10hv)
+ eairaread2 = (eairaread2_pld30b_sphv_10hv)
+ eais1stid2 = (eais1stid2_pld30b_sphv_10hv)
+ eais2stid2 = (eais2stid2_pld30b_sphv_10hv)
+ eairstid2 = (eairstid2_pld30b_sphv_10hv)
+ ikfarea = (ikfarea_pld30b_sphv_10hv)
+ ikflsti = (ikfarea_pld30b_sphv_10hv*djunc)
+ ikflgat = (ikfarea_pld30b_sphv_10hv*djunc)
+ stikfarea = (stikfarea_pld30b_sphv_10hv)
+ stikfsti = (stikfarea_pld30b_sphv_10hv)
+ stikfgat = (stikfarea_pld30b_sphv_10hv)
+ ikfaread = (ikfaread_pld30b_sphv_10hv*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflstid = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflgatd = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikfaread2 = (ikfaread_pld30b_sphv_10hv*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ ikflstid2 = (ikfaread_pld30b_sphv_10hv*djunc*(w/(w+dwikfaread_pld30b_sphv_10hv*(1-fem))))
+ stikfaread = (stikfaread_pld30b_sphv_10hv)
+ stikfstid = (stikfaread_pld30b_sphv_10hv)
+ stikfgatd = (stikfaread_pld30b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld30b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld30b_sphv_10hv)

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax          = (1e12)
+ jmelt         = (1e12)
+ tnom          = (27)
+ is            = (1e-30)
+ n             = (1.0)
+ cj            = (1e-30)
+ pta           = (0)
+ tlevc         = (2)
+ tlev          = (2)
+ bv            = (dcbv_pld30b_sphv_10hv+bvdss_shift)
+ ibv           = (1e-5/1e-12)

mpowermos (d gi s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2
cgd (gi d) capacitor c=(cgd_ply_fld*1.3) m=ng
cgs (gi s) capacitor c=(cgs_ply_fld) m=ng
rg (g gi) resistor r=rgate
dbodyBV (d di) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (di s) resistor r=0.01
xdsub (s sub) cdgoptub_box_sub_10hv area=(aiso*(1-lpe)+1e-12) perim=(piso*(1-lpe)+1e-12) soa=1

if (ng_dmy>=2) {

cgd_dmy (s d) capacitor c=(cgd_ply_fld*1.3) m=ng_dmy
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad pd=pd as=as ps=ps ad2=ad2 pd2=pd2

}

include "./smos10hv_ade_dfrt.scs" section=pld30b_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld10_10hv (d g s sub)
parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    fem                            = 0
+    soa                            = 1
+    sti_dummy                      = 0


parameters
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.25)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)

//
+    dw_mos                         = (0.03525*(1-fem))
+    numbernplus                    = (int_round(w/0.8))
+    w_um                           = (numbernplus*0.4+dw_mos*(1-fem))
+    l_um                           = (lch_drawn)

+    wdrift                         = (w)
+    wnwx                           = (0.6)
+    ldrift                         = (0.35)
+    ldr1                           = (lacc_drawn)
+    lacts                          = (0.375)
+    lactd                          = (0.57)
+    wg2nhv                         = (0.765*(1-fem))
+    aplyfld_d                      = (((ldr1)*2*wg2nhv)*ngeff)
+    aplyfld_s                      = (1e-15*ng)
+    as_xdr                         = (lacts*w_um)
+    ps_xdr                         = ((2*(lacts+0.4))*numbernplus)
+    ad_xdr                         = ((ldr1+ldrift+lactd*0.5)*(w+2*wnwx))
+    pd_xdr                         = ((2*((ldr1+ldrift+lactd*0.5)+(w+2*wnwx))))
//+    ad2_xdr                        = ((lactd+ldrift)*0.5*(w+2*wg2nhv*(1-fem)))
//+    pd2_xdr                        = ((lactd+ldrift))
+    as_i                           = (as_xdr)
+    ps_i                           = (ps_xdr)
+    ad_i                           = (ad_xdr)
+    pd_i                           = (pd_xdr)
//+    ad2_i                          = (ad2_xdr)
//+    pd2_i                          = (pd2_xdr)
+    lg2dt                          = (1.485)
+    wg2dt                          = (1.35*(1-fem))
+    lg2g_d                         = ((ldrift+lactd*0.5)*2)
+    lg2g_s                         = (0.42)
+    lg2w                           = (l_um)
+    xnbl_xdr                       = (lg2dt*nse+lg2w*ngeff+ldr1*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (2*wg2dt+w)
+    anbl_xdr                       = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_nld10_sphv_10hv+tc2_ecrit_nld10_sphv_10hv*(temp-tnom))*(temp-tnom))
+    wfact_ecrit                    = (1+ecritw_nld10_sphv_10hv/w*(1-fem))
+    w_heat=w
+    l_heat=(lg2w*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1.7)
+    rth_f=(((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld10_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld10_sphv_10hv)*ngeff/she_fit)
+    cth_f=(((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.82)

+    nsmm_delr_gox_nld10_sphv_10hv  = 0
+    nsmm_dela_dw_nld10_sphv_10hv   = tmp_nsmm_dela_dw_nld10_sphv_10hv
+    nsmm_dela_vfb_nld10_sphv_10hv  = tmp_nsmm_dela_vfb_nld10_sphv_10hv
+    nsmm_delr_mobref_nld10_sphv_10hv = 0
+    nsmm_delr_rshl_nld10_sphv_10hv = 0
+    nsmm_delr_nsub_nld10_sphv_10hv = tmp_nsmm_delr_nsub_nld10_sphv_10hv

+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld10_vthratio      = 1.0
+    presto_nld10_ronratio      = 0.01/1/9.8537

//**parameters for multi ng
+ fac_ng_rshldd=(1+(ngeff/(ngeff-1.0*(1-fem))-2/(2-1.0))*(0.2))
+ fac_ng_vfbo= ((ngeff/(ngeff+0.8*(1-fem))-2/(2+0.8))*(0.02))

//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
//+    delr_tox_nld10_sphv_10hv      = (nom_delr_tox_nld10_sphv_10hv*(1.0+nsig_delr_tox_nld10_sphv_10hv*sig_delr_tox_nld10_sphv_10hv+nsmm_delr_gox_nld10_sphv_10hv*smm_delr_gox_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_tox_nld10_sphv_10hv      = (nom_delr_tox_nld10_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld10_sphv_10hv+nsmm_delr_gox_nld10_sphv_10hv*smm_delr_gox_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld10_sphv_10hv       = (nom_dela_dw_nld10_sphv_10hv+nsig_dela_dw_nld10_sphv_10hv*sig_dela_dw_nld10_sphv_10hv+nsmm_dela_dw_nld10_sphv_10hv*smm_dela_dw_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld10_sphv_10hv       = (nom_dela_xw_nld10_sphv_10hv+nsig_dela_xw_nld10_sphv_10hv*sig_dela_xw_nld10_sphv_10hv)
+    dela_vfb_nld10_sphv_10hv      = (nom_dela_vfb_nld10_sphv_10hv+nsig_dela_vfb_nld10_sphv_10hv*sig_dela_vfb_nld10_sphv_10hv+nsmm_dela_vfb_nld10_sphv_10hv*smm_dela_vfb_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_nld10_sphv_10hv     = (nom_dela_vtwl_nld10_sphv_10hv+nsig_dela_vtwl_nld10_sphv_10hv*sig_dela_vtwl_nld10_sphv_10hv)
+    delr_mobref_nld10_sphv_10hv   = (nom_delr_mobref_nld10_sphv_10hv*(1.0+nsig_delr_mobref_nld10_sphv_10hv*sig_delr_mobref_nld10_sphv_10hv+nsmm_delr_mobref_nld10_sphv_10hv*smm_delr_mobref_nld10_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_nld10_sphv_10hv     = (nom_delr_rshl_nld10_sphv_10hv*(1.0+nsig_delr_rshl_nld10_sphv_10hv*sig_delr_rshl_nld10_sphv_10hv)+nsmm_delr_rshl_nld10_sphv_10hv*smm_delr_rshl_nld10_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_thesato_nld10_sphv_10hv     = (nom_delr_thesato_nld10_sphv_10hv*(1.0+nsig_delr_thesato_nld10_sphv_10hv*sig_delr_thesato_nld10_sphv_10hv))
+    delr_nsub_nld10_sphv_10hv     = (1+nsmm_delr_nsub_nld10_sphv_10hv*smm_delr_nsub_nld10_sphv_10hv(l,w)/sqrt(ng/2))
//+    cj0_junc_nld10_d_body         = ((nom_delr_cj0_junc_nld10_d_body*(1+nsig_delr_cj0_junc_nld10_d_body*sig_delr_cj0_junc_nld10_d_body)))
//+    js_junc_nld10_d_body          = ((nom_delr_js_junc_nld10_d_body*(1+nsig_delr_js_junc_nld10_d_body*sig_delr_js_junc_nld10_d_body)))
+    delr_cj_nld10_sphv_10hv = (nom_delr_cj_nld10_sphv_10hv*(1+sig_delr_cj_nld10_sphv_10hv*nsig_delr_cj_nld10_sphv_10hv))
+    delr_is_nld10_sphv_10hv = (nom_delr_is_nld10_sphv_10hv*exp(sig_delr_is_nld10_sphv_10hv*nsig_delr_is_nld10_sphv_10hv))
+    delr_is2_nld10_sphv_10hv = (nom_delr_is2_nld10_sphv_10hv*exp(sig_delr_is2_nld10_sphv_10hv*nsig_delr_is2_nld10_sphv_10hv))
+    delr_ir_nld10_sphv_10hv = (nom_delr_ir_nld10_sphv_10hv*exp(sig_delr_ir_nld10_sphv_10hv*nsig_delr_ir_nld10_sphv_10hv))


//+    cpp_ply_fld		    = (nom_cpp_ply_fld)
//+    nom_cpp_ply_fld		    = (0.092229166666667e-15)
//+    cpp_ply_sdt		    = (nom_cpp_ply_sdt)
//+    nom_cpp_ply_sdt		    = (2.6460229885057e-15)

+    lfr_ct_ply_s		    = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d		    = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d		    = ((w+0*0.06*(1-fem))*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s		    = ((w+0*0.06*(1-fem))*ng-lfr_ct_ply_s)


//+    cfr_nld10_d_ply_m1ct	= (4.36e-17)

//+    cfr_nld10_s_ply_m1ct	= (1.29e-16)

//+    cfr_nld10_s_ply_met	= (4.25e-17)

//+    cfr_nld10_d_ply_met	= (3.96e-17)

+    lfring                         = (w*ng)
+    lch_drawn                      = (0.55)
+    lch                            = (0.401)
+    lacc_drawn                     = (0.45)
+    lacc                           = (0.554)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    lflap                          = (0.25)

+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))

if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr
}


model sphvt_simkit sphvt
+ type     =(n)
+ vdscale  = (vdscale_nld10_sphv_10hv*(1-0.06*(1-fem)/w))
+ ctgo     = (0.1)
+ stcto    = (0.2)
+ stvdscale= (-0.27)
+ strthao  = (0.8)
+ tr       = (27)
+ swgeo    = (1)
+ swgedi    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec    = (1)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swdrlin  = swdrlin
+ xvsat = (xvsat_nld10_sphv_10hv*(1+xvsatw_nld10_sphv_10hv/w*(1-fem)))
+ qmc      = (qmc_nld10_sphv_10hv)
+ lvaro    = (lvaro_nld10_sphv_10hv)
+ lvarl    = (lvarl_nld10_sphv_10hv)
+ lvarw    = (lvarw_nld10_sphv_10hv*(1-fem))
+ lap      = (lap_nld10_sphv_10hv)
+ wvaro    = (wvaro_nld10_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld10_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld10_sphv_10hv*(1-fem))
+ wot      = ((wot_nld10_sphv_10hv+0.5e-6*dela_dw_nld10_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld10_sphv_10hv)
+ dwq      = (dwq_nld10_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld10_sphv_10hv+fac_ng_vfbo+dela_vfb_nld10_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld10_vthratio)
+ vfbl     = (vfbl_nld10_sphv_10hv)
+ vfbw     = (vfbw_nld10_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld10_sphv_10hv+dela_vtwl_nld10_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld10_sphv_10hv)
+ stvfbl   = (stvfbl_nld10_sphv_10hv)
+ stvfbw   = (stvfbw_nld10_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld10_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ epsroxo  = (epsroxo_nld10_sphv_10hv)
+ nsubo    = (nsubo_nld10_sphv_10hv*delr_nsub_nld10_sphv_10hv)
+ nsubw    = (nsubw_nld10_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld10_sphv_10hv)
+ npck     = (npck_nld10_sphv_10hv)
+ npckw    = (npckw_nld10_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld10_sphv_10hv)
+ lpck     = (lpck_nld10_sphv_10hv)
+ lpckw    = (lpckw_nld10_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld10_sphv_10hv)
+ fol2     = (fol2_nld10_sphv_10hv)
+ facneffaco = (facneffaco_nld10_sphv_10hv)
+ facneffacl = (facneffacl_nld10_sphv_10hv)
+ facneffacw = (facneffacw_nld10_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld10_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld10_sphv_10hv)
+ gfacnudl = (gfacnudl_nld10_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld10_sphv_10hv)
+ gfacnudw = (gfacnudw_nld10_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld10_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld10_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld10_sphv_10hv)
+ vnsubo   = (vnsubo_nld10_sphv_10hv)
+ nslpo    = (nslpo_nld10_sphv_10hv)
+ dnsubo   = (dnsubo_nld10_sphv_10hv)
+ dphibo   = (dphibo_nld10_sphv_10hv)
+ dphibl   = (dphibl_nld10_sphv_10hv)
+ dphiblexp = (dphiblexp_nld10_sphv_10hv)
+ dphibw   = (dphibw_nld10_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld10_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld10_sphv_10hv)
+ delvtacl = (delvtacl_nld10_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld10_sphv_10hv)
+ delvtacw = (delvtacw_nld10_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld10_sphv_10hv)*(1-fem)
+ npo      = (npo_nld10_sphv_10hv)
+ npl      = (npl_nld10_sphv_10hv)
+ cto      = (cto_nld10_sphv_10hv)
+ ctl      = (ctl_nld10_sphv_10hv)
+ ctlexp   = (ctlexp_nld10_sphv_10hv)
+ ctw      = (ctw_nld10_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld10_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ toxovdo  = (toxovdo_nld10_sphv_10hv*delr_tox_nld10_sphv_10hv)
+ lov      = (lov_nld10_sphv_10hv)
+ dlovd    = (dlovd_nld10_sphv_10hv)
+ novo     = (novo_nld10_sphv_10hv)
+ novdo    = (novdo_nld10_sphv_10hv)
+ cfl      = (cfl_nld10_sphv_10hv)
+ cflexp   = (cflexp_nld10_sphv_10hv)
+ cfw      = (cfw_nld10_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld10_sphv_10hv)
+ uo       = (uo_nld10_sphv_10hv*delr_mobref_nld10_sphv_10hv*delr_u0_relimo)*w_um/wdrift
+ fbet1    = (fbet1_nld10_sphv_10hv)
+ fbet1w   = (fbet1w_nld10_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld10_sphv_10hv)
+ lp1w     = (lp1w_nld10_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld10_sphv_10hv)
+ lp2      = (lp2_nld10_sphv_10hv)
+ betw1    = (betw1_nld10_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld10_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld10_sphv_10hv)
+ stbeto   = (stbeto_nld10_sphv_10hv)
+ stbetl   = (stbetl_nld10_sphv_10hv)
+ stbetw   = (stbetw_nld10_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld10_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld10_sphv_10hv)
+ muew     = (muew_nld10_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld10_sphv_10hv)
+ themuo   = (themuo_nld10_sphv_10hv)
+ stthemuo = (stthemuo_nld10_sphv_10hv)
+ cso      = (cso_nld10_sphv_10hv)
+ csl      = (csl_nld10_sphv_10hv)
+ cslexp   = (cslexp_nld10_sphv_10hv)
+ csw      = (csw_nld10_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld10_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld10_sphv_10hv)
+ xcoro    = (xcoro_nld10_sphv_10hv)
+ xcorl    = (xcorl_nld10_sphv_10hv)
+ xcorw    = (xcorw_nld10_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld10_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld10_sphv_10hv)
+ fetao    = (fetao_nld10_sphv_10hv)
+ rsw1     = (rsw1_nld10_sphv_10hv)
+ rsw2     = (rsw2_nld10_sphv_10hv)*(1-fem)
+ strso    = (strso_nld10_sphv_10hv)
+ rsbo     = (rsbo_nld10_sphv_10hv)
+ rsgo     = (rsgo_nld10_sphv_10hv)
+ thesato  = (thesato_nld10_sphv_10hv*delr_thesato_nld10_sphv_10hv)
+ thesatl  = (thesatl_nld10_sphv_10hv)
+ thesatlexp = (thesatlexp_nld10_sphv_10hv)
+ thesatw  = (thesatw_nld10_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld10_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld10_sphv_10hv)
+ stthesatl = (stthesatl_nld10_sphv_10hv)
+ stthesatw = (stthesatw_nld10_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld10_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld10_sphv_10hv)
+ thesatgo = (thesatgo_nld10_sphv_10hv)
+ thesatgl = (thesatgl_nld10_sphv_10hv)
+ thesatgw = (thesatgw_nld10_sphv_10hv*(1-fem))
+ axo      = (axo_nld10_sphv_10hv)
+ axl      = (axl_nld10_sphv_10hv)
+ alpl     = (alpl_nld10_sphv_10hv)
+ alplexp  = (alplexp_nld10_sphv_10hv)
+ alpw     = (alpw_nld10_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld10_sphv_10hv)
+ alp1lexp = (alp1lexp_nld10_sphv_10hv)
+ alp1l2   = (alp1l2_nld10_sphv_10hv)
+ alp1w    = (alp1w_nld10_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld10_sphv_10hv)
+ alp2lexp = (alp2lexp_nld10_sphv_10hv)
+ alp2l2   = (alp2l2_nld10_sphv_10hv)
+ alp2w    = (alp2w_nld10_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld10_sphv_10hv)
+ a1o      = (a1o_nld10_sphv_10hv)
+ a1l      = (a1l_nld10_sphv_10hv)
+ a1w      = (a1w_nld10_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld10_sphv_10hv)
+ sta2o    = (sta2o_nld10_sphv_10hv)
+ a3o      = (a3o_nld10_sphv_10hv)
+ a3l      = (a3l_nld10_sphv_10hv)
+ a3w      = (a3w_nld10_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld10_sphv_10hv)
+ a4l      = (a4l_nld10_sphv_10hv)
+ a4w      = (a4w_nld10_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld10_sphv_10hv)
+ iginvlw  = (iginvlw_nld10_sphv_10hv)
+ igovw    = (igovw_nld10_sphv_10hv)
+ igovdw   = (igovdw_nld10_sphv_10hv)
+ stigo    = (stigo_nld10_sphv_10hv)
+ gc2o     = (gc2o_nld10_sphv_10hv)
+ gc3o     = (gc3o_nld10_sphv_10hv)
+ chibo    = (chibo_nld10_sphv_10hv)
+ agidlw   = (agidlw_nld10_sphv_10hv)
+ agidldw  = (agidldw_nld10_sphv_10hv)
+ bgidlo   = (bgidlo_nld10_sphv_10hv)
+ bgidldo  = (bgidldo_nld10_sphv_10hv)
+ stbgidlo = (stbgidlo_nld10_sphv_10hv)
+ stbgidldo = (stbgidldo_nld10_sphv_10hv)
+ cgidlo   = (cgidlo_nld10_sphv_10hv)
+ cgidldo  = (cgidldo_nld10_sphv_10hv)
+ cgbovl   = (cgbovl_nld10_sphv_10hv)
+ cfrw     = (cfrw_nld10_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld10_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld10_sphv_10hv)
+ nfalw    = (nfalw_nld10_sphv_10hv)
+ nfblw    = (nfblw_nld10_sphv_10hv)
+ nfclw    = (nfclw_nld10_sphv_10hv)
+ efo      = (efo_nld10_sphv_10hv)
+ lintnoi  = (lintnoi_nld10_sphv_10hv)
+ alpnoi   = (alpnoi_nld10_sphv_10hv)
+ kvthoweo = (kvthoweo_nld10_sphv_10hv)
+ kvthowel = (kvthowel_nld10_sphv_10hv)
+ kvthowew = (kvthowew_nld10_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld10_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld10_sphv_10hv)
+ kuowel   = (kuowel_nld10_sphv_10hv)
+ kuowew   = (kuowew_nld10_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld10_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld10_sphv_10hv)
+ rsh      = (rsh_nld10_sphv_10hv)
+ rbulko   = (rbulko_nld10_sphv_10hv)
+ rwello   = (rwello_nld10_sphv_10hv)
+ rjunso   = (rjunso_nld10_sphv_10hv/(w_um+dwrjunso_nld10_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld10_sphv_10hv/(wdrift+dwrjundo_nld10_sphv_10hv*(1-fem)))
+ rint     = (rint_nld10_sphv_10hv)
+ rvpoly   = (rvpoly_nld10_sphv_10hv)
+ rshg     = (rshg_nld10_sphv_10hv)
+ dlsil    = (dlsil_nld10_sphv_10hv)
+ saref    = (saref_nld10_sphv_10hv)
+ sbref    = (sbref_nld10_sphv_10hv)
+ wlod     = (wlod_nld10_sphv_10hv)
+ kuo      = (kuo_nld10_sphv_10hv)
+ kvsat    = (kvsat_nld10_sphv_10hv)
+ tkuo     = (tkuo_nld10_sphv_10hv)
+ lkuo     = (lkuo_nld10_sphv_10hv)
+ wkuo     = (wkuo_nld10_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld10_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld10_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld10_sphv_10hv)
+ kvtho    = (kvtho_nld10_sphv_10hv)
+ lkvtho   = (lkvtho_nld10_sphv_10hv)
+ wkvtho   = (wkvtho_nld10_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld10_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld10_sphv_10hv)
+ wlodvth  = (wlodvth_nld10_sphv_10hv)
+ stetao   = (stetao_nld10_sphv_10hv)
+ lodetao  = (lodetao_nld10_sphv_10hv)
+ scref    = (scref_nld10_sphv_10hv)
+ web      = (web_nld10_sphv_10hv)
+ wec      = (wec_nld10_sphv_10hv)
+ adr1o    = (adr1o_nld10_sphv_10hv)
+ adr1l    = (adr1l_nld10_sphv_10hv)
+ adr1w    = (adr1w_nld10_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld10_sphv_10hv)
+ stadr2o  = (stadr2o_nld10_sphv_10hv)
+ adr3o    = (adr3o_nld10_sphv_10hv)
+ adr3l    = (adr3l_nld10_sphv_10hv)
+ adr3w    = (adr3w_nld10_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld10_sphv_10hv)
+ adr4l    = (adr4l_nld10_sphv_10hv)
+ adr4w    = (adr4w_nld10_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld10_sphv_10hv)
+ adr5l    = (adr5l_nld10_sphv_10hv)
+ adr5w    = (adr5w_nld10_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld10_sphv_10hv)
+ bidr1l   = (bidr1l_nld10_sphv_10hv)
+ bidr1w   = (bidr1w_nld10_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld10_sphv_10hv)
+ bidr2w   = (bidr2w_nld10_sphv_10hv)*(1-fem)
//+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld10_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld10_sphv_10hv*fac_ng_rshldd*delr_rshl_nld10_sphv_10hv*delr_rdsw_relimo*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld10_ronratio))
+ xw       = ((xw_nld10_sphv_10hv+0.5e-6*dela_xw_nld10_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld10_sphv_10hv*(1-fem))
+ xl       = (xl_nld10_sphv_10hv)
+ xlw      = (xlw_nld10_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld10_sphv_10hv)
+ nst      = (nst_nld10_sphv_10hv)
+ ats      = (ats_nld10_sphv_10hv)
+ dfinf    = (dfinf_nld10_sphv_10hv)
+ dfw      = (dfw_nld10_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld10_sphv_10hv)
+ dflw     = (dflw_nld10_sphv_10hv*(1-fem))
+ dp       = (dp_nld10_sphv_10hv)
+ ecrit    = (ecrit_nld10_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ ecorn    = (ecorn_nld10_sphv_10hv*tfact_ecrit)*wfact_ecrit
+ du       = (du_nld10_sphv_10hv)
+ tc1      = (tc1_nld10_sphv_10hv)
+ tc2      = (tc2_nld10_sphv_10hv)
+ tc1l     = (tc1l_nld10_sphv_10hv)
+ tc2l     = (tc2l_nld10_sphv_10hv)
+ tc1w     = (tc1w_nld10_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld10_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld10_sphv_10hv)
+ theacc2  = (theacc2_nld10_sphv_10hv)
+ aacc     = (aacc_nld10_sphv_10hv)
+ rva      = (rva_nld10_sphv_10hv)*(1+2.5/w*(1-fem))
+ dta      = (dta_nld10_sphv_10hv)
+ trj      = (trj_nld10_sphv_10hv)
+ cjarea   = (cjarea_nld10_sphv_10hv)*delr_cj_nld10_sphv_10hv
+ cjlsti   = (cjlsti_nld10_sphv_10hv)*djunc*delr_cj_nld10_sphv_10hv
+ cjlgat   = (cjlgat_nld10_sphv_10hv)*djunc*delr_cj_nld10_sphv_10hv
+ vbiarea  = (vbiarea_nld10_sphv_10hv)
+ vbisti   = (vbisti_nld10_sphv_10hv)
+ vbigat   = (vbigat_nld10_sphv_10hv)
+ parea    = (parea_nld10_sphv_10hv)
+ psti     = (psti_nld10_sphv_10hv)
+ pgat     = (pgat_nld10_sphv_10hv)
+ is1area  = (is1area_nld10_sphv_10hv)
+ ttarea   = (ttarea_nld10_sphv_10hv)
+ is2area  = (is2area_nld10_sphv_10hv)
+ irarea   = (irarea_nld10_sphv_10hv)
+ stis1area = (stis1area_nld10_sphv_10hv)
+ stis2area = (stis2area_nld10_sphv_10hv)
+ stirarea = (stirarea_nld10_sphv_10hv)
+ n1area   = (n1area_nld10_sphv_10hv)
+ n2area   = (n2area_nld10_sphv_10hv)
+ nrarea   = (nrarea_nld10_sphv_10hv)
+ is1lsti  = (is1lsti_nld10_sphv_10hv)
+ ttlsti   = (ttlsti_nld10_sphv_10hv)
+ is2lsti  = (is2lsti_nld10_sphv_10hv)
+ irlsti   = (irlsti_nld10_sphv_10hv)
+ stis1sti = (stis1sti_nld10_sphv_10hv)
+ stis2sti = (stis2sti_nld10_sphv_10hv)
+ stirsti  = (stirsti_nld10_sphv_10hv)
+ n1sti    = (n1sti_nld10_sphv_10hv)
+ n2sti    = (n2sti_nld10_sphv_10hv)
+ nrsti    = (nrsti_nld10_sphv_10hv)
+ is1lgat  = (is1lgat_nld10_sphv_10hv)
+ ttlgat   = (ttlgat_nld10_sphv_10hv)
+ is2lgat  = (is2lgat_nld10_sphv_10hv)
+ irlgat   = (irlgat_nld10_sphv_10hv)
+ stis1gat = (stis1gat_nld10_sphv_10hv)
+ stis2gat = (stis2gat_nld10_sphv_10hv)
+ stirgat  = (stirgat_nld10_sphv_10hv)
+ n1gat    = (n1gat_nld10_sphv_10hv)
+ n2gat    = (n2gat_nld10_sphv_10hv)
+ nrgat    = (nrgat_nld10_sphv_10hv)
+ cjaread  = (cjaread_nld10_sphv_10hv*delr_cj_nld10_sphv_10hv)
+ cjlstid  = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ cjlgatd  = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ vbiaread = (vbiaread_nld10_sphv_10hv)
+ vbistid  = (vbistid_nld10_sphv_10hv)
+ vbigatd  = (vbigatd_nld10_sphv_10hv)
+ paread   = (paread_nld10_sphv_10hv)
+ pstid    = (pstid_nld10_sphv_10hv)
+ pgatd    = (pgatd_nld10_sphv_10hv)
+ is1aread = (is1aread_nld10_sphv_10hv*delr_is_nld10_sphv_10hv)
+ ttaread  = (ttaread_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread = (is2aread_nld10_sphv_10hv*delr_is2_nld10_sphv_10hv)
+ iraread  = (iraread_nld10_sphv_10hv*delr_ir_nld10_sphv_10hv)
+ stis1aread = (stis1aread_nld10_sphv_10hv)
+ stis2aread = (stis2aread_nld10_sphv_10hv)
+ stiraread = (stiraread_nld10_sphv_10hv)
+ n1aread  = (n1aread_nld10_sphv_10hv)
+ n2aread  = (n2aread_nld10_sphv_10hv)
+ nraread  = (nraread_nld10_sphv_10hv)
+ is1lstid = (is1aread_nld10_sphv_10hv*djunc*delr_is_nld10_sphv_10hv)
+ ttlstid  = (ttlstid_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid = (is2aread_nld10_sphv_10hv*djunc*delr_is2_nld10_sphv_10hv)
+ irlstid  = (irlstid_nld10_sphv_10hv*djunc*delr_ir_nld10_sphv_10hv)
+ stis1stid = (stis1stid_nld10_sphv_10hv)
+ stis2stid = (stis2stid_nld10_sphv_10hv)
+ stirstid = (stirstid_nld10_sphv_10hv)
+ n1stid   = (n1stid_nld10_sphv_10hv)
+ n2stid   = (n2stid_nld10_sphv_10hv)
+ nrstid   = (nrstid_nld10_sphv_10hv)
+ is1lgatd = (is1aread_nld10_sphv_10hv*djunc*delr_is_nld10_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lgatd = (is2aread_nld10_sphv_10hv*djunc*delr_is2_nld10_sphv_10hv)
+ irlgatd  = (irlgatd_nld10_sphv_10hv*djunc*delr_ir_nld10_sphv_10hv)
+ stis1gatd = (stis1gatd_nld10_sphv_10hv)
+ stis2gatd = (stis2gatd_nld10_sphv_10hv)
+ stirgatd = (stirgatd_nld10_sphv_10hv)
+ n1gatd   = (n1gatd_nld10_sphv_10hv)
+ n2gatd   = (n2gatd_nld10_sphv_10hv)
+ nrgatd   = (nrgatd_nld10_sphv_10hv)
+ cjaread2 = (cjaread_nld10_sphv_10hv*delr_cj_nld10_sphv_10hv)
+ cjlstid2 = (cjaread_nld10_sphv_10hv*djunc*delr_cj_nld10_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld10_sphv_10hv)
+ vbistid2 = (vbistid2_nld10_sphv_10hv)
+ paread2  = (paread2_nld10_sphv_10hv)
+ pstid2   = (pstid2_nld10_sphv_10hv)
+ is1aread2 = (is1aread_nld10_sphv_10hv)*delr_is_nld10_sphv_10hv
+ ttaread2 = (ttaread2_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2aread2 = (is2aread_nld10_sphv_10hv)*delr_is2_nld10_sphv_10hv
+ iraread2 = (iraread2_nld10_sphv_10hv)*delr_ir_nld10_sphv_10hv
+ stis1aread2 = (stis1aread_nld10_sphv_10hv)
+ stis2aread2 = (stis2aread_nld10_sphv_10hv)
+ stiraread2 = (stiraread2_nld10_sphv_10hv)
+ n1aread2 = (n1aread2_nld10_sphv_10hv)
+ n2aread2 = (n2aread2_nld10_sphv_10hv)
+ nraread2 = (nraread2_nld10_sphv_10hv)
+ is1lstid2 = (is1aread_nld10_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld10_sphv_10hv)*(4.23/w*(1-fem)+3.18)
+ is2lstid2 = (is2aread_nld10_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_nld10_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld10_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld10_sphv_10hv)
+ stirstid2 = (stirstid2_nld10_sphv_10hv)
+ n1stid2  = (n1stid2_nld10_sphv_10hv)
+ n2stid2  = (n2stid2_nld10_sphv_10hv)
+ nrstid2  = (nrstid2_nld10_sphv_10hv)

+ eais1area = (eais1area_nld10_sphv_10hv)
+ eais2area = (eais2area_nld10_sphv_10hv)
+ eairarea = (eairarea_nld10_sphv_10hv)
+ eais1sti = (eais1sti_nld10_sphv_10hv)
+ eais2sti = (eais2sti_nld10_sphv_10hv)
+ eairsti = (eairsti_nld10_sphv_10hv)
+ eais1gat = (eais1gat_nld10_sphv_10hv)
+ eais2gat = (eais2gat_nld10_sphv_10hv)
+ eairgat = (eairgat_nld10_sphv_10hv)

+ eais1aread = (eais1aread_nld10_sphv_10hv)
+ eais2aread = (eais2aread_nld10_sphv_10hv)
+ eairaread = (eairaread_nld10_sphv_10hv)
+ eais1stid = (eais1stid_nld10_sphv_10hv)
+ eais2stid = (eais2stid_nld10_sphv_10hv)
+ eairstid = (eairstid_nld10_sphv_10hv)
+ eais1gatd = (eais1gatd_nld10_sphv_10hv)
+ eais2gatd = (eais2gatd_nld10_sphv_10hv)
+ eairgatd = (eairgatd_nld10_sphv_10hv)

+ eais1aread2 = (eais1aread2_nld10_sphv_10hv)
+ eais2aread2 = (eais2aread2_nld10_sphv_10hv)
+ eairaread2 = (eairaread2_nld10_sphv_10hv)
+ eais1stid2 = (eais1stid2_nld10_sphv_10hv)
+ eais2stid2 = (eais2stid2_nld10_sphv_10hv)
+ eairstid2 = (eairstid2_nld10_sphv_10hv)

+ ikfarea               = ikfarea_nld10_sphv_10hv
+ ikflsti               = ikfarea_nld10_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld10_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld10_sphv_10hv
+ stikfsti              = stikfarea_nld10_sphv_10hv
+ stikfgat              = stikfarea_nld10_sphv_10hv
+ ikfaread              = ikfaread_nld10_sphv_10hv*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflstid              = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflgatd              = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikfaread2             = ikfaread_nld10_sphv_10hv*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ ikflstid2             = ikfaread_nld10_sphv_10hv*djunc*(w/(w+dwikfaread_nld10_sphv_10hv*(1-fem)))
+ stikfaread             = stikfaread_nld10_sphv_10hv
+ stikfstid             = stikfaread_nld10_sphv_10hv
+ stikfgatd             = stikfaread_nld10_sphv_10hv
+ stikfaread2            = stikfaread_nld10_sphv_10hv
+ stikfstid2            = stikfaread_nld10_sphv_10hv

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt    = (1e12)
+ tnom    = (27)
+ is           = (1e-30)
+ n           = (1.0)
+ cj          = (1e-30)
+ pta        = (0)
+ tlevc     = (2)
+ tlev       = (2)
+ bv         = (17.5+bvdss_shift)
+ ibv         = (1e-5/1e-12)

mpowermos (d intg s s dtemp) sphvt_simkit w=w l=l_um ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i
//cgs_frg_s (intg s) capacitor c=(cpp_ply_sdt*(lovlap+lfrs)*lfring)
//cgd_frg_d (intg d) capacitor c=(cpp_ply_sdt*(lfrd)*lfring)
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
//cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
//cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld10_s_ply_met+lfr_ct_ply_s*cfr_nld10_s_ply_m1ct))
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld10_d_ply_met*(1-fem*(1-0.295))+lfr_ct_ply_d*cfr_nld10_d_ply_m1ct*(1-fem*(1-0.436)))
//cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld10_d_ply_met+lfr_ct_ply_d*cfr_nld10_d_ply_m1ct))
dbodyBV (s rd)  dbodyBV  area=((ad_i)*ng)
rlimit  (rd d)   resistor r=0.01

rgate (g intg) resistor r=((rply*((w+2*0.525*(1-fem))/((lch+lacc)*3*ng))))
xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1

include "./smos10hv_ade_dfrt.scs" section=nld10_10hv_dfrt
ends

//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_he_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = (1)
+    selfheat                       = (1)
+    fscale			    = (1)
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_he_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_he_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_he_sphv_10hv
+    nsmm_dela_vfb_nld45b_he_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_he_sphv_10hv
+    nsmm_dela_vtw_nld45b_he_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_he_sphv_10hv
+    nsmm_delr_mobref_nld45b_he_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_he_sphv_10hv
+    nsmm_delr_rsh_nld45b_he_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_he_sphv_10hv
+    nsmm_delr_thesato_nld45b_he_sphv_10hv = tmp_nsmm_delr_thesato_nld45b_he_sphv_10hv
+    nsmm_delr_nsub_nld45b_he_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_he_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_he_vthratio  = 1.0
+    presto_nld45b_he_ronratio  = 0.01/1.6
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.55)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.3)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.45)
+    ldr1 			    = (0.55)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.305)
+    wd2g			    = (0.675)*(1-fem)
+    wg1			    = (0.925)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.55)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lacc                           = (0.552)
+    lch                            = (0.475)
+    lflap                          = (0.7)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w+2*s2r)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w+2*s2r)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.78)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w+2*s2r)+0.5*pi4models*(rin_dr1-sg)*(rin_dr1-sg))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_he_sphv_10hv+tc2_ecrit_nld45b_he_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_he_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_he_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-1.5e-3))
+    delr_tox_nld45b_he_sphv_10hv      = (nom_delr_tox_nld45b_he_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_he_sphv_10hv+nsmm_delr_gox_nld45b_he_sphv_10hv*smm_delr_gox_nld45b_he_sphv_10hv(l,w,ng)))
//+    delr_tox_nld45b_he_sphv_10hv      = (nom_delr_tox_nld45b_he_sphv_10hv*(1.0+nsig_delr_tox_nld45b_he_sphv_10hv*sig_delr_tox_nld45b_he_sphv_10hv+nsmm_delr_gox_nld45b_he_sphv_10hv*smm_delr_gox_nld45b_he_sphv_10hv(l,w,ng)))
+    dela_xw_nld45b_he_sphv_10hv       = (nom_dela_xw_nld45b_he_sphv_10hv+nsig_dela_xw_nld45b_he_sphv_10hv*sig_dela_xw_nld45b_he_sphv_10hv+nsmm_dela_xw_nld45b_he_sphv_10hv*smm_dela_xw_nld45b_he_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_he_sphv_10hv      = (nom_dela_vfb_nld45b_he_sphv_10hv+nsig_dela_vfb_nld45b_he_sphv_10hv*sig_dela_vfb_nld45b_he_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_he_sphv_10hv*smm_dela_vfb_nld45b_he_sphv_10hv(l,w,ng))
+    dela_vtw_nld45b_he_sphv_10hv     = (nom_dela_vtw_nld45b_he_sphv_10hv+nsig_dela_vtw_nld45b_he_sphv_10hv*sig_dela_vtw_nld45b_he_sphv_10hv+nsmm_dela_vtw_nld45b_he_sphv_10hv*smm_dela_vtw_nld45b_he_sphv_10hv(l,w,ng))
+    delr_mobref_nld45b_he_sphv_10hv   = (nom_delr_mobref_nld45b_he_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_he_sphv_10hv*sig_delr_mobref_nld45b_he_sphv_10hv+nsmm_delr_mobref_nld45b_he_sphv_10hv*smm_delr_mobref_nld45b_he_sphv_10hv(l,w,ng)))
+    delr_rsh_nld45b_he_sphv_10hv     = (nom_delr_rsh_nld45b_he_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_he_sphv_10hv*sig_delr_rsh_nld45b_he_sphv_10hv)+nsmm_delr_rsh_nld45b_he_sphv_10hv*smm_delr_rsh_nld45b_he_sphv_10hv(l,w,ng))
+    delr_thesato_nld45b_he_sphv_10hv     = (nom_delr_thesato_nld45b_he_sphv_10hv*(1.0+nsig_delr_thesato_nld45b_he_sphv_10hv*sig_delr_thesato_nld45b_he_sphv_10hv)+nsmm_delr_thesato_nld45b_he_sphv_10hv*smm_delr_thesato_nld45b_he_sphv_10hv(l,w,ng))
+    delr_nsub_nld45b_he_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_he_sphv_10hv*smm_delr_nsub_nld45b_he_sphv_10hv(l,w,ng))
+    delr_cj_nld45b_he_sphv_10hv        = ((nom_delr_cj_nld45b_he_sphv_10hv*(1+nsig_delr_cj_nld45b_he_sphv_10hv*sig_delr_cj_nld45b_he_sphv_10hv)))
+    delr_is_nld45b_he_sphv_10hv = (nom_delr_is_nld45b_he_sphv_10hv*exp(sig_delr_is_nld45b_he_sphv_10hv*nsig_delr_is_nld45b_he_sphv_10hv))
+    delr_is2_nld45b_he_sphv_10hv = (nom_delr_is2_nld45b_he_sphv_10hv*exp(sig_delr_is2_nld45b_he_sphv_10hv*nsig_delr_is2_nld45b_he_sphv_10hv))
+    delr_ir_nld45b_he_sphv_10hv = (nom_delr_ir_nld45b_he_sphv_10hv*exp(sig_delr_ir_nld45b_he_sphv_10hv*nsig_delr_ir_nld45b_he_sphv_10hv))
// binning parameters
+    dwvdscale =(dwvdscale_nld45b_he_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_he_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_he_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_he_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_he_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(-0.45)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ dvth_ng=weff/(weff+0.25)*(0.026)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(-0.01)*(1-fem)
// simple model
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.81)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}

// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (59+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rply*((w+2*3.675*(1-fem))/((lch+lacc+lflap)*3*ng)))
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+     dphibo=(dphibo_nld45b_he_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_he_pspmoscap_10hv+dela_vfb_nld45b_he_sphv_10hv)
+     nsubo=(nsubo_nld45b_he_sphv_10hv)
+     nsubw=(nsubw_nld45b_he_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =(amoscap/l-w_nld45b_he_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_he_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_he_mosb_10hv)
+ wdrift     =(w_nld45b_he_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_he_mosb_10hv)+(stdelvto_nld45b_he_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)
+ factuo     =(factuo_nld45b_he_mosb_10hv)*(1+(stfactuo_nld45b_he_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=((vdscale_nld45b_he_sphv_10hv)*(1+dwvdscale/weff+dwvdscalew/(weff*weff)))
+ stvdscale=(stvdscale_nld45b_he_sphv_10hv)
+ ctgo=(ctgo_nld45b_he_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgeo    = (1)
+ swgedi   = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (0)
+ swexp    = (0)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_he_sphv_10hv)
+ qmc      = (qmc_nld45b_he_sphv_10hv)
+ lvaro    = (lvaro_nld45b_he_sphv_10hv)
+ lvarl    = (lvarl_nld45b_he_sphv_10hv)
+ lvarw    = (lvarw_nld45b_he_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_he_sphv_10hv)
+ wvaro    = (wvaro_nld45b_he_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_he_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_he_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_he_sphv_10hv+0.5e-6*dela_dw_nld45b_he_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_he_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_he_sphv_10hv)
+ dwq      = (dwq_nld45b_he_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_he_sphv_10hv+dela_vfb_nld45b_he_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_he_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_he_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_he_sphv_10hv+dela_vtw_nld45b_he_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_he_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_he_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_he_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_he_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_he_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_he_sphv_10hv)
+ nsubo    = (nsubo_nld45b_he_sphv_10hv*delr_nsub_nld45b_he_sphv_10hv)
+ nsubw    = (nsubw_nld45b_he_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_he_sphv_10hv)
+ npck     = (npck_nld45b_he_sphv_10hv)
+ npckw    = (npckw_nld45b_he_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_he_sphv_10hv)
+ lpck     = (lpck_nld45b_he_sphv_10hv)
+ lpckw    = (lpckw_nld45b_he_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_he_sphv_10hv)
+ fol2     = (fol2_nld45b_he_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_he_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_he_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_he_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_he_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_he_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_he_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_he_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_he_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_he_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_he_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_he_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_he_sphv_10hv)
+ nslpo    = (nslpo_nld45b_he_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_he_sphv_10hv)
+ dphibo   = (dphibo_nld45b_he_sphv_10hv)
+ dphibl   = (dphibl_nld45b_he_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_he_sphv_10hv)
+ dphibw   = (dphibw_nld45b_he_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_he_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_he_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_he_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_he_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_he_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_he_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_he_sphv_10hv)
+ npl      = (npl_nld45b_he_sphv_10hv)
+ cto      = (cto_nld45b_he_sphv_10hv)
+ ctl      = (ctl_nld45b_he_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_he_sphv_10hv)
+ ctw      = (ctw_nld45b_he_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_he_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_he_sphv_10hv*delr_tox_nld45b_he_sphv_10hv)
+ lov      = (lov_nld45b_he_sphv_10hv)
+ dlovd    = (dlovd_nld45b_he_sphv_10hv)
+ novo     = (novo_nld45b_he_sphv_10hv)
+ novdo    = (novdo_nld45b_he_sphv_10hv)
+ cfl      = (cfl_nld45b_he_sphv_10hv)
+ cflexp   = (cflexp_nld45b_he_sphv_10hv)
+ cfw      = (cfw_nld45b_he_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_he_sphv_10hv)
+ uo       = (uo_nld45b_he_sphv_10hv*delr_mobref_nld45b_he_sphv_10hv*delr_u0_relimo)*(weff/w)
+ fbet1    = (fbet1_nld45b_he_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_he_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_he_sphv_10hv)
+ lp1w     = (lp1w_nld45b_he_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_he_sphv_10hv)
+ lp2      = (lp2_nld45b_he_sphv_10hv)
+ betw1    = (betw1_nld45b_he_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_he_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_he_sphv_10hv)
+ stbeto   = (stbeto_nld45b_he_sphv_10hv)
+ stbetl   = (stbetl_nld45b_he_sphv_10hv)
+ stbetw   = (stbetw_nld45b_he_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_he_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_he_sphv_10hv)
+ muew     = (muew_nld45b_he_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_he_sphv_10hv)
+ themuo   = (themuo_nld45b_he_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_he_sphv_10hv)
+ cso      = (cso_nld45b_he_sphv_10hv)
+ csl      = (csl_nld45b_he_sphv_10hv)
+ cslexp   = (cslexp_nld45b_he_sphv_10hv)
+ csw      = (csw_nld45b_he_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_he_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_he_sphv_10hv)
+ xcoro    = (xcoro_nld45b_he_sphv_10hv)
+ xcorl    = (xcorl_nld45b_he_sphv_10hv)
+ xcorw    = (xcorw_nld45b_he_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_he_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_he_sphv_10hv)
+ fetao    = (fetao_nld45b_he_sphv_10hv)
+ rsw1     = (rsw1_nld45b_he_sphv_10hv)
+ rsw2     = (rsw2_nld45b_he_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_he_sphv_10hv)
+ rsbo     = (rsbo_nld45b_he_sphv_10hv)
+ rsgo     = (rsgo_nld45b_he_sphv_10hv)
+ thesato  = (thesato_nld45b_he_sphv_10hv*delr_thesato_nld45b_he_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_he_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_he_sphv_10hv)
+ thesatw  = (thesatw_nld45b_he_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_he_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_he_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_he_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_he_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_he_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_he_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_he_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_he_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_he_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_he_sphv_10hv)
+ axl      = (axl_nld45b_he_sphv_10hv)
+ alpl     = (alpl_nld45b_he_sphv_10hv)
+ alplexp  = (alplexp_nld45b_he_sphv_10hv)
+ alpw     = (alpw_nld45b_he_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_he_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_he_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_he_sphv_10hv)
+ alp1w    = (alp1w_nld45b_he_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_he_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_he_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_he_sphv_10hv)
+ alp2w    = (alp2w_nld45b_he_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_he_sphv_10hv)
+ a1o      = (a1o_nld45b_he_sphv_10hv)
+ a1l      = (a1l_nld45b_he_sphv_10hv)
+ a1w      = (a1w_nld45b_he_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_he_sphv_10hv)
+ sta2o    = (sta2o_nld45b_he_sphv_10hv)
+ a3o      = (a3o_nld45b_he_sphv_10hv)
+ a3l      = (a3l_nld45b_he_sphv_10hv)
+ a3w      = (a3w_nld45b_he_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_he_sphv_10hv)
+ a4l      = (a4l_nld45b_he_sphv_10hv)
+ a4w      = (a4w_nld45b_he_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_he_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_he_sphv_10hv)
+ igovw    = (igovw_nld45b_he_sphv_10hv)
+ igovdw   = (igovdw_nld45b_he_sphv_10hv)
+ stigo    = (stigo_nld45b_he_sphv_10hv)
+ gc2o     = (gc2o_nld45b_he_sphv_10hv)
+ gc3o     = (gc3o_nld45b_he_sphv_10hv)
+ chibo    = (chibo_nld45b_he_sphv_10hv)
+ agidlw   = (agidlw_nld45b_he_sphv_10hv*(1-fem))
+ agidldw  = (agidldw_nld45b_he_sphv_10hv*(1-fem))
+ bgidlo   = (bgidlo_nld45b_he_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_he_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_he_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_he_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_he_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_he_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_he_sphv_10hv)
+ cfrw     = (cfrw_nld45b_he_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_he_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_he_sphv_10hv)
+ nfalw    = (nfalw_nld45b_he_sphv_10hv)
+ nfblw    = (nfblw_nld45b_he_sphv_10hv)
+ nfclw    = (nfclw_nld45b_he_sphv_10hv)
+ efo      = (efo_nld45b_he_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_he_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_he_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_he_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_he_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_he_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_he_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_he_sphv_10hv)
+ kuowel   = (kuowel_nld45b_he_sphv_10hv)
+ kuowew   = (kuowew_nld45b_he_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_he_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_he_sphv_10hv)
+ rsh      = (rsh_nld45b_he_sphv_10hv)
+ rbulko   = (rbulko_nld45b_he_sphv_10hv)
+ rwello   = (rwello_nld45b_he_sphv_10hv)
+ rjunso   = (rjunso_nld45b_he_sphv_10hv/(weff+dwrjunso_nld45b_he_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_he_sphv_10hv/(weff+dwrjundo_nld45b_he_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_he_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_he_sphv_10hv)
+ rshg     = (rshg_nld45b_he_sphv_10hv)
+ dlsil    = (dlsil_nld45b_he_sphv_10hv)
+ saref    = (saref_nld45b_he_sphv_10hv)
+ sbref    = (sbref_nld45b_he_sphv_10hv)
+ wlod     = (wlod_nld45b_he_sphv_10hv)
+ kuo      = (kuo_nld45b_he_sphv_10hv)
+ kvsat    = (kvsat_nld45b_he_sphv_10hv)
+ tkuo     = (tkuo_nld45b_he_sphv_10hv)
+ lkuo     = (lkuo_nld45b_he_sphv_10hv)
+ wkuo     = (wkuo_nld45b_he_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_he_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_he_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_he_sphv_10hv)
+ kvtho    = (kvtho_nld45b_he_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_he_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_he_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_he_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_he_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_he_sphv_10hv)
+ stetao   = (stetao_nld45b_he_sphv_10hv)
+ lodetao  = (lodetao_nld45b_he_sphv_10hv)
+ scref    = (scref_nld45b_he_sphv_10hv)
+ web      = (web_nld45b_he_sphv_10hv)
+ wec      = (wec_nld45b_he_sphv_10hv)
+ adr1o    = (adr1o_nld45b_he_sphv_10hv)
+ adr1l    = (adr1l_nld45b_he_sphv_10hv)
+ adr1w    = (adr1w_nld45b_he_sphv_10hv)*(1-fem)
+ adr2o    = (adr2o_nld45b_he_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_he_sphv_10hv)
+ adr3o    = (adr3o_nld45b_he_sphv_10hv)
+ adr3l    = (adr3l_nld45b_he_sphv_10hv)
+ adr3w    = (adr3w_nld45b_he_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_he_sphv_10hv)
+ adr4l    = (adr4l_nld45b_he_sphv_10hv)
+ adr4w    = (adr4w_nld45b_he_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_he_sphv_10hv)
+ adr5l    = (adr5l_nld45b_he_sphv_10hv)
+ adr5w    = (adr5w_nld45b_he_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_he_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_he_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_he_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_he_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_he_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_he_sphv_10hv)
+ strthao   = (strthao_nld45b_he_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld45b_he_sphv_10hv*delr_rsh_nld45b_he_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_he_ronratio))*(fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_he_sphv_10hv+(1e-6)*dela_xw_nld45b_he_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_he_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_he_sphv_10hv)
+ xlw      = (xlw_nld45b_he_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_he_sphv_10hv)
+ nst      = (nst_nld45b_he_sphv_10hv)
+ ats      = (ats_nld45b_he_sphv_10hv)
+ dfinf    = (dfinf_nld45b_he_sphv_10hv)
+ dfw      = (dfw_nld45b_he_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_he_sphv_10hv)
+ dflw     = (dflw_nld45b_he_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_he_sphv_10hv)
+ ecrit    = (ecrit_nld45b_he_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_he_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ du       = (du_nld45b_he_sphv_10hv)
+ tc1      = (tc1_nld45b_he_sphv_10hv)
+ tc2      = (tc2_nld45b_he_sphv_10hv)
+ tc1l     = (tc1l_nld45b_he_sphv_10hv)
+ tc2l     = (tc2l_nld45b_he_sphv_10hv)
+ tc1w     = (tc1w_nld45b_he_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_he_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_he_sphv_10hv)
+ theacc2  = (theacc2_nld45b_he_sphv_10hv)
+ aacc     = (aacc_nld45b_he_sphv_10hv)
+ rva      = (rva_nld45b_he_sphv_10hv)
+ dta      = (dta_nld45b_he_sphv_10hv)
+ trj      = (trj_nld45b_he_sphv_10hv)
+ cjarea   = (cjarea_nld45b_he_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_he_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_he_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_he_sphv_10hv)
+ vbisti   = (vbisti_nld45b_he_sphv_10hv)
+ vbigat   = (vbigat_nld45b_he_sphv_10hv)
+ parea    = (parea_nld45b_he_sphv_10hv)
+ psti     = (psti_nld45b_he_sphv_10hv)
+ pgat     = (pgat_nld45b_he_sphv_10hv)
+ is1area  = (is1area_nld45b_he_sphv_10hv)
+ ttarea   = (ttarea_nld45b_he_sphv_10hv)
+ is2area  = (is2area_nld45b_he_sphv_10hv)
+ irarea   = (irarea_nld45b_he_sphv_10hv)
+ stis1area = (stis1area_nld45b_he_sphv_10hv)
+ stis2area = (stis2area_nld45b_he_sphv_10hv)
+ stirarea = (stirarea_nld45b_he_sphv_10hv)
+ n1area   = (n1area_nld45b_he_sphv_10hv)
+ n2area   = (n2area_nld45b_he_sphv_10hv)
+ nrarea   = (nrarea_nld45b_he_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_he_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_he_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_he_sphv_10hv)
+ irlsti   = (irlsti_nld45b_he_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_he_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_he_sphv_10hv)
+ stirsti  = (stirsti_nld45b_he_sphv_10hv)
+ n1sti    = (n1sti_nld45b_he_sphv_10hv)
+ n2sti    = (n2sti_nld45b_he_sphv_10hv)
+ nrsti    = (nrsti_nld45b_he_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_he_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_he_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_he_sphv_10hv)
+ irlgat   = (irlgat_nld45b_he_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_he_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_he_sphv_10hv)
+ stirgat  = (stirgat_nld45b_he_sphv_10hv)
+ n1gat    = (n1gat_nld45b_he_sphv_10hv)
+ n2gat    = (n2gat_nld45b_he_sphv_10hv)
+ nrgat    = (nrgat_nld45b_he_sphv_10hv)
+ cjaread  = (cjaread_nld45b_he_sphv_10hv*delr_cj_nld45b_he_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_he_sphv_10hv)
+ vbistid  = (vbistid_nld45b_he_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_he_sphv_10hv)
+ paread   = (paread_nld45b_he_sphv_10hv)
+ pstid    = (pstid_nld45b_he_sphv_10hv)
+ pgatd    = (pgatd_nld45b_he_sphv_10hv)
+ is1aread = (is1aread_nld45b_he_sphv_10hv*delr_is_nld45b_he_sphv_10hv)
+ ttaread  = (ttaread_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2aread = (is2aread_nld45b_he_sphv_10hv*delr_is2_nld45b_he_sphv_10hv)
+ iraread  = (iraread_nld45b_he_sphv_10hv*delr_ir_nld45b_he_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_he_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_he_sphv_10hv)
+ stiraread = (stiraread_nld45b_he_sphv_10hv)
+ n1aread  = (n1aread_nld45b_he_sphv_10hv)
+ n2aread  = (n2aread_nld45b_he_sphv_10hv)
+ nraread  = (nraread_nld45b_he_sphv_10hv)
+ is1lstid = (is1aread_nld45b_he_sphv_10hv*djunc*delr_is_nld45b_he_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lstid = (is2aread_nld45b_he_sphv_10hv*djunc*delr_is2_nld45b_he_sphv_10hv)
+ irlstid  = (iraread_nld45b_he_sphv_10hv*djunc*delr_ir_nld45b_he_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_he_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_he_sphv_10hv)
+ stirstid = (stirstid_nld45b_he_sphv_10hv)
+ n1stid   = (n1stid_nld45b_he_sphv_10hv)
+ n2stid   = (n2stid_nld45b_he_sphv_10hv)
+ nrstid   = (nrstid_nld45b_he_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_he_sphv_10hv*djunc*delr_is_nld45b_he_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lgatd = (is2aread_nld45b_he_sphv_10hv*djunc*delr_is2_nld45b_he_sphv_10hv)
+ irlgatd  = (iraread_nld45b_he_sphv_10hv*djunc*delr_ir_nld45b_he_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_he_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_he_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_he_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_he_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_he_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_he_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_he_sphv_10hv*delr_cj_nld45b_he_sphv_10hv)
+ cjlstid2 = (cjaread_nld45b_he_sphv_10hv*djunc*delr_cj_nld45b_he_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_he_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_he_sphv_10hv)
+ paread2  = (paread2_nld45b_he_sphv_10hv)
+ pstid2   = (pstid2_nld45b_he_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_he_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2aread2 = (is2aread_nld45b_he_sphv_10hv)
+ iraread2 = (iraread2_nld45b_he_sphv_10hv*delr_ir_nld45b_he_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_he_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_he_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_he_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_he_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_he_sphv_10hv)
+ nraread2 = (nraread2_nld45b_he_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_he_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_he_sphv_10hv)*(1+dwtt/weff)
+ is2lstid2 = (is2aread_nld45b_he_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_he_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld45b_he_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_he_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_he_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_he_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_he_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_he_sphv_10hv)
+ eais1area		= eais1area_nld45b_he_sphv_10hv
+ eais2area		= eais2area_nld45b_he_sphv_10hv
+ eairarea		= eairarea_nld45b_he_sphv_10hv
+ eais1sti		= eais1sti_nld45b_he_sphv_10hv
+ eais2sti		= eais2sti_nld45b_he_sphv_10hv
+ eairsti	  = eairsti_nld45b_he_sphv_10hv
+ eais1gat		= eais1gat_nld45b_he_sphv_10hv
+ eais2gat		= eais2gat_nld45b_he_sphv_10hv
+ eairgat	  = eairgat_nld45b_he_sphv_10hv
+ eais1aread		= eais1aread_nld45b_he_sphv_10hv
+ eais2aread		= eais2aread_nld45b_he_sphv_10hv
+ eairaread		= eairaread_nld45b_he_sphv_10hv
+ eais1stid		= eais1stid_nld45b_he_sphv_10hv
+ eais2stid		= eais2stid_nld45b_he_sphv_10hv
+ eairstid		= eairstid_nld45b_he_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_he_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_he_sphv_10hv
+ eairgatd		= eairgatd_nld45b_he_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_he_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_he_sphv_10hv
+ eairaread2		= eairaread2_nld45b_he_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_he_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_he_sphv_10hv
+ eairstid2		= eairstid2_nld45b_he_sphv_10hv
+ ikfarea               = ikfarea_nld45b_he_sphv_10hv
+ ikflsti               = ikfarea_nld45b_he_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_he_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_he_sphv_10hv
+ stikfsti              = stikfarea_nld45b_he_sphv_10hv
+ stikfgat              = stikfarea_nld45b_he_sphv_10hv
+ ikfaread              = ikfaread_nld45b_he_sphv_10hv*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_he_sphv_10hv*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_he_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_he_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_he_sphv_10hv
+ stikfstid             = stikfaread_nld45b_he_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_he_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_he_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_he_sphv_10hv



include "./smos10hv_ade_dfrt.scs" section=nld45b_he_10hv_dfrt
ends


//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nld45b_tlp_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    mode_rthcth                    = (1)
+    selfheat                       = (1)
+    fscale			    = (1)
+    sti_dummy                      = 0
+    nsmm_delr_gox_nld45b_tlp_sphv_10hv  = 0
+    nsmm_dela_xw_nld45b_tlp_sphv_10hv   = tmp_nsmm_dela_xw_nld45b_tlp_sphv_10hv
+    nsmm_dela_vfb_nld45b_tlp_sphv_10hv  = tmp_nsmm_dela_vfb_nld45b_tlp_sphv_10hv
+    nsmm_dela_vtw_nld45b_tlp_sphv_10hv  = tmp_nsmm_dela_vtw_nld45b_tlp_sphv_10hv
+    nsmm_delr_mobref_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_mobref_nld45b_tlp_sphv_10hv
+    nsmm_delr_rsh_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_rsh_nld45b_tlp_sphv_10hv
+    nsmm_delr_vdscale_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_vdscale_nld45b_tlp_sphv_10hv
+    nsmm_delr_thesato_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_thesato_nld45b_tlp_sphv_10hv
+    nsmm_delr_nsub_nld45b_tlp_sphv_10hv = tmp_nsmm_delr_nsub_nld45b_tlp_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45b_tlp_vthratio = 1.0
+    presto_nld45b_tlp_ronratio = 0.01/1.6
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    l                              = (0.55)
+    numbernplus 		    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff			    = (numbernplus*0.42)
+    ldrift			    = (1.7)
+    wdrift			    = (w)
+    lacts			    = (0.375)
+    lactd			    = (0.69)
+    ld2g                           = (0.5)
+    ldr1 			    = (0.55)
+    lgply2sti			    = (0.35)
+    s2r			    = (0.505)
+    wd2g			    = (0.75)*(1-fem)
+    wg1			    = (1.45)*(1-fem)
+    sg				    = (0.7)*(1-fem)
+    wg2			    = (0.55)*(1-fem)
+    wg3			    = (0.5)*(1-fem)
+    wnc			    = (ldr1)*(1-fem)
//layout calculations
+    rin_dr1			  =(lgply2sti+ldrift+lactd/2)
+    rout_dr1			  =(ldr1+lgply2sti+ldrift+lactd/2)
+    ain_dr1                      =((0.5*pi4models*(rin_dr1)*(rin_dr1))+(2*s2r*(rin_dr1)))
+    aout_dr1	                  =((0.5*pi4models*(rout_dr1)*(rout_dr1))+(2*s2r*(rout_dr1)))
+    a_dr1                        =(aout_dr1-ain_dr1)
+    ldr1_eff			  =(ldr1+a_dr1/w)
+    as_xdr			  = (lacts*(weff))
+    ps_xdr			  = (2*(lacts+(weff)))
+    adtot_xdr			  = ((rout_dr1)*(w)+aout_dr1)
+    pdtot_xdr			  = ((pi4models*(rout_dr1))+w+2*s2r)
+    rd2_xdr			  =((lactd+ldrift+lgply2sti)/2)
+    ad2_xdr			  = ((rd2_xdr)*(w+2*s2r)+0.5*pi4models*(rd2_xdr)*(rd2_xdr))
+    pd2_xdr			  = 0
+    ad_xdr 			  = (adtot_xdr-ad2_xdr)
+    pd_xdr 			  = (pdtot_xdr)
+    la2dt			  = (1.485)
+    wa2dt			  = (1.11)*(1-fem)
+    lg2g_d			  = (2*(ldr1+lgply2sti+ldrift+lactd/2))
+    lg2g_s			  = (0.78)
+    xnbl_xdr			  = (la2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr			  = (w+(wd2g+wg1+sg+wnc+wg2+wa2dt)*2)
+    anbl_xdr			  = (xnbl_xdr*ynbl_xdr)
+    pnbl_xdr			  = (2*(xnbl_xdr+ynbl_xdr))
+    djunc			  = (2.0*1e-6)
// for the moscap
+    rect_area                      = ((wd2g+wg1+sg+wnc+wg2)*(l+ldr1+lgply2sti+ldrift+lactd/2)*2)
+    cutout_area                    = (aout_dr1)
+    amoscap                        = (rect_area-cutout_area)
// for the parastic cap
+    aplyfld_d_out	            = ((rin_dr1-sg)*(w+2*s2r)+0.5*pi4models*(rin_dr1-sg)*(rin_dr1-sg))
+    aplyfld_d_in	            = ((ld2g+lactd/2)*(w)+0.5*pi4models*(ld2g+lactd/2)*(ld2g+lactd/2))
+    aplyfld_d                      = ((aplyfld_d_out-aplyfld_d_in)*ngeff)
+    aplyfld_s                      = ((l+rout_dr1)*(wg3)*2*ng)
//Rg geo parameters copied from ams3p8
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.499)
+    lacc                           = (0.539)
+    lch                            = (0.499)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    lflap                          = (1.05)
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*(-0.095))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*(0.505))*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    arplyfld_d                      = (apoly-ahole) //changed from ams3p8 name aplyfld_d, conflictd with psp_cap
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    rgateout                       = (rply*(w+2*4.5*(1-fem))/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*arplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
// self-heating
+    tfact_ecrit                    = (1+(tc1_ecrit_nld45b_tlp_sphv_10hv+tc2_ecrit_nld45b_tlp_sphv_10hv*(temp-tnom))*(temp-tnom))
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    ngeff_rth=((2*ng+ng_dmy)/2)
+    she_fit=(1+ng_dmy/(ng_dmy+1)/ng*1)
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld45b_tlp_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld45b_tlp_sphv_10hv)*ngeff_rth/she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff_rth*she_fit
//process parameters
+    tc_vth_mm                      = (1+(temp-27)*(-1.5e-3))
+    delr_tox_nld45b_tlp_sphv_10hv      = (nom_delr_tox_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld45b_tlp_sphv_10hv+nsmm_delr_gox_nld45b_tlp_sphv_10hv*smm_delr_gox_nld45b_tlp_sphv_10hv(l,w,ng)))
//+    delr_tox_nld45b_tlp_sphv_10hv      = (nom_delr_tox_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_tox_nld45b_tlp_sphv_10hv*sig_delr_tox_nld45b_tlp_sphv_10hv+nsmm_delr_gox_nld45b_tlp_sphv_10hv*smm_delr_gox_nld45b_tlp_sphv_10hv(l,w,ng)))
+    dela_xw_nld45b_tlp_sphv_10hv       = (nom_dela_xw_nld45b_tlp_sphv_10hv+nsig_dela_xw_nld45b_tlp_sphv_10hv*sig_dela_xw_nld45b_tlp_sphv_10hv+nsmm_dela_xw_nld45b_tlp_sphv_10hv*smm_dela_xw_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_tlp_sphv_10hv      = (nom_dela_vfb_nld45b_tlp_sphv_10hv+nsig_dela_vfb_nld45b_tlp_sphv_10hv*sig_dela_vfb_nld45b_tlp_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nld45b_tlp_sphv_10hv*smm_dela_vfb_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vtw_nld45b_tlp_sphv_10hv     = (nom_dela_vtw_nld45b_tlp_sphv_10hv+nsig_dela_vtw_nld45b_tlp_sphv_10hv*sig_dela_vtw_nld45b_tlp_sphv_10hv+nsmm_dela_vtw_nld45b_tlp_sphv_10hv*smm_dela_vtw_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_mobref_nld45b_tlp_sphv_10hv   = (nom_delr_mobref_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_mobref_nld45b_tlp_sphv_10hv*sig_delr_mobref_nld45b_tlp_sphv_10hv+nsmm_delr_mobref_nld45b_tlp_sphv_10hv*smm_delr_mobref_nld45b_tlp_sphv_10hv(l,w,ng)))
+    delr_rsh_nld45b_tlp_sphv_10hv     = (nom_delr_rsh_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_rsh_nld45b_tlp_sphv_10hv*sig_delr_rsh_nld45b_tlp_sphv_10hv)+nsmm_delr_rsh_nld45b_tlp_sphv_10hv*smm_delr_rsh_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_vdscale_nld45b_tlp_sphv_10hv     = (nom_delr_vdscale_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_vdscale_nld45b_tlp_sphv_10hv*sig_delr_vdscale_nld45b_tlp_sphv_10hv)+nsmm_delr_vdscale_nld45b_tlp_sphv_10hv*smm_delr_vdscale_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_thesato_nld45b_tlp_sphv_10hv     = (nom_delr_thesato_nld45b_tlp_sphv_10hv*(1.0+nsig_delr_thesato_nld45b_tlp_sphv_10hv*sig_delr_thesato_nld45b_tlp_sphv_10hv)+nsmm_delr_thesato_nld45b_tlp_sphv_10hv*smm_delr_thesato_nld45b_tlp_sphv_10hv(l,w,ng))
+    dela_vfb_nld45b_tlp_mosb_10hv      = (nom_dela_vfb_nld45b_tlp_mosb_10hv+nsig_dela_vfb_nld45b_tlp_mosb_10hv*sig_dela_vfb_nld45b_tlp_mosb_10hv)
+    delr_nsub_nld45b_tlp_sphv_10hv     = (1+nsmm_delr_nsub_nld45b_tlp_sphv_10hv*smm_delr_nsub_nld45b_tlp_sphv_10hv(l,w,ng))
+    delr_cj_nld45b_tlp_sphv_10hv        = ((nom_delr_cj_nld45b_tlp_sphv_10hv*(1+nsig_delr_cj_nld45b_tlp_sphv_10hv*sig_delr_cj_nld45b_tlp_sphv_10hv)))
+    delr_is_nld45b_tlp_sphv_10hv = (nom_delr_is_nld45b_tlp_sphv_10hv*exp(sig_delr_is_nld45b_tlp_sphv_10hv*nsig_delr_is_nld45b_tlp_sphv_10hv))
+    delr_is2_nld45b_tlp_sphv_10hv = (nom_delr_is2_nld45b_tlp_sphv_10hv*exp(sig_delr_is2_nld45b_tlp_sphv_10hv*nsig_delr_is2_nld45b_tlp_sphv_10hv))
+    delr_ir_nld45b_tlp_sphv_10hv = (nom_delr_ir_nld45b_tlp_sphv_10hv*exp(sig_delr_ir_nld45b_tlp_sphv_10hv*nsig_delr_ir_nld45b_tlp_sphv_10hv))
// bin parameters
+    dwvdscale =(dwvdscale_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwvdscalew =(dwvdscalew_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwecrit =(dwecrit_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld45b_tlp_sphv_10hv)*(1-fem)
+    dwtt =(dwtt_nld45b_tlp_sphv_10hv)*(1-fem)
// multi-ng scaling
+ thesat_ng_del =   (weff/(weff+2))*(3)
+ thesat_ng_fac =   (ngeff/(ngeff+thesat_ng_del))/(2/(2+thesat_ng_del))
+ uo_ng_del =	  (0.12)
+ uo_ng_fac =	  (ngeff/(ngeff+uo_ng_del))/(2/(2+uo_ng_del))
+ dvth_ng=(0)*(ngeff-2)/ngeff
+ ecrit_ng_del= (0.1)
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ adr1w_ng_del =   (0.45)
+ adr1w_ng_fac =   (ngeff/(ngeff+adr1w_ng_del))/(2/(2+adr1w_ng_del))
+ rshldd_ng_fac=1+(ngeff/(ngeff+6)-2/(2+6))*(0.09)*(1-fem)
// simple model
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.78)

//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1_eff mult=ng_dmy ad=ad_xdr pd=pd_xdr as=as_xdr ps=ps_xdr ad2=ad2_xdr pd2=pd2_xdr
}

// BV diode model card:
model dbody_bv diode
+ allow_scaling = (yes)
+ jmax          = (100)
+ jmelt         = (100)
+ tnom          = (27)
+ is            = (1e-40)
+ cj            = (1e-40)
+ bv            = (69+bvdss_shift)
+ ibv           = ((1e-5)/(1e-12))
+ xti           = (3)
+ fc            = (0.9)
+ tlev          = (2)
+ gap1          = (0.001)
+ gap2          = (900)

xdsub (s sub) cdgontub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
cgd_fld_d (intg d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgs_fld_d (intg s) capacitor c=(cpp_ply_fld*aplyfld_s)
rgate (g intg) resistor r=(rgatetot)
dsd_bv (rd d) dbody_bv area=(adtot_xdr*ngeff)
rlimit (s rd)   resistor r=0.01

model pspmoscap psp103t type=n
+     tr= (27)
+     toxo=(toxo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+     dphibo=(dphibo_nld45b_tlp_pspmoscap_10hv)
+     vfbo=(vfbo_nld45b_tlp_pspmoscap_10hv+dela_vfb_nld45b_tlp_sphv_10hv)
+     nsubo=(nsubo_nld45b_tlp_sphv_10hv)
+     nsubw=(nsubw_nld45b_tlp_sphv_10hv*(1-fem))
+     rtho=(1e18)
+     ctho=(0)

mmoscap (s intg s s dtemp) pspmoscap
+ w          =(amoscap/l-w_nld45b_tlp_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =l
+ mult       =ng

//core mos model
mpowermos (d intg s s dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift     =ldrift
+ wdrift     =wdrift
+ ldr1       =ldr1_eff
+ mult       =ng
+ ad         =ad_xdr
+ pd         =pd_xdr
+ as         =as_xdr
+ ps         =ps_xdr
+ ad2        =ad2_xdr
+ pd2        =pd2_xdr
//second peak gm
mpowermosb (d intg s s dtemp) sphvt_simkit
+ w          =(w_nld45b_tlp_mosb_10hv)*(1-fem)+fem*1e-3
+ l          =(l)
+ ldrift     =(ldrift_nld45b_tlp_mosb_10hv)
+ wdrift     =(w_nld45b_tlp_mosb_10hv)
+ ldr1       =(0)
+ mult       =(ng)
+ ad         =(0)
+ pd         =(0)
+ as         =(0)
+ ps         =(0)
+ ad2        =(0)
+ pd2        =(0)
+ delvto     =(delvto_nld45b_tlp_mosb_10hv)+(stdelvto_nld45b_tlp_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1)+(dela_vfb_nld45b_tlp_mosb_10hv)
+ factuo     =(factuo_nld45b_tlp_mosb_10hv)*(1+(stfactuo_nld45b_tlp_mosb_10hv)*((temp+273.15)/(tnom+273.15)-1))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale=(vdscale_nld45b_tlp_sphv_10hv)*(1+dwvdscale/weff+dwvdscalew/(weff*weff))*(delr_vdscale_nld45b_tlp_sphv_10hv)
+ stvdscale=(stvdscale_nld45b_tlp_sphv_10hv)
+ ctgo=(ctgo_nld45b_tlp_sphv_10hv)
+ tr       = (27)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swtcec  = (1)
+ swimpdr  = (1)
+ swexp    = (1)
+ swdelvtac = (0)
+ swnud    = (0)
+ swptest  = (0)
+ xvsat    = (xvsat_nld45b_tlp_sphv_10hv)
+ qmc      = (qmc_nld45b_tlp_sphv_10hv)
+ lvaro    = (lvaro_nld45b_tlp_sphv_10hv)
+ lvarl    = (lvarl_nld45b_tlp_sphv_10hv)
+ lvarw    = (lvarw_nld45b_tlp_sphv_10hv*(1-fem))
+ lap      = (lap_nld45b_tlp_sphv_10hv)
+ wvaro    = (wvaro_nld45b_tlp_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld45b_tlp_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld45b_tlp_sphv_10hv*(1-fem))
//+ wot      = ((wot_nld45b_tlp_sphv_10hv+0.5e-6*dela_dw_nld45b_tlp_sphv_10hv)*(1-fem))
+ wot      = ((wot_nld45b_tlp_sphv_10hv)*(1-fem))
+ dlq      = (dlq_nld45b_tlp_sphv_10hv)
+ dwq      = (dwq_nld45b_tlp_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld45b_tlp_sphv_10hv+dela_vfb_nld45b_tlp_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nld45b_tlp_vthratio)+(dvth_ng)
+ vfbl     = (vfbl_nld45b_tlp_sphv_10hv)
+ vfbw     = ((vfbw_nld45b_tlp_sphv_10hv+dela_vtw_nld45b_tlp_sphv_10hv)*(1-fem))
+ vfblw    = ((vfblw_nld45b_tlp_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld45b_tlp_sphv_10hv)
+ stvfbl   = (stvfbl_nld45b_tlp_sphv_10hv)
+ stvfbw   = (stvfbw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stvfblw  = (stvfblw_nld45b_tlp_sphv_10hv)*(1-fem)
+ toxo     = (toxo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ epsroxo  = (epsroxo_nld45b_tlp_sphv_10hv)
+ nsubo    = (nsubo_nld45b_tlp_sphv_10hv*delr_nsub_nld45b_tlp_sphv_10hv)
+ nsubw    = (nsubw_nld45b_tlp_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld45b_tlp_sphv_10hv)
+ npck     = (npck_nld45b_tlp_sphv_10hv)
+ npckw    = (npckw_nld45b_tlp_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld45b_tlp_sphv_10hv)
+ lpck     = (lpck_nld45b_tlp_sphv_10hv)
+ lpckw    = (lpckw_nld45b_tlp_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld45b_tlp_sphv_10hv)
+ fol2     = (fol2_nld45b_tlp_sphv_10hv)
+ facneffaco = (facneffaco_nld45b_tlp_sphv_10hv)
+ facneffacl = (facneffacl_nld45b_tlp_sphv_10hv)
+ facneffacw = (facneffacw_nld45b_tlp_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld45b_tlp_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld45b_tlp_sphv_10hv)
+ gfacnudl = (gfacnudl_nld45b_tlp_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld45b_tlp_sphv_10hv)
+ gfacnudw = (gfacnudw_nld45b_tlp_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld45b_tlp_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld45b_tlp_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld45b_tlp_sphv_10hv)
+ vnsubo   = (vnsubo_nld45b_tlp_sphv_10hv)
+ nslpo    = (nslpo_nld45b_tlp_sphv_10hv)
+ dnsubo   = (dnsubo_nld45b_tlp_sphv_10hv)
+ dphibo   = (dphibo_nld45b_tlp_sphv_10hv)
+ dphibl   = (dphibl_nld45b_tlp_sphv_10hv)
+ dphiblexp = (dphiblexp_nld45b_tlp_sphv_10hv)
+ dphibw   = (dphibw_nld45b_tlp_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld45b_tlp_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld45b_tlp_sphv_10hv)
+ delvtacl = (delvtacl_nld45b_tlp_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld45b_tlp_sphv_10hv)
+ delvtacw = (delvtacw_nld45b_tlp_sphv_10hv)*(1-fem)
+ delvtaclw = (delvtaclw_nld45b_tlp_sphv_10hv)*(1-fem)
+ npo      = (npo_nld45b_tlp_sphv_10hv)
+ npl      = (npl_nld45b_tlp_sphv_10hv)
+ cto      = (cto_nld45b_tlp_sphv_10hv)
+ ctl      = (ctl_nld45b_tlp_sphv_10hv)
+ ctlexp   = (ctlexp_nld45b_tlp_sphv_10hv)
+ ctw      = (ctw_nld45b_tlp_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld45b_tlp_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ toxovdo  = (toxovdo_nld45b_tlp_sphv_10hv*delr_tox_nld45b_tlp_sphv_10hv)
+ lov      = (lov_nld45b_tlp_sphv_10hv)
+ dlovd    = (dlovd_nld45b_tlp_sphv_10hv)
+ novo     = (novo_nld45b_tlp_sphv_10hv)
+ novdo    = (novdo_nld45b_tlp_sphv_10hv)
+ cfl      = (cfl_nld45b_tlp_sphv_10hv)
+ cflexp   = (cflexp_nld45b_tlp_sphv_10hv)
+ cfw      = (cfw_nld45b_tlp_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld45b_tlp_sphv_10hv)
+ uo       = (uo_nld45b_tlp_sphv_10hv*delr_mobref_nld45b_tlp_sphv_10hv*delr_u0_relimo)*(weff/w)*(uo_ng_fac)
+ fbet1    = (fbet1_nld45b_tlp_sphv_10hv)
+ fbet1w   = (fbet1w_nld45b_tlp_sphv_10hv*(1-fem))
+ lp1      = (lp1_nld45b_tlp_sphv_10hv)
+ lp1w     = (lp1w_nld45b_tlp_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld45b_tlp_sphv_10hv)
+ lp2      = (lp2_nld45b_tlp_sphv_10hv)
+ betw1    = (betw1_nld45b_tlp_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld45b_tlp_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld45b_tlp_sphv_10hv)
+ stbeto   = (stbeto_nld45b_tlp_sphv_10hv)
+ stbetl   = (stbetl_nld45b_tlp_sphv_10hv)
+ stbetw   = (stbetw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stbetlw  = (stbetlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ mueo     = (mueo_nld45b_tlp_sphv_10hv)
+ muew     = (muew_nld45b_tlp_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld45b_tlp_sphv_10hv)
+ themuo   = (themuo_nld45b_tlp_sphv_10hv)
+ stthemuo = (stthemuo_nld45b_tlp_sphv_10hv)
+ cso      = (cso_nld45b_tlp_sphv_10hv)
+ csl      = (csl_nld45b_tlp_sphv_10hv)
+ cslexp   = (cslexp_nld45b_tlp_sphv_10hv)
+ csw      = (csw_nld45b_tlp_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld45b_tlp_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld45b_tlp_sphv_10hv)
+ xcoro    = (xcoro_nld45b_tlp_sphv_10hv)
+ xcorl    = (xcorl_nld45b_tlp_sphv_10hv)
+ xcorw    = (xcorw_nld45b_tlp_sphv_10hv)*(1-fem)
+ xcorlw   = (xcorlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stxcoro  = (stxcoro_nld45b_tlp_sphv_10hv)
+ fetao    = (fetao_nld45b_tlp_sphv_10hv)
+ rsw1     = (rsw1_nld45b_tlp_sphv_10hv)
+ rsw2     = (rsw2_nld45b_tlp_sphv_10hv)*(1-fem)
+ strso    = (strso_nld45b_tlp_sphv_10hv)
+ rsbo     = (rsbo_nld45b_tlp_sphv_10hv)
+ rsgo     = (rsgo_nld45b_tlp_sphv_10hv)
+ thesato  = (thesato_nld45b_tlp_sphv_10hv*delr_thesato_nld45b_tlp_sphv_10hv)*(thesat_ng_fac)
+ thesatl  = (thesatl_nld45b_tlp_sphv_10hv)
+ thesatlexp = (thesatlexp_nld45b_tlp_sphv_10hv)
+ thesatw  = (thesatw_nld45b_tlp_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld45b_tlp_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld45b_tlp_sphv_10hv)
+ stthesatl = (stthesatl_nld45b_tlp_sphv_10hv)
+ stthesatw = (stthesatw_nld45b_tlp_sphv_10hv)*(1-fem)
+ stthesatlw = (stthesatlw_nld45b_tlp_sphv_10hv)*(1-fem)
+ thesatbo = (thesatbo_nld45b_tlp_sphv_10hv)
+ thesatgo = (thesatgo_nld45b_tlp_sphv_10hv)
+ thesatgl = (thesatgl_nld45b_tlp_sphv_10hv)
+ thesatgw = (thesatgw_nld45b_tlp_sphv_10hv*(1-fem))
+ axo      = (axo_nld45b_tlp_sphv_10hv)
+ axl      = (axl_nld45b_tlp_sphv_10hv)
+ alpl     = (alpl_nld45b_tlp_sphv_10hv)
+ alplexp  = (alplexp_nld45b_tlp_sphv_10hv)
+ alpw     = (alpw_nld45b_tlp_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld45b_tlp_sphv_10hv)
+ alp1lexp = (alp1lexp_nld45b_tlp_sphv_10hv)
+ alp1l2   = (alp1l2_nld45b_tlp_sphv_10hv)
+ alp1w    = (alp1w_nld45b_tlp_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld45b_tlp_sphv_10hv)
+ alp2lexp = (alp2lexp_nld45b_tlp_sphv_10hv)
+ alp2l2   = (alp2l2_nld45b_tlp_sphv_10hv)
+ alp2w    = (alp2w_nld45b_tlp_sphv_10hv*(1-fem))
+ vpo      = (vpo_nld45b_tlp_sphv_10hv)
+ a1o      = (a1o_nld45b_tlp_sphv_10hv)
+ a1l      = (a1l_nld45b_tlp_sphv_10hv)
+ a1w      = (a1w_nld45b_tlp_sphv_10hv*(1-fem))
+ a2o      = (a2o_nld45b_tlp_sphv_10hv)
+ sta2o    = (sta2o_nld45b_tlp_sphv_10hv)
+ a3o      = (a3o_nld45b_tlp_sphv_10hv)
+ a3l      = (a3l_nld45b_tlp_sphv_10hv)
+ a3w      = (a3w_nld45b_tlp_sphv_10hv*(1-fem))
+ a4o      = (a4o_nld45b_tlp_sphv_10hv)
+ a4l      = (a4l_nld45b_tlp_sphv_10hv)
+ a4w      = (a4w_nld45b_tlp_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld45b_tlp_sphv_10hv)
+ iginvlw  = (iginvlw_nld45b_tlp_sphv_10hv)
+ igovw    = (igovw_nld45b_tlp_sphv_10hv)
+ igovdw   = (igovdw_nld45b_tlp_sphv_10hv)
+ stigo    = (stigo_nld45b_tlp_sphv_10hv)
+ gc2o     = (gc2o_nld45b_tlp_sphv_10hv)
+ gc3o     = (gc3o_nld45b_tlp_sphv_10hv)
+ chibo    = (chibo_nld45b_tlp_sphv_10hv)
+ agidlw   = (agidlw_nld45b_tlp_sphv_10hv*(1-fem))
+ agidldw  = (agidldw_nld45b_tlp_sphv_10hv*(1-fem))
+ bgidlo   = (bgidlo_nld45b_tlp_sphv_10hv)
+ bgidldo  = (bgidldo_nld45b_tlp_sphv_10hv)
+ stbgidlo = (stbgidlo_nld45b_tlp_sphv_10hv)
+ stbgidldo = (stbgidldo_nld45b_tlp_sphv_10hv)
+ cgidlo   = (cgidlo_nld45b_tlp_sphv_10hv)
+ cgidldo  = (cgidldo_nld45b_tlp_sphv_10hv)
+ cgbovl   = (cgbovl_nld45b_tlp_sphv_10hv)
+ cfrw     = (cfrw_nld45b_tlp_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_nld45b_tlp_sphv_10hv*(1-fem))
+ fnto     = (fnto_nld45b_tlp_sphv_10hv)
+ nfalw    = (nfalw_nld45b_tlp_sphv_10hv)
+ nfblw    = (nfblw_nld45b_tlp_sphv_10hv)
+ nfclw    = (nfclw_nld45b_tlp_sphv_10hv)
+ efo      = (efo_nld45b_tlp_sphv_10hv)
+ lintnoi  = (lintnoi_nld45b_tlp_sphv_10hv)
+ alpnoi   = (alpnoi_nld45b_tlp_sphv_10hv)
+ kvthoweo = (kvthoweo_nld45b_tlp_sphv_10hv)
+ kvthowel = (kvthowel_nld45b_tlp_sphv_10hv)
+ kvthowew = (kvthowew_nld45b_tlp_sphv_10hv)*(1-fem)
+ kvthowelw = (kvthowelw_nld45b_tlp_sphv_10hv)*(1-fem)
+ kuoweo   = (kuoweo_nld45b_tlp_sphv_10hv)
+ kuowel   = (kuowel_nld45b_tlp_sphv_10hv)
+ kuowew   = (kuowew_nld45b_tlp_sphv_10hv)*(1-fem)
+ kuowelw  = (kuowelw_nld45b_tlp_sphv_10hv)*(1-fem)
+ rgo      = (rgo_nld45b_tlp_sphv_10hv)
+ rsh      = (rsh_nld45b_tlp_sphv_10hv)
+ rbulko   = (rbulko_nld45b_tlp_sphv_10hv)
+ rwello   = (rwello_nld45b_tlp_sphv_10hv)
+ rjunso   = (rjunso_nld45b_tlp_sphv_10hv/(weff+dwrjunso_nld45b_tlp_sphv_10hv*(1-fem)))
+ rjundo   = (rjundo_nld45b_tlp_sphv_10hv/(weff+dwrjundo_nld45b_tlp_sphv_10hv*(1-fem)))
+ rint     = (rint_nld45b_tlp_sphv_10hv)
+ rvpoly   = (rvpoly_nld45b_tlp_sphv_10hv)
+ rshg     = (rshg_nld45b_tlp_sphv_10hv)
+ dlsil    = (dlsil_nld45b_tlp_sphv_10hv)
+ saref    = (saref_nld45b_tlp_sphv_10hv)
+ sbref    = (sbref_nld45b_tlp_sphv_10hv)
+ wlod     = (wlod_nld45b_tlp_sphv_10hv)
+ kuo      = (kuo_nld45b_tlp_sphv_10hv)
+ kvsat    = (kvsat_nld45b_tlp_sphv_10hv)
+ tkuo     = (tkuo_nld45b_tlp_sphv_10hv)
+ lkuo     = (lkuo_nld45b_tlp_sphv_10hv)
+ wkuo     = (wkuo_nld45b_tlp_sphv_10hv)*(1-fem)
+ pkuo     = (pkuo_nld45b_tlp_sphv_10hv)*(1-fem)
+ llodkuo  = (llodkuo_nld45b_tlp_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld45b_tlp_sphv_10hv)
+ kvtho    = (kvtho_nld45b_tlp_sphv_10hv)
+ lkvtho   = (lkvtho_nld45b_tlp_sphv_10hv)
+ wkvtho   = (wkvtho_nld45b_tlp_sphv_10hv)*(1-fem)
+ pkvtho   = (pkvtho_nld45b_tlp_sphv_10hv)*(1-fem)
+ llodvth  = (llodvth_nld45b_tlp_sphv_10hv)
+ wlodvth  = (wlodvth_nld45b_tlp_sphv_10hv)
+ stetao   = (stetao_nld45b_tlp_sphv_10hv)
+ lodetao  = (lodetao_nld45b_tlp_sphv_10hv)
+ scref    = (scref_nld45b_tlp_sphv_10hv)
+ web      = (web_nld45b_tlp_sphv_10hv)
+ wec      = (wec_nld45b_tlp_sphv_10hv)
+ adr1o    = (adr1o_nld45b_tlp_sphv_10hv)
+ adr1l    = (adr1l_nld45b_tlp_sphv_10hv)
+ adr1w    = ((adr1w_nld45b_tlp_sphv_10hv)/(weff)*(adr1w_ng_fac))*(1-fem)
+ adr2o    = (adr2o_nld45b_tlp_sphv_10hv)
+ stadr2o  = (stadr2o_nld45b_tlp_sphv_10hv)
+ adr3o    = (adr3o_nld45b_tlp_sphv_10hv)
+ adr3l    = (adr3l_nld45b_tlp_sphv_10hv)
+ adr3w    = (adr3w_nld45b_tlp_sphv_10hv)*(1-fem)
+ adr4o    = (adr4o_nld45b_tlp_sphv_10hv)
+ adr4l    = (adr4l_nld45b_tlp_sphv_10hv)
+ adr4w    = (adr4w_nld45b_tlp_sphv_10hv)*(1-fem)
+ adr5o    = (adr5o_nld45b_tlp_sphv_10hv)
+ adr5l    = (adr5l_nld45b_tlp_sphv_10hv)
+ adr5w    = (adr5w_nld45b_tlp_sphv_10hv)*(1-fem)
+ bidr1o   = (bidr1o_nld45b_tlp_sphv_10hv)
+ bidr1l   = (bidr1l_nld45b_tlp_sphv_10hv)
+ bidr1w   = (bidr1w_nld45b_tlp_sphv_10hv)*(1-fem)
+ bidr2o   = (bidr2o_nld45b_tlp_sphv_10hv)
+ bidr2w   = (bidr2w_nld45b_tlp_sphv_10hv)*(1-fem)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
//+ rtho=(rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld45b_tlp_sphv_10hv)
+ strthao   = (strthao_nld45b_tlp_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = (rshldd_nld45b_tlp_sphv_10hv*delr_rsh_nld45b_tlp_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45b_tlp_ronratio))*(fac_rshldd)*(rshldd_ng_fac)
+ xw       = ((xw_nld45b_tlp_sphv_10hv+(1e-6)*dela_xw_nld45b_tlp_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld45b_tlp_sphv_10hv*(1-fem))
+ xl       = (xl_nld45b_tlp_sphv_10hv)
+ xlw      = (xlw_nld45b_tlp_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld45b_tlp_sphv_10hv)
+ nst      = (nst_nld45b_tlp_sphv_10hv)
+ ats      = (ats_nld45b_tlp_sphv_10hv)
+ dfinf    = (dfinf_nld45b_tlp_sphv_10hv)
+ dfw      = (dfw_nld45b_tlp_sphv_10hv*(1-fem))
+ dfl      = (dfl_nld45b_tlp_sphv_10hv)
+ dflw     = (dflw_nld45b_tlp_sphv_10hv*(1-fem))
+ dp       = (dp_nld45b_tlp_sphv_10hv)
+ ecrit    = (ecrit_nld45b_tlp_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ ecorn    = (ecorn_nld45b_tlp_sphv_10hv*tfact_ecrit)*(1+dwecrit/weff+dwecritw/(weff*weff))*(ecrit_ng_fac)
+ du       = (du_nld45b_tlp_sphv_10hv)
+ tc1      = (tc1_nld45b_tlp_sphv_10hv)
+ tc2      = (tc2_nld45b_tlp_sphv_10hv)
+ tc1l     = (tc1l_nld45b_tlp_sphv_10hv)
+ tc2l     = (tc2l_nld45b_tlp_sphv_10hv)
+ tc1w     = (tc1w_nld45b_tlp_sphv_10hv)*(1-fem)
+ tc2w     = (tc2w_nld45b_tlp_sphv_10hv)*(1-fem)
+ theacc   = (theacc_nld45b_tlp_sphv_10hv)
+ theacc2  = (theacc2_nld45b_tlp_sphv_10hv)
+ aacc     = (aacc_nld45b_tlp_sphv_10hv)
