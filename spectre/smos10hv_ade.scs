+    sig_delr_tox_nld90b_sphv_10hv = 0.012
+    sig_dela_dw_nld90b_sphv_10hv = 0.01993
+    sig_dela_xw_nld90b_sphv_10hv = 0.01865
+    sig_dela_vfb_nld90b_sphv_10hv = 0.04043
+    sig_delr_mobref_nld90b_sphv_10hv = 0.02
+    sig_delr_ids_nld90b_sphv_10hv = 0.01
+    sig_delr_rshl_nld90b_sphv_10hv = 0.02026
+    sig_dela_vtwl_nld90b_sphv_10hv = 0.02939
+    sig_delr_cj_nld90b_sphv_10hv = 0.033
+    sig_delr_is_nld90b_sphv_10hv = 0.055
+    sig_delr_is2_nld90b_sphv_10hv = 0.768
+    sig_delr_ir_nld90b_sphv_10hv = 0.768
+    sig_delr_cfr_s_ply_met_nld90b_sphv_10hv = 0.0465
+    sig_delr_cfr_d_ply_met_nld90b_sphv_10hv = 0.0096
+    sig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = 0.028
+    sig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = 0.0063
+    fac_rth_nld90b_sphv_10hv  = 0.8
+    tc1_ecrit_nld90b_sphv_10hv = 0.0062
+    tc2_ecrit_nld90b_sphv_10hv = 1.2e-05
+    dwrjundo_nld90b_sphv_10hv = 2.4
+    dwrjunso_nld90b_sphv_10hv = 8e-06
+    qmc_nld90b_sphv_10hv      = 1.0
+    lvaro_nld90b_sphv_10hv    = 0.0
+    lvarl_nld90b_sphv_10hv    = 0.0
+    lvarw_nld90b_sphv_10hv    = 0.0
+    lap_nld90b_sphv_10hv      = 0.0
+    wvaro_nld90b_sphv_10hv    = 3e-07
+    wvarl_nld90b_sphv_10hv    = 0.0
+    wvarw_nld90b_sphv_10hv    = 0.0
+    wot_nld90b_sphv_10hv      = 0.0
+    dlq_nld90b_sphv_10hv      = 0.0
+    dwq_nld90b_sphv_10hv      = 3e-08
+    vfbo_nld90b_sphv_10hv     = -1.07
+    vfbl_nld90b_sphv_10hv     = 0.0
+    vfbw_nld90b_sphv_10hv     = 0.028
+    vfblw_nld90b_sphv_10hv    = 0.0
+    stvfbo_nld90b_sphv_10hv   = 0.000965
+    stvfbl_nld90b_sphv_10hv   = 0.0
+    stvfbw_nld90b_sphv_10hv   = -0.12
+    stvfblw_nld90b_sphv_10hv  = 0.0
+    toxo_nld90b_sphv_10hv     = 1.32e-08
+    epsroxo_nld90b_sphv_10hv  = 3.9
+    nsubo_nld90b_sphv_10hv    = 3.83e+23
+    nsubw_nld90b_sphv_10hv    = 0.0
+    wseg_nld90b_sphv_10hv     = 1e-08
+    npck_nld90b_sphv_10hv     = 1e+23
+    npckw_nld90b_sphv_10hv    = 0.0
+    wsegp_nld90b_sphv_10hv    = 1e-08
+    lpck_nld90b_sphv_10hv     = 0.0
+    lpckw_nld90b_sphv_10hv    = 0.0
+    fol1_nld90b_sphv_10hv     = 0.0
+    fol2_nld90b_sphv_10hv     = 0.0
+    facneffaco_nld90b_sphv_10hv = 0.3
+    facneffacl_nld90b_sphv_10hv = 0.0
+    facneffacw_nld90b_sphv_10hv = 0.4
+    facneffaclw_nld90b_sphv_10hv = 0.0
+    gfacnudo_nld90b_sphv_10hv = 1.1
+    gfacnudl_nld90b_sphv_10hv = 0.0
+    gfacnudlexp_nld90b_sphv_10hv = 1.0
+    gfacnudw_nld90b_sphv_10hv = 0.0
+    gfacnudlw_nld90b_sphv_10hv = 0.0
+    vsbnudo_nld90b_sphv_10hv  = 0.0
+    dvsbnudo_nld90b_sphv_10hv = 1.0
+    vnsubo_nld90b_sphv_10hv   = 0.0
+    nslpo_nld90b_sphv_10hv    = 0.05
+    dnsubo_nld90b_sphv_10hv   = 0.0
+    dphibo_nld90b_sphv_10hv   = 0.0
+    dphibl_nld90b_sphv_10hv   = 0.0
+    dphiblexp_nld90b_sphv_10hv = 1.0
+    dphibw_nld90b_sphv_10hv   = 0.0
+    dphiblw_nld90b_sphv_10hv  = 0.0
+    delvtaco_nld90b_sphv_10hv = 0.05
+    delvtacl_nld90b_sphv_10hv = 0.0
+    delvtaclexp_nld90b_sphv_10hv = 1.0
+    delvtacw_nld90b_sphv_10hv = -0.3
+    delvtaclw_nld90b_sphv_10hv = 0.0
+    npo_nld90b_sphv_10hv      = 1e+26
+    npl_nld90b_sphv_10hv      = 0.0
+    cto_nld90b_sphv_10hv      = 0.019
+    ctl_nld90b_sphv_10hv      = 0.0
+    ctlexp_nld90b_sphv_10hv   = 1.0
+    ctw_nld90b_sphv_10hv      = 0.0
+    ctlw_nld90b_sphv_10hv     = 0.0
+    toxovo_nld90b_sphv_10hv   = 1.32e-08
+    toxovdo_nld90b_sphv_10hv  = 1.32e-08
+    lov_nld90b_sphv_10hv      = 3e-08
+    dlovd_nld90b_sphv_10hv    = -4e-08
+    novo_nld90b_sphv_10hv     = 1e+24
+    novdo_nld90b_sphv_10hv    = 3.5e+22
+    cfl_nld90b_sphv_10hv      = 0.0001
+    cflexp_nld90b_sphv_10hv   = 2.0
+    cfw_nld90b_sphv_10hv      = 0.0
+    cfbo_nld90b_sphv_10hv     = 0.0
+    uo_nld90b_sphv_10hv       = 0.073
+    fbet1_nld90b_sphv_10hv    = 0.0
+    fbet1w_nld90b_sphv_10hv   = 0.0
+    lp1_nld90b_sphv_10hv      = 1e-08
+    lp1w_nld90b_sphv_10hv     = 0.0
+    fbet2_nld90b_sphv_10hv    = 0.0
+    lp2_nld90b_sphv_10hv      = 1e-08
+    betw1_nld90b_sphv_10hv    = -0.04
+    betw2_nld90b_sphv_10hv    = 0.0
+    wbet_nld90b_sphv_10hv     = 1e-09
+    stbeto_nld90b_sphv_10hv   = 1.0
+    stbetl_nld90b_sphv_10hv   = 0.0
+    stbetw_nld90b_sphv_10hv   = 0.5
+    stbetlw_nld90b_sphv_10hv  = 0.0
+    mueo_nld90b_sphv_10hv     = 0.8
+    muew_nld90b_sphv_10hv     = 0.9
+    stmueo_nld90b_sphv_10hv   = 0.0
+    themuo_nld90b_sphv_10hv   = 1.0
+    stthemuo_nld90b_sphv_10hv = 1.1
+    cso_nld90b_sphv_10hv      = 0.0
+    csl_nld90b_sphv_10hv      = 0.0
+    cslexp_nld90b_sphv_10hv   = 0.0
+    csw_nld90b_sphv_10hv      = 0.0
+    cslw_nld90b_sphv_10hv     = 0.0
+    stcso_nld90b_sphv_10hv    = 0.0
+    xcoro_nld90b_sphv_10hv    = 0.0
+    xcorl_nld90b_sphv_10hv    = 0.0
+    xcorw_nld90b_sphv_10hv    = 0.0
+    xcorlw_nld90b_sphv_10hv   = 0.0
+    stxcoro_nld90b_sphv_10hv  = 0.0
+    fetao_nld90b_sphv_10hv    = 1.0
+    rsw1_nld90b_sphv_10hv     = 200.0
+    rsw2_nld90b_sphv_10hv     = -3.0
+    strso_nld90b_sphv_10hv    = 1.0
+    rsbo_nld90b_sphv_10hv     = 0.0
+    rsgo_nld90b_sphv_10hv     = 0.0
+    thesato_nld90b_sphv_10hv  = 0.0935
+    thesatl_nld90b_sphv_10hv  = 0.0
+    thesatlexp_nld90b_sphv_10hv = 1.0
+    thesatw_nld90b_sphv_10hv  = -0.14
+    thesatlw_nld90b_sphv_10hv = 0.0
+    stthesato_nld90b_sphv_10hv = 0.3
+    stthesatl_nld90b_sphv_10hv = 0.0
+    stthesatw_nld90b_sphv_10hv = 0.0
+    stthesatlw_nld90b_sphv_10hv = 0.0
+    thesatbo_nld90b_sphv_10hv = 0.0
+    thesatgo_nld90b_sphv_10hv = 3.9
+    thesatgl_nld90b_sphv_10hv = 0.0
+    thesatgw_nld90b_sphv_10hv = 0.0
+    axo_nld90b_sphv_10hv      = 3.0
+    axl_nld90b_sphv_10hv      = 0.4
+    alpl_nld90b_sphv_10hv     = 0.0005
+    alplexp_nld90b_sphv_10hv  = 1.0
+    alpw_nld90b_sphv_10hv     = 0.0
+    alp1l1_nld90b_sphv_10hv   = 0.0
+    alp1lexp_nld90b_sphv_10hv = 0.5
+    alp1l2_nld90b_sphv_10hv   = 0.0
+    alp1w_nld90b_sphv_10hv    = 0.0
+    alp2l1_nld90b_sphv_10hv   = 0.0
+    alp2lexp_nld90b_sphv_10hv = 0.5
+    alp2l2_nld90b_sphv_10hv   = 0.0
+    alp2w_nld90b_sphv_10hv    = 0.0
+    vpo_nld90b_sphv_10hv      = 0.05
+    a1o_nld90b_sphv_10hv      = 0.013
+    a1l_nld90b_sphv_10hv      = 0.0
+    a1w_nld90b_sphv_10hv      = 0.0
+    a2o_nld90b_sphv_10hv      = 7.0
+    sta2o_nld90b_sphv_10hv    = 6.0
+    a3o_nld90b_sphv_10hv      = 170.0
+    a3l_nld90b_sphv_10hv      = 0.0
+    a3w_nld90b_sphv_10hv      = 0.0
+    a4o_nld90b_sphv_10hv      = 0.0
+    a4l_nld90b_sphv_10hv      = 0.0
+    a4w_nld90b_sphv_10hv      = 0.0
+    gcoo_nld90b_sphv_10hv     = 0.0
+    iginvlw_nld90b_sphv_10hv  = 0.0
+    igovw_nld90b_sphv_10hv    = 0.0
+    igovdw_nld90b_sphv_10hv   = 0.0
+    stigo_nld90b_sphv_10hv    = 2.0
+    gc2o_nld90b_sphv_10hv     = 0.375
+    gc3o_nld90b_sphv_10hv     = 0.063
+    chibo_nld90b_sphv_10hv    = 3.1
+    agidlw_nld90b_sphv_10hv   = 0.0
+    agidldw_nld90b_sphv_10hv  = 0.0
+    bgidlo_nld90b_sphv_10hv   = 41.0
+    bgidldo_nld90b_sphv_10hv  = 41.0
+    stbgidlo_nld90b_sphv_10hv = 0.0
+    stbgidldo_nld90b_sphv_10hv = 0.0
+    cgidlo_nld90b_sphv_10hv   = 0.0
+    cgidldo_nld90b_sphv_10hv  = 0.0
+    cgbovl_nld90b_sphv_10hv   = 0.0
+    cfrw_nld90b_sphv_10hv     = 1e-16
+    cfrdw_nld90b_sphv_10hv    = 4e-17
+    fnto_nld90b_sphv_10hv     = 1.0
+    nfalw_nld90b_sphv_10hv    = 3.9e+26
+    nfblw_nld90b_sphv_10hv    = 30000000.0
+    nfclw_nld90b_sphv_10hv    = 0.0
+    efo_nld90b_sphv_10hv      = 0.9
+    lintnoi_nld90b_sphv_10hv  = 0.0
+    alpnoi_nld90b_sphv_10hv   = 2.0
+    kvthoweo_nld90b_sphv_10hv = 0.0
+    kvthowel_nld90b_sphv_10hv = 0.0
+    kvthowew_nld90b_sphv_10hv = 0.0
+    kvthowelw_nld90b_sphv_10hv = 0.0
+    kuoweo_nld90b_sphv_10hv   = 0.0
+    kuowel_nld90b_sphv_10hv   = 0.0
+    kuowew_nld90b_sphv_10hv   = 0.0
+    kuowelw_nld90b_sphv_10hv  = 0.0
+    rgo_nld90b_sphv_10hv      = 0.0
+    rsh_nld90b_sphv_10hv      = 0.0
+    rbulko_nld90b_sphv_10hv   = 0.0
+    rwello_nld90b_sphv_10hv   = 0.0
+    rjunso_nld90b_sphv_10hv   = 10.0
+    rjundo_nld90b_sphv_10hv   = 270.0
+    rint_nld90b_sphv_10hv     = 0.0
+    rvpoly_nld90b_sphv_10hv   = 0.0
+    rshg_nld90b_sphv_10hv     = 0.0
+    dlsil_nld90b_sphv_10hv    = 0.0
+    saref_nld90b_sphv_10hv    = 1e-06
+    sbref_nld90b_sphv_10hv    = 1e-06
+    wlod_nld90b_sphv_10hv     = 0.0
+    kuo_nld90b_sphv_10hv      = 0.0
+    kvsat_nld90b_sphv_10hv    = 0.0
+    tkuo_nld90b_sphv_10hv     = 0.0
+    lkuo_nld90b_sphv_10hv     = 0.0
+    wkuo_nld90b_sphv_10hv     = 0.0
+    pkuo_nld90b_sphv_10hv     = 0.0
+    llodkuo_nld90b_sphv_10hv  = 0.0
+    wlodkuo_nld90b_sphv_10hv  = 0.0
+    kvtho_nld90b_sphv_10hv    = 0.0
+    lkvtho_nld90b_sphv_10hv   = 0.0
+    wkvtho_nld90b_sphv_10hv   = 0.0
+    pkvtho_nld90b_sphv_10hv   = 0.0
+    llodvth_nld90b_sphv_10hv  = 0.0
+    wlodvth_nld90b_sphv_10hv  = 0.0
+    stetao_nld90b_sphv_10hv   = 0.0
+    lodetao_nld90b_sphv_10hv  = 1.0
+    scref_nld90b_sphv_10hv    = 1e-05
+    web_nld90b_sphv_10hv      = 0.0
+    wec_nld90b_sphv_10hv      = 0.0
+    adr1o_nld90b_sphv_10hv    = 0.0002
+    adr1l_nld90b_sphv_10hv    = 0.0
+    adr1w_nld90b_sphv_10hv    = 0.07
+    adr2o_nld90b_sphv_10hv    = 2.0
+    stadr2o_nld90b_sphv_10hv  = 1.0
+    adr3o_nld90b_sphv_10hv    = 0.1
+    adr3l_nld90b_sphv_10hv    = 0.0
+    adr3w_nld90b_sphv_10hv    = -0.07
+    adr4o_nld90b_sphv_10hv    = 0.0
+    adr4l_nld90b_sphv_10hv    = 0.0
+    adr4w_nld90b_sphv_10hv    = 0.0
+    adr5o_nld90b_sphv_10hv    = 0.0
+    adr5l_nld90b_sphv_10hv    = 0.0
+    adr5w_nld90b_sphv_10hv    = 0.0
+    bidr1o_nld90b_sphv_10hv   = 0.0
+    bidr1l_nld90b_sphv_10hv   = 0.0
+    bidr1w_nld90b_sphv_10hv   = 0.0
+    bidr2o_nld90b_sphv_10hv   = 0.0
+    bidr2w_nld90b_sphv_10hv   = 0.0
+    rtho_nld90b_sphv_10hv     = 750.0
+    rthl_nld90b_sphv_10hv     = 0.0
+    rthw_nld90b_sphv_10hv     = 0.0
+    rthlw_nld90b_sphv_10hv    = 0.0
+    strtho_nld90b_sphv_10hv   = 0.0
+    ctho_nld90b_sphv_10hv     = 0.0
+    cthl_nld90b_sphv_10hv     = 0.0
+    cthw_nld90b_sphv_10hv     = 0.0
+    cthlw_nld90b_sphv_10hv    = 0.0
+    rshldd_nld90b_sphv_10hv   = 3240.0
+    xw_nld90b_sphv_10hv       = 2.9e-06
+    nwxw_nld90b_sphv_10hv     = 0.0
+    xl_nld90b_sphv_10hv       = 0.0
+    xlw_nld90b_sphv_10hv      = 0.0
+    dxlsat_nld90b_sphv_10hv   = 0.0
+    nst_nld90b_sphv_10hv      = 1.0
+    ats_nld90b_sphv_10hv      = 0.0
+    dfinf_nld90b_sphv_10hv    = 0.01
+    dfw_nld90b_sphv_10hv      = 0.0
+    dfl_nld90b_sphv_10hv      = 0.0
+    dflw_nld90b_sphv_10hv     = 0.0
+    dp_nld90b_sphv_10hv       = 2.0
+    ecrit_nld90b_sphv_10hv    = 1270000.0
+    ecorn_nld90b_sphv_10hv    = 120000.0
+    du_nld90b_sphv_10hv       = 0.02
+    tc1_nld90b_sphv_10hv      = 0.0055
+    tc2_nld90b_sphv_10hv      = 1.57e-05
+    tc1l_nld90b_sphv_10hv     = 0.0
+    tc2l_nld90b_sphv_10hv     = 0.0
+    tc1w_nld90b_sphv_10hv     = -1.8e-09
+    tc2w_nld90b_sphv_10hv     = 0.0
+    theacc_nld90b_sphv_10hv   = 0.0
+    theacc2_nld90b_sphv_10hv  = 0.0
+    rva_nld90b_sphv_10hv      = 53.5
+    dta_nld90b_sphv_10hv      = 0.0
+    trj_nld90b_sphv_10hv      = 25.0
+    cjarea_nld90b_sphv_10hv   = 0.0
+    cjlsti_nld90b_sphv_10hv   = 0.0
+    cjlgat_nld90b_sphv_10hv   = 0.0
+    vbiarea_nld90b_sphv_10hv  = 1.0
+    vbisti_nld90b_sphv_10hv   = 1.0
+    vbigat_nld90b_sphv_10hv   = 1.0
+    parea_nld90b_sphv_10hv    = 0.5
+    psti_nld90b_sphv_10hv     = 0.5
+    pgat_nld90b_sphv_10hv     = 0.5
+    is1area_nld90b_sphv_10hv  = 1e-12
+    ttarea_nld90b_sphv_10hv   = 0.0
+    is2area_nld90b_sphv_10hv  = 0.0
+    irarea_nld90b_sphv_10hv   = 0.0
+    stis1area_nld90b_sphv_10hv = 3.0
+    stis2area_nld90b_sphv_10hv = 3.0
+    stirarea_nld90b_sphv_10hv = 3.0
+    n1area_nld90b_sphv_10hv   = 1.0
+    n2area_nld90b_sphv_10hv   = 2.0
+    nrarea_nld90b_sphv_10hv   = 100.0
+    is1lsti_nld90b_sphv_10hv  = 1e-18
+    ttlsti_nld90b_sphv_10hv   = 0.0
+    is2lsti_nld90b_sphv_10hv  = 0.0
+    irlsti_nld90b_sphv_10hv   = 0.0
+    stis1sti_nld90b_sphv_10hv = 3.0
+    stis2sti_nld90b_sphv_10hv = 3.0
+    stirsti_nld90b_sphv_10hv  = 3.0
+    n1sti_nld90b_sphv_10hv    = 1.0
+    n2sti_nld90b_sphv_10hv    = 2.0
+    nrsti_nld90b_sphv_10hv    = 100.0
+    is1lgat_nld90b_sphv_10hv  = 1e-18
+    ttlgat_nld90b_sphv_10hv   = 0.0
+    is2lgat_nld90b_sphv_10hv  = 0.0
+    irlgat_nld90b_sphv_10hv   = 0.0
+    stis1gat_nld90b_sphv_10hv = 3.0
+    stis2gat_nld90b_sphv_10hv = 3.0
+    stirgat_nld90b_sphv_10hv  = 3.0
+    n1gat_nld90b_sphv_10hv    = 1.0
+    n2gat_nld90b_sphv_10hv    = 2.0
+    nrgat_nld90b_sphv_10hv    = 100.0
+    cjaread_nld90b_sphv_10hv  = 0.00015
+    cjlstid_nld90b_sphv_10hv  = 1e-18
+    cjlgatd_nld90b_sphv_10hv  = 1e-18
+    vbiaread_nld90b_sphv_10hv = 0.35
+    vbistid_nld90b_sphv_10hv  = 0.6
+    vbigatd_nld90b_sphv_10hv  = 0.35
+    paread_nld90b_sphv_10hv   = 0.42
+    pstid_nld90b_sphv_10hv    = 0.5
+    pgatd_nld90b_sphv_10hv    = 0.42
+    is1aread_nld90b_sphv_10hv = 2.573e-08
+    ttaread_nld90b_sphv_10hv  = 0.0
+    is2aread_nld90b_sphv_10hv = 8.5e-06
+    iraread_nld90b_sphv_10hv  = 2.2e-09
+    stis1aread_nld90b_sphv_10hv = 4.3
+    stis2aread_nld90b_sphv_10hv = 3.0
+    stiraread_nld90b_sphv_10hv = 77000.0
+    n1aread_nld90b_sphv_10hv  = 0.99
+    n2aread_nld90b_sphv_10hv  = 1.72
+    nraread_nld90b_sphv_10hv  = 3800.0
+    is1lstid_nld90b_sphv_10hv = 2e-09
+    ttlstid_nld90b_sphv_10hv  = 0.0
+    is2lstid_nld90b_sphv_10hv = 0.0
+    irlstid_nld90b_sphv_10hv  = 2.2e-09
+    stis1stid_nld90b_sphv_10hv = 3.0
+    stis2stid_nld90b_sphv_10hv = 3.0
+    stirstid_nld90b_sphv_10hv = 77000.0
+    n1stid_nld90b_sphv_10hv   = 1.0
+    n2stid_nld90b_sphv_10hv   = 1.68
+    nrstid_nld90b_sphv_10hv   = 3800.0
+    is1lgatd_nld90b_sphv_10hv = 2e-09
+    ttlgatd_nld90b_sphv_10hv  = 0.0
+    is2lgatd_nld90b_sphv_10hv = 0.0
+    irlgatd_nld90b_sphv_10hv  = 2.2e-09
+    stis1gatd_nld90b_sphv_10hv = 3.0
+    stis2gatd_nld90b_sphv_10hv = 3.0
+    stirgatd_nld90b_sphv_10hv = 77000.0
+    n1gatd_nld90b_sphv_10hv   = 0.99
+    n2gatd_nld90b_sphv_10hv   = 1.5
+    nrgatd_nld90b_sphv_10hv   = 3800.0
+    cjaread2_nld90b_sphv_10hv = 0.000178
+    cjlstid2_nld90b_sphv_10hv = 1e-18
+    vbiaread2_nld90b_sphv_10hv = 0.6
+    vbistid2_nld90b_sphv_10hv = 0.35
+    paread2_nld90b_sphv_10hv  = 0.51
+    pstid2_nld90b_sphv_10hv   = 0.42
+    is1aread2_nld90b_sphv_10hv = 2.873e-08
+    ttaread2_nld90b_sphv_10hv = 0.0
+    is2aread2_nld90b_sphv_10hv = 1.5e-06
+    iraread2_nld90b_sphv_10hv = 4.4e-10
+    stis1aread2_nld90b_sphv_10hv = 1.0
+    stis2aread2_nld90b_sphv_10hv = 3.0
+    stiraread2_nld90b_sphv_10hv = 77000.0
+    n1aread2_nld90b_sphv_10hv = 1.024
+    n2aread2_nld90b_sphv_10hv = 1.68
+    nraread2_nld90b_sphv_10hv = 3000.0
+    is1lstid2_nld90b_sphv_10hv = 0
+    ttlstid2_nld90b_sphv_10hv = 0.0
+    is2lstid2_nld90b_sphv_10hv = 0.0
+    irlstid2_nld90b_sphv_10hv = 4.4e-10
+    stis1stid2_nld90b_sphv_10hv = 4.0
+    stis2stid2_nld90b_sphv_10hv = 3.0
+    stirstid2_nld90b_sphv_10hv = 77000.0
+    n1stid2_nld90b_sphv_10hv  = 1.5
+    n2stid2_nld90b_sphv_10hv  = 1.68
+    nrstid2_nld90b_sphv_10hv  = 3500.0
+    aacc_nld90b_sphv_10hv     = 36.0
+    ikfarea_nld90b_sphv_10hv  = 0.0
+    stikfarea_nld90b_sphv_10hv = 0.0
+    ikfaread_nld90b_sphv_10hv = 11000000.0
+    dwikfaread_nld90b_sphv_10hv = 8.0
+    stikfaread_nld90b_sphv_10hv = 0.0
+    nom_delr_tox_nld45b_tlp_sphv_10hv = 1.0
+    nom_dela_xw_nld45b_tlp_sphv_10hv = 0.08604
+    nom_dela_vfb_nld45b_tlp_sphv_10hv = 0.0489260555675
+    nom_delr_mobref_nld45b_tlp_sphv_10hv = 0.9997
+    nom_delr_rsh_nld45b_tlp_sphv_10hv = 1.025
+    nom_delr_vdscale_nld45b_tlp_sphv_10hv = 1.0
+    nom_delr_thesato_nld45b_tlp_sphv_10hv = 1.496
+    nom_dela_vtw_nld45b_tlp_sphv_10hv = 0.0127976342242
+    nom_dela_vfb_nld45b_tlp_mosb_10hv = 0.0
+    nom_delr_cj_nld45b_tlp_sphv_10hv = 1.0
+    nom_delr_is_nld45b_tlp_sphv_10hv = 1.0
+    nom_delr_is2_nld45b_tlp_sphv_10hv = 1.0
+    nom_delr_ir_nld45b_tlp_sphv_10hv = 1.0
+    sig_delr_tox_nld45b_tlp_sphv_10hv = 0.012
+    sig_dela_xw_nld45b_tlp_sphv_10hv = 0.066
+    sig_dela_vfb_nld45b_tlp_sphv_10hv = 0.07
+    sig_delr_mobref_nld45b_tlp_sphv_10hv = 0.032
+    sig_delr_rsh_nld45b_tlp_sphv_10hv = 0.0287
+    sig_delr_vdscale_nld45b_tlp_sphv_10hv = 0.03
+    sig_delr_thesato_nld45b_tlp_sphv_10hv = 0.03
+    sig_dela_vtw_nld45b_tlp_sphv_10hv = 0.05
+    sig_dela_vfb_nld45b_tlp_mosb_10hv = 0.05
+    sig_delr_cj_nld45b_tlp_sphv_10hv = 0.0333
+    sig_delr_is_nld45b_tlp_sphv_10hv = 0.055
+    sig_delr_is2_nld45b_tlp_sphv_10hv = 0.768
+    sig_delr_ir_nld45b_tlp_sphv_10hv = 0.768
+    fac_rth_nld45b_tlp_sphv_10hv = 1.89
+    tc1_ecrit_nld45b_tlp_sphv_10hv = 0.0
+    tc2_ecrit_nld45b_tlp_sphv_10hv = 0.0
+    dwrjundo_nld45b_tlp_sphv_10hv = 0.6
+    dwrjunso_nld45b_tlp_sphv_10hv = 8e-06
+    qmc_nld45b_tlp_sphv_10hv  = 0.0
+    lvaro_nld45b_tlp_sphv_10hv = 0.0
+    lvarl_nld45b_tlp_sphv_10hv = 0.0
+    lvarw_nld45b_tlp_sphv_10hv = 0.0
+    lap_nld45b_tlp_sphv_10hv  = 0.0
+    wvaro_nld45b_tlp_sphv_10hv = 1.399e-06
+    wvarl_nld45b_tlp_sphv_10hv = 0.0
+    wvarw_nld45b_tlp_sphv_10hv = -1.112
+    wot_nld45b_tlp_sphv_10hv  = 0.0
+    dlq_nld45b_tlp_sphv_10hv  = 0.0
+    dwq_nld45b_tlp_sphv_10hv  = -5e-07
+    vfbo_nld45b_tlp_sphv_10hv = -1.112
+    vfbl_nld45b_tlp_sphv_10hv = 0.0
+    vfbw_nld45b_tlp_sphv_10hv = 0.0
+    vfblw_nld45b_tlp_sphv_10hv = 0.0
+    stvfbo_nld45b_tlp_sphv_10hv = 0.001392
+    stvfbl_nld45b_tlp_sphv_10hv = 0.0
+    stvfbw_nld45b_tlp_sphv_10hv = -0.02553
+    stvfblw_nld45b_tlp_sphv_10hv = 0.0
+    toxo_nld45b_tlp_sphv_10hv = 1.4e-08
+    epsroxo_nld45b_tlp_sphv_10hv = 3.9
+    nsubo_nld45b_tlp_sphv_10hv = 2.6e+23
+    nsubw_nld45b_tlp_sphv_10hv = 0.0
+    wseg_nld45b_tlp_sphv_10hv = 1e-08
+    npck_nld45b_tlp_sphv_10hv = 1e+23
+    npckw_nld45b_tlp_sphv_10hv = 0.0
+    wsegp_nld45b_tlp_sphv_10hv = 1e-08
+    lpck_nld45b_tlp_sphv_10hv = 0.0
+    lpckw_nld45b_tlp_sphv_10hv = 0.0
+    fol1_nld45b_tlp_sphv_10hv = 0.0
+    fol2_nld45b_tlp_sphv_10hv = 0.0
+    facneffaco_nld45b_tlp_sphv_10hv = 0.3
+    facneffacl_nld45b_tlp_sphv_10hv = 0.0
+    facneffacw_nld45b_tlp_sphv_10hv = -0.3
+    facneffaclw_nld45b_tlp_sphv_10hv = 0.0
+    gfacnudo_nld45b_tlp_sphv_10hv = 1.0
+    gfacnudl_nld45b_tlp_sphv_10hv = 0.0
+    gfacnudlexp_nld45b_tlp_sphv_10hv = 1.0
+    gfacnudw_nld45b_tlp_sphv_10hv = 0.0
+    gfacnudlw_nld45b_tlp_sphv_10hv = 0.0
+    vsbnudo_nld45b_tlp_sphv_10hv = 0.0
+    dvsbnudo_nld45b_tlp_sphv_10hv = 1.0
+    vnsubo_nld45b_tlp_sphv_10hv = 0.0
+    nslpo_nld45b_tlp_sphv_10hv = 0.05
+    dnsubo_nld45b_tlp_sphv_10hv = 0.1783
+    dphibo_nld45b_tlp_sphv_10hv = 0.1449
+    dphibl_nld45b_tlp_sphv_10hv = -0.006442
+    dphiblexp_nld45b_tlp_sphv_10hv = 1.0
+    dphibw_nld45b_tlp_sphv_10hv = 0.0
+    dphiblw_nld45b_tlp_sphv_10hv = 0.0
+    delvtaco_nld45b_tlp_sphv_10hv = 0.29
+    delvtacl_nld45b_tlp_sphv_10hv = 0.0
+    delvtaclexp_nld45b_tlp_sphv_10hv = 1.0
+    delvtacw_nld45b_tlp_sphv_10hv = 0.5
+    delvtaclw_nld45b_tlp_sphv_10hv = -0.05
+    npo_nld45b_tlp_sphv_10hv  = 6e+25
+    npl_nld45b_tlp_sphv_10hv  = 0.0
+    cto_nld45b_tlp_sphv_10hv  = 0.0005103
+    ctl_nld45b_tlp_sphv_10hv  = 0.0
+    ctlexp_nld45b_tlp_sphv_10hv = 1.0
+    ctw_nld45b_tlp_sphv_10hv  = 0.0
+    ctlw_nld45b_tlp_sphv_10hv = 0.0
+    toxovo_nld45b_tlp_sphv_10hv = 1.4e-08
+    toxovdo_nld45b_tlp_sphv_10hv = 1.4e-08
+    lov_nld45b_tlp_sphv_10hv  = 0.0
+    dlovd_nld45b_tlp_sphv_10hv = 4e-08
+    novo_nld45b_tlp_sphv_10hv = 1e+22
+    novdo_nld45b_tlp_sphv_10hv = 5.5e+22
+    cfl_nld45b_tlp_sphv_10hv  = 3e-06
+    cflexp_nld45b_tlp_sphv_10hv = 2.0
+    cfw_nld45b_tlp_sphv_10hv  = 0.0
+    cfbo_nld45b_tlp_sphv_10hv = 1.0
+    uo_nld45b_tlp_sphv_10hv   = 0.065
+    fbet1_nld45b_tlp_sphv_10hv = 0.0
+    fbet1w_nld45b_tlp_sphv_10hv = 0.0
+    lp1_nld45b_tlp_sphv_10hv  = 1e-10
+    lp1w_nld45b_tlp_sphv_10hv = 0.0
+    fbet2_nld45b_tlp_sphv_10hv = 0.0
+    lp2_nld45b_tlp_sphv_10hv  = 1e-10
+    betw1_nld45b_tlp_sphv_10hv = -0.4
+    betw2_nld45b_tlp_sphv_10hv = 0.02
+    wbet_nld45b_tlp_sphv_10hv = 1e-09
+    stbeto_nld45b_tlp_sphv_10hv = 1.25
+    stbetl_nld45b_tlp_sphv_10hv = 0.0
+    stbetw_nld45b_tlp_sphv_10hv = 0.3
+    stbetlw_nld45b_tlp_sphv_10hv = 0.0
+    mueo_nld45b_tlp_sphv_10hv = 1.164
+    muew_nld45b_tlp_sphv_10hv = 0.47
+    stmueo_nld45b_tlp_sphv_10hv = 0.1388
+    themuo_nld45b_tlp_sphv_10hv = 2.636
+    stthemuo_nld45b_tlp_sphv_10hv = 0.05441
+    cso_nld45b_tlp_sphv_10hv  = 0.0
+    csl_nld45b_tlp_sphv_10hv  = 0.0
+    cslexp_nld45b_tlp_sphv_10hv = 0.0
+    csw_nld45b_tlp_sphv_10hv  = 0.0
+    cslw_nld45b_tlp_sphv_10hv = 0.0
+    stcso_nld45b_tlp_sphv_10hv = 0.0
+    xcoro_nld45b_tlp_sphv_10hv = 0.0
+    xcorl_nld45b_tlp_sphv_10hv = 0.0
+    xcorw_nld45b_tlp_sphv_10hv = 0.0
+    xcorlw_nld45b_tlp_sphv_10hv = 0.0
+    stxcoro_nld45b_tlp_sphv_10hv = 0.0
+    fetao_nld45b_tlp_sphv_10hv = 1.0
+    rsw1_nld45b_tlp_sphv_10hv = 0.0
+    rsw2_nld45b_tlp_sphv_10hv = 0.0
+    strso_nld45b_tlp_sphv_10hv = 0.0
+    rsbo_nld45b_tlp_sphv_10hv = 0.0
+    rsgo_nld45b_tlp_sphv_10hv = 1.0
+    thesato_nld45b_tlp_sphv_10hv = 0.35
+    thesatl_nld45b_tlp_sphv_10hv = 0.0
+    thesatlexp_nld45b_tlp_sphv_10hv = 1.0
+    thesatw_nld45b_tlp_sphv_10hv = 0.4
+    thesatlw_nld45b_tlp_sphv_10hv = 0.0
+    stthesato_nld45b_tlp_sphv_10hv = 1.5
+    stthesatl_nld45b_tlp_sphv_10hv = 0.0
+    stthesatw_nld45b_tlp_sphv_10hv = 0.0
+    stthesatlw_nld45b_tlp_sphv_10hv = 0.0
+    thesatbo_nld45b_tlp_sphv_10hv = 0.0
+    thesatgo_nld45b_tlp_sphv_10hv = 0.0
+    thesatgl_nld45b_tlp_sphv_10hv = 0.0
+    thesatgw_nld45b_tlp_sphv_10hv = 0.0
+    axo_nld45b_tlp_sphv_10hv  = 3.0
+    axl_nld45b_tlp_sphv_10hv  = 0.0
+    alpl_nld45b_tlp_sphv_10hv = 0.002
+    alplexp_nld45b_tlp_sphv_10hv = 1.0
+    alpw_nld45b_tlp_sphv_10hv = 0.0
+    alp1l1_nld45b_tlp_sphv_10hv = 1e-06
+    alp1lexp_nld45b_tlp_sphv_10hv = 1.0
+    alp1l2_nld45b_tlp_sphv_10hv = 0.0
+    alp1w_nld45b_tlp_sphv_10hv = 0.0
+    alp2l1_nld45b_tlp_sphv_10hv = 0.0
+    alp2lexp_nld45b_tlp_sphv_10hv = 1.0
+    alp2l2_nld45b_tlp_sphv_10hv = 0.0
+    alp2w_nld45b_tlp_sphv_10hv = 0.0
+    vpo_nld45b_tlp_sphv_10hv  = 0.1
+    a1o_nld45b_tlp_sphv_10hv  = 0.075
+    a1l_nld45b_tlp_sphv_10hv  = 0.0
+    a1w_nld45b_tlp_sphv_10hv  = -1.0
+    a2o_nld45b_tlp_sphv_10hv  = 53
+    sta2o_nld45b_tlp_sphv_10hv = 1.125
+    a3o_nld45b_tlp_sphv_10hv  = 14
+    a3l_nld45b_tlp_sphv_10hv  = 0.0
+    a3w_nld45b_tlp_sphv_10hv  = 0.0
+    a4o_nld45b_tlp_sphv_10hv  = 0.0
+    a4l_nld45b_tlp_sphv_10hv  = 0.0
+    a4w_nld45b_tlp_sphv_10hv  = 0.0
+    gcoo_nld45b_tlp_sphv_10hv = 0.0
+    iginvlw_nld45b_tlp_sphv_10hv = 0.0
+    igovw_nld45b_tlp_sphv_10hv = 0.0
+    igovdw_nld45b_tlp_sphv_10hv = 0.0
+    stigo_nld45b_tlp_sphv_10hv = 2.0
+    gc2o_nld45b_tlp_sphv_10hv = 0.375
+    gc3o_nld45b_tlp_sphv_10hv = 0.063
+    chibo_nld45b_tlp_sphv_10hv = 3.1
+    agidlw_nld45b_tlp_sphv_10hv = 0.0
+    agidldw_nld45b_tlp_sphv_10hv = 0.0
+    bgidlo_nld45b_tlp_sphv_10hv = 41.0
+    bgidldo_nld45b_tlp_sphv_10hv = 41.0
+    stbgidlo_nld45b_tlp_sphv_10hv = 0.0
+    stbgidldo_nld45b_tlp_sphv_10hv = 0.0
+    cgidlo_nld45b_tlp_sphv_10hv = 0.0
+    cgidldo_nld45b_tlp_sphv_10hv = 0.0
+    cgbovl_nld45b_tlp_sphv_10hv = 1e-15
+    cfrw_nld45b_tlp_sphv_10hv = 2.35e-16
+    cfrdw_nld45b_tlp_sphv_10hv = 0.0
+    fnto_nld45b_tlp_sphv_10hv = 1.0
+    nfalw_nld45b_tlp_sphv_10hv = 3e+26
+    nfblw_nld45b_tlp_sphv_10hv = 30000000.0
+    nfclw_nld45b_tlp_sphv_10hv = 0.0
+    efo_nld45b_tlp_sphv_10hv  = 0.9
+    lintnoi_nld45b_tlp_sphv_10hv = 0.0
+    alpnoi_nld45b_tlp_sphv_10hv = 2.0
+    kvthoweo_nld45b_tlp_sphv_10hv = 0.0
+    kvthowel_nld45b_tlp_sphv_10hv = 0.0
+    kvthowew_nld45b_tlp_sphv_10hv = 0.0
+    kvthowelw_nld45b_tlp_sphv_10hv = 0.0
+    kuoweo_nld45b_tlp_sphv_10hv = 0.0
+    kuowel_nld45b_tlp_sphv_10hv = 0.0
+    kuowew_nld45b_tlp_sphv_10hv = 0.0
+    kuowelw_nld45b_tlp_sphv_10hv = 0.0
+    rgo_nld45b_tlp_sphv_10hv  = 0.0
+    rsh_nld45b_tlp_sphv_10hv  = 0.0
+    rbulko_nld45b_tlp_sphv_10hv = 0.0
+    rwello_nld45b_tlp_sphv_10hv = 0.0
+    rjunso_nld45b_tlp_sphv_10hv = 1000.0
+    rjundo_nld45b_tlp_sphv_10hv = 121.0
+    rint_nld45b_tlp_sphv_10hv = 0.0
+    rvpoly_nld45b_tlp_sphv_10hv = 0.0
+    rshg_nld45b_tlp_sphv_10hv = 0.0
+    dlsil_nld45b_tlp_sphv_10hv = 0.0
+    saref_nld45b_tlp_sphv_10hv = 1e-06
+    sbref_nld45b_tlp_sphv_10hv = 1e-06
+    wlod_nld45b_tlp_sphv_10hv = 0.0
+    kuo_nld45b_tlp_sphv_10hv  = 0.0
+    kvsat_nld45b_tlp_sphv_10hv = 0.0
+    tkuo_nld45b_tlp_sphv_10hv = 0.0
+    lkuo_nld45b_tlp_sphv_10hv = 0.0
+    wkuo_nld45b_tlp_sphv_10hv = 0.0
+    pkuo_nld45b_tlp_sphv_10hv = 0.0
+    llodkuo_nld45b_tlp_sphv_10hv = 0.0
+    wlodkuo_nld45b_tlp_sphv_10hv = 0.0
+    kvtho_nld45b_tlp_sphv_10hv = 0.0
+    lkvtho_nld45b_tlp_sphv_10hv = 0.0
+    wkvtho_nld45b_tlp_sphv_10hv = 0.0
+    pkvtho_nld45b_tlp_sphv_10hv = 0.0
+    llodvth_nld45b_tlp_sphv_10hv = 0.0
+    wlodvth_nld45b_tlp_sphv_10hv = 0.0
+    stetao_nld45b_tlp_sphv_10hv = 0.0
+    lodetao_nld45b_tlp_sphv_10hv = 1.0
+    scref_nld45b_tlp_sphv_10hv = 1e-05
+    web_nld45b_tlp_sphv_10hv  = 0.0
+    wec_nld45b_tlp_sphv_10hv  = 0.0
+    adr1o_nld45b_tlp_sphv_10hv = 0.0
+    adr1l_nld45b_tlp_sphv_10hv = 0.0
+    adr1w_nld45b_tlp_sphv_10hv = 0.1
+    adr2o_nld45b_tlp_sphv_10hv = 1.0
+    stadr2o_nld45b_tlp_sphv_10hv = 4.0
+    stadr2o1_nld45b_tlp_sphv_10hv = 0.0
+    adr3o_nld45b_tlp_sphv_10hv = 0.0
+    adr3l_nld45b_tlp_sphv_10hv = 0.0
+    adr3w_nld45b_tlp_sphv_10hv = 0.0
+    adr4o_nld45b_tlp_sphv_10hv = 0.0
+    adr4l_nld45b_tlp_sphv_10hv = 0.0
+    adr4w_nld45b_tlp_sphv_10hv = 0.0
+    adr5o_nld45b_tlp_sphv_10hv = 0.0
+    adr5l_nld45b_tlp_sphv_10hv = 0.0
+    adr5w_nld45b_tlp_sphv_10hv = 0.0
+    bidr1o_nld45b_tlp_sphv_10hv = 0.0
+    bidr1l_nld45b_tlp_sphv_10hv = 0.0
+    bidr1w_nld45b_tlp_sphv_10hv = 0.23
+    bidr2o_nld45b_tlp_sphv_10hv = 0.0
+    bidr2w_nld45b_tlp_sphv_10hv = 0.0
+    rtho_nld45b_tlp_sphv_10hv = 750.0
+    rthl_nld45b_tlp_sphv_10hv = 0.0
+    rthw_nld45b_tlp_sphv_10hv = 0.0
+    rthlw_nld45b_tlp_sphv_10hv = 0.0
+    strtho_nld45b_tlp_sphv_10hv = 0.0
+    ctho_nld45b_tlp_sphv_10hv = 0.0
+    cthl_nld45b_tlp_sphv_10hv = 0.0
+    cthw_nld45b_tlp_sphv_10hv = 0.0
+    cthlw_nld45b_tlp_sphv_10hv = 0.0
+    rshldd_nld45b_tlp_sphv_10hv = 5020.0
+    xw_nld45b_tlp_sphv_10hv   = 8.5e-07
+    nwxw_nld45b_tlp_sphv_10hv = 2.5e-13
+    xl_nld45b_tlp_sphv_10hv   = 0.0
+    xlw_nld45b_tlp_sphv_10hv  = 0.0
+    dxlsat_nld45b_tlp_sphv_10hv = 0.0
+    nst_nld45b_tlp_sphv_10hv  = 1.0
+    ats_nld45b_tlp_sphv_10hv  = 0.0
+    dfinf_nld45b_tlp_sphv_10hv = 0.015
+    dfw_nld45b_tlp_sphv_10hv  = 0.0
+    dfl_nld45b_tlp_sphv_10hv  = 0.0
+    dflw_nld45b_tlp_sphv_10hv = 0.0
+    dp_nld45b_tlp_sphv_10hv   = 2.0
+    ecrit_nld45b_tlp_sphv_10hv = 1550000.0
+    ecorn_nld45b_tlp_sphv_10hv = 500000.0
+    xvsat_nld45b_tlp_sphv_10hv = -0.28
+    du_nld45b_tlp_sphv_10hv   = 0.02
+    tc1_nld45b_tlp_sphv_10hv  = 0.006171
+    tc2_nld45b_tlp_sphv_10hv  = 1.781e-05
+    tc1l_nld45b_tlp_sphv_10hv = 0.0
+    tc2l_nld45b_tlp_sphv_10hv = 0.0
+    tc1w_nld45b_tlp_sphv_10hv = -7.639e-10
+    tc2w_nld45b_tlp_sphv_10hv = -4.18e-12
+    theacc_nld45b_tlp_sphv_10hv = 0.0
+    theacc2_nld45b_tlp_sphv_10hv = 0.05327
+    rva_nld45b_tlp_sphv_10hv  = 100000.0
+    dta_nld45b_tlp_sphv_10hv  = 0.0
+    trj_nld45b_tlp_sphv_10hv  = 25.0
+    cjarea_nld45b_tlp_sphv_10hv = 0.0
+    cjlsti_nld45b_tlp_sphv_10hv = 0.0
+    cjlgat_nld45b_tlp_sphv_10hv = 0.0
+    vbiarea_nld45b_tlp_sphv_10hv = 0.7
+    vbisti_nld45b_tlp_sphv_10hv = 0.7
+    vbigat_nld45b_tlp_sphv_10hv = 0.7
+    parea_nld45b_tlp_sphv_10hv = 0.5
+    psti_nld45b_tlp_sphv_10hv = 0.5
+    pgat_nld45b_tlp_sphv_10hv = 0.5
+    is1area_nld45b_tlp_sphv_10hv = 0.0
+    ttarea_nld45b_tlp_sphv_10hv = 0.0
+    is2area_nld45b_tlp_sphv_10hv = 0.0
+    irarea_nld45b_tlp_sphv_10hv = 0.0
+    stis1area_nld45b_tlp_sphv_10hv = 3.0
+    stis2area_nld45b_tlp_sphv_10hv = 3.0
+    stirarea_nld45b_tlp_sphv_10hv = 1.0
+    n1area_nld45b_tlp_sphv_10hv = 1.0
+    n2area_nld45b_tlp_sphv_10hv = 2.0
+    nrarea_nld45b_tlp_sphv_10hv = 200.0
+    is1lsti_nld45b_tlp_sphv_10hv = 0.0
+    ttlsti_nld45b_tlp_sphv_10hv = 0.0
+    is2lsti_nld45b_tlp_sphv_10hv = 0.0
+    irlsti_nld45b_tlp_sphv_10hv = 0.0
+    stis1sti_nld45b_tlp_sphv_10hv = 3.0
+    stis2sti_nld45b_tlp_sphv_10hv = 3.0
+    stirsti_nld45b_tlp_sphv_10hv = 1.0
+    n1sti_nld45b_tlp_sphv_10hv = 1.0
+    n2sti_nld45b_tlp_sphv_10hv = 2.0
+    nrsti_nld45b_tlp_sphv_10hv = 200.0
+    is1lgat_nld45b_tlp_sphv_10hv = 0.0
+    ttlgat_nld45b_tlp_sphv_10hv = 0.0
+    is2lgat_nld45b_tlp_sphv_10hv = 0.0
+    irlgat_nld45b_tlp_sphv_10hv = 0.0
+    stis1gat_nld45b_tlp_sphv_10hv = 3.0
+    stis2gat_nld45b_tlp_sphv_10hv = 3.0
+    stirgat_nld45b_tlp_sphv_10hv = 1.0
+    n1gat_nld45b_tlp_sphv_10hv = 1.0
+    n2gat_nld45b_tlp_sphv_10hv = 2.0
+    nrgat_nld45b_tlp_sphv_10hv = 200.0
+    cjaread_nld45b_tlp_sphv_10hv = 0.000145
+    cjlstid_nld45b_tlp_sphv_10hv = 1e-18
+    cjlgatd_nld45b_tlp_sphv_10hv = 1e-18
+    vbiaread_nld45b_tlp_sphv_10hv = 0.95
+    vbistid_nld45b_tlp_sphv_10hv = 0.55
+    vbigatd_nld45b_tlp_sphv_10hv = 0.5912
+    paread_nld45b_tlp_sphv_10hv = 0.3785
+    pstid_nld45b_tlp_sphv_10hv = 0.6051
+    pgatd_nld45b_tlp_sphv_10hv = 0.4315
+    is1aread_nld45b_tlp_sphv_10hv = 3e-08
+    ttaread_nld45b_tlp_sphv_10hv = 5.8e-08
+    is2aread_nld45b_tlp_sphv_10hv = 1.1e-05
+    iraread_nld45b_tlp_sphv_10hv = 0.0002
+    stis1aread_nld45b_tlp_sphv_10hv = 5.0
+    stis2aread_nld45b_tlp_sphv_10hv = 3.0
+    stiraread_nld45b_tlp_sphv_10hv = 55000.0
+    n1aread_nld45b_tlp_sphv_10hv = 1.0
+    n2aread_nld45b_tlp_sphv_10hv = 2.0
+    nraread_nld45b_tlp_sphv_10hv = 2500.0
+    is1lstid_nld45b_tlp_sphv_10hv = 0.0
+    ttlstid_nld45b_tlp_sphv_10hv = 5.8e-08
+    is2lstid_nld45b_tlp_sphv_10hv = 0.0
+    irlstid_nld45b_tlp_sphv_10hv = 4e-10
+    stis1stid_nld45b_tlp_sphv_10hv = 5.0
+    stis2stid_nld45b_tlp_sphv_10hv = 3.0
+    stirstid_nld45b_tlp_sphv_10hv = 55000.0
+    n1stid_nld45b_tlp_sphv_10hv = 1.05
+    n2stid_nld45b_tlp_sphv_10hv = 2.0
+    nrstid_nld45b_tlp_sphv_10hv = 2500.0
+    is1lgatd_nld45b_tlp_sphv_10hv = 0.0
+    ttlgatd_nld45b_tlp_sphv_10hv = 5.8e-08
+    is2lgatd_nld45b_tlp_sphv_10hv = 0.0
+    irlgatd_nld45b_tlp_sphv_10hv = 4e-10
+    stis1gatd_nld45b_tlp_sphv_10hv = 5.0
+    stis2gatd_nld45b_tlp_sphv_10hv = 3.0
+    stirgatd_nld45b_tlp_sphv_10hv = 55000.0
+    n1gatd_nld45b_tlp_sphv_10hv = 1.0
+    n2gatd_nld45b_tlp_sphv_10hv = 2.0
+    nrgatd_nld45b_tlp_sphv_10hv = 2500.0
+    cjaread2_nld45b_tlp_sphv_10hv = 0.000178
+    cjlstid2_nld45b_tlp_sphv_10hv = 1e-18
+    vbiaread2_nld45b_tlp_sphv_10hv = 0.7
+    vbistid2_nld45b_tlp_sphv_10hv = 0.7
+    paread2_nld45b_tlp_sphv_10hv = 0.5
+    pstid2_nld45b_tlp_sphv_10hv = 0.5
+    is1aread2_nld45b_tlp_sphv_10hv = 3e-08
+    ttaread2_nld45b_tlp_sphv_10hv = 5.8e-08
+    is2aread2_nld45b_tlp_sphv_10hv = 3e-06
+    iraread2_nld45b_tlp_sphv_10hv = 0.0002
+    stis1aread2_nld45b_tlp_sphv_10hv = 3.0
+    stis2aread2_nld45b_tlp_sphv_10hv = 3.0
+    stiraread2_nld45b_tlp_sphv_10hv = 55000.0
+    n1aread2_nld45b_tlp_sphv_10hv = 1.0
+    n2aread2_nld45b_tlp_sphv_10hv = 2.0
+    nraread2_nld45b_tlp_sphv_10hv = 2500.0
+    is1lstid2_nld45b_tlp_sphv_10hv = 0
+    ttlstid2_nld45b_tlp_sphv_10hv = 5.8e-08
+    is2lstid2_nld45b_tlp_sphv_10hv = 0.0
+    irlstid2_nld45b_tlp_sphv_10hv = 0.0
+    stis1stid2_nld45b_tlp_sphv_10hv = 3.0
+    stis2stid2_nld45b_tlp_sphv_10hv = 3.0
+    stirstid2_nld45b_tlp_sphv_10hv = 55000.0
+    n1stid2_nld45b_tlp_sphv_10hv = 1.0
+    n2stid2_nld45b_tlp_sphv_10hv = 2.0
+    nrstid2_nld45b_tlp_sphv_10hv = 2500.0
+    eais1area_nld45b_tlp_sphv_10hv = 1.12
+    eais2area_nld45b_tlp_sphv_10hv = 1.12
+    eairarea_nld45b_tlp_sphv_10hv = 1.12
+    eais1sti_nld45b_tlp_sphv_10hv = 1.12
+    eais2sti_nld45b_tlp_sphv_10hv = 1.12
+    eairsti_nld45b_tlp_sphv_10hv = 1.12
+    eais1gat_nld45b_tlp_sphv_10hv = 1.12
+    eais2gat_nld45b_tlp_sphv_10hv = 1.12
+    eairgat_nld45b_tlp_sphv_10hv = 1.12
+    eais1aread_nld45b_tlp_sphv_10hv = 1.12
+    eais2aread_nld45b_tlp_sphv_10hv = 1.12
+    eairaread_nld45b_tlp_sphv_10hv = 1.12
+    eais1stid_nld45b_tlp_sphv_10hv = 1.12
+    eais2stid_nld45b_tlp_sphv_10hv = 1.12
+    eairstid_nld45b_tlp_sphv_10hv = 1.12
+    eais1gatd_nld45b_tlp_sphv_10hv = 1.12
+    eais2gatd_nld45b_tlp_sphv_10hv = 1.12
+    eairgatd_nld45b_tlp_sphv_10hv = 1.12
+    eais1aread2_nld45b_tlp_sphv_10hv = 1.12
+    eais2aread2_nld45b_tlp_sphv_10hv = 1.12
+    eairaread2_nld45b_tlp_sphv_10hv = 1.12
+    eais1stid2_nld45b_tlp_sphv_10hv = 1.12
+    eais2stid2_nld45b_tlp_sphv_10hv = 1.12
+    eairstid2_nld45b_tlp_sphv_10hv = 1.12
+    aacc_nld45b_tlp_sphv_10hv = 36.0
+    vdscale_nld45b_tlp_sphv_10hv = 1.58
+    dwvdscale_nld45b_tlp_sphv_10hv = -0.11
+    dwvdscalew_nld45b_tlp_sphv_10hv = 0.0
+    dwecrit_nld45b_tlp_sphv_10hv = 0.0
+    dwecritw_nld45b_tlp_sphv_10hv = -0.6
+    stvdscale_nld45b_tlp_sphv_10hv = -0.08
+    stvdscale1_nld45b_tlp_sphv_10hv = 0.0
+    ctgo_nld45b_tlp_sphv_10hv = 0.242
+    strthao_nld45b_tlp_sphv_10hv = 0.9
+    dwtt_nld45b_tlp_sphv_10hv = 0.9
+    ikfarea_nld45b_tlp_sphv_10hv = 0.0
+    stikfarea_nld45b_tlp_sphv_10hv = 0.0
+    ikfaread_nld45b_tlp_sphv_10hv = 17060000.0
+    dwikfaread_nld45b_tlp_sphv_10hv = 2.0
+    stikfaread_nld45b_tlp_sphv_10hv = 0.1
+    dphibo_nld45b_tlp_pspmoscap_10hv = -0.1
+    vfbo_nld45b_tlp_pspmoscap_10hv = -1.6
+    w_nld45b_tlp_mosb_10hv    = 2.6
+    ldrift_nld45b_tlp_mosb_10hv = 8.0
+    delvto_nld45b_tlp_mosb_10hv = 1.11
+    factuo_nld45b_tlp_mosb_10hv = 0.5
+    stdelvto_nld45b_tlp_mosb_10hv = -0.3
+    stfactuo_nld45b_tlp_mosb_10hv = 0.4
+    nom_delr_tox_pld120_sphv_10hv = 1.0
+    nom_delr_uch_pld120_sphv_10hv = 1.0
+    nom_delr_res_pld120_sphv_10hv = 1.025
+    nom_dela_vfb_pld120_sphv_10hv = 0.01
+    nom_dela_vtw_pld120_sphv_10hv = 0.025
+    nom_dela_vtl_pld120_sphv_10hv = -0.002
+    nom_dela_dw_pld120_sphv_10hv = 0.0
+    nom_dela_dwox_pld120_sphv_10hv = -0.5
+    nom_dela_mueo_pld120_sphv_10hv = 0.0
+    nom_dela_vdscale_pld120_sphv_10hv = 0.0
+    nom_dela_vdscalel_pld120_sphv_10hv = 0.0
+    nom_dela_vdscalew_pld120_sphv_10hv = 0.0
+    nom_dela_vdscalelw_pld120_sphv_10hv = 0.015
+    sig_delr_tox_pld120_sphv_10hv = 0.012
+    sig_delr_uch_pld120_sphv_10hv = 0.035
+    sig_delr_res_pld120_sphv_10hv = 0.088
+    sig_dela_vfb_pld120_sphv_10hv = 0.023
+    sig_dela_vtw_pld120_sphv_10hv = 0.020
+    sig_dela_vtl_pld120_sphv_10hv = 0.006
+    sig_dela_mueo_pld120_sphv_10hv = 0.0
+    sig_dela_dw_pld120_sphv_10hv = 0.0
+    sig_dela_dwox_pld120_sphv_10hv = 0.98
+    sig_dela_vdscale_pld120_sphv_10hv = 0.0172
+    sig_dela_vdscalel_pld120_sphv_10hv = 0.038
+    sig_dela_vdscalew_pld120_sphv_10hv = 0.0
+    sig_dela_vdscalelw_pld120_sphv_10hv = 0.0
+    nom_delr_cj_pld120_sphv_10hv = 1.0
+    nom_delr_is_pld120_sphv_10hv = 1.0
+    nom_delr_is2_pld120_sphv_10hv = 1.0
+    nom_delr_ir_pld120_sphv_10hv = 1.0
+    sig_delr_cj_pld120_sphv_10hv = 0.0333
+    sig_delr_is_pld120_sphv_10hv = 0.055
+    sig_delr_is2_pld120_sphv_10hv = 0.768
+    sig_delr_ir_pld120_sphv_10hv = 0.768
+    fac_rth_pld120_sphv_10hv  = 0.4
+    tc1_ecrit_pld120_sphv_10hv = 9.999999999999999e-05
+    tc2_ecrit_pld120_sphv_10hv = 1.6e-06
+    dwrjundo_pld120_sphv_10hv = 7.0
+    dwrjunso_pld120_sphv_10hv = 0.0
+    qmc_pld120_sphv_10hv      = 0.0
+    lvaro_pld120_sphv_10hv    = 1.4e-07
+    lvarl_pld120_sphv_10hv    = 0.192
+    lvarw_pld120_sphv_10hv    = 2.7
+    lap_pld120_sphv_10hv      = 0.0
+    wvaro_pld120_sphv_10hv    = 3.0000000000000004e-07
+    wvarl_pld120_sphv_10hv    = 0.0
+    wvarw_pld120_sphv_10hv    = -20.0
+    wot_pld120_sphv_10hv      = 0.0
+    dlq_pld120_sphv_10hv      = -1.8800000000000002e-07
+    dwq_pld120_sphv_10hv      = 4.0000000000000003e-07
+    vfbo_pld120_sphv_10hv     = -0.9665
+    vfbl_pld120_sphv_10hv     = -0.1008
+    vfbw_pld120_sphv_10hv     = 0.038
+    vfblw_pld120_sphv_10hv    = 0.054
+    stvfbo_pld120_sphv_10hv   = 0.0008889999999999999
+    stvfbl_pld120_sphv_10hv   = 0.0
+    stvfbw_pld120_sphv_10hv   = 0.0
+    stvfblw_pld120_sphv_10hv  = 0.0
+    toxo_pld120_sphv_10hv     = 1.3250000000000001e-08
+    epsroxo_pld120_sphv_10hv  = 3.9
+    nsubo_pld120_sphv_10hv    = 1.24e+23
+    nsubw_pld120_sphv_10hv    = 0.0
+    wseg_pld120_sphv_10hv     = 1e-09
+    npck_pld120_sphv_10hv     = 1e+23
+    npckw_pld120_sphv_10hv    = 0.0
+    wsegp_pld120_sphv_10hv    = 2.474e-06
+    lpck_pld120_sphv_10hv     = 1e-10
+    lpckw_pld120_sphv_10hv    = 0.0
+    fol1_pld120_sphv_10hv     = 0.0
+    fol2_pld120_sphv_10hv     = 0.0
+    facneffaco_pld120_sphv_10hv = 0.8
+    facneffacl_pld120_sphv_10hv = 0.55
+    facneffacw_pld120_sphv_10hv = 0.0
+    facneffaclw_pld120_sphv_10hv = 0.0
+    gfacnudo_pld120_sphv_10hv = 1.0
+    gfacnudl_pld120_sphv_10hv = 0.0
+    gfacnudlexp_pld120_sphv_10hv = 1.0
+    gfacnudw_pld120_sphv_10hv = 0.0
+    gfacnudlw_pld120_sphv_10hv = 0.0
+    vsbnudo_pld120_sphv_10hv  = 2.75
+    dvsbnudo_pld120_sphv_10hv = 1.0
+    vnsubo_pld120_sphv_10hv   = 0.0
+    nslpo_pld120_sphv_10hv    = 0.05
+    dnsubo_pld120_sphv_10hv   = 0.013
+    dphibo_pld120_sphv_10hv   = 0.0
+    dphibl_pld120_sphv_10hv   = 0.0
+    dphiblexp_pld120_sphv_10hv = 1.0
+    dphibw_pld120_sphv_10hv   = 0.0
+    dphiblw_pld120_sphv_10hv  = 0.0
+    delvtaco_pld120_sphv_10hv = 0.05
+    delvtacl_pld120_sphv_10hv = -0.11
+    delvtaclexp_pld120_sphv_10hv = 1.0
+    delvtacw_pld120_sphv_10hv = 0.0
+    delvtaclw_pld120_sphv_10hv = 0.0
+    npo_pld120_sphv_10hv      = 6e+25
+    npl_pld120_sphv_10hv      = 0.0
+    cto_pld120_sphv_10hv      = 0.02
+    ctl_pld120_sphv_10hv      = 0.0
+    ctlexp_pld120_sphv_10hv   = 0.4772
+    ctw_pld120_sphv_10hv      = -0.09186
+    ctlw_pld120_sphv_10hv     = 0.0
+    toxovo_pld120_sphv_10hv   = 1.3250000000000001e-08
+    toxovdo_pld120_sphv_10hv  = 1.3250000000000001e-08
+    lov_pld120_sphv_10hv      = 1.2000000000000002e-07
+    dlovd_pld120_sphv_10hv    = -1.0000000000000001e-07
+    novo_pld120_sphv_10hv     = 9e+24
+    novdo_pld120_sphv_10hv    = 1e+20
+    cfl_pld120_sphv_10hv      = 0.0
+    cflexp_pld120_sphv_10hv   = 0.839
+    cfw_pld120_sphv_10hv      = 0.0
+    cfbo_pld120_sphv_10hv     = 2.22e-15
+    uo_pld120_sphv_10hv       = 0.0182
+    fbet1_pld120_sphv_10hv    = 0.0
+    fbet1w_pld120_sphv_10hv   = 0.0
+    lp1_pld120_sphv_10hv      = 0.0
+    lp1w_pld120_sphv_10hv     = 0.0
+    fbet2_pld120_sphv_10hv    = 0.0
+    lp2_pld120_sphv_10hv      = 0.0
+    betw1_pld120_sphv_10hv    = 0.0
+    betw2_pld120_sphv_10hv    = 0.0
+    wbet_pld120_sphv_10hv     = 0.0
+    stbeto_pld120_sphv_10hv   = 1.2
+    stbetl_pld120_sphv_10hv   = 0.01
+    stbetw_pld120_sphv_10hv   = 0.0
+    stbetlw_pld120_sphv_10hv  = 1.5
+    mueo_pld120_sphv_10hv     = 2.21
+    muew_pld120_sphv_10hv     = -0.2
+    stmueo_pld120_sphv_10hv   = 0.45
+    themuo_pld120_sphv_10hv   = 1.16
+    stthemuo_pld120_sphv_10hv = 0.25
+    cso_pld120_sphv_10hv      = 0.0
+    csl_pld120_sphv_10hv      = 0.0
+    cslexp_pld120_sphv_10hv   = 0.0
+    csw_pld120_sphv_10hv      = 0.0
+    cslw_pld120_sphv_10hv     = 0.0
+    stcso_pld120_sphv_10hv    = 0.0
+    xcoro_pld120_sphv_10hv    = 0.01
+    xcorl_pld120_sphv_10hv    = 0.0
+    xcorw_pld120_sphv_10hv    = 0.0
+    xcorlw_pld120_sphv_10hv   = 0.0
+    stxcoro_pld120_sphv_10hv  = 1.4
+    fetao_pld120_sphv_10hv    = 1.0
+    rsw1_pld120_sphv_10hv     = 0.0
+    rsw2_pld120_sphv_10hv     = 0.0
+    strso_pld120_sphv_10hv    = 0.0
+    rsbo_pld120_sphv_10hv     = 0.0
+    rsgo_pld120_sphv_10hv     = 0.0
+    thesato_pld120_sphv_10hv  = 0.1
+    thesatl_pld120_sphv_10hv  = 0.36
+    thesatlexp_pld120_sphv_10hv = 1.0
+    thesatw_pld120_sphv_10hv  = 0.5
+    thesatlw_pld120_sphv_10hv = -0.2
+    stthesato_pld120_sphv_10hv = 1.0
+    stthesatl_pld120_sphv_10hv = -0.2
+    stthesatw_pld120_sphv_10hv = 10.0
+    stthesatlw_pld120_sphv_10hv = 0.0
+    thesatbo_pld120_sphv_10hv = 0.0
+    thesatgo_pld120_sphv_10hv = -1.0
+    thesatgl_pld120_sphv_10hv = 2.0
+    thesatgw_pld120_sphv_10hv = -1.2
+    axo_pld120_sphv_10hv      = 1.0
+    axl_pld120_sphv_10hv      = 2.0
+    alpl_pld120_sphv_10hv     = 0.0
+    alplexp_pld120_sphv_10hv  = 1.0
+    alpw_pld120_sphv_10hv     = 0.0
+    alp1l1_pld120_sphv_10hv   = 0.0
+    alp1lexp_pld120_sphv_10hv = 0.5
+    alp1l2_pld120_sphv_10hv   = 0.0
+    alp1w_pld120_sphv_10hv    = 0.0
+    alp2l1_pld120_sphv_10hv   = 0.0
+    alp2lexp_pld120_sphv_10hv = 1.0
+    alp2l2_pld120_sphv_10hv   = 0.0
+    alp2w_pld120_sphv_10hv    = 0.0
+    vpo_pld120_sphv_10hv      = 10.0
+    a1o_pld120_sphv_10hv      = 0.000535
+    a1l_pld120_sphv_10hv      = 0.0
+    a1w_pld120_sphv_10hv      = 0.0
+    a2o_pld120_sphv_10hv      = 30.0
+    sta2o_pld120_sphv_10hv    = 0.4
+    a3o_pld120_sphv_10hv      = 1.0
+    a3l_pld120_sphv_10hv      = 0.0
+    a3w_pld120_sphv_10hv      = 0.0
+    a4o_pld120_sphv_10hv      = 0.0
+    a4l_pld120_sphv_10hv      = 0.0
+    a4w_pld120_sphv_10hv      = 0.0
+    gcoo_pld120_sphv_10hv     = 0.0
+    iginvlw_pld120_sphv_10hv  = 0.0
+    igovw_pld120_sphv_10hv    = 0.0
+    igovdw_pld120_sphv_10hv   = 0.0
+    stigo_pld120_sphv_10hv    = 2.0
+    gc2o_pld120_sphv_10hv     = 0.375
+    gc3o_pld120_sphv_10hv     = 0.063
+    chibo_pld120_sphv_10hv    = 3.1
+    agidlw_pld120_sphv_10hv   = 1.5e-06
+    agidldw_pld120_sphv_10hv  = 0.0
+    bgidlo_pld120_sphv_10hv   = 7.0
+    bgidldo_pld120_sphv_10hv  = 10.0
+    stbgidlo_pld120_sphv_10hv = -0.0015
+    stbgidldo_pld120_sphv_10hv = 0.0
+    cgidlo_pld120_sphv_10hv   = 0.0
+    cgidldo_pld120_sphv_10hv  = 1.0
+    cgbovl_pld120_sphv_10hv   = 0.0
+    cfrw_pld120_sphv_10hv     = 0.0
+    cfrdw_pld120_sphv_10hv    = 0.0
+    fnto_pld120_sphv_10hv     = 1.0
+    nfalw_pld120_sphv_10hv    = 4e+24
+    nfblw_pld120_sphv_10hv    = 1.5e+09
+    nfclw_pld120_sphv_10hv    = 4.5e-07
+    efo_pld120_sphv_10hv      = 1.1
+    lintnoi_pld120_sphv_10hv  = 0.0
+    alpnoi_pld120_sphv_10hv   = 2.0
+    kvthoweo_pld120_sphv_10hv = 0.0
+    kvthowel_pld120_sphv_10hv = 0.0
+    kvthowew_pld120_sphv_10hv = 0.0
+    kvthowelw_pld120_sphv_10hv = 0.0
+    kuoweo_pld120_sphv_10hv   = 0.0
+    kuowel_pld120_sphv_10hv   = 0.0
+    kuowew_pld120_sphv_10hv   = 0.0
+    kuowelw_pld120_sphv_10hv  = 0.0
+    rgo_pld120_sphv_10hv      = 0.0
+    rsh_pld120_sphv_10hv      = 0.0
+    rbulko_pld120_sphv_10hv   = 0.0
+    rwello_pld120_sphv_10hv   = 0.0
+    rjunso_pld120_sphv_10hv   = 1000.0
+    rjundo_pld120_sphv_10hv   = 850.0
+    rint_pld120_sphv_10hv     = 0.0
+    rvpoly_pld120_sphv_10hv   = 0.0
+    rshg_pld120_sphv_10hv     = 0.0
+    dlsil_pld120_sphv_10hv    = 0.0
+    saref_pld120_sphv_10hv    = 1e-06
+    sbref_pld120_sphv_10hv    = 1e-06
+    wlod_pld120_sphv_10hv     = 0.0
+    kuo_pld120_sphv_10hv      = 0.0
+    kvsat_pld120_sphv_10hv    = 0.0
+    tkuo_pld120_sphv_10hv     = 0.0
+    lkuo_pld120_sphv_10hv     = 0.0
+    wkuo_pld120_sphv_10hv     = 0.0
+    pkuo_pld120_sphv_10hv     = 0.0
+    llodkuo_pld120_sphv_10hv  = 0.0
+    wlodkuo_pld120_sphv_10hv  = 0.0
+    kvtho_pld120_sphv_10hv    = 0.0
+    lkvtho_pld120_sphv_10hv   = 0.0
+    wkvtho_pld120_sphv_10hv   = 0.0
+    pkvtho_pld120_sphv_10hv   = 0.0
+    llodvth_pld120_sphv_10hv  = 0.0
+    wlodvth_pld120_sphv_10hv  = 0.0
+    stetao_pld120_sphv_10hv   = 0.0
+    lodetao_pld120_sphv_10hv  = 1.0
+    scref_pld120_sphv_10hv    = 1e-05
+    web_pld120_sphv_10hv      = 0.0
+    wec_pld120_sphv_10hv      = 0.0
+    adr1o_pld120_sphv_10hv    = 9.999999999999999e-06
+    adr1l_pld120_sphv_10hv    = 0.0
+    adr1w_pld120_sphv_10hv    = 0.0
+    adr2o_pld120_sphv_10hv    = 101.0
+    stadr2o_pld120_sphv_10hv  = 0.5
+    adr3o_pld120_sphv_10hv    = 0.0
+    adr3l_pld120_sphv_10hv    = 0.0
+    adr3w_pld120_sphv_10hv    = 0.0
+    adr4o_pld120_sphv_10hv    = 0.0
+    adr4l_pld120_sphv_10hv    = 0.0
+    adr4w_pld120_sphv_10hv    = 0.0
+    adr5o_pld120_sphv_10hv    = 0.0
+    adr5l_pld120_sphv_10hv    = 0.0
+    adr5w_pld120_sphv_10hv    = 0.0
+    bidr1o_pld120_sphv_10hv   = 0.0
+    bidr1l_pld120_sphv_10hv   = 0.0
+    bidr1w_pld120_sphv_10hv   = 0.0
+    bidr2o_pld120_sphv_10hv   = 0.0
+    bidr2w_pld120_sphv_10hv   = 0.0
+    rtho_pld120_sphv_10hv     = 650.0
+    rthl_pld120_sphv_10hv     = 0.0
+    rthw_pld120_sphv_10hv     = 0.0
+    rthlw_pld120_sphv_10hv    = 0.0
+    strtho_pld120_sphv_10hv   = 0.5
+    strthao_pld120_sphv_10hv  = 0.0
+    ctho_pld120_sphv_10hv     = 0.0
+    cthl_pld120_sphv_10hv     = 0.0
+    cthw_pld120_sphv_10hv     = 0.0
+    cthlw_pld120_sphv_10hv    = 0.0
+    rshldd_pld120_sphv_10hv   = 15000.0
+    xw_pld120_sphv_10hv       = 2.24e-06
+    nwxw_pld120_sphv_10hv     = -1e-12
+    xl_pld120_sphv_10hv       = 0.0
+    xlw_pld120_sphv_10hv      = 0.0
+    dxlsat_pld120_sphv_10hv   = 0.0
+    nst_pld120_sphv_10hv      = 1.0
+    ats_pld120_sphv_10hv      = 0.0
+    dfinf_pld120_sphv_10hv    = 0.03
+    dfw_pld120_sphv_10hv      = 0.0
+    dfl_pld120_sphv_10hv      = 0.0
+    dflw_pld120_sphv_10hv     = 1e-12
+    dp_pld120_sphv_10hv       = 2.0
+    ecrit_pld120_sphv_10hv    = 2450000.0
+    ecorn_pld120_sphv_10hv    = 10000.0
+    xvsat_pld120_sphv_10hv    = 0.0
+    du_pld120_sphv_10hv       = 0.0
+    tc1_pld120_sphv_10hv      = 0.004900000000000001
+    tc2_pld120_sphv_10hv      = 6e-06
+    tc1l_pld120_sphv_10hv     = 5.1e-09
+    tc2l_pld120_sphv_10hv     = 3e-12
+    tc1w_pld120_sphv_10hv     = -2e-09
+    tc2w_pld120_sphv_10hv     = -2e-11
+    theacc_pld120_sphv_10hv   = 0.0
+    theacc2_pld120_sphv_10hv  = 0.06
+    aacc_pld120_sphv_10hv     = 36.0
+    rva_pld120_sphv_10hv      = 900.0
+    dta_pld120_sphv_10hv      = 0.0
+    trj_pld120_sphv_10hv      = 27.0
+    cjarea_pld120_sphv_10hv   = 0.000215
+    cjlsti_pld120_sphv_10hv   = 0.0
+    cjlgat_pld120_sphv_10hv   = 5.375e-10
+    vbiarea_pld120_sphv_10hv  = 0.75
+    vbisti_pld120_sphv_10hv   = 0.75
+    vbigat_pld120_sphv_10hv   = 0.75
+    parea_pld120_sphv_10hv    = 0.3
+    psti_pld120_sphv_10hv     = 0.3
+    pgat_pld120_sphv_10hv     = 0.3
+    is1area_pld120_sphv_10hv  = 2e-08
+    ttarea_pld120_sphv_10hv   = 3e-09
+    is2area_pld120_sphv_10hv  = 4e-05
+    irarea_pld120_sphv_10hv   = 0.0003
+    stis1area_pld120_sphv_10hv = 3.0
+    stis2area_pld120_sphv_10hv = 3.0
+    stirarea_pld120_sphv_10hv = 1100.0
+    n1area_pld120_sphv_10hv   = 1.02
+    n2area_pld120_sphv_10hv   = 2.0
+    nrarea_pld120_sphv_10hv   = 50.0
+    is1lsti_pld120_sphv_10hv  = 1e-16
+    ttlsti_pld120_sphv_10hv   = 3e-09
+    is2lsti_pld120_sphv_10hv  = 1e-13
+    irlsti_pld120_sphv_10hv   = 5e-15
+    stis1sti_pld120_sphv_10hv = 3.0
+    stis2sti_pld120_sphv_10hv = 3.0
+    stirsti_pld120_sphv_10hv  = 1100.0
+    n1sti_pld120_sphv_10hv    = 1.02
+    n2sti_pld120_sphv_10hv    = 2.0
+    nrsti_pld120_sphv_10hv    = 50.0
+    is1lgat_pld120_sphv_10hv  = 5e-14
+    ttlgat_pld120_sphv_10hv   = 3e-09
+    is2lgat_pld120_sphv_10hv  = 1e-10
+    irlgat_pld120_sphv_10hv   = 7.5e-12
+    stis1gat_pld120_sphv_10hv = 3.0
+    stis2gat_pld120_sphv_10hv = 3.0
+    stirgat_pld120_sphv_10hv  = 1100.0
+    n1gat_pld120_sphv_10hv    = 1.02
+    n2gat_pld120_sphv_10hv    = 2.0
+    nrgat_pld120_sphv_10hv    = 50.0
+    cjaread_pld120_sphv_10hv  = 0.00015199999999999998
+    cjlstid_pld120_sphv_10hv  = 5e-11
+    cjlgatd_pld120_sphv_10hv  = 0.0
+    vbiaread_pld120_sphv_10hv = 0.46
+    vbistid_pld120_sphv_10hv  = 0.46
+    vbigatd_pld120_sphv_10hv  = 0.46
+    paread_pld120_sphv_10hv   = 0.38
+    pstid_pld120_sphv_10hv    = 0.38
+    pgatd_pld120_sphv_10hv    = 0.38
+    is1aread_pld120_sphv_10hv = 3.6e-08
+    ttaread_pld120_sphv_10hv  = 3.5e-08
+    is2aread_pld120_sphv_10hv = 2e-05
+    iraread_pld120_sphv_10hv  = 0.0004
+    stis1aread_pld120_sphv_10hv = 4.0
+    stis2aread_pld120_sphv_10hv = 10.0
+    stiraread_pld120_sphv_10hv = 172000.0
+    n1aread_pld120_sphv_10hv  = 1.02
+    n2aread_pld120_sphv_10hv  = 2.0
+    nraread_pld120_sphv_10hv  = 8000.0
+    is1lstid_pld120_sphv_10hv = 0
+    ttlstid_pld120_sphv_10hv  = 3.6e-07
+    is2lstid_pld120_sphv_10hv = 0.0
+    irlstid_pld120_sphv_10hv  = 1.5e-15
+    stis1stid_pld120_sphv_10hv = 2.0
+    stis2stid_pld120_sphv_10hv = 10.0
+    stirstid_pld120_sphv_10hv = 172000.0
+    n1stid_pld120_sphv_10hv   = 1.02
+    n2stid_pld120_sphv_10hv   = 2.0
+    nrstid_pld120_sphv_10hv   = 8000.0
+    is1lgatd_pld120_sphv_10hv = 0
+    ttlgatd_pld120_sphv_10hv  = 3.5e-08
+    is2lgatd_pld120_sphv_10hv = 0.0
+    irlgatd_pld120_sphv_10hv  = 1e-09
+    stis1gatd_pld120_sphv_10hv = 2.0
+    stis2gatd_pld120_sphv_10hv = 10.0
+    stirgatd_pld120_sphv_10hv = 172000.0
+    n1gatd_pld120_sphv_10hv   = 1.02
+    n2gatd_pld120_sphv_10hv   = 2.0
+    nrgatd_pld120_sphv_10hv   = 8000.0
+    cjaread2_pld120_sphv_10hv = 1e-12
+    cjlstid2_pld120_sphv_10hv = 1e-18
+    vbiaread2_pld120_sphv_10hv = 0.46
+    vbistid2_pld120_sphv_10hv = 0.46
+    paread2_pld120_sphv_10hv  = 0.38
+    pstid2_pld120_sphv_10hv   = 0.38
+    is1aread2_pld120_sphv_10hv = 0
+    ttaread2_pld120_sphv_10hv = 3.5e-08
+    is2aread2_pld120_sphv_10hv = 0.0
+    iraread2_pld120_sphv_10hv = 0.0004
+    stis1aread2_pld120_sphv_10hv = 25
+    stis2aread2_pld120_sphv_10hv = 15
+    stiraread2_pld120_sphv_10hv = 172000.0
+    n1aread2_pld120_sphv_10hv = 1.02
+    n2aread2_pld120_sphv_10hv = 2.0
+    nraread2_pld120_sphv_10hv = 8000.0
+    is1lstid2_pld120_sphv_10hv = 0
+    ttlstid2_pld120_sphv_10hv = 3.6e-07
+    is2lstid2_pld120_sphv_10hv = 0.0
+    irlstid2_pld120_sphv_10hv = 1.5e-15
+    stis1stid2_pld120_sphv_10hv = 2.0
+    stis2stid2_pld120_sphv_10hv = 10.0
+    stirstid2_pld120_sphv_10hv = 172000.0
+    n1stid2_pld120_sphv_10hv  = 1.02
+    n2stid2_pld120_sphv_10hv  = 2.0
+    nrstid2_pld120_sphv_10hv  = 8000.0
+    eais1area_pld120_sphv_10hv = 1.12
+    eais2area_pld120_sphv_10hv = 1.12
+    eairarea_pld120_sphv_10hv = 1.12
+    eais1sti_pld120_sphv_10hv = 1.12
+    eais2sti_pld120_sphv_10hv = 1.12
+    eairsti_pld120_sphv_10hv  = 1.12
+    eais1gat_pld120_sphv_10hv = 1.12
+    eais2gat_pld120_sphv_10hv = 1.12
+    eairgat_pld120_sphv_10hv  = 1.12
+    eais1aread_pld120_sphv_10hv = 1.12
+    eais2aread_pld120_sphv_10hv = 1.12
+    eairaread_pld120_sphv_10hv = 1.12
+    eais1stid_pld120_sphv_10hv = 1.12
+    eais2stid_pld120_sphv_10hv = 1.12
+    eairstid_pld120_sphv_10hv = 1.12
+    eais1gatd_pld120_sphv_10hv = 1.12
+    eais2gatd_pld120_sphv_10hv = 1.12
+    eairgatd_pld120_sphv_10hv = 1.12
+    eais1aread2_pld120_sphv_10hv = 1.12
+    eais2aread2_pld120_sphv_10hv = 1.12
+    eairaread2_pld120_sphv_10hv = 1.12
+    eais1stid2_pld120_sphv_10hv = 1.12
+    eais2stid2_pld120_sphv_10hv = 1.12
+    eairstid2_pld120_sphv_10hv = 1.12
+    vdscale_pld120_sphv_10hv  = 1.01
+    vdscalel_pld120_sphv_10hv = 0.26
+    vdscalew_pld120_sphv_10hv = 0.1
+    vdscalelw_pld120_sphv_10hv = 0.38
+    vdscaleb_pld120_sphv_10hv = 0.0
+    vdscalebl_pld120_sphv_10hv = 0.0
+    mumb_pld120_sphv_10hv     = 0.09
+    mumbexp_pld120_sphv_10hv  = 1.0
+    mumbvclmp_pld120_sphv_10hv = 5.0
+    stvdscale_pld120_sphv_10hv = 0.0
+    ctgo_pld120_sphv_10hv     = 0.0
+    ctbo_pld120_sphv_10hv     = 0.0
+    stcto_pld120_sphv_10hv    = 0.0
+    ikfarea_pld120_sphv_10hv  = 0.0
+    stikfarea_pld120_sphv_10hv = 0.0
+    ikfaread_pld120_sphv_10hv = 800000.0
+    dwikfaread_pld120_sphv_10hv = 15.0
+    stikfaread_pld120_sphv_10hv = 3.0
+    nom_delr_tox_nld45b_he_sphv_10hv = 1.0
+    nom_dela_xw_nld45b_he_sphv_10hv = -0.1
+    nom_dela_vfb_nld45b_he_sphv_10hv = 0.03012
+    nom_delr_mobref_nld45b_he_sphv_10hv = 1.011
+    nom_delr_rsh_nld45b_he_sphv_10hv = 1.01
+    nom_delr_thesato_nld45b_he_sphv_10hv = 1.175
+    nom_dela_vtw_nld45b_he_sphv_10hv = 0.04
+    nom_delr_cj_nld45b_he_sphv_10hv = 1.0
+    nom_delr_is_nld45b_he_sphv_10hv = 1.0
+    nom_delr_is2_nld45b_he_sphv_10hv = 1.0
+    nom_delr_ir_nld45b_he_sphv_10hv = 1.0
+    sig_delr_tox_nld45b_he_sphv_10hv = 0.012
+    sig_dela_xw_nld45b_he_sphv_10hv = 0.04748
+    sig_dela_vfb_nld45b_he_sphv_10hv = 0.055
+    sig_delr_mobref_nld45b_he_sphv_10hv = 0.03719
+    sig_delr_rsh_nld45b_he_sphv_10hv = 0.015
+    sig_delr_thesato_nld45b_he_sphv_10hv = 0.09
+    sig_dela_vtw_nld45b_he_sphv_10hv = 0.06
+    sig_delr_cj_nld45b_he_sphv_10hv = 0.0333
+    sig_delr_is_nld45b_he_sphv_10hv = 0.055
+    sig_delr_is2_nld45b_he_sphv_10hv = 0.768
+    sig_delr_ir_nld45b_he_sphv_10hv = 0.768
+    fac_rth_nld45b_he_sphv_10hv = 1.8
+    tc1_ecrit_nld45b_he_sphv_10hv = 0.0
+    tc2_ecrit_nld45b_he_sphv_10hv = 0.0
+    dwrjundo_nld45b_he_sphv_10hv = 0.9
+    dwrjunso_nld45b_he_sphv_10hv = 8e-06
+    qmc_nld45b_he_sphv_10hv   = 0.0
+    lvaro_nld45b_he_sphv_10hv = 0.0
+    lvarl_nld45b_he_sphv_10hv = 0.0
+    lvarw_nld45b_he_sphv_10hv = 0.0
+    lap_nld45b_he_sphv_10hv   = 0.0
+    wvaro_nld45b_he_sphv_10hv = 6.581e-07
+    wvarl_nld45b_he_sphv_10hv = 0.0
+    wvarw_nld45b_he_sphv_10hv = -0.275
+    wot_nld45b_he_sphv_10hv   = 0.0
+    dlq_nld45b_he_sphv_10hv   = 0.0
+    dwq_nld45b_he_sphv_10hv   = -4.9e-07
+    vfbo_nld45b_he_sphv_10hv  = -0.652
+    vfbl_nld45b_he_sphv_10hv  = 0.0
+    vfbw_nld45b_he_sphv_10hv  = 0.0
+    vfblw_nld45b_he_sphv_10hv = 0.0
+    stvfbo_nld45b_he_sphv_10hv = 0.001148
+    stvfbl_nld45b_he_sphv_10hv = 0.0
+    stvfbw_nld45b_he_sphv_10hv = 0.2978
+    stvfblw_nld45b_he_sphv_10hv = 0.0
+    toxo_nld45b_he_sphv_10hv  = 1.325e-08
+    epsroxo_nld45b_he_sphv_10hv = 3.9
+    nsubo_nld45b_he_sphv_10hv = 1.5e+23
+    nsubw_nld45b_he_sphv_10hv = -0.02
+    wseg_nld45b_he_sphv_10hv  = 1e-08
+    npck_nld45b_he_sphv_10hv  = 1e+23
+    npckw_nld45b_he_sphv_10hv = 0.0
+    wsegp_nld45b_he_sphv_10hv = 1e-08
+    lpck_nld45b_he_sphv_10hv  = 0.0
+    lpckw_nld45b_he_sphv_10hv = 0.0
+    fol1_nld45b_he_sphv_10hv  = 0.0
+    fol2_nld45b_he_sphv_10hv  = 0.0
+    facneffaco_nld45b_he_sphv_10hv = 0.3
+    facneffacl_nld45b_he_sphv_10hv = 0.0
+    facneffacw_nld45b_he_sphv_10hv = -0.3
+    facneffaclw_nld45b_he_sphv_10hv = 0.0
+    gfacnudo_nld45b_he_sphv_10hv = 1.0
+    gfacnudl_nld45b_he_sphv_10hv = 0.0
+    gfacnudlexp_nld45b_he_sphv_10hv = 1.0
+    gfacnudw_nld45b_he_sphv_10hv = 0.0
+    gfacnudlw_nld45b_he_sphv_10hv = 0.0
+    vsbnudo_nld45b_he_sphv_10hv = 0.0
+    dvsbnudo_nld45b_he_sphv_10hv = 1.0
+    vnsubo_nld45b_he_sphv_10hv = 0.0
+    nslpo_nld45b_he_sphv_10hv = 0.05
+    dnsubo_nld45b_he_sphv_10hv = 0.32
+    dphibo_nld45b_he_sphv_10hv = -0.01963
+    dphibl_nld45b_he_sphv_10hv = -0.006442
+    dphiblexp_nld45b_he_sphv_10hv = 1.0
+    dphibw_nld45b_he_sphv_10hv = 0.0
+    dphiblw_nld45b_he_sphv_10hv = 0.0
+    delvtaco_nld45b_he_sphv_10hv = 0.29
+    delvtacl_nld45b_he_sphv_10hv = 0.0
+    delvtaclexp_nld45b_he_sphv_10hv = 1.0
+    delvtacw_nld45b_he_sphv_10hv = 0.5
+    delvtaclw_nld45b_he_sphv_10hv = -0.05
+    npo_nld45b_he_sphv_10hv   = 4.5e+25
+    npl_nld45b_he_sphv_10hv   = 0.0
+    cto_nld45b_he_sphv_10hv   = 0.0004366
+    ctl_nld45b_he_sphv_10hv   = 0.0
+    ctlexp_nld45b_he_sphv_10hv = 1.0
+    ctw_nld45b_he_sphv_10hv   = 0.0
+    ctlw_nld45b_he_sphv_10hv  = 0.0
+    toxovo_nld45b_he_sphv_10hv = 1.325e-08
+    toxovdo_nld45b_he_sphv_10hv = 1.325e-08
+    lov_nld45b_he_sphv_10hv   = 0.0
+    dlovd_nld45b_he_sphv_10hv = 0.0
+    novo_nld45b_he_sphv_10hv  = 5e+19
+    novdo_nld45b_he_sphv_10hv = 8e+22
+    cfl_nld45b_he_sphv_10hv   = 0.0
+    cflexp_nld45b_he_sphv_10hv = 2.0
+    cfw_nld45b_he_sphv_10hv   = 0.0
+    cfbo_nld45b_he_sphv_10hv  = 1.0
+    uo_nld45b_he_sphv_10hv    = 0.07
+    fbet1_nld45b_he_sphv_10hv = 0.0
+    fbet1w_nld45b_he_sphv_10hv = 0.0
+    lp1_nld45b_he_sphv_10hv   = 1e-10
+    lp1w_nld45b_he_sphv_10hv  = 0.0
+    fbet2_nld45b_he_sphv_10hv = 0.0
+    lp2_nld45b_he_sphv_10hv   = 1e-10
+    betw1_nld45b_he_sphv_10hv = -0.4
+    betw2_nld45b_he_sphv_10hv = 0.02
+    wbet_nld45b_he_sphv_10hv  = 1e-09
+    stbeto_nld45b_he_sphv_10hv = 1.41
+    stbetl_nld45b_he_sphv_10hv = 0.0
+    stbetw_nld45b_he_sphv_10hv = -0.1344
+    stbetlw_nld45b_he_sphv_10hv = 0.0
+    mueo_nld45b_he_sphv_10hv  = 1.427
+    muew_nld45b_he_sphv_10hv  = 0.15
+    stmueo_nld45b_he_sphv_10hv = 0.5
+    themuo_nld45b_he_sphv_10hv = 1.698
+    stthemuo_nld45b_he_sphv_10hv = 0.25
+    cso_nld45b_he_sphv_10hv   = 0.0
+    csl_nld45b_he_sphv_10hv   = 0.0
+    cslexp_nld45b_he_sphv_10hv = 0.0
+    csw_nld45b_he_sphv_10hv   = 0.0
+    cslw_nld45b_he_sphv_10hv  = 0.0
+    stcso_nld45b_he_sphv_10hv = 0.0
+    xcoro_nld45b_he_sphv_10hv = 0.0
+    xcorl_nld45b_he_sphv_10hv = 0.0
+    xcorw_nld45b_he_sphv_10hv = 0.0
+    xcorlw_nld45b_he_sphv_10hv = 0.0
+    stxcoro_nld45b_he_sphv_10hv = 0.0
+    fetao_nld45b_he_sphv_10hv = 1.0
+    rsw1_nld45b_he_sphv_10hv  = 0.0
+    rsw2_nld45b_he_sphv_10hv  = 0.0
+    strso_nld45b_he_sphv_10hv = 0.0
+    rsbo_nld45b_he_sphv_10hv  = 0.0
+    rsgo_nld45b_he_sphv_10hv  = 1.0
+    thesato_nld45b_he_sphv_10hv = 0.79
+    thesatl_nld45b_he_sphv_10hv = 0.0
+    thesatlexp_nld45b_he_sphv_10hv = 1.0
+    thesatw_nld45b_he_sphv_10hv = 0.15
+    thesatlw_nld45b_he_sphv_10hv = 0.0
+    stthesato_nld45b_he_sphv_10hv = 1.5
+    stthesatl_nld45b_he_sphv_10hv = 0.0
+    stthesatw_nld45b_he_sphv_10hv = -0.7
+    stthesatlw_nld45b_he_sphv_10hv = 0.0
+    thesatbo_nld45b_he_sphv_10hv = 0.0
+    thesatgo_nld45b_he_sphv_10hv = 0.2
+    thesatgl_nld45b_he_sphv_10hv = 0.0
+    thesatgw_nld45b_he_sphv_10hv = -0.23
+    axo_nld45b_he_sphv_10hv   = 4.0
+    axl_nld45b_he_sphv_10hv   = 0.0
+    alpl_nld45b_he_sphv_10hv  = 0.0002
+    alplexp_nld45b_he_sphv_10hv = 1.0
+    alpw_nld45b_he_sphv_10hv  = 0.0
+    alp1l1_nld45b_he_sphv_10hv = 1e-06
+    alp1lexp_nld45b_he_sphv_10hv = 1.0
+    alp1l2_nld45b_he_sphv_10hv = 0.0
+    alp1w_nld45b_he_sphv_10hv = 0.0
+    alp2l1_nld45b_he_sphv_10hv = 0.0
+    alp2lexp_nld45b_he_sphv_10hv = 1.0
+    alp2l2_nld45b_he_sphv_10hv = 0.0
+    alp2w_nld45b_he_sphv_10hv = 0.0
+    vpo_nld45b_he_sphv_10hv   = 0.1
+    a1o_nld45b_he_sphv_10hv   = 0.102
+    a1l_nld45b_he_sphv_10hv   = 0.0
+    a1w_nld45b_he_sphv_10hv   = -1.023
+    a2o_nld45b_he_sphv_10hv   = 52.05
+    sta2o_nld45b_he_sphv_10hv = 1.0
+    a3o_nld45b_he_sphv_10hv   = 14.09
+    a3l_nld45b_he_sphv_10hv   = 0.0
+    a3w_nld45b_he_sphv_10hv   = 0.0
+    a4o_nld45b_he_sphv_10hv   = 0.0
+    a4l_nld45b_he_sphv_10hv   = 0.0
+    a4w_nld45b_he_sphv_10hv   = 0.0
+    gcoo_nld45b_he_sphv_10hv  = 0.0
+    iginvlw_nld45b_he_sphv_10hv = 0.0
+    igovw_nld45b_he_sphv_10hv = 0.0
+    igovdw_nld45b_he_sphv_10hv = 0.0
+    stigo_nld45b_he_sphv_10hv = 2.0
+    gc2o_nld45b_he_sphv_10hv  = 0.375
+    gc3o_nld45b_he_sphv_10hv  = 0.063
+    chibo_nld45b_he_sphv_10hv = 3.1
+    agidlw_nld45b_he_sphv_10hv = 0.0
+    agidldw_nld45b_he_sphv_10hv = 0.0
+    bgidlo_nld45b_he_sphv_10hv = 41.0
+    bgidldo_nld45b_he_sphv_10hv = 41.0
+    stbgidlo_nld45b_he_sphv_10hv = 0.0
+    stbgidldo_nld45b_he_sphv_10hv = 0.0
+    cgidlo_nld45b_he_sphv_10hv = 0.0
+    cgidldo_nld45b_he_sphv_10hv = 0.0
+    cgbovl_nld45b_he_sphv_10hv = 1e-15
+    cfrw_nld45b_he_sphv_10hv  = 2.35e-16
+    cfrdw_nld45b_he_sphv_10hv = 0.0
+    fnto_nld45b_he_sphv_10hv  = 1.0
+    nfalw_nld45b_he_sphv_10hv = 1e+26
+    nfblw_nld45b_he_sphv_10hv = 30000000.0
+    nfclw_nld45b_he_sphv_10hv = 0.0
+    efo_nld45b_he_sphv_10hv   = 0.9
+    lintnoi_nld45b_he_sphv_10hv = 0.0
+    alpnoi_nld45b_he_sphv_10hv = 2.0
+    kvthoweo_nld45b_he_sphv_10hv = 0.0
+    kvthowel_nld45b_he_sphv_10hv = 0.0
+    kvthowew_nld45b_he_sphv_10hv = 0.0
+    kvthowelw_nld45b_he_sphv_10hv = 0.0
+    kuoweo_nld45b_he_sphv_10hv = 0.0
+    kuowel_nld45b_he_sphv_10hv = 0.0
+    kuowew_nld45b_he_sphv_10hv = 0.0
+    kuowelw_nld45b_he_sphv_10hv = 0.0
+    rgo_nld45b_he_sphv_10hv   = 0.0
+    rsh_nld45b_he_sphv_10hv   = 0.0
+    rbulko_nld45b_he_sphv_10hv = 0.0
+    rwello_nld45b_he_sphv_10hv = 0.0
+    rjunso_nld45b_he_sphv_10hv = 1000.0
+    rjundo_nld45b_he_sphv_10hv = 110.0
+    rint_nld45b_he_sphv_10hv  = 0.0
+    rvpoly_nld45b_he_sphv_10hv = 0.0
+    rshg_nld45b_he_sphv_10hv  = 0.0
+    dlsil_nld45b_he_sphv_10hv = 0.0
+    saref_nld45b_he_sphv_10hv = 1e-06
+    sbref_nld45b_he_sphv_10hv = 1e-06
+    wlod_nld45b_he_sphv_10hv  = 0.0
+    kuo_nld45b_he_sphv_10hv   = 0.0
+    kvsat_nld45b_he_sphv_10hv = 0.0
+    tkuo_nld45b_he_sphv_10hv  = 0.0
+    lkuo_nld45b_he_sphv_10hv  = 0.0
+    wkuo_nld45b_he_sphv_10hv  = 0.0
+    pkuo_nld45b_he_sphv_10hv  = 0.0
+    llodkuo_nld45b_he_sphv_10hv = 0.0
+    wlodkuo_nld45b_he_sphv_10hv = 0.0
+    kvtho_nld45b_he_sphv_10hv = 0.0
+    lkvtho_nld45b_he_sphv_10hv = 0.0
+    wkvtho_nld45b_he_sphv_10hv = 0.0
+    pkvtho_nld45b_he_sphv_10hv = 0.0
+    llodvth_nld45b_he_sphv_10hv = 0.0
+    wlodvth_nld45b_he_sphv_10hv = 0.0
+    stetao_nld45b_he_sphv_10hv = 0.0
+    lodetao_nld45b_he_sphv_10hv = 1.0
+    scref_nld45b_he_sphv_10hv = 1e-05
+    web_nld45b_he_sphv_10hv   = 0.0
+    wec_nld45b_he_sphv_10hv   = 0.0
+    adr1o_nld45b_he_sphv_10hv = 0.0
+    adr1l_nld45b_he_sphv_10hv = 0.0
+    adr1w_nld45b_he_sphv_10hv = 0.0
+    adr2o_nld45b_he_sphv_10hv = 26.0
+    stadr2o_nld45b_he_sphv_10hv = 0.0
+    adr3o_nld45b_he_sphv_10hv = 0.0
+    adr3l_nld45b_he_sphv_10hv = 0.0
+    adr3w_nld45b_he_sphv_10hv = 0.0
+    adr4o_nld45b_he_sphv_10hv = 0.0
+    adr4l_nld45b_he_sphv_10hv = 0.0
+    adr4w_nld45b_he_sphv_10hv = 0.0
+    adr5o_nld45b_he_sphv_10hv = 0.0
+    adr5l_nld45b_he_sphv_10hv = 0.0
+    adr5w_nld45b_he_sphv_10hv = 0.0
+    bidr1o_nld45b_he_sphv_10hv = 0.0
+    bidr1l_nld45b_he_sphv_10hv = 0.0
+    bidr1w_nld45b_he_sphv_10hv = 0.0
+    bidr2o_nld45b_he_sphv_10hv = 0.0
+    bidr2w_nld45b_he_sphv_10hv = 0.0
+    rtho_nld45b_he_sphv_10hv  = 750.0
+    rthl_nld45b_he_sphv_10hv  = 0.0
+    rthw_nld45b_he_sphv_10hv  = 0.0
+    rthlw_nld45b_he_sphv_10hv = 0.0
+    strtho_nld45b_he_sphv_10hv = 0.0
+    ctho_nld45b_he_sphv_10hv  = 0.0
+    cthl_nld45b_he_sphv_10hv  = 0.0
+    cthw_nld45b_he_sphv_10hv  = 0.0
+    cthlw_nld45b_he_sphv_10hv = 0.0
+    rshldd_nld45b_he_sphv_10hv = 5900.0
+    xw_nld45b_he_sphv_10hv    = 4.5e-07
+    nwxw_nld45b_he_sphv_10hv  = 2.5e-13
+    xl_nld45b_he_sphv_10hv    = 0.0
+    xlw_nld45b_he_sphv_10hv   = 0.0
+    dxlsat_nld45b_he_sphv_10hv = 0.0
+    nst_nld45b_he_sphv_10hv   = 1.0
+    ats_nld45b_he_sphv_10hv   = 0.0
+    dfinf_nld45b_he_sphv_10hv = 0.01
+    dfw_nld45b_he_sphv_10hv   = 0.0
+    dfl_nld45b_he_sphv_10hv   = 0.0
+    dflw_nld45b_he_sphv_10hv  = 0.0
+    dp_nld45b_he_sphv_10hv    = 2.0
+    ecrit_nld45b_he_sphv_10hv = 1870000.0
+    ecorn_nld45b_he_sphv_10hv = 750000.0
+    xvsat_nld45b_he_sphv_10hv = -0.28
+    du_nld45b_he_sphv_10hv    = 0.02
+    tc1_nld45b_he_sphv_10hv   = 0.005833
+    tc2_nld45b_he_sphv_10hv   = 1.645e-05
+    tc1l_nld45b_he_sphv_10hv  = 0.0
+    tc2l_nld45b_he_sphv_10hv  = 0.0
+    tc1w_nld45b_he_sphv_10hv  = 3.228e-09
+    tc2w_nld45b_he_sphv_10hv  = 1.996e-11
+    theacc_nld45b_he_sphv_10hv = 0.0
+    theacc2_nld45b_he_sphv_10hv = 0.04008
+    rva_nld45b_he_sphv_10hv   = 1000.0
+    dta_nld45b_he_sphv_10hv   = 0.0
+    trj_nld45b_he_sphv_10hv   = 25.0
+    cjarea_nld45b_he_sphv_10hv = 0.0
+    cjlsti_nld45b_he_sphv_10hv = 0.0
+    cjlgat_nld45b_he_sphv_10hv = 0.0
+    vbiarea_nld45b_he_sphv_10hv = 0.7
+    vbisti_nld45b_he_sphv_10hv = 0.7
+    vbigat_nld45b_he_sphv_10hv = 0.7
+    parea_nld45b_he_sphv_10hv = 0.5
+    psti_nld45b_he_sphv_10hv  = 0.5
+    pgat_nld45b_he_sphv_10hv  = 0.5
+    is1area_nld45b_he_sphv_10hv = 0.0
+    ttarea_nld45b_he_sphv_10hv = 0.0
+    is2area_nld45b_he_sphv_10hv = 0.0
+    irarea_nld45b_he_sphv_10hv = 0.0
+    stis1area_nld45b_he_sphv_10hv = 3.0
+    stis2area_nld45b_he_sphv_10hv = 3.0
+    stirarea_nld45b_he_sphv_10hv = 1.0
+    n1area_nld45b_he_sphv_10hv = 1.0
+    n2area_nld45b_he_sphv_10hv = 2.0
+    nrarea_nld45b_he_sphv_10hv = 200.0
+    is1lsti_nld45b_he_sphv_10hv = 0.0
+    ttlsti_nld45b_he_sphv_10hv = 0.0
+    is2lsti_nld45b_he_sphv_10hv = 0.0
+    irlsti_nld45b_he_sphv_10hv = 0.0
+    stis1sti_nld45b_he_sphv_10hv = 3.0
+    stis2sti_nld45b_he_sphv_10hv = 3.0
+    stirsti_nld45b_he_sphv_10hv = 1.0
+    n1sti_nld45b_he_sphv_10hv = 1.0
+    n2sti_nld45b_he_sphv_10hv = 2.0
+    nrsti_nld45b_he_sphv_10hv = 200.0
+    is1lgat_nld45b_he_sphv_10hv = 0.0
+    ttlgat_nld45b_he_sphv_10hv = 0.0
+    is2lgat_nld45b_he_sphv_10hv = 0.0
+    irlgat_nld45b_he_sphv_10hv = 0.0
+    stis1gat_nld45b_he_sphv_10hv = 3.0
+    stis2gat_nld45b_he_sphv_10hv = 3.0
+    stirgat_nld45b_he_sphv_10hv = 1.0
+    n1gat_nld45b_he_sphv_10hv = 1.0
+    n2gat_nld45b_he_sphv_10hv = 2.0
+    nrgat_nld45b_he_sphv_10hv = 200.0
+    cjaread_nld45b_he_sphv_10hv = 0.000152
+    cjlstid_nld45b_he_sphv_10hv = 1e-18
+    cjlgatd_nld45b_he_sphv_10hv = 1e-18
+    vbiaread_nld45b_he_sphv_10hv = 1.0
+    vbistid_nld45b_he_sphv_10hv = 0.6
+    vbigatd_nld45b_he_sphv_10hv = 0.7
+    paread_nld45b_he_sphv_10hv = 0.42
+    pstid_nld45b_he_sphv_10hv = 0.57
+    pgatd_nld45b_he_sphv_10hv = 0.4156
+    is1aread_nld45b_he_sphv_10hv = 5e-08
+    ttaread_nld45b_he_sphv_10hv = 4e-08
+    is2aread_nld45b_he_sphv_10hv = 1e-05
+    iraread_nld45b_he_sphv_10hv = 0.0002
+    stis1aread_nld45b_he_sphv_10hv = 4.5
+    stis2aread_nld45b_he_sphv_10hv = 3.0
+    stiraread_nld45b_he_sphv_10hv = 47000.0
+    n1aread_nld45b_he_sphv_10hv = 1.02
+    n2aread_nld45b_he_sphv_10hv = 2.0
+    nraread_nld45b_he_sphv_10hv = 2000.0
+    is1lstid_nld45b_he_sphv_10hv = 1e-12
+    ttlstid_nld45b_he_sphv_10hv = 4e-08
+    is2lstid_nld45b_he_sphv_10hv = 0.0
+    irlstid_nld45b_he_sphv_10hv = 1e-09
+    stis1stid_nld45b_he_sphv_10hv = 4.5
+    stis2stid_nld45b_he_sphv_10hv = 3.0
+    stirstid_nld45b_he_sphv_10hv = 47000.0
+    n1stid_nld45b_he_sphv_10hv = 1.09
+    n2stid_nld45b_he_sphv_10hv = 2.0
+    nrstid_nld45b_he_sphv_10hv = 2000.0
+    is1lgatd_nld45b_he_sphv_10hv = 1e-12
+    ttlgatd_nld45b_he_sphv_10hv = 4e-08
+    is2lgatd_nld45b_he_sphv_10hv = 0.0
+    irlgatd_nld45b_he_sphv_10hv = 1e-09
+    stis1gatd_nld45b_he_sphv_10hv = 4.5
+    stis2gatd_nld45b_he_sphv_10hv = 3.0
+    stirgatd_nld45b_he_sphv_10hv = 47000.0
+    n1gatd_nld45b_he_sphv_10hv = 1.02
+    n2gatd_nld45b_he_sphv_10hv = 2.0
+    nrgatd_nld45b_he_sphv_10hv = 2000.0
+    cjaread2_nld45b_he_sphv_10hv = 0.000178
+    cjlstid2_nld45b_he_sphv_10hv = 1e-18
+    vbiaread2_nld45b_he_sphv_10hv = 0.7
+    vbistid2_nld45b_he_sphv_10hv = 0.7
+    paread2_nld45b_he_sphv_10hv = 0.5
+    pstid2_nld45b_he_sphv_10hv = 0.5
+    is1aread2_nld45b_he_sphv_10hv = 3e-08
+    ttaread2_nld45b_he_sphv_10hv = 4e-08
+    is2aread2_nld45b_he_sphv_10hv = 3e-06
+    iraread2_nld45b_he_sphv_10hv = 0.0002
+    stis1aread2_nld45b_he_sphv_10hv = 3.0
+    stis2aread2_nld45b_he_sphv_10hv = 3.0
+    stiraread2_nld45b_he_sphv_10hv = 47000.0
+    n1aread2_nld45b_he_sphv_10hv = 1.0
+    n2aread2_nld45b_he_sphv_10hv = 2.0
+    nraread2_nld45b_he_sphv_10hv = 2000.0
+    is1lstid2_nld45b_he_sphv_10hv = 0
+    ttlstid2_nld45b_he_sphv_10hv = 4e-08
+    is2lstid2_nld45b_he_sphv_10hv = 0.0
+    irlstid2_nld45b_he_sphv_10hv = 1.188e-07
+    stis1stid2_nld45b_he_sphv_10hv = 3.0
+    stis2stid2_nld45b_he_sphv_10hv = 3.0
+    stirstid2_nld45b_he_sphv_10hv = 47000.0
+    n1stid2_nld45b_he_sphv_10hv = 1.0
+    n2stid2_nld45b_he_sphv_10hv = 2.0
+    nrstid2_nld45b_he_sphv_10hv = 2000.0
+    eais1area_nld45b_he_sphv_10hv = 1.12
+    eais2area_nld45b_he_sphv_10hv = 1.12
+    eairarea_nld45b_he_sphv_10hv = 1.12
+    eais1sti_nld45b_he_sphv_10hv = 1.12
+    eais2sti_nld45b_he_sphv_10hv = 1.12
+    eairsti_nld45b_he_sphv_10hv = 1.12
+    eais1gat_nld45b_he_sphv_10hv = 1.12
+    eais2gat_nld45b_he_sphv_10hv = 1.12
+    eairgat_nld45b_he_sphv_10hv = 1.12
+    eais1aread_nld45b_he_sphv_10hv = 1.12
+    eais2aread_nld45b_he_sphv_10hv = 1.12
+    eairaread_nld45b_he_sphv_10hv = 1.12
+    eais1stid_nld45b_he_sphv_10hv = 1.12
+    eais2stid_nld45b_he_sphv_10hv = 1.12
+    eairstid_nld45b_he_sphv_10hv = 1.12
+    eais1gatd_nld45b_he_sphv_10hv = 1.12
+    eais2gatd_nld45b_he_sphv_10hv = 1.12
+    eairgatd_nld45b_he_sphv_10hv = 1.12
+    eais1aread2_nld45b_he_sphv_10hv = 1.12
+    eais2aread2_nld45b_he_sphv_10hv = 1.12
+    eairaread2_nld45b_he_sphv_10hv = 1.12
+    eais1stid2_nld45b_he_sphv_10hv = 1.12
+    eais2stid2_nld45b_he_sphv_10hv = 1.12
+    eairstid2_nld45b_he_sphv_10hv = 1.12
+    aacc_nld45b_he_sphv_10hv  = 36.0
+    vdscale_nld45b_he_sphv_10hv = 1.42
+    dwvdscale_nld45b_he_sphv_10hv = 0.0
+    dwvdscalew_nld45b_he_sphv_10hv = -0.16
+    dwecrit_nld45b_he_sphv_10hv = 0.0
+    dwecritw_nld45b_he_sphv_10hv = 0.035
+    stvdscale_nld45b_he_sphv_10hv = 0.0
+    ctgo_nld45b_he_sphv_10hv  = 0.25
+    strthao_nld45b_he_sphv_10hv = 1.2
+    dwtt_nld45b_he_sphv_10hv  = 2.0
+    ikfarea_nld45b_he_sphv_10hv = 0.0
+    stikfarea_nld45b_he_sphv_10hv = 0.0
+    ikfaread_nld45b_he_sphv_10hv = 19560000.0
+    dwikfaread_nld45b_he_sphv_10hv = 6.0
+    stikfaread_nld45b_he_sphv_10hv = 1.0
+    dphibo_nld45b_he_pspmoscap_10hv = -0.2
+    vfbo_nld45b_he_pspmoscap_10hv = -1.2
+    w_nld45b_he_mosb_10hv     = 2.2
+    ldrift_nld45b_he_mosb_10hv = 0.65
+    delvto_nld45b_he_mosb_10hv = 0.85
+    factuo_nld45b_he_mosb_10hv = 0.1
+    stdelvto_nld45b_he_mosb_10hv = -0.4
+    stfactuo_nld45b_he_mosb_10hv = 0.25
+    nom_delr_cj_nld30b_sphv_10hv = 1.0
+    nom_delr_is_nld30b_sphv_10hv = 1.0
+    nom_delr_is2_nld30b_sphv_10hv = 1.0
+    nom_delr_ir_nld30b_sphv_10hv = 1.0
+    nom_delr_tox_nld30b_sphv_10hv = 1.0
+    nom_dela_dw_nld30b_sphv_10hv = 0.006
+    nom_dela_xw_nld30b_sphv_10hv = 0.0
+    nom_dela_vfb_nld30b_sphv_10hv = 0.0115
+    nom_delr_mobref_nld30b_sphv_10hv = 1.02
+    nom_delr_rshl_nld30b_sphv_10hv = 1.12
+    nom_dela_vtwl_nld30b_sphv_10hv = 0.028
+    sig_delr_cj_nld30b_sphv_10hv = 0.0333
+    sig_delr_is_nld30b_sphv_10hv = 0.055
+    sig_delr_is2_nld30b_sphv_10hv = 0.768
+    sig_delr_ir_nld30b_sphv_10hv = 0.768
+    sig_delr_tox_nld30b_sphv_10hv = 0.012
+    sig_dela_dw_nld30b_sphv_10hv = 0.0
+    sig_dela_xw_nld30b_sphv_10hv = 0.0707
+    sig_dela_vfb_nld30b_sphv_10hv = 0.05
+    sig_delr_mobref_nld30b_sphv_10hv = 0.0285
+    sig_delr_rshl_nld30b_sphv_10hv = 0.0257
+    sig_dela_vtwl_nld30b_sphv_10hv = 0.009
+    vdscale_nld30b_sphv_10hv  = 1.26629202543
+    fac_rth_nld30b_sphv_10hv  = 0.6
+    tc1_ecrit_nld30b_sphv_10hv = 0.0
+    tc2_ecrit_nld30b_sphv_10hv = 0.0
+    dwrjundo_nld30b_sphv_10hv = 1.0
+    dwrjunso_nld30b_sphv_10hv = 0.0
+    qmc_nld30b_sphv_10hv      = 0.0
+    lvaro_nld30b_sphv_10hv    = 0.0
+    lvarl_nld30b_sphv_10hv    = 0.0
+    lvarw_nld30b_sphv_10hv    = 0.0
+    lap_nld30b_sphv_10hv      = 0.0
+    wvaro_nld30b_sphv_10hv    = -8e-08
+    wvarl_nld30b_sphv_10hv    = 0.0
+    wvarw_nld30b_sphv_10hv    = 0.0
+    wot_nld30b_sphv_10hv      = 0.0
+    dlq_nld30b_sphv_10hv      = 8e-08
+    dwq_nld30b_sphv_10hv      = 3e-07
+    vfbo_nld30b_sphv_10hv     = -0.75
+    vfbl_nld30b_sphv_10hv     = 0.0
+    vfbw_nld30b_sphv_10hv     = 0.15
+    vfblw_nld30b_sphv_10hv    = 0.0
+    stvfbo_nld30b_sphv_10hv   = 0.001
+    stvfbl_nld30b_sphv_10hv   = 0.1
+    stvfbw_nld30b_sphv_10hv   = 0.0
+    stvfblw_nld30b_sphv_10hv  = 0.0
+    toxo_nld30b_sphv_10hv     = 1.35e-08
+    epsroxo_nld30b_sphv_10hv  = 3.9
+    nsubo_nld30b_sphv_10hv    = 1.5e+23
+    nsubw_nld30b_sphv_10hv    = 0.08
+    wseg_nld30b_sphv_10hv     = 1e-09
+    npck_nld30b_sphv_10hv     = 1e+23
+    npckw_nld30b_sphv_10hv    = 0.0
+    wsegp_nld30b_sphv_10hv    = 2.474e-06
+    lpck_nld30b_sphv_10hv     = 0.0
+    lpckw_nld30b_sphv_10hv    = 0.0
+    fol1_nld30b_sphv_10hv     = 0.05
+    fol2_nld30b_sphv_10hv     = 0.0
+    facneffaco_nld30b_sphv_10hv = 1.0
+    facneffacl_nld30b_sphv_10hv = 0.0
+    facneffacw_nld30b_sphv_10hv = 0.0
+    facneffaclw_nld30b_sphv_10hv = 0.0
+    gfacnudo_nld30b_sphv_10hv = 1.0
+    gfacnudl_nld30b_sphv_10hv = 0.0
+    gfacnudlexp_nld30b_sphv_10hv = 1.0
+    gfacnudw_nld30b_sphv_10hv = 0.0
+    gfacnudlw_nld30b_sphv_10hv = 0.0
+    vsbnudo_nld30b_sphv_10hv  = 2.75
+    dvsbnudo_nld30b_sphv_10hv = 1.0
+    vnsubo_nld30b_sphv_10hv   = 0.0
+    nslpo_nld30b_sphv_10hv    = 0.05
+    dnsubo_nld30b_sphv_10hv   = 0.0
+    dphibo_nld30b_sphv_10hv   = -0.04
+    dphibl_nld30b_sphv_10hv   = 0.0
+    dphiblexp_nld30b_sphv_10hv = 1.0
+    dphibw_nld30b_sphv_10hv   = 0.0
+    dphiblw_nld30b_sphv_10hv  = 0.0
+    delvtaco_nld30b_sphv_10hv = 0.0
+    delvtacl_nld30b_sphv_10hv = 0.0
+    delvtaclexp_nld30b_sphv_10hv = 1.0
+    delvtacw_nld30b_sphv_10hv = 0.0
+    delvtaclw_nld30b_sphv_10hv = 0.0
+    npo_nld30b_sphv_10hv      = 1e+26
+    npl_nld30b_sphv_10hv      = 0.0
+    cto_nld30b_sphv_10hv      = 0.03
+    ctl_nld30b_sphv_10hv      = 0.0
+    ctlexp_nld30b_sphv_10hv   = 0.4772
+    ctw_nld30b_sphv_10hv      = -0.05
+    ctlw_nld30b_sphv_10hv     = 0.0
+    toxovo_nld30b_sphv_10hv   = 1.35e-08
+    toxovdo_nld30b_sphv_10hv  = 1.35e-08
+    lov_nld30b_sphv_10hv      = 0.0
+    dlovd_nld30b_sphv_10hv    = 0.0
+    novo_nld30b_sphv_10hv     = 1.6e+23
+    novdo_nld30b_sphv_10hv    = 5e+22
+    cfl_nld30b_sphv_10hv      = 0.00018
+    cflexp_nld30b_sphv_10hv   = 1.0
+    cfw_nld30b_sphv_10hv      = 0.0
+    cfbo_nld30b_sphv_10hv     = 0.0
+    uo_nld30b_sphv_10hv       = 0.048
+    fbet1_nld30b_sphv_10hv    = 0.0
+    fbet1w_nld30b_sphv_10hv   = 0.0
+    lp1_nld30b_sphv_10hv      = 0.0
+    lp1w_nld30b_sphv_10hv     = 0.0
+    fbet2_nld30b_sphv_10hv    = 0.0
+    lp2_nld30b_sphv_10hv      = 0.0
+    betw1_nld30b_sphv_10hv    = 0.0
+    betw2_nld30b_sphv_10hv    = 0.0
+    wbet_nld30b_sphv_10hv     = 0.0
+    stbeto_nld30b_sphv_10hv   = 0.9
+    stbetl_nld30b_sphv_10hv   = 0.0
+    stbetw_nld30b_sphv_10hv   = 0.0
+    stbetlw_nld30b_sphv_10hv  = -0.03
+    mueo_nld30b_sphv_10hv     = 2.45
+    muew_nld30b_sphv_10hv     = -0.47
+    stmueo_nld30b_sphv_10hv   = -0.4
+    themuo_nld30b_sphv_10hv   = 1.82
+    stthemuo_nld30b_sphv_10hv = 0.32
+    cso_nld30b_sphv_10hv      = 0.0
+    csl_nld30b_sphv_10hv      = 0.0
+    cslexp_nld30b_sphv_10hv   = 0.0
+    csw_nld30b_sphv_10hv      = 0.0
+    cslw_nld30b_sphv_10hv     = 0.0
+    stcso_nld30b_sphv_10hv    = 0.0
+    xcoro_nld30b_sphv_10hv    = 0.0
+    xcorl_nld30b_sphv_10hv    = 0.0
+    xcorw_nld30b_sphv_10hv    = 0.0
+    xcorlw_nld30b_sphv_10hv   = 0.0
+    stxcoro_nld30b_sphv_10hv  = 0.0
+    fetao_nld30b_sphv_10hv    = 0.8
+    rsw1_nld30b_sphv_10hv     = 0.0
+    rsw2_nld30b_sphv_10hv     = 0.0
+    strso_nld30b_sphv_10hv    = 0.0
+    rsbo_nld30b_sphv_10hv     = 0.0
+    rsgo_nld30b_sphv_10hv     = 0.0
+    thesato_nld30b_sphv_10hv  = 0.23
+    thesatl_nld30b_sphv_10hv  = 0.0
+    thesatlexp_nld30b_sphv_10hv = 1.0
+    thesatw_nld30b_sphv_10hv  = 0.1
+    thesatlw_nld30b_sphv_10hv = 0.3
+    stthesato_nld30b_sphv_10hv = 2.0
+    stthesatl_nld30b_sphv_10hv = 0.0
+    stthesatw_nld30b_sphv_10hv = 0.0
+    stthesatlw_nld30b_sphv_10hv = 0.0
+    thesatbo_nld30b_sphv_10hv = 0.0
+    thesatgo_nld30b_sphv_10hv = 0.4
+    thesatgl_nld30b_sphv_10hv = 0.0
+    thesatgw_nld30b_sphv_10hv = 0.05
+    axo_nld30b_sphv_10hv      = 4.0
+    axl_nld30b_sphv_10hv      = 0.0
+    alpl_nld30b_sphv_10hv     = 0.0
+    alplexp_nld30b_sphv_10hv  = 1.0
+    alpw_nld30b_sphv_10hv     = 0.0
+    alp1l1_nld30b_sphv_10hv   = 0.0
+    alp1lexp_nld30b_sphv_10hv = 0.5
+    alp1l2_nld30b_sphv_10hv   = 0.0
+    alp1w_nld30b_sphv_10hv    = 0.0
+    alp2l1_nld30b_sphv_10hv   = 0.0
+    alp2lexp_nld30b_sphv_10hv = 1.0
+    alp2l2_nld30b_sphv_10hv   = 0.0
+    alp2w_nld30b_sphv_10hv    = 0.0
+    vpo_nld30b_sphv_10hv      = 10.0
+    a1o_nld30b_sphv_10hv      = 0.0121
+    a1l_nld30b_sphv_10hv      = 0.8
+    a1w_nld30b_sphv_10hv      = 0.0
+    a2o_nld30b_sphv_10hv      = 14.78
+    sta2o_nld30b_sphv_10hv    = 0.0
+    a3o_nld30b_sphv_10hv      = 20.58
+    a3l_nld30b_sphv_10hv      = 1.2
+    a3w_nld30b_sphv_10hv      = 1.5
+    a4o_nld30b_sphv_10hv      = 0.0
+    a4l_nld30b_sphv_10hv      = 0.0
+    a4w_nld30b_sphv_10hv      = 0.0
+    gcoo_nld30b_sphv_10hv     = 0.0
+    iginvlw_nld30b_sphv_10hv  = 0.0
+    igovw_nld30b_sphv_10hv    = 0.0
+    igovdw_nld30b_sphv_10hv   = 0.0
+    stigo_nld30b_sphv_10hv    = 2.0
+    gc2o_nld30b_sphv_10hv     = 0.375
+    gc3o_nld30b_sphv_10hv     = 0.063
+    chibo_nld30b_sphv_10hv    = 3.1
+    agidlw_nld30b_sphv_10hv   = 0.0
+    agidldw_nld30b_sphv_10hv  = 0.0
+    bgidlo_nld30b_sphv_10hv   = 10.0
+    bgidldo_nld30b_sphv_10hv  = 10.0
+    stbgidlo_nld30b_sphv_10hv = 0.0
+    stbgidldo_nld30b_sphv_10hv = 0.0
+    cgidlo_nld30b_sphv_10hv   = 1.0
+    cgidldo_nld30b_sphv_10hv  = 1.0
+    cgbovl_nld30b_sphv_10hv   = 1.06e-15
+    cfrw_nld30b_sphv_10hv     = 0.0
+    cfrdw_nld30b_sphv_10hv    = 2.5e-17
+    fnto_nld30b_sphv_10hv     = 1.0
+    nfalw_nld30b_sphv_10hv    = 3e+25
+    nfblw_nld30b_sphv_10hv    = 0.0
+    nfclw_nld30b_sphv_10hv    = 0.0
+    efo_nld30b_sphv_10hv      = 0.9
+    lintnoi_nld30b_sphv_10hv  = 9e-08
+    alpnoi_nld30b_sphv_10hv   = 2.0
+    kvthoweo_nld30b_sphv_10hv = 0.0
+    kvthowel_nld30b_sphv_10hv = 0.0
+    kvthowew_nld30b_sphv_10hv = 0.0
+    kvthowelw_nld30b_sphv_10hv = 0.0
+    kuoweo_nld30b_sphv_10hv   = 0.0
+    kuowel_nld30b_sphv_10hv   = 0.0
+    kuowew_nld30b_sphv_10hv   = 0.0
+    kuowelw_nld30b_sphv_10hv  = 0.0
+    rgo_nld30b_sphv_10hv      = 0.0
+    rsh_nld30b_sphv_10hv      = 0.0
+    rbulko_nld30b_sphv_10hv   = 0.0
+    rwello_nld30b_sphv_10hv   = 0.0
+    rjunso_nld30b_sphv_10hv   = 550.0
+    rjundo_nld30b_sphv_10hv   = 430.0
+    rint_nld30b_sphv_10hv     = 0.0
+    rvpoly_nld30b_sphv_10hv   = 0.0
+    rshg_nld30b_sphv_10hv     = 0.0
+    dlsil_nld30b_sphv_10hv    = 0.0
+    saref_nld30b_sphv_10hv    = 1e-06
+    sbref_nld30b_sphv_10hv    = 1e-06
+    wlod_nld30b_sphv_10hv     = 0.0
+    kuo_nld30b_sphv_10hv      = 0.0
+    kvsat_nld30b_sphv_10hv    = 0.0
+    tkuo_nld30b_sphv_10hv     = 0.0
+    lkuo_nld30b_sphv_10hv     = 0.0
+    wkuo_nld30b_sphv_10hv     = 0.0
+    pkuo_nld30b_sphv_10hv     = 0.0
+    llodkuo_nld30b_sphv_10hv  = 0.0
+    wlodkuo_nld30b_sphv_10hv  = 0.0
+    kvtho_nld30b_sphv_10hv    = 0.0
+    lkvtho_nld30b_sphv_10hv   = 0.0
+    wkvtho_nld30b_sphv_10hv   = 0.0
+    pkvtho_nld30b_sphv_10hv   = 0.0
+    llodvth_nld30b_sphv_10hv  = 0.0
+    wlodvth_nld30b_sphv_10hv  = 0.0
+    stetao_nld30b_sphv_10hv   = 0.0
+    lodetao_nld30b_sphv_10hv  = 1.0
+    scref_nld30b_sphv_10hv    = 1e-05
+    web_nld30b_sphv_10hv      = 0.0
+    wec_nld30b_sphv_10hv      = 0.0
+    adr1o_nld30b_sphv_10hv    = 0.0
+    adr1l_nld30b_sphv_10hv    = 0.0
+    adr1w_nld30b_sphv_10hv    = 0.0
+    adr2o_nld30b_sphv_10hv    = 0.0
+    stadr2o_nld30b_sphv_10hv  = 1.0
+    adr3o_nld30b_sphv_10hv    = 0.0
+    adr3l_nld30b_sphv_10hv    = 0.0
+    adr3w_nld30b_sphv_10hv    = 0.0
+    adr4o_nld30b_sphv_10hv    = 0.0
+    adr4l_nld30b_sphv_10hv    = 0.0
+    adr4w_nld30b_sphv_10hv    = 0.0
+    adr5o_nld30b_sphv_10hv    = 0.0
+    adr5l_nld30b_sphv_10hv    = 0.0
+    adr5w_nld30b_sphv_10hv    = 0.0
+    bidr1o_nld30b_sphv_10hv   = 0.0
+    bidr1l_nld30b_sphv_10hv   = 0.0
+    bidr1w_nld30b_sphv_10hv   = 0.0
+    bidr2o_nld30b_sphv_10hv   = 0.0
+    bidr2w_nld30b_sphv_10hv   = 0.0
+    rtho_nld30b_sphv_10hv     = 650.0
+    rthl_nld30b_sphv_10hv     = 0.0
+    rthw_nld30b_sphv_10hv     = 0.0
+    rthlw_nld30b_sphv_10hv    = 0.0
+    strtho_nld30b_sphv_10hv   = -0.02096
+    ctho_nld30b_sphv_10hv     = 0.0
+    cthl_nld30b_sphv_10hv     = 0.0
+    cthw_nld30b_sphv_10hv     = 0.0
+    cthlw_nld30b_sphv_10hv    = 0.0
+    rshldd_nld30b_sphv_10hv   = 3700.0
+    xw_nld30b_sphv_10hv       = 1.55e-07
+    nwxw_nld30b_sphv_10hv     = -1e-13
+    xl_nld30b_sphv_10hv       = 0.0
+    xlw_nld30b_sphv_10hv      = 0.0
+    dxlsat_nld30b_sphv_10hv   = 5.65e-07
+    nst_nld30b_sphv_10hv      = 1.0
+    ats_nld30b_sphv_10hv      = 0.0
+    dfinf_nld30b_sphv_10hv    = 0.01
+    dfw_nld30b_sphv_10hv      = 0.0
+    dfl_nld30b_sphv_10hv      = 0.0
+    dflw_nld30b_sphv_10hv     = 0.0
+    dp_nld30b_sphv_10hv       = 1.922
+    ecrit_nld30b_sphv_10hv    = 750000.0
+    ecorn_nld30b_sphv_10hv    = 200000.0
+    ecritw_nld30b_sphv_10hv   = 0.45
+    du_nld30b_sphv_10hv       = 110.0
+    xvsat_nld30b_sphv_10hv    = -0.2
+    xvsatw_nld30b_sphv_10hv   = 2.0
+    tc1_nld30b_sphv_10hv      = 0.006
+    tc2_nld30b_sphv_10hv      = 2.8e-05
+    tc1l_nld30b_sphv_10hv     = 0.0
+    tc2l_nld30b_sphv_10hv     = 0.0
+    tc1w_nld30b_sphv_10hv     = -1.4e-09
+    tc2w_nld30b_sphv_10hv     = -6e-12
+    theacc_nld30b_sphv_10hv   = 0.0
+    theacc2_nld30b_sphv_10hv  = 0.046
+    aacc_nld30b_sphv_10hv     = 36.0
+    rva_nld30b_sphv_10hv      = 1000.0
+    dta_nld30b_sphv_10hv      = 0.0
+    trj_nld30b_sphv_10hv      = 27.0
+    cjarea_nld30b_sphv_10hv   = 0.00061
+    cjlsti_nld30b_sphv_10hv   = 1e-10
+    cjlgat_nld30b_sphv_10hv   = 6e-10
+    vbiarea_nld30b_sphv_10hv  = 1.0
+    vbisti_nld30b_sphv_10hv   = 1.0
+    vbigat_nld30b_sphv_10hv   = 1.0
+    parea_nld30b_sphv_10hv    = 0.35
+    psti_nld30b_sphv_10hv     = 0.5
+    pgat_nld30b_sphv_10hv     = 0.5
+    is1area_nld30b_sphv_10hv  = 1e-11
+    ttarea_nld30b_sphv_10hv   = 0.0
+    is2area_nld30b_sphv_10hv  = 1e-11
+    irarea_nld30b_sphv_10hv   = 1e-12
+    stis1area_nld30b_sphv_10hv = 3.0
+    stis2area_nld30b_sphv_10hv = 3.0
+    stirarea_nld30b_sphv_10hv = 20.0
+    n1area_nld30b_sphv_10hv   = 1.0
+    n2area_nld30b_sphv_10hv   = 3.0
+    nrarea_nld30b_sphv_10hv   = 100.0
+    is1lsti_nld30b_sphv_10hv  = 1e-16
+    ttlsti_nld30b_sphv_10hv   = 0.0
+    is2lsti_nld30b_sphv_10hv  = 1e-16
+    irlsti_nld30b_sphv_10hv   = 0.0
+    stis1sti_nld30b_sphv_10hv = 3.0
+    stis2sti_nld30b_sphv_10hv = 3.0
+    stirsti_nld30b_sphv_10hv  = 20.0
+    n1sti_nld30b_sphv_10hv    = 1.0
+    n2sti_nld30b_sphv_10hv    = 3.0
+    nrsti_nld30b_sphv_10hv    = 100.0
+    is1lgat_nld30b_sphv_10hv  = 1e-16
+    ttlgat_nld30b_sphv_10hv   = 0.0
+    is2lgat_nld30b_sphv_10hv  = 1e-16
+    irlgat_nld30b_sphv_10hv   = 0.0
+    stis1gat_nld30b_sphv_10hv = 3.0
+    stis2gat_nld30b_sphv_10hv = 3.0
+    stirgat_nld30b_sphv_10hv  = 20.0
+    n1gat_nld30b_sphv_10hv    = 1.0
+    n2gat_nld30b_sphv_10hv    = 3.0
+    nrgat_nld30b_sphv_10hv    = 100.0
+    cjaread_nld30b_sphv_10hv  = 9.3e-05
+    cjlstid_nld30b_sphv_10hv  = 4e-10
+    cjlgatd_nld30b_sphv_10hv  = 4e-10
+    vbiaread_nld30b_sphv_10hv = 0.6
+    vbistid_nld30b_sphv_10hv  = 0.5
+    vbigatd_nld30b_sphv_10hv  = 1.1
+    paread_nld30b_sphv_10hv   = 0.38
+    pstid_nld30b_sphv_10hv    = 0.38
+    pgatd_nld30b_sphv_10hv    = 0.38
+    is1aread_nld30b_sphv_10hv = 6e-08
+    ttaread_nld30b_sphv_10hv  = 1e-08
+    is2aread_nld30b_sphv_10hv = 5e-06
+    iraread_nld30b_sphv_10hv  = 0.00028
+    stis1aread_nld30b_sphv_10hv = 5.0
+    stis2aread_nld30b_sphv_10hv = 3.0
+    stiraread_nld30b_sphv_10hv = 65000.0
+    n1aread_nld30b_sphv_10hv  = 1.0
+    n2aread_nld30b_sphv_10hv  = 2.0
+    nraread_nld30b_sphv_10hv  = 2760.0
+    is1lstid_nld30b_sphv_10hv = 5.5e-08
+    ttlstid_nld30b_sphv_10hv  = 1e-08
+    is2lstid_nld30b_sphv_10hv = 0.0
+    irlstid_nld30b_sphv_10hv  = 0.00028
+    stis1stid_nld30b_sphv_10hv = 5.0
+    stis2stid_nld30b_sphv_10hv = 3.0
+    stirstid_nld30b_sphv_10hv = 65000.0
+    n1stid_nld30b_sphv_10hv   = 1.0
+    n2stid_nld30b_sphv_10hv   = 2.0
+    nrstid_nld30b_sphv_10hv   = 2760.0
+    is1lgatd_nld30b_sphv_10hv = 5.5e-08
+    ttlgatd_nld30b_sphv_10hv  = 1e-08
+    is2lgatd_nld30b_sphv_10hv = 0.0
+    irlgatd_nld30b_sphv_10hv  = 0.00028
+    stis1gatd_nld30b_sphv_10hv = 5.0
+    stis2gatd_nld30b_sphv_10hv = 3.0
+    stirgatd_nld30b_sphv_10hv = 65000.0
+    n1gatd_nld30b_sphv_10hv   = 1.0
+    n2gatd_nld30b_sphv_10hv   = 2.0
+    nrgatd_nld30b_sphv_10hv   = 2760.0
+    cjaread2_nld30b_sphv_10hv = 1e-12
+    cjlstid2_nld30b_sphv_10hv = 1e-18
+    vbiaread2_nld30b_sphv_10hv = 0.5
+    vbistid2_nld30b_sphv_10hv = 1.0
+    paread2_nld30b_sphv_10hv  = 0.38
+    pstid2_nld30b_sphv_10hv   = 0.38
+    is1aread2_nld30b_sphv_10hv = 0
+    ttaread2_nld30b_sphv_10hv = 1e-08
+    is2aread2_nld30b_sphv_10hv = 0.0
+    iraread2_nld30b_sphv_10hv = 0.0
+    stis1aread2_nld30b_sphv_10hv = 3
+    stis2aread2_nld30b_sphv_10hv = 3
+    stiraread2_nld30b_sphv_10hv = 5.0
+    n1aread2_nld30b_sphv_10hv = 1.0
+    n2aread2_nld30b_sphv_10hv = 2.0
+    nraread2_nld30b_sphv_10hv = 250.0
+    is1lstid2_nld30b_sphv_10hv = 0
+    ttlstid2_nld30b_sphv_10hv = 1e-08
+    is2lstid2_nld30b_sphv_10hv = 0.0
+    irlstid2_nld30b_sphv_10hv = 0.0
+    stis1stid2_nld30b_sphv_10hv = 8.0
+    stis2stid2_nld30b_sphv_10hv = 3.0
+    stirstid2_nld30b_sphv_10hv = 5.0
+    n1stid2_nld30b_sphv_10hv  = 1.0
+    n2stid2_nld30b_sphv_10hv  = 2.0
+    nrstid2_nld30b_sphv_10hv  = 250.0
+    stis1gatd2_nld30b_sphv_10hv = 3.0
+    stis2gatd2_nld30b_sphv_10hv = 3.0
+    eais1area_nld30b_sphv_10hv = 1.12
+    eais2area_nld30b_sphv_10hv = 1.12
+    eairarea_nld30b_sphv_10hv = 1.12
+    eais1sti_nld30b_sphv_10hv = 1.12
+    eais2sti_nld30b_sphv_10hv = 1.12
+    eairsti_nld30b_sphv_10hv  = 1.12
+    eais1gat_nld30b_sphv_10hv = 1.12
+    eais2gat_nld30b_sphv_10hv = 1.12
+    eairgat_nld30b_sphv_10hv  = 1.12
+    eais1aread_nld30b_sphv_10hv = 1.12
+    eais2aread_nld30b_sphv_10hv = 1.12
+    eairaread_nld30b_sphv_10hv = 1.12
+    eais1stid_nld30b_sphv_10hv = 1.12
+    eais2stid_nld30b_sphv_10hv = 1.12
+    eairstid_nld30b_sphv_10hv = 1.12
+    eais1gatd_nld30b_sphv_10hv = 1.12
+    eais2gatd_nld30b_sphv_10hv = 1.12
+    eairgatd_nld30b_sphv_10hv = 1.12
+    eais1aread2_nld30b_sphv_10hv = 1.12
+    eais2aread2_nld30b_sphv_10hv = 1.12
+    eairaread2_nld30b_sphv_10hv = 1.12
+    eais1stid2_nld30b_sphv_10hv = 1.12
+    eais2stid2_nld30b_sphv_10hv = 1.12
+    eairstid2_nld30b_sphv_10hv = 1.12
+    ikfarea_nld30b_sphv_10hv  = 0.0
+    stikfarea_nld30b_sphv_10hv = 0.0
+    ikfaread_nld30b_sphv_10hv = 15000000.0
+    dwikfaread_nld30b_sphv_10hv = 0.0
+    stikfaread_nld30b_sphv_10hv = 0.0
+    nom_delr_tox_pld100_sphv_10hv = 1.0
+    nom_dela_vfb_pld100_sphv_10hv = 0.01436
+    nom_dela_vtw_pld100_sphv_10hv = 0.051
+    nom_delr_uch_pld100_sphv_10hv = 0.988
+    nom_delr_res_pld100_sphv_10hv = 1.037
+    nom_dela_dwox_pld100_sphv_10hv = -0.52
+    nom_delr_cj_pld100_sphv_10hv = 1.0
+    nom_delr_is_pld100_sphv_10hv = 1.0
+    nom_delr_is2_pld100_sphv_10hv = 1.0
+    nom_delr_ir_pld100_sphv_10hv = 1.0
+    nom_dela_dw_pld100_sphv_10hv = 1.7e-07
+    nom_delr_thesat_pld100_sphv_10hv = 1.0
+    nom_delr_vdscale_pld100_sphv_10hv = 1.0
+    nom_delr_vdscalew_pld100_sphv_10hv = 1.0
+    nom_delr_theacc2_pld100_sphv_10hv = 1.0
+    sig_delr_tox_pld100_sphv_10hv = 0.012
+    sig_dela_vfb_pld100_sphv_10hv = 0.019
+    sig_dela_vtw_pld100_sphv_10hv = 0.004
+    sig_delr_uch_pld100_sphv_10hv = 0.015
+    sig_delr_res_pld100_sphv_10hv = 0.08
+    sig_dela_dwox_pld100_sphv_10hv = 0.06
+    sig_delr_cj_pld100_sphv_10hv = 0.0333
+    sig_delr_is_pld100_sphv_10hv = 0.055
+    sig_delr_is2_pld100_sphv_10hv = 0.768
+    sig_delr_ir_pld100_sphv_10hv = 0.768
+    sig_dela_dw_pld100_sphv_10hv = 0.0
+    sig_delr_thesat_pld100_sphv_10hv = 0.0
+    sig_delr_vdscale_pld100_sphv_10hv = 0.0
+    sig_delr_vdscalew_pld100_sphv_10hv = 0.0
+    sig_delr_theacc2_pld100_sphv_10hv = 0.0
+    fac_rth_pld100_sphv_10hv  = 0.6
+    tc1_ecrit_pld100_sphv_10hv = -0.0001
+    tc2_ecrit_pld100_sphv_10hv = 1.8e-06
+    dwrjundo_pld100_sphv_10hv = 0.7
+    dwrjunso_pld100_sphv_10hv = 8e-06
+    qmc_pld100_sphv_10hv      = 0.0
+    lvaro_pld100_sphv_10hv    = 0.0
+    lvarl_pld100_sphv_10hv    = 0.0
+    lvarw_pld100_sphv_10hv    = 0.0
+    lap_pld100_sphv_10hv      = 0.0
+    wvaro_pld100_sphv_10hv    = 7.888e-08
+    wvarl_pld100_sphv_10hv    = 0.0
+    wvarw_pld100_sphv_10hv    = 0.0
+    wot_pld100_sphv_10hv      = 0.0
+    dlq_pld100_sphv_10hv      = 1.7e-08
+    dwq_pld100_sphv_10hv      = 3e-08
+    vfbo_pld100_sphv_10hv     = -0.8381
+    vfbl_pld100_sphv_10hv     = 0.1
+    vfbw_pld100_sphv_10hv     = 0.1
+    vfblw_pld100_sphv_10hv    = 0.0
+    stvfbo_pld100_sphv_10hv   = 0.001
+    stvfbl_pld100_sphv_10hv   = 0.0
+    stvfbw_pld100_sphv_10hv   = -0.2413
+    stvfblw_pld100_sphv_10hv  = 0.0
+    toxo_pld100_sphv_10hv     = 1.3e-08
+    epsroxo_pld100_sphv_10hv  = 3.9
+    nsubo_pld100_sphv_10hv    = 1.5e+23
+    nsubw_pld100_sphv_10hv    = 0.0
+    wseg_pld100_sphv_10hv     = 1e-08
+    npck_pld100_sphv_10hv     = 1e+23
+    npckw_pld100_sphv_10hv    = 0.0
+    wsegp_pld100_sphv_10hv    = 1e-08
+    lpck_pld100_sphv_10hv     = 0.0
+    lpckw_pld100_sphv_10hv    = 0.0
+    fol1_pld100_sphv_10hv     = 0.0
+    fol2_pld100_sphv_10hv     = 0.0
+    facneffaco_pld100_sphv_10hv = 1.0
+    facneffacl_pld100_sphv_10hv = 0.0
+    facneffacw_pld100_sphv_10hv = -1.0
+    facneffaclw_pld100_sphv_10hv = 0.0
+    gfacnudo_pld100_sphv_10hv = 1.0
+    gfacnudl_pld100_sphv_10hv = 0.0
+    gfacnudlexp_pld100_sphv_10hv = 1.0
+    gfacnudw_pld100_sphv_10hv = 0.0
+    gfacnudlw_pld100_sphv_10hv = 0.0
+    vsbnudo_pld100_sphv_10hv  = 0.0
+    dvsbnudo_pld100_sphv_10hv = 1.0
+    vnsubo_pld100_sphv_10hv   = 0.0
+    nslpo_pld100_sphv_10hv    = 0.05
+    dnsubo_pld100_sphv_10hv   = -0.01068
+    dphibo_pld100_sphv_10hv   = 0.0
+    dphibl_pld100_sphv_10hv   = 0.0
+    dphiblexp_pld100_sphv_10hv = 1.0
+    dphibw_pld100_sphv_10hv   = 0.0
+    dphiblw_pld100_sphv_10hv  = 0.0
+    delvtaco_pld100_sphv_10hv = 0.0
+    delvtacl_pld100_sphv_10hv = 0.0
+    delvtaclexp_pld100_sphv_10hv = 1.0
+    delvtacw_pld100_sphv_10hv = 0.2
+    delvtaclw_pld100_sphv_10hv = 0.0
+    npo_pld100_sphv_10hv      = 5.7e+25
+    npl_pld100_sphv_10hv      = 0.0
+    cto_pld100_sphv_10hv      = 0.0
+    ctl_pld100_sphv_10hv      = 0.0
+    ctlexp_pld100_sphv_10hv   = 1.0
+    ctw_pld100_sphv_10hv      = 0.2929
+    ctlw_pld100_sphv_10hv     = 0.0
+    ctgo_pld100_sphv_10hv     = 0.0
+    ctbo_pld100_sphv_10hv     = 0.0
+    stcto_pld100_sphv_10hv    = 1.0
+    toxovo_pld100_sphv_10hv   = 1.3e-08
+    toxovdo_pld100_sphv_10hv  = 1.3e-08
+    lov_pld100_sphv_10hv      = 4e-08
+    dlovd_pld100_sphv_10hv    = -1e-07
+    novo_pld100_sphv_10hv     = 8e+25
+    novdo_pld100_sphv_10hv    = 3e+21
+    cfl_pld100_sphv_10hv      = 0.0
+    cflexp_pld100_sphv_10hv   = 2.0
+    cfw_pld100_sphv_10hv      = 0.0
+    cfbo_pld100_sphv_10hv     = 1.0
+    uo_pld100_sphv_10hv       = 0.022
+    fbet1_pld100_sphv_10hv    = 0.0
+    fbet1w_pld100_sphv_10hv   = 0.0
+    lp1_pld100_sphv_10hv      = 1e-10
+    lp1w_pld100_sphv_10hv     = 0.0
+    fbet2_pld100_sphv_10hv    = 0.0
+    lp2_pld100_sphv_10hv      = 1e-10
+    betw1_pld100_sphv_10hv    = 0.2
+    betw2_pld100_sphv_10hv    = -0.01
+    wbet_pld100_sphv_10hv     = 1e-09
+    stbeto_pld100_sphv_10hv   = 1.5
+    stbetl_pld100_sphv_10hv   = 0.0
+    stbetw_pld100_sphv_10hv   = -0.2398
+    stbetlw_pld100_sphv_10hv  = 0.0
+    mueo_pld100_sphv_10hv     = 4.5
+    muew_pld100_sphv_10hv     = 30.0
+    stmueo_pld100_sphv_10hv   = 0.01
+    themuo_pld100_sphv_10hv   = 0.2
+    stthemuo_pld100_sphv_10hv = 1.0
+    cso_pld100_sphv_10hv      = 0.0
+    csl_pld100_sphv_10hv      = 0.0
+    cslexp_pld100_sphv_10hv   = 0.0
+    csw_pld100_sphv_10hv      = 0.0
+    cslw_pld100_sphv_10hv     = 0.0
+    stcso_pld100_sphv_10hv    = 0.0
+    xcoro_pld100_sphv_10hv    = 0.0
+    xcorl_pld100_sphv_10hv    = 0.0
+    xcorw_pld100_sphv_10hv    = 0.0
+    xcorlw_pld100_sphv_10hv   = 0.0
+    stxcoro_pld100_sphv_10hv  = 0.0
+    fetao_pld100_sphv_10hv    = 1.0
+    rsw1_pld100_sphv_10hv     = 0.0
+    rsw2_pld100_sphv_10hv     = 0.0
+    strso_pld100_sphv_10hv    = 1.0
+    rsbo_pld100_sphv_10hv     = 0.0
+    rsgo_pld100_sphv_10hv     = 1.0
+    thesato_pld100_sphv_10hv  = 1.52
+    thesatl_pld100_sphv_10hv  = 0.0
+    thesatlexp_pld100_sphv_10hv = 1.0
+    thesatw_pld100_sphv_10hv  = 1.45
+    thesatlw_pld100_sphv_10hv = 0.0
+    stthesato_pld100_sphv_10hv = 1.4
+    stthesatl_pld100_sphv_10hv = 0.0
+    stthesatw_pld100_sphv_10hv = -1.5
+    stthesatlw_pld100_sphv_10hv = 0.0
+    thesatbo_pld100_sphv_10hv = -0.065
+    thesatgo_pld100_sphv_10hv = 1.12
+    thesatgl_pld100_sphv_10hv = 0.0
+    thesatgw_pld100_sphv_10hv = -2.8
+    vdscale_pld100_sphv_10hv  = 1.22
+    vdscaleb_pld100_sphv_10hv = 0.0
+    stvdscale_pld100_sphv_10hv = -0.02
+    vdscalew_pld100_sphv_10hv = 0.2
+    axo_pld100_sphv_10hv      = 2.0
+    axl_pld100_sphv_10hv      = 0.0
+    alpl_pld100_sphv_10hv     = 0.012
+    alplexp_pld100_sphv_10hv  = 1.0
+    alpw_pld100_sphv_10hv     = 0.0
+    alp1l1_pld100_sphv_10hv   = 1e-06
+    alp1lexp_pld100_sphv_10hv = 1.0
+    alp1l2_pld100_sphv_10hv   = 0.0
+    alp1w_pld100_sphv_10hv    = 0.0
+    alp2l1_pld100_sphv_10hv   = 0.0
+    alp2lexp_pld100_sphv_10hv = 1.0
+    alp2l2_pld100_sphv_10hv   = 0.0
+    alp2w_pld100_sphv_10hv    = 0.0
+    vpo_pld100_sphv_10hv      = 0.1
+    a1o_pld100_sphv_10hv      = 0.000535
+    a1l_pld100_sphv_10hv      = 0.0
+    a1w_pld100_sphv_10hv      = -0.485
+    a2o_pld100_sphv_10hv      = 73.75
+    sta2o_pld100_sphv_10hv    = 0.45
+    a3o_pld100_sphv_10hv      = 1.2
+    a3l_pld100_sphv_10hv      = 0.0
+    a3w_pld100_sphv_10hv      = 0.0
+    a4o_pld100_sphv_10hv      = 0.0
+    a4l_pld100_sphv_10hv      = 0.0
+    a4w_pld100_sphv_10hv      = 0.0
+    gcoo_pld100_sphv_10hv     = 0.0
+    iginvlw_pld100_sphv_10hv  = 0.0
+    igovw_pld100_sphv_10hv    = 0.0
+    igovdw_pld100_sphv_10hv   = 0.0
+    stigo_pld100_sphv_10hv    = 2.0
+    gc2o_pld100_sphv_10hv     = 0.375
+    gc3o_pld100_sphv_10hv     = 0.063
+    chibo_pld100_sphv_10hv    = 3.1
+    agidlw_pld100_sphv_10hv   = 0.0
+    agidldw_pld100_sphv_10hv  = 0.0
+    bgidlo_pld100_sphv_10hv   = 41.0
+    bgidldo_pld100_sphv_10hv  = 41.0
+    stbgidlo_pld100_sphv_10hv = 0.0
+    stbgidldo_pld100_sphv_10hv = 0.0
+    cgidlo_pld100_sphv_10hv   = 0.0
+    cgidldo_pld100_sphv_10hv  = 0.0
+    cgbovl_pld100_sphv_10hv   = 1e-15
+    cfrw_pld100_sphv_10hv     = 2.35e-16
+    cfrdw_pld100_sphv_10hv    = 0.0
+    fnto_pld100_sphv_10hv     = 1.0
+    nfalw_pld100_sphv_10hv    = 5e+24
+    nfblw_pld100_sphv_10hv    = 0.0
+    nfclw_pld100_sphv_10hv    = 2.5e-07
+    efo_pld100_sphv_10hv      = 1.08
+    lintnoi_pld100_sphv_10hv  = 0.0
+    alpnoi_pld100_sphv_10hv   = 2.0
+    kvthoweo_pld100_sphv_10hv = 0.0
+    kvthowel_pld100_sphv_10hv = 0.0
+    kvthowew_pld100_sphv_10hv = 0.0
+    kvthowelw_pld100_sphv_10hv = 0.0
+    kuoweo_pld100_sphv_10hv   = 0.0
+    kuowel_pld100_sphv_10hv   = 0.0
+    kuowew_pld100_sphv_10hv   = 0.0
+    kuowelw_pld100_sphv_10hv  = 0.0
+    rgo_pld100_sphv_10hv      = 0.0
+    rsh_pld100_sphv_10hv      = 0.0
+    rbulko_pld100_sphv_10hv   = 0.0
+    rwello_pld100_sphv_10hv   = 0.0
+    rjunso_pld100_sphv_10hv   = 300.0
+    rjundo_pld100_sphv_10hv   = 480.0
+    rint_pld100_sphv_10hv     = 0.0
+    rvpoly_pld100_sphv_10hv   = 0.0
+    rshg_pld100_sphv_10hv     = 0.0
+    dlsil_pld100_sphv_10hv    = 0.0
+    saref_pld100_sphv_10hv    = 1e-06
+    sbref_pld100_sphv_10hv    = 1e-06
+    wlod_pld100_sphv_10hv     = 0.0
+    kuo_pld100_sphv_10hv      = 0.0
+    kvsat_pld100_sphv_10hv    = 0.0
+    tkuo_pld100_sphv_10hv     = 0.0
+    lkuo_pld100_sphv_10hv     = 0.0
+    wkuo_pld100_sphv_10hv     = 0.0
+    pkuo_pld100_sphv_10hv     = 0.0
+    llodkuo_pld100_sphv_10hv  = 0.0
+    wlodkuo_pld100_sphv_10hv  = 0.0
+    kvtho_pld100_sphv_10hv    = 0.0
+    lkvtho_pld100_sphv_10hv   = 0.0
+    wkvtho_pld100_sphv_10hv   = 0.0
+    pkvtho_pld100_sphv_10hv   = 0.0
+    llodvth_pld100_sphv_10hv  = 0.0
+    wlodvth_pld100_sphv_10hv  = 0.0
+    stetao_pld100_sphv_10hv   = 0.0
+    lodetao_pld100_sphv_10hv  = 1.0
+    scref_pld100_sphv_10hv    = 1e-05
+    web_pld100_sphv_10hv      = 0.0
+    wec_pld100_sphv_10hv      = 0.0
+    adr1o_pld100_sphv_10hv    = 2.5e-05
+    adr1l_pld100_sphv_10hv    = 0.0
+    adr1w_pld100_sphv_10hv    = 0.0002
+    adr2o_pld100_sphv_10hv    = 160.0
+    stadr2o_pld100_sphv_10hv  = -0.3
+    adr3o_pld100_sphv_10hv    = 1.2
+    adr3l_pld100_sphv_10hv    = 0.0
+    adr3w_pld100_sphv_10hv    = 0.0
+    adr4o_pld100_sphv_10hv    = 0.0
+    adr4l_pld100_sphv_10hv    = 0.0
+    adr4w_pld100_sphv_10hv    = 0.0
+    adr5o_pld100_sphv_10hv    = 0.0
+    adr5l_pld100_sphv_10hv    = 0.0
+    adr5w_pld100_sphv_10hv    = 0.0
+    bidr1o_pld100_sphv_10hv   = 0.0
+    bidr1l_pld100_sphv_10hv   = 0.0
+    bidr1w_pld100_sphv_10hv   = 0.0
+    bidr2o_pld100_sphv_10hv   = 0.0
+    bidr2w_pld100_sphv_10hv   = 0.0
+    rtho_pld100_sphv_10hv     = 750.0
+    rthl_pld100_sphv_10hv     = 0.0
+    rthw_pld100_sphv_10hv     = 0.0
+    rthlw_pld100_sphv_10hv    = 0.0
+    strtho_pld100_sphv_10hv   = 0.0
+    strthao_pld100_sphv_10hv  = 0.0
+    ctho_pld100_sphv_10hv     = 0.0
+    cthl_pld100_sphv_10hv     = 0.0
+    cthw_pld100_sphv_10hv     = 0.0
+    cthlw_pld100_sphv_10hv    = 0.0
+    rshldd_pld100_sphv_10hv   = 13380.0
+    xw_pld100_sphv_10hv       = 2.02e-06
+    nwxw_pld100_sphv_10hv     = -7e-13
+    xl_pld100_sphv_10hv       = 0.0
+    xlw_pld100_sphv_10hv      = 0.0
+    dxlsat_pld100_sphv_10hv   = -5e-08
+    nst_pld100_sphv_10hv      = 2.0
+    ats_pld100_sphv_10hv      = 0.0
+    dfinf_pld100_sphv_10hv    = 0.067
+    dfw_pld100_sphv_10hv      = -5e-08
+    dfl_pld100_sphv_10hv      = 0.0
+    dflw_pld100_sphv_10hv     = 0.0
+    dp_pld100_sphv_10hv       = 2.0
+    ecrit_pld100_sphv_10hv    = 3670000.0
+    ecorn_pld100_sphv_10hv    = 150000.0
+    xvsat_pld100_sphv_10hv    = 0.0
+    du_pld100_sphv_10hv       = 0.01
+    tc1_pld100_sphv_10hv      = 0.0053
+    tc2_pld100_sphv_10hv      = 6.4e-06
+    tc1l_pld100_sphv_10hv     = 0.0
+    tc2l_pld100_sphv_10hv     = 0.0
+    tc1w_pld100_sphv_10hv     = 2e-10
+    tc2w_pld100_sphv_10hv     = -1.1e-11
+    theacc_pld100_sphv_10hv   = 0.0
+    theacc2_pld100_sphv_10hv  = 0.0355
+    rva_pld100_sphv_10hv      = 1000.0
+    dta_pld100_sphv_10hv      = 0.0
+    trj_pld100_sphv_10hv      = 27.0
+    cjarea_pld100_sphv_10hv   = 0.00014
+    cjlsti_pld100_sphv_10hv   = 1e-10
+    cjlgat_pld100_sphv_10hv   = 5e-08
+    vbiarea_pld100_sphv_10hv  = 0.7
+    vbisti_pld100_sphv_10hv   = 0.7
+    vbigat_pld100_sphv_10hv   = 0.7
+    parea_pld100_sphv_10hv    = 0.2
+    psti_pld100_sphv_10hv     = 0.2
+    pgat_pld100_sphv_10hv     = 0.35
+    is1area_pld100_sphv_10hv  = 1e-08
+    ttarea_pld100_sphv_10hv   = 0.0
+    is2area_pld100_sphv_10hv  = 0.0
+    irarea_pld100_sphv_10hv   = 3e-09
+    stis1area_pld100_sphv_10hv = 3.0
+    stis2area_pld100_sphv_10hv = 3.0
+    stirarea_pld100_sphv_10hv = 3.0
+    n1area_pld100_sphv_10hv   = 1.0
+    n2area_pld100_sphv_10hv   = 2.0
+    nrarea_pld100_sphv_10hv   = 200.0
+    is1lsti_pld100_sphv_10hv  = 0.0
+    ttlsti_pld100_sphv_10hv   = 0.0
+    is2lsti_pld100_sphv_10hv  = 0.0
+    irlsti_pld100_sphv_10hv   = 3e-09
+    stis1sti_pld100_sphv_10hv = 3.0
+    stis2sti_pld100_sphv_10hv = 3.0
+    stirsti_pld100_sphv_10hv  = 3.0
+    n1sti_pld100_sphv_10hv    = 1.0
+    n2sti_pld100_sphv_10hv    = 2.0
+    nrsti_pld100_sphv_10hv    = 200.0
+    is1lgat_pld100_sphv_10hv  = 0.0
+    ttlgat_pld100_sphv_10hv   = 0.0
+    is2lgat_pld100_sphv_10hv  = 0.0
+    irlgat_pld100_sphv_10hv   = 0.0
+    stis1gat_pld100_sphv_10hv = 3.0
+    stis2gat_pld100_sphv_10hv = 3.0
+    stirgat_pld100_sphv_10hv  = 3.0
+    n1gat_pld100_sphv_10hv    = 1.0
+    n2gat_pld100_sphv_10hv    = 2.0
+    nrgat_pld100_sphv_10hv    = 200.0
+    cjaread_pld100_sphv_10hv  = 9.5e-05
+    cjlstid_pld100_sphv_10hv  = 0.0
+    cjlgatd_pld100_sphv_10hv  = 1.35e-10
+    vbiaread_pld100_sphv_10hv = 1.0
+    vbistid_pld100_sphv_10hv  = 1.0
+    vbigatd_pld100_sphv_10hv  = 1.0
+    paread_pld100_sphv_10hv   = 0.45
+    pstid_pld100_sphv_10hv    = 0.38
+    pgatd_pld100_sphv_10hv    = 0.07
+    is1aread_pld100_sphv_10hv = 0.0
+    ttaread_pld100_sphv_10hv  = 5.1e-08
+    is2aread_pld100_sphv_10hv = 0.0
+    iraread_pld100_sphv_10hv  = 0.0
+    stis1aread_pld100_sphv_10hv = 4.0
+    stis2aread_pld100_sphv_10hv = 0.0
+    stiraread_pld100_sphv_10hv = 610000.0
+    n1aread_pld100_sphv_10hv  = 1.2
+    n2aread_pld100_sphv_10hv  = 2.0
+    nraread_pld100_sphv_10hv  = 30000.0
+    is1lstid_pld100_sphv_10hv = 1e-15
+    ttlstid_pld100_sphv_10hv  = 1.05e-07
+    is2lstid_pld100_sphv_10hv = 1e-12
+    irlstid_pld100_sphv_10hv  = 1.5e-08
+    stis1stid_pld100_sphv_10hv = 4.0
+    stis2stid_pld100_sphv_10hv = 0.0
+    stirstid_pld100_sphv_10hv = 610000.0
+    n1stid_pld100_sphv_10hv   = 1.0
+    n2stid_pld100_sphv_10hv   = 2.0
+    nrstid_pld100_sphv_10hv   = 30000.0
+    is1lgatd_pld100_sphv_10hv = 2.5e-13
+    ttlgatd_pld100_sphv_10hv  = 1.05e-07
+    is2lgatd_pld100_sphv_10hv = 6.25e-11
+    irlgatd_pld100_sphv_10hv  = 2.7e-08
+    stis1gatd_pld100_sphv_10hv = 4.0
+    stis2gatd_pld100_sphv_10hv = 0.0
+    stirgatd_pld100_sphv_10hv = 670000.0
+    n1gatd_pld100_sphv_10hv   = 1.0
+    n2gatd_pld100_sphv_10hv   = 2.0
+    nrgatd_pld100_sphv_10hv   = 30000.0
+    cjaread2_pld100_sphv_10hv = 0.00024
+    cjlstid2_pld100_sphv_10hv = 0.0
+    vbiaread2_pld100_sphv_10hv = 0.5
+    vbistid2_pld100_sphv_10hv = 0.5
+    paread2_pld100_sphv_10hv  = 0.4
+    pstid2_pld100_sphv_10hv   = 0.4
+    is1aread2_pld100_sphv_10hv = 2e-06
+    ttaread2_pld100_sphv_10hv = 5.1e-08
+    is2aread2_pld100_sphv_10hv = 0.0
+    iraread2_pld100_sphv_10hv = 0.0
+    stis1aread2_pld100_sphv_10hv = 4.0
+    stis2aread2_pld100_sphv_10hv = 10.0
+    stiraread2_pld100_sphv_10hv = 610000.0
+    n1aread2_pld100_sphv_10hv = 1.2
+    n2aread2_pld100_sphv_10hv = 2.0
+    nraread2_pld100_sphv_10hv = 30000.0
+    is1lstid2_pld100_sphv_10hv = 1e-14
+    ttlstid2_pld100_sphv_10hv = 1.05e-07
+    is2lstid2_pld100_sphv_10hv = 0.0
+    irlstid2_pld100_sphv_10hv = 0.0
+    stis1stid2_pld100_sphv_10hv = 4.0
+    stis2stid2_pld100_sphv_10hv = 10.0
+    stirstid2_pld100_sphv_10hv = 610000.0
+    n1stid2_pld100_sphv_10hv  = 1.0
+    n2stid2_pld100_sphv_10hv  = 2.0
+    nrstid2_pld100_sphv_10hv  = 30000.0
+    aacc_pld100_sphv_10hv     = 36.0
+    eais1area_pld100_sphv_10hv = 1.12
+    eais2area_pld100_sphv_10hv = 1.12
+    eairarea_pld100_sphv_10hv = 1.12
+    eais1sti_pld100_sphv_10hv = 1.12
+    eais2sti_pld100_sphv_10hv = 1.12
+    eairsti_pld100_sphv_10hv  = 1.12
+    eais1gat_pld100_sphv_10hv = 1.12
+    eais2gat_pld100_sphv_10hv = 1.12
+    eairgat_pld100_sphv_10hv  = 1.12
+    eais1aread_pld100_sphv_10hv = 1.12
+    eais2aread_pld100_sphv_10hv = 1.12
+    eairaread_pld100_sphv_10hv = 1.12
+    eais1stid_pld100_sphv_10hv = 1.12
+    eais2stid_pld100_sphv_10hv = 1.12
+    eairstid_pld100_sphv_10hv = 1.12
+    eais1gatd_pld100_sphv_10hv = 1.12
+    eais2gatd_pld100_sphv_10hv = 1.12
+    eairgatd_pld100_sphv_10hv = 1.12
+    eais1aread2_pld100_sphv_10hv = 1.12
+    eais2aread2_pld100_sphv_10hv = 1.12
+    eairaread2_pld100_sphv_10hv = 1.12
+    eais1stid2_pld100_sphv_10hv = 1.12
+    eais2stid2_pld100_sphv_10hv = 1.12
+    eairstid2_pld100_sphv_10hv = 1.12
+    ecritw_pld100_sphv_10hv   = 3.15
+    ikfaread_pld100_sphv_10hv = 20000000.0
+    ikflstid_pld100_sphv_10hv = 0.0
+    ikfaread2_pld100_sphv_10hv = 20000000.0
+    ikflstid2_pld100_sphv_10hv = 0.0
+    ikflgatd_pld100_sphv_10hv = 0.0
+    stikfaread_pld100_sphv_10hv = 0.0
+    stikfstid_pld100_sphv_10hv = 0.0
+    stikfgatd_pld100_sphv_10hv = 0.0
+    dwikfaread_pld100_sphv_10hv = 45.0
+    nom_delr_cj_nld10_sphv_10hv = 1.0
+    nom_delr_is_nld10_sphv_10hv = 1.0
+    nom_delr_is2_nld10_sphv_10hv = 1.0
+    nom_delr_ir_nld10_sphv_10hv = 1.0
+    nom_delr_tox_nld10_sphv_10hv = 1.0
+    nom_dela_dw_nld10_sphv_10hv = -0.09223
+    nom_dela_xw_nld10_sphv_10hv = -1.217
+    nom_dela_vfb_nld10_sphv_10hv = 0.00635
+    nom_delr_mobref_nld10_sphv_10hv = 0.9524
+    nom_delr_rshl_nld10_sphv_10hv = 0.5972
+    nom_delr_thesato_nld10_sphv_10hv = 1.016
+    nom_dela_vtwl_nld10_sphv_10hv = 0.01566
+    sig_delr_cj_nld10_sphv_10hv = 0.0333
+    sig_delr_is_nld10_sphv_10hv = 0.055
+    sig_delr_is2_nld10_sphv_10hv = 0.768
+    sig_delr_ir_nld10_sphv_10hv = 0.768
+    sig_delr_tox_nld10_sphv_10hv = 0.012
+    sig_dela_dw_nld10_sphv_10hv = 0.01253
+    sig_dela_xw_nld10_sphv_10hv = 0.384
+    sig_dela_vfb_nld10_sphv_10hv = 0.05962
+    sig_delr_mobref_nld10_sphv_10hv = 0.02381
+    sig_delr_rshl_nld10_sphv_10hv = 0.02814
+    sig_delr_thesato_nld10_sphv_10hv = 0.1314
+    sig_dela_vtwl_nld10_sphv_10hv = 0.02851
+    vdscale_nld10_sphv_10hv   = 1.266
+    fac_rth_nld10_sphv_10hv   = 1.1
+    tc1_ecrit_nld10_sphv_10hv = 0.0015
+    tc2_ecrit_nld10_sphv_10hv = 0.0
+    dwrjundo_nld10_sphv_10hv  = 0.0
+    dwrjunso_nld10_sphv_10hv  = 0.0
+    qmc_nld10_sphv_10hv       = 0.0
+    lvaro_nld10_sphv_10hv     = 0.0
+    lvarl_nld10_sphv_10hv     = 0.0
+    lvarw_nld10_sphv_10hv     = 0.0
+    lap_nld10_sphv_10hv       = 0.0
+    wvaro_nld10_sphv_10hv     = -2.7e-07
+    wvarl_nld10_sphv_10hv     = 0.0
+    wvarw_nld10_sphv_10hv     = 0.0
+    wot_nld10_sphv_10hv       = 3e-09
+    dlq_nld10_sphv_10hv       = 1.5e-08
+    dwq_nld10_sphv_10hv       = 2.5e-07
+    vfbo_nld10_sphv_10hv      = -0.7213
+    vfbl_nld10_sphv_10hv      = 0.0
+    vfbw_nld10_sphv_10hv      = -0.12
+    vfblw_nld10_sphv_10hv     = 0.02635
+    stvfbo_nld10_sphv_10hv    = 0.00135
+    stvfbl_nld10_sphv_10hv    = 0.0
+    stvfbw_nld10_sphv_10hv    = -0.005
+    stvfblw_nld10_sphv_10hv   = 0.0
+    toxo_nld10_sphv_10hv      = 1.32e-08
+    epsroxo_nld10_sphv_10hv   = 3.9
+    nsubo_nld10_sphv_10hv     = 1.15e+23
+    nsubw_nld10_sphv_10hv     = 0.01
+    wseg_nld10_sphv_10hv      = 1e-09
+    npck_nld10_sphv_10hv      = 1e+23
+    npckw_nld10_sphv_10hv     = 0.0
+    wsegp_nld10_sphv_10hv     = 2.474e-06
+    lpck_nld10_sphv_10hv      = 0.0
+    lpckw_nld10_sphv_10hv     = 0.0
+    fol1_nld10_sphv_10hv      = 0.05
+    fol2_nld10_sphv_10hv      = 0.0
+    facneffaco_nld10_sphv_10hv = 1.0
+    facneffacl_nld10_sphv_10hv = 0.0
+    facneffacw_nld10_sphv_10hv = 0.0
+    facneffaclw_nld10_sphv_10hv = 0.0
+    gfacnudo_nld10_sphv_10hv  = 1.0
+    gfacnudl_nld10_sphv_10hv  = 0.0
+    gfacnudlexp_nld10_sphv_10hv = 1.0
+    gfacnudw_nld10_sphv_10hv  = 0.0
+    gfacnudlw_nld10_sphv_10hv = 0.0
+    vsbnudo_nld10_sphv_10hv   = 2.75
+    dvsbnudo_nld10_sphv_10hv  = 1.0
+    vnsubo_nld10_sphv_10hv    = 0.0
+    nslpo_nld10_sphv_10hv     = 0.05
+    dnsubo_nld10_sphv_10hv    = 0.0
+    dphibo_nld10_sphv_10hv    = -0.02
+    dphibl_nld10_sphv_10hv    = 0.0
+    dphiblexp_nld10_sphv_10hv = 1.0
+    dphibw_nld10_sphv_10hv    = 0.0
+    dphiblw_nld10_sphv_10hv   = 0.0
+    delvtaco_nld10_sphv_10hv  = 0.0
+    delvtacl_nld10_sphv_10hv  = 0.0
+    delvtaclexp_nld10_sphv_10hv = 1.0
+    delvtacw_nld10_sphv_10hv  = 0.0
+    delvtaclw_nld10_sphv_10hv = 0.0
+    npo_nld10_sphv_10hv       = 1e+26
+    npl_nld10_sphv_10hv       = 0.0
+    cto_nld10_sphv_10hv       = 0.05
+    ctl_nld10_sphv_10hv       = 0.0
+    ctlexp_nld10_sphv_10hv    = 0.4772
+    ctw_nld10_sphv_10hv       = -0.05
+    ctlw_nld10_sphv_10hv      = 0.0
+    toxovo_nld10_sphv_10hv    = 1.32e-08
+    toxovdo_nld10_sphv_10hv   = 1.32e-08
+    lov_nld10_sphv_10hv       = 0.0
+    dlovd_nld10_sphv_10hv     = 0.0
+    novo_nld10_sphv_10hv      = 1.8e+23
+    novdo_nld10_sphv_10hv     = 7.5e+22
+    cfl_nld10_sphv_10hv       = 0.00012
+    cflexp_nld10_sphv_10hv    = 1.0
+    cfw_nld10_sphv_10hv       = 0.0
+    cfbo_nld10_sphv_10hv      = 0.0
+    uo_nld10_sphv_10hv        = 0.068
+    fbet1_nld10_sphv_10hv     = 0.0
+    fbet1w_nld10_sphv_10hv    = 0.0
+    lp1_nld10_sphv_10hv       = 0.0
+    lp1w_nld10_sphv_10hv      = 0.0
+    fbet2_nld10_sphv_10hv     = 0.0
+    lp2_nld10_sphv_10hv       = 0.0
+    betw1_nld10_sphv_10hv     = 0.0
+    betw2_nld10_sphv_10hv     = 0.0
+    wbet_nld10_sphv_10hv      = 0.0
+    stbeto_nld10_sphv_10hv    = 1.28
+    stbetl_nld10_sphv_10hv    = 0.0
+    stbetw_nld10_sphv_10hv    = -0.12
+    stbetlw_nld10_sphv_10hv   = 0.0
+    mueo_nld10_sphv_10hv      = 1.615
+    muew_nld10_sphv_10hv      = -0.35
+    stmueo_nld10_sphv_10hv    = -0.05
+    themuo_nld10_sphv_10hv    = 1.85
+    stthemuo_nld10_sphv_10hv  = 0.2
+    cso_nld10_sphv_10hv       = 0.0
+    csl_nld10_sphv_10hv       = 0.0
+    cslexp_nld10_sphv_10hv    = 0.0
+    csw_nld10_sphv_10hv       = 0.0
+    cslw_nld10_sphv_10hv      = 0.0
+    stcso_nld10_sphv_10hv     = 0.0
+    xcoro_nld10_sphv_10hv     = 0.0
+    xcorl_nld10_sphv_10hv     = 0.0
+    xcorw_nld10_sphv_10hv     = 0.0
+    xcorlw_nld10_sphv_10hv    = 0.0
+    stxcoro_nld10_sphv_10hv   = 0.0
+    fetao_nld10_sphv_10hv     = 0.8
+    rsw1_nld10_sphv_10hv      = 0.0
+    rsw2_nld10_sphv_10hv      = 0.0
+    strso_nld10_sphv_10hv     = 0.0
+    rsbo_nld10_sphv_10hv      = 0.0
+    rsgo_nld10_sphv_10hv      = 0.0
+    thesato_nld10_sphv_10hv   = 0.6
+    thesatl_nld10_sphv_10hv   = 0.0
+    thesatlexp_nld10_sphv_10hv = 1.0
+    thesatw_nld10_sphv_10hv   = -0.05
+    thesatlw_nld10_sphv_10hv  = 0.0
+    stthesato_nld10_sphv_10hv = 1.3
+    stthesatl_nld10_sphv_10hv = 0.0
+    stthesatw_nld10_sphv_10hv = 0.05
+    stthesatlw_nld10_sphv_10hv = 0.0
+    thesatbo_nld10_sphv_10hv  = 0.0
+    thesatgo_nld10_sphv_10hv  = 0.03
+    thesatgl_nld10_sphv_10hv  = 0.0
+    thesatgw_nld10_sphv_10hv  = -0.18
+    axo_nld10_sphv_10hv       = 5.0
+    axl_nld10_sphv_10hv       = 0.4
+    alpl_nld10_sphv_10hv      = 0.0
+    alplexp_nld10_sphv_10hv   = 1.0
+    alpw_nld10_sphv_10hv      = 0.0
+    alp1l1_nld10_sphv_10hv    = 0.0
+    alp1lexp_nld10_sphv_10hv  = 0.5
+    alp1l2_nld10_sphv_10hv    = 0.0
+    alp1w_nld10_sphv_10hv     = 0.0
+    alp2l1_nld10_sphv_10hv    = 0.0
+    alp2lexp_nld10_sphv_10hv  = 1.0
+    alp2l2_nld10_sphv_10hv    = 0.0
+    alp2w_nld10_sphv_10hv     = 0.0
+    vpo_nld10_sphv_10hv       = 10.0
+    a1o_nld10_sphv_10hv       = 0.01
+    a1l_nld10_sphv_10hv       = 0.0
+    a1w_nld10_sphv_10hv       = 0.0
+    a2o_nld10_sphv_10hv       = 12.0
+    sta2o_nld10_sphv_10hv     = 0.0
+    a3o_nld10_sphv_10hv       = 1.0
+    a3l_nld10_sphv_10hv       = 0.2
+    a3w_nld10_sphv_10hv       = 0.0
+    a4o_nld10_sphv_10hv       = 0.0
+    a4l_nld10_sphv_10hv       = 0.0
+    a4w_nld10_sphv_10hv       = 0.0
+    gcoo_nld10_sphv_10hv      = 0.0
+    iginvlw_nld10_sphv_10hv   = 0.0
+    igovw_nld10_sphv_10hv     = 0.0
+    igovdw_nld10_sphv_10hv    = 0.0
+    stigo_nld10_sphv_10hv     = 2.0
+    gc2o_nld10_sphv_10hv      = 0.375
+    gc3o_nld10_sphv_10hv      = 0.063
+    chibo_nld10_sphv_10hv     = 3.1
+    agidlw_nld10_sphv_10hv    = 0.0
+    agidldw_nld10_sphv_10hv   = 0.0
+    bgidlo_nld10_sphv_10hv    = 10.0
+    bgidldo_nld10_sphv_10hv   = 10.0
+    stbgidlo_nld10_sphv_10hv  = 0.0
+    stbgidldo_nld10_sphv_10hv = 0.0
+    cgidlo_nld10_sphv_10hv    = 1.0
+    cgidldo_nld10_sphv_10hv   = 1.0
+    cgbovl_nld10_sphv_10hv    = 1.06e-15
+    cfrw_nld10_sphv_10hv      = 0.0
+    cfrdw_nld10_sphv_10hv     = 0.0
+    fnto_nld10_sphv_10hv      = 1.0
+    nfalw_nld10_sphv_10hv     = 6e+25
+    nfblw_nld10_sphv_10hv     = 0.0
+    nfclw_nld10_sphv_10hv     = 0.0
+    efo_nld10_sphv_10hv       = 0.9
+    lintnoi_nld10_sphv_10hv   = 9e-08
+    alpnoi_nld10_sphv_10hv    = 2.0
+    kvthoweo_nld10_sphv_10hv  = 0.0
+    kvthowel_nld10_sphv_10hv  = 0.0
+    kvthowew_nld10_sphv_10hv  = 0.0
+    kvthowelw_nld10_sphv_10hv = 0.0
+    kuoweo_nld10_sphv_10hv    = 0.0
+    kuowel_nld10_sphv_10hv    = 0.0
+    kuowew_nld10_sphv_10hv    = 0.0
+    kuowelw_nld10_sphv_10hv   = 0.0
+    rgo_nld10_sphv_10hv       = 0.0
+    rsh_nld10_sphv_10hv       = 0.0
+    rbulko_nld10_sphv_10hv    = 0.0
+    rwello_nld10_sphv_10hv    = 0.0
+    rjunso_nld10_sphv_10hv    = 150.0
+    rjundo_nld10_sphv_10hv    = 130.0
+    rint_nld10_sphv_10hv      = 0.0
+    rvpoly_nld10_sphv_10hv    = 0.0
+    rshg_nld10_sphv_10hv      = 0.0
+    dlsil_nld10_sphv_10hv     = 0.0
+    saref_nld10_sphv_10hv     = 1e-06
+    sbref_nld10_sphv_10hv     = 1e-06
+    wlod_nld10_sphv_10hv      = 0.0
+    kuo_nld10_sphv_10hv       = 0.0
+    kvsat_nld10_sphv_10hv     = 0.0
+    tkuo_nld10_sphv_10hv      = 0.0
+    lkuo_nld10_sphv_10hv      = 0.0
+    wkuo_nld10_sphv_10hv      = 0.0
+    pkuo_nld10_sphv_10hv      = 0.0
+    llodkuo_nld10_sphv_10hv   = 0.0
+    wlodkuo_nld10_sphv_10hv   = 0.0
+    kvtho_nld10_sphv_10hv     = 0.0
+    lkvtho_nld10_sphv_10hv    = 0.0
+    wkvtho_nld10_sphv_10hv    = 0.0
+    pkvtho_nld10_sphv_10hv    = 0.0
+    llodvth_nld10_sphv_10hv   = 0.0
+    wlodvth_nld10_sphv_10hv   = 0.0
+    stetao_nld10_sphv_10hv    = 0.0
+    lodetao_nld10_sphv_10hv   = 1.0
+    scref_nld10_sphv_10hv     = 1e-05
+    web_nld10_sphv_10hv       = 0.0
+    wec_nld10_sphv_10hv       = 0.0
+    adr1o_nld10_sphv_10hv     = 0.0
+    adr1l_nld10_sphv_10hv     = 0.0
+    adr1w_nld10_sphv_10hv     = 0.0
+    adr2o_nld10_sphv_10hv     = 0.0
+    stadr2o_nld10_sphv_10hv   = 1.0
+    adr3o_nld10_sphv_10hv     = 0.0
+    adr3l_nld10_sphv_10hv     = 0.0
+    adr3w_nld10_sphv_10hv     = 0.0
+    adr4o_nld10_sphv_10hv     = 0.0
+    adr4l_nld10_sphv_10hv     = 0.0
+    adr4w_nld10_sphv_10hv     = 0.0
+    adr5o_nld10_sphv_10hv     = 0.0
+    adr5l_nld10_sphv_10hv     = 0.0
+    adr5w_nld10_sphv_10hv     = 0.0
+    bidr1o_nld10_sphv_10hv    = 0.0
+    bidr1l_nld10_sphv_10hv    = 0.0
+    bidr1w_nld10_sphv_10hv    = 0.0
+    bidr2o_nld10_sphv_10hv    = 0.0
+    bidr2w_nld10_sphv_10hv    = 0.0
+    rtho_nld10_sphv_10hv      = 650.0
+    rthl_nld10_sphv_10hv      = 0.0
+    rthw_nld10_sphv_10hv      = 0.0
+    rthlw_nld10_sphv_10hv     = 0.0
+    strtho_nld10_sphv_10hv    = -0.01
+    ctho_nld10_sphv_10hv      = 0.0
+    cthl_nld10_sphv_10hv      = 0.0
+    cthw_nld10_sphv_10hv      = 0.0
+    cthlw_nld10_sphv_10hv     = 0.0
+    rshldd_nld10_sphv_10hv    = 2108.0
+    xw_nld10_sphv_10hv        = 1.55e-07
+    nwxw_nld10_sphv_10hv      = -5e-14
+    xl_nld10_sphv_10hv        = 0.0
+    xlw_nld10_sphv_10hv       = 0.0
+    dxlsat_nld10_sphv_10hv    = 5.65e-07
+    nst_nld10_sphv_10hv       = 1.0
+    ats_nld10_sphv_10hv       = 0.0
+    dfinf_nld10_sphv_10hv     = 0.01
+    dfw_nld10_sphv_10hv       = 0.0
+    dfl_nld10_sphv_10hv       = 0.0
+    dflw_nld10_sphv_10hv      = 0.0
+    dp_nld10_sphv_10hv        = 1.922
+    ecrit_nld10_sphv_10hv     = 470000.0
+    ecorn_nld10_sphv_10hv     = 160000.0
+    ecritw_nld10_sphv_10hv    = -0.22
+    du_nld10_sphv_10hv        = 110.0
+    xvsat_nld10_sphv_10hv     = -0.2
+    xvsatw_nld10_sphv_10hv    = 2.0
+    tc1_nld10_sphv_10hv       = 0.003
+    tc2_nld10_sphv_10hv       = 5e-05
+    tc1l_nld10_sphv_10hv      = 0.0
+    tc2l_nld10_sphv_10hv      = 0.0
+    tc1w_nld10_sphv_10hv      = 0.0
+    tc2w_nld10_sphv_10hv      = 0.0
+    theacc_nld10_sphv_10hv    = 0.0
+    theacc2_nld10_sphv_10hv   = 0.036
+    aacc_nld10_sphv_10hv      = 36.0
+    rva_nld10_sphv_10hv       = 1000.0
+    dta_nld10_sphv_10hv       = 0.0
+    trj_nld10_sphv_10hv       = 27.0
+    cjarea_nld10_sphv_10hv    = 0.00061
+    cjlsti_nld10_sphv_10hv    = 1e-10
+    cjlgat_nld10_sphv_10hv    = 6e-10
+    vbiarea_nld10_sphv_10hv   = 1.0
+    vbisti_nld10_sphv_10hv    = 1.0
+    vbigat_nld10_sphv_10hv    = 1.0
+    parea_nld10_sphv_10hv     = 0.35
+    psti_nld10_sphv_10hv      = 0.5
+    pgat_nld10_sphv_10hv      = 0.5
+    is1area_nld10_sphv_10hv   = 1e-11
+    ttarea_nld10_sphv_10hv    = 2e-09
+    is2area_nld10_sphv_10hv   = 1e-11
+    irarea_nld10_sphv_10hv    = 1e-12
+    stis1area_nld10_sphv_10hv = 3.0
+    stis2area_nld10_sphv_10hv = 3.0
+    stirarea_nld10_sphv_10hv  = 20.0
+    n1area_nld10_sphv_10hv    = 1.0
+    n2area_nld10_sphv_10hv    = 3.0
+    nrarea_nld10_sphv_10hv    = 100.0
+    is1lsti_nld10_sphv_10hv   = 1e-16
+    ttlsti_nld10_sphv_10hv    = 2e-09
+    is2lsti_nld10_sphv_10hv   = 1e-16
+    irlsti_nld10_sphv_10hv    = 0.0
+    stis1sti_nld10_sphv_10hv  = 3.0
+    stis2sti_nld10_sphv_10hv  = 3.0
+    stirsti_nld10_sphv_10hv   = 20.0
+    n1sti_nld10_sphv_10hv     = 1.0
+    n2sti_nld10_sphv_10hv     = 3.0
+    nrsti_nld10_sphv_10hv     = 100.0
+    is1lgat_nld10_sphv_10hv   = 1e-16
+    ttlgat_nld10_sphv_10hv    = 2e-09
+    is2lgat_nld10_sphv_10hv   = 1e-16
+    irlgat_nld10_sphv_10hv    = 0.0
+    stis1gat_nld10_sphv_10hv  = 3.0
+    stis2gat_nld10_sphv_10hv  = 3.0
+    stirgat_nld10_sphv_10hv   = 20.0
+    n1gat_nld10_sphv_10hv     = 1.0
+    n2gat_nld10_sphv_10hv     = 3.0
+    nrgat_nld10_sphv_10hv     = 100.0
+    cjaread_nld10_sphv_10hv   = 0.00013
+    cjlstid_nld10_sphv_10hv   = 4e-10
+    cjlgatd_nld10_sphv_10hv   = 4e-10
+    vbiaread_nld10_sphv_10hv  = 0.5
+    vbistid_nld10_sphv_10hv   = 0.5
+    vbigatd_nld10_sphv_10hv   = 0.5
+    paread_nld10_sphv_10hv    = 0.375
+    pstid_nld10_sphv_10hv     = 0.375
+    pgatd_nld10_sphv_10hv     = 0.375
+    is1aread_nld10_sphv_10hv  = 2.5e-07
+    ttaread_nld10_sphv_10hv   = 1.9e-09
+    is2aread_nld10_sphv_10hv  = 6.8e-06
+    iraread_nld10_sphv_10hv   = 6.5e-05
+    stis1aread_nld10_sphv_10hv = 6.0
+    stis2aread_nld10_sphv_10hv = 3.0
+    stiraread_nld10_sphv_10hv = 24000.0
+    n1aread_nld10_sphv_10hv   = 1.1
+    n2aread_nld10_sphv_10hv   = 2.0
+    nraread_nld10_sphv_10hv   = 1000.0
+    is1lstid_nld10_sphv_10hv  = 5.5e-08
+    ttlstid_nld10_sphv_10hv   = 1.9e-09
+    is2lstid_nld10_sphv_10hv  = 0.0
+    irlstid_nld10_sphv_10hv   = 6.5e-05
+    stis1stid_nld10_sphv_10hv = 6.0
+    stis2stid_nld10_sphv_10hv = 3.0
+    stirstid_nld10_sphv_10hv  = 24000.0
+    n1stid_nld10_sphv_10hv    = 1.1
+    n2stid_nld10_sphv_10hv    = 2.0
+    nrstid_nld10_sphv_10hv    = 1000.0
+    is1lgatd_nld10_sphv_10hv  = 5.5e-08
+    ttlgatd_nld10_sphv_10hv   = 1.9e-09
+    is2lgatd_nld10_sphv_10hv  = 0.0
+    irlgatd_nld10_sphv_10hv   = 6.5e-05
+    stis1gatd_nld10_sphv_10hv = 6.0
+    stis2gatd_nld10_sphv_10hv = 3.0
+    stirgatd_nld10_sphv_10hv  = 24000.0
+    n1gatd_nld10_sphv_10hv    = 1.1
+    n2gatd_nld10_sphv_10hv    = 2.0
+    nrgatd_nld10_sphv_10hv    = 1000.0
+    cjaread2_nld10_sphv_10hv  = 1e-12
+    cjlstid2_nld10_sphv_10hv  = 1e-18
+    vbiaread2_nld10_sphv_10hv = 0.5
+    vbistid2_nld10_sphv_10hv  = 0.5
+    paread2_nld10_sphv_10hv   = 0.2
+    pstid2_nld10_sphv_10hv    = 0.2
+    is1aread2_nld10_sphv_10hv = 0
+    ttaread2_nld10_sphv_10hv  = 1.9e-09
+    is2aread2_nld10_sphv_10hv = 0.0
+    iraread2_nld10_sphv_10hv  = 5e-09
+    stis1aread2_nld10_sphv_10hv = 3
+    stis2aread2_nld10_sphv_10hv = 3
+    stiraread2_nld10_sphv_10hv = 24000.0
+    n1aread2_nld10_sphv_10hv  = 1.0
+    n2aread2_nld10_sphv_10hv  = 2.0
+    nraread2_nld10_sphv_10hv  = 1000.0
+    is1lstid2_nld10_sphv_10hv = 0
+    ttlstid2_nld10_sphv_10hv  = 1.9e-09
+    is2lstid2_nld10_sphv_10hv = 0.0
+    irlstid2_nld10_sphv_10hv  = 5e-09
+    stis1stid2_nld10_sphv_10hv = 4.0
+    stis2stid2_nld10_sphv_10hv = 3.0
+    stirstid2_nld10_sphv_10hv = 24000.0
+    n1stid2_nld10_sphv_10hv   = 1.0
+    n2stid2_nld10_sphv_10hv   = 2.0
+    nrstid2_nld10_sphv_10hv   = 1000.0
+    stis1gatd2_nld10_sphv_10hv = 3.0
+    stis2gatd2_nld10_sphv_10hv = 3.0
+    eais1area_nld10_sphv_10hv = 1.12
+    eais2area_nld10_sphv_10hv = 1.12
+    eairarea_nld10_sphv_10hv  = 1.12
+    eais1sti_nld10_sphv_10hv  = 1.12
+    eais2sti_nld10_sphv_10hv  = 1.12
+    eairsti_nld10_sphv_10hv   = 1.12
+    eais1gat_nld10_sphv_10hv  = 1.12
+    eais2gat_nld10_sphv_10hv  = 1.12
+    eairgat_nld10_sphv_10hv   = 1.12
+    eais1aread_nld10_sphv_10hv = 1.12
+    eais2aread_nld10_sphv_10hv = 1.12
+    eairaread_nld10_sphv_10hv = 1.12
+    eais1stid_nld10_sphv_10hv = 1.12
+    eais2stid_nld10_sphv_10hv = 1.12
+    eairstid_nld10_sphv_10hv  = 1.12
+    eais1gatd_nld10_sphv_10hv = 1.12
+    eais2gatd_nld10_sphv_10hv = 1.12
+    eairgatd_nld10_sphv_10hv  = 1.12
+    eais1aread2_nld10_sphv_10hv = 1.12
+    eais2aread2_nld10_sphv_10hv = 1.12
+    eairaread2_nld10_sphv_10hv = 1.12
+    eais1stid2_nld10_sphv_10hv = 1.12
+    eais2stid2_nld10_sphv_10hv = 1.12
+    eairstid2_nld10_sphv_10hv = 1.12
+    ikfarea_nld10_sphv_10hv   = 0.0
+    stikfarea_nld10_sphv_10hv = 0.0
+    ikfaread_nld10_sphv_10hv  = 20000000.0
+    dwikfaread_nld10_sphv_10hv = 0.0
+    stikfaread_nld10_sphv_10hv = 0.0
+    nom_delr_tox_nld100_sphv_10hv = 1.0
+    nom_dela_xw_nld100_sphv_10hv = 0.0
+    nom_dela_vfb_nld100_sphv_10hv = 0.0
+    nom_dela_vfbw_nld100_sphv_10hv = 0.0
+    nom_dela_vdscale_nld100_sphv_10hv = 0.0
+    nom_dela_vdscalew_nld100_sphv_10hv = 0.0
+    nom_dela_thesatgo_nld100_sphv_10hv = 0.0
+    nom_delr_rshl_nld100_sphv_10hv = 1.0
+    nom_delr_cj_nld100_sphv_10hv = 1.0
+    nom_delr_is_nld100_sphv_10hv = 1.0
+    nom_delr_is2_nld100_sphv_10hv = 1.0
+    nom_delr_ir_nld100_sphv_10hv = 1.0
+    nom_cfr_s_ply_met_nld100_sphv_10hv = 7.97e-17
+    nom_cfr_d_ply_met_nld100_sphv_10hv = 1.04e-17
+    nom_cfr_s_ply_m1ct_nld100_sphv_10hv = 1.15e-16
+    nom_cfr_d_ply_m1ct_nld100_sphv_10hv = 1.06e-17
+    nom_delr_cfr_s_ply_met_nld100_sphv_10hv = 1.0
+    nom_delr_cfr_d_ply_met_nld100_sphv_10hv = 1.0
+    nom_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = 1.0
+    nom_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = 1.0
+    sig_delr_tox_nld100_sphv_10hv = 0.012
+    sig_dela_xw_nld100_sphv_10hv = 0.066
+    sig_dela_vfb_nld100_sphv_10hv = 0.0465
+    sig_dela_vfbw_nld100_sphv_10hv = 0.057
+    sig_dela_vdscale_nld100_sphv_10hv = 0.00625
+    sig_dela_vdscalew_nld100_sphv_10hv = 0.08
+    sig_dela_thesatgo_nld100_sphv_10hv = 0.015
+    sig_delr_rshl_nld100_sphv_10hv = 0.028
+    sig_delr_cj_nld100_sphv_10hv = 0.033
+    sig_delr_is_nld100_sphv_10hv = 0.055
+    sig_delr_is2_nld100_sphv_10hv = 0.768
+    sig_delr_ir_nld100_sphv_10hv = 0.768
+    sig_delr_cfr_s_ply_met_nld100_sphv_10hv = 0.0465
+    sig_delr_cfr_d_ply_met_nld100_sphv_10hv = 0.0096
+    sig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = 0.028
+    sig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = 0.0063
+    fac_rth_nld100_sphv_10hv  = 0.6
+    tc1_ecrit_nld100_sphv_10hv = 0.006
+    tc2_ecrit_nld100_sphv_10hv = 1.3e-05
+    dwrjundo_nld100_sphv_10hv = 4.0
+    dwrjunso_nld100_sphv_10hv = 8e-06
+    qmc_nld100_sphv_10hv      = 1.0
+    lvaro_nld100_sphv_10hv    = 0.0
+    lvarl_nld100_sphv_10hv    = 0.0
+    lvarw_nld100_sphv_10hv    = 0.0
+    lap_nld100_sphv_10hv      = 0.0
+    wvaro_nld100_sphv_10hv    = -1e-07
+    wvarl_nld100_sphv_10hv    = 0.0
+    wvarw_nld100_sphv_10hv    = 0.0
+    wot_nld100_sphv_10hv      = 0.0
+    dlq_nld100_sphv_10hv      = 5e-09
+    dwq_nld100_sphv_10hv      = 1.18e-06
+    vfbo_nld100_sphv_10hv     = -0.994
+    vfbl_nld100_sphv_10hv     = 0.0
+    vfbw_nld100_sphv_10hv     = -0.016
+    vfblw_nld100_sphv_10hv    = 0.0
+    stvfbo_nld100_sphv_10hv   = 0.0012
+    stvfbl_nld100_sphv_10hv   = 0.0
+    stvfbw_nld100_sphv_10hv   = -0.12
+    stvfblw_nld100_sphv_10hv  = 0.0
+    toxo_nld100_sphv_10hv     = 1.32e-08
+    epsroxo_nld100_sphv_10hv  = 3.9
+    nsubo_nld100_sphv_10hv    = 3.63e+23
+    nsubw_nld100_sphv_10hv    = 0.0
+    wseg_nld100_sphv_10hv     = 1e-08
+    npck_nld100_sphv_10hv     = 1e+23
+    npckw_nld100_sphv_10hv    = 0.0
+    wsegp_nld100_sphv_10hv    = 1e-08
+    lpck_nld100_sphv_10hv     = 0.0
+    lpckw_nld100_sphv_10hv    = 0.0
+    fol1_nld100_sphv_10hv     = 0.0
+    fol2_nld100_sphv_10hv     = 0.0
+    facneffaco_nld100_sphv_10hv = 0.8
+    facneffacl_nld100_sphv_10hv = 0.0
+    facneffacw_nld100_sphv_10hv = 0.0
+    facneffaclw_nld100_sphv_10hv = 0.0
+    gfacnudo_nld100_sphv_10hv = 1.1
+    gfacnudl_nld100_sphv_10hv = 0.0
+    gfacnudlexp_nld100_sphv_10hv = 1.0
+    gfacnudw_nld100_sphv_10hv = 0.0
+    gfacnudlw_nld100_sphv_10hv = 0.0
+    vsbnudo_nld100_sphv_10hv  = 0.0
+    dvsbnudo_nld100_sphv_10hv = 1.0
+    vnsubo_nld100_sphv_10hv   = 0.0
+    nslpo_nld100_sphv_10hv    = 0.05
+    dnsubo_nld100_sphv_10hv   = 0.0
+    dphibo_nld100_sphv_10hv   = 0.0
+    dphibl_nld100_sphv_10hv   = 0.0
+    dphiblexp_nld100_sphv_10hv = 1.0
+    dphibw_nld100_sphv_10hv   = 0.0
+    dphiblw_nld100_sphv_10hv  = 0.0
+    delvtaco_nld100_sphv_10hv = -0.2
+    delvtacl_nld100_sphv_10hv = 0.0
+    delvtaclexp_nld100_sphv_10hv = 1.0
+    delvtacw_nld100_sphv_10hv = 0.0
+    delvtaclw_nld100_sphv_10hv = 0.0
+    npo_nld100_sphv_10hv      = 1e+26
+    npl_nld100_sphv_10hv      = 0.0
+    cto_nld100_sphv_10hv      = 0.04
+    ctl_nld100_sphv_10hv      = 0.0
+    ctlexp_nld100_sphv_10hv   = 1.0
+    ctw_nld100_sphv_10hv      = 0.0
+    ctlw_nld100_sphv_10hv     = 0.0
+    toxovo_nld100_sphv_10hv   = 1.32e-08
+    toxovdo_nld100_sphv_10hv  = 1.32e-08
+    lov_nld100_sphv_10hv      = 0.0
+    dlovd_nld100_sphv_10hv    = 0.0
+    novo_nld100_sphv_10hv     = 1e+24
+    novdo_nld100_sphv_10hv    = 4.5e+22
+    cfl_nld100_sphv_10hv      = 0.0003
+    cflexp_nld100_sphv_10hv   = 2.0
+    cfw_nld100_sphv_10hv      = 0.0
+    cfbo_nld100_sphv_10hv     = 0.0
+    uo_nld100_sphv_10hv       = 0.071
+    fbet1_nld100_sphv_10hv    = 0.0
+    fbet1w_nld100_sphv_10hv   = 0.0
+    lp1_nld100_sphv_10hv      = 1e-08
+    lp1w_nld100_sphv_10hv     = 0.0
+    fbet2_nld100_sphv_10hv    = 0.0
+    lp2_nld100_sphv_10hv      = 1e-08
+    betw1_nld100_sphv_10hv    = -0.04
+    betw2_nld100_sphv_10hv    = 0.0
+    wbet_nld100_sphv_10hv     = 1e-09
+    stbeto_nld100_sphv_10hv   = 1.0
+    stbetl_nld100_sphv_10hv   = 0.0
+    stbetw_nld100_sphv_10hv   = 0.5
+    stbetlw_nld100_sphv_10hv  = 0.0
+    mueo_nld100_sphv_10hv     = 0.8
+    muew_nld100_sphv_10hv     = 0.02
+    stmueo_nld100_sphv_10hv   = 0.0
+    themuo_nld100_sphv_10hv   = 1.0
+    stthemuo_nld100_sphv_10hv = 0.5
+    cso_nld100_sphv_10hv      = 0.0
+    csl_nld100_sphv_10hv      = 0.0
+    cslexp_nld100_sphv_10hv   = 0.0
+    csw_nld100_sphv_10hv      = 0.0
+    cslw_nld100_sphv_10hv     = 0.0
+    stcso_nld100_sphv_10hv    = 0.0
+    xcoro_nld100_sphv_10hv    = 0.0
+    xcorl_nld100_sphv_10hv    = 0.0
+    xcorw_nld100_sphv_10hv    = 0.0
+    xcorlw_nld100_sphv_10hv   = 0.0
+    stxcoro_nld100_sphv_10hv  = 0.0
+    fetao_nld100_sphv_10hv    = 1.0
+    rsw1_nld100_sphv_10hv     = 0.0
+    rsw2_nld100_sphv_10hv     = 0.0
+    strso_nld100_sphv_10hv    = 1.0
+    rsbo_nld100_sphv_10hv     = 0.0
+    rsgo_nld100_sphv_10hv     = 0.0
+    thesato_nld100_sphv_10hv  = 0.75
+    thesatl_nld100_sphv_10hv  = 0.0
+    thesatlexp_nld100_sphv_10hv = 1.0
+    thesatw_nld100_sphv_10hv  = 0.0
+    thesatlw_nld100_sphv_10hv = 0.0
+    stthesato_nld100_sphv_10hv = 0.4
+    stthesatl_nld100_sphv_10hv = 0.0
+    stthesatw_nld100_sphv_10hv = 0.0
+    stthesatlw_nld100_sphv_10hv = 0.0
+    thesatbo_nld100_sphv_10hv = 0.0
+    thesatgo_nld100_sphv_10hv = 0.48
+    thesatgl_nld100_sphv_10hv = 0.0
+    thesatgw_nld100_sphv_10hv = 0.0
+    axo_nld100_sphv_10hv      = 3.0
+    axl_nld100_sphv_10hv      = 0.4
+    alpl_nld100_sphv_10hv     = 0.0005
+    alplexp_nld100_sphv_10hv  = 1.0
+    alpw_nld100_sphv_10hv     = 0.0
+    alp1l1_nld100_sphv_10hv   = 0.0
+    alp1lexp_nld100_sphv_10hv = 0.5
+    alp1l2_nld100_sphv_10hv   = 0.0
+    alp1w_nld100_sphv_10hv    = 0.0
+    alp2l1_nld100_sphv_10hv   = 0.0
+    alp2lexp_nld100_sphv_10hv = 0.5
+    alp2l2_nld100_sphv_10hv   = 0.0
+    alp2w_nld100_sphv_10hv    = 0.0
+    vpo_nld100_sphv_10hv      = 0.05
+    a1o_nld100_sphv_10hv      = 0.013
+    a1l_nld100_sphv_10hv      = 0.0
+    a1w_nld100_sphv_10hv      = 0.0
+    a2o_nld100_sphv_10hv      = 7.0
+    sta2o_nld100_sphv_10hv    = 6.0
+    a3o_nld100_sphv_10hv      = 170.0
+    a3l_nld100_sphv_10hv      = 0.0
+    a3w_nld100_sphv_10hv      = 0.0
+    a4o_nld100_sphv_10hv      = 0.0
+    a4l_nld100_sphv_10hv      = 0.0
+    a4w_nld100_sphv_10hv      = 0.0
+    gcoo_nld100_sphv_10hv     = 0.0
+    iginvlw_nld100_sphv_10hv  = 0.0
+    igovw_nld100_sphv_10hv    = 0.0
+    igovdw_nld100_sphv_10hv   = 0.0
+    stigo_nld100_sphv_10hv    = 2.0
+    gc2o_nld100_sphv_10hv     = 0.375
+    gc3o_nld100_sphv_10hv     = 0.063
+    chibo_nld100_sphv_10hv    = 3.1
+    agidlw_nld100_sphv_10hv   = 0.0
+    agidldw_nld100_sphv_10hv  = 0.0
+    bgidlo_nld100_sphv_10hv   = 41.0
+    bgidldo_nld100_sphv_10hv  = 41.0
+    stbgidlo_nld100_sphv_10hv = 0.0
+    stbgidldo_nld100_sphv_10hv = 0.0
+    cgidlo_nld100_sphv_10hv   = 0.0
+    cgidldo_nld100_sphv_10hv  = 0.0
+    cgbovl_nld100_sphv_10hv   = 0.0
+    cfrw_nld100_sphv_10hv     = 2e-17
+    cfrdw_nld100_sphv_10hv    = 0.0
+    fnto_nld100_sphv_10hv     = 1.0
+    nfalw_nld100_sphv_10hv    = 2e+26
+    nfblw_nld100_sphv_10hv    = 0.0
+    nfclw_nld100_sphv_10hv    = 0.0
+    efo_nld100_sphv_10hv      = 0.9
+    lintnoi_nld100_sphv_10hv  = 0.0
+    alpnoi_nld100_sphv_10hv   = 2.0
+    kvthoweo_nld100_sphv_10hv = 0.0
+    kvthowel_nld100_sphv_10hv = 0.0
+    kvthowew_nld100_sphv_10hv = 0.0
+    kvthowelw_nld100_sphv_10hv = 0.0
+    kuoweo_nld100_sphv_10hv   = 0.0
+    kuowel_nld100_sphv_10hv   = 0.0
+    kuowew_nld100_sphv_10hv   = 0.0
+    kuowelw_nld100_sphv_10hv  = 0.0
+    rgo_nld100_sphv_10hv      = 0.0
+    rsh_nld100_sphv_10hv      = 0.0
+    rbulko_nld100_sphv_10hv   = 0.0
+    rwello_nld100_sphv_10hv   = 0.0
+    rjunso_nld100_sphv_10hv   = 10.0
+    rjundo_nld100_sphv_10hv   = 300.0
+    rint_nld100_sphv_10hv     = 0.0
+    rvpoly_nld100_sphv_10hv   = 0.0
+    rshg_nld100_sphv_10hv     = 0.0
+    dlsil_nld100_sphv_10hv    = 0.0
+    saref_nld100_sphv_10hv    = 1e-06
+    sbref_nld100_sphv_10hv    = 1e-06
+    wlod_nld100_sphv_10hv     = 0.0
+    kuo_nld100_sphv_10hv      = 0.0
+    kvsat_nld100_sphv_10hv    = 0.0
+    tkuo_nld100_sphv_10hv     = 0.0
+    lkuo_nld100_sphv_10hv     = 0.0
+    wkuo_nld100_sphv_10hv     = 0.0
+    pkuo_nld100_sphv_10hv     = 0.0
+    llodkuo_nld100_sphv_10hv  = 0.0
+    wlodkuo_nld100_sphv_10hv  = 0.0
+    kvtho_nld100_sphv_10hv    = 0.0
+    lkvtho_nld100_sphv_10hv   = 0.0
+    wkvtho_nld100_sphv_10hv   = 0.0
+    pkvtho_nld100_sphv_10hv   = 0.0
+    llodvth_nld100_sphv_10hv  = 0.0
+    wlodvth_nld100_sphv_10hv  = 0.0
+    stetao_nld100_sphv_10hv   = 0.0
+    lodetao_nld100_sphv_10hv  = 1.0
+    scref_nld100_sphv_10hv    = 1e-05
+    web_nld100_sphv_10hv      = 0.0
+    wec_nld100_sphv_10hv      = 0.0
+    adr1o_nld100_sphv_10hv    = 0.001
+    adr1l_nld100_sphv_10hv    = 0.0
+    adr1w_nld100_sphv_10hv    = 0.02
+    adr2o_nld100_sphv_10hv    = 2.0
+    stadr2o_nld100_sphv_10hv  = 1.0
+    adr3o_nld100_sphv_10hv    = 0.0
+    adr3l_nld100_sphv_10hv    = 0.0
+    adr3w_nld100_sphv_10hv    = 0.4
+    adr4o_nld100_sphv_10hv    = 0.0
+    adr4l_nld100_sphv_10hv    = 0.0
+    adr4w_nld100_sphv_10hv    = 0.0
+    adr5o_nld100_sphv_10hv    = 0.0
+    adr5l_nld100_sphv_10hv    = 0.0
+    adr5w_nld100_sphv_10hv    = 0.0
+    bidr1o_nld100_sphv_10hv   = 0.0
+    bidr1l_nld100_sphv_10hv   = 0.0
+    bidr1w_nld100_sphv_10hv   = 0.0
+    bidr2o_nld100_sphv_10hv   = 0.0
+    bidr2w_nld100_sphv_10hv   = 0.0
+    rtho_nld100_sphv_10hv     = 750.0
+    rthl_nld100_sphv_10hv     = 0.0
+    rthw_nld100_sphv_10hv     = 0.0
+    rthlw_nld100_sphv_10hv    = 0.0
+    strtho_nld100_sphv_10hv   = 0.2
+    ctho_nld100_sphv_10hv     = 0.0
+    cthl_nld100_sphv_10hv     = 0.0
+    cthw_nld100_sphv_10hv     = 0.0
+    cthlw_nld100_sphv_10hv    = 0.0
+    rshldd_nld100_sphv_10hv   = 3184.0
+    xw_nld100_sphv_10hv       = 1.9e-06
+    nwxw_nld100_sphv_10hv     = -6e-13
+    xl_nld100_sphv_10hv       = 0.0
+    xlw_nld100_sphv_10hv      = 0.0
+    dxlsat_nld100_sphv_10hv   = 0.0
+    nst_nld100_sphv_10hv      = 1.0
+    ats_nld100_sphv_10hv      = 0.0
+    dfinf_nld100_sphv_10hv    = 0.015
+    dfw_nld100_sphv_10hv      = 1e-08
+    dfl_nld100_sphv_10hv      = 0.0
+    dflw_nld100_sphv_10hv     = 0.0
+    dp_nld100_sphv_10hv       = 2.0
+    ecrit_nld100_sphv_10hv    = 970000.0
+    ecorn_nld100_sphv_10hv    = 120000.0
+    du_nld100_sphv_10hv       = 0.02
+    tc1_nld100_sphv_10hv      = 0.0055
+    tc2_nld100_sphv_10hv      = 1.57e-05
+    tc1l_nld100_sphv_10hv     = 0.0
+    tc2l_nld100_sphv_10hv     = 0.0
+    tc1w_nld100_sphv_10hv     = -1.8e-09
+    tc2w_nld100_sphv_10hv     = 0.0
+    theacc_nld100_sphv_10hv   = 0.0
+    theacc2_nld100_sphv_10hv  = 0.0025
+    rva_nld100_sphv_10hv      = 53.5
+    dta_nld100_sphv_10hv      = 0.0
+    trj_nld100_sphv_10hv      = 25.0
+    cjarea_nld100_sphv_10hv   = 0.0
+    cjlsti_nld100_sphv_10hv   = 0.0
+    cjlgat_nld100_sphv_10hv   = 0.0
+    vbiarea_nld100_sphv_10hv  = 1.0
+    vbisti_nld100_sphv_10hv   = 1.0
+    vbigat_nld100_sphv_10hv   = 1.0
+    parea_nld100_sphv_10hv    = 0.5
+    psti_nld100_sphv_10hv     = 0.5
+    pgat_nld100_sphv_10hv     = 0.5
+    is1area_nld100_sphv_10hv  = 1e-12
+    ttarea_nld100_sphv_10hv   = 0.0
+    is2area_nld100_sphv_10hv  = 0.0
+    irarea_nld100_sphv_10hv   = 0.0
+    stis1area_nld100_sphv_10hv = 3.0
+    stis2area_nld100_sphv_10hv = 3.0
+    stirarea_nld100_sphv_10hv = 3.0
+    n1area_nld100_sphv_10hv   = 1.0
+    n2area_nld100_sphv_10hv   = 2.0
+    nrarea_nld100_sphv_10hv   = 100.0
+    is1lsti_nld100_sphv_10hv  = 1e-18
+    ttlsti_nld100_sphv_10hv   = 0.0
+    is2lsti_nld100_sphv_10hv  = 0.0
+    irlsti_nld100_sphv_10hv   = 0.0
+    stis1sti_nld100_sphv_10hv = 3.0
+    stis2sti_nld100_sphv_10hv = 3.0
+    stirsti_nld100_sphv_10hv  = 3.0
+    n1sti_nld100_sphv_10hv    = 1.0
+    n2sti_nld100_sphv_10hv    = 2.0
+    nrsti_nld100_sphv_10hv    = 100.0
+    is1lgat_nld100_sphv_10hv  = 1e-18
+    ttlgat_nld100_sphv_10hv   = 0.0
+    is2lgat_nld100_sphv_10hv  = 0.0
+    irlgat_nld100_sphv_10hv   = 0.0
+    stis1gat_nld100_sphv_10hv = 3.0
+    stis2gat_nld100_sphv_10hv = 3.0
+    stirgat_nld100_sphv_10hv  = 3.0
+    n1gat_nld100_sphv_10hv    = 1.0
+    n2gat_nld100_sphv_10hv    = 2.0
+    nrgat_nld100_sphv_10hv    = 100.0
+    cjaread_nld100_sphv_10hv  = 0.00016
+    cjlstid_nld100_sphv_10hv  = 0.0
+    cjlgatd_nld100_sphv_10hv  = 6e-11
+    vbiaread_nld100_sphv_10hv = 0.5
+    vbistid_nld100_sphv_10hv  = 0.5
+    vbigatd_nld100_sphv_10hv  = 0.2
+    paread_nld100_sphv_10hv   = 0.4
+    pstid_nld100_sphv_10hv    = 0.4
+    pgatd_nld100_sphv_10hv    = 0.5
+    is1aread_nld100_sphv_10hv = 2.5e-08
+    ttaread_nld100_sphv_10hv  = 0.0
+    is2aread_nld100_sphv_10hv = 8e-06
+    iraread_nld100_sphv_10hv  = 1.7e-06
+    stis1aread_nld100_sphv_10hv = 3.5
+    stis2aread_nld100_sphv_10hv = 7.0
+    stiraread_nld100_sphv_10hv = 130000.0
+    n1aread_nld100_sphv_10hv  = 1.01
+    n2aread_nld100_sphv_10hv  = 1.72
+    nraread_nld100_sphv_10hv  = 6000.0
+    is1lstid_nld100_sphv_10hv = 4e-15
+    ttlstid_nld100_sphv_10hv  = 0.0
+    is2lstid_nld100_sphv_10hv = 0.0
+    irlstid_nld100_sphv_10hv  = 5.4e-10
+    stis1stid_nld100_sphv_10hv = 3.5
+    stis2stid_nld100_sphv_10hv = 7.0
+    stirstid_nld100_sphv_10hv = 130000.0
+    n1stid_nld100_sphv_10hv   = 1.01
+    n2stid_nld100_sphv_10hv   = 1.72
+    nrstid_nld100_sphv_10hv   = 6000.0
+    is1lgatd_nld100_sphv_10hv = 4e-15
+    ttlgatd_nld100_sphv_10hv  = 0.0
+    is2lgatd_nld100_sphv_10hv = 0.0
+    irlgatd_nld100_sphv_10hv  = 3.4e-09
+    stis1gatd_nld100_sphv_10hv = 3.5
+    stis2gatd_nld100_sphv_10hv = 7.0
+    stirgatd_nld100_sphv_10hv = 130000.0
+    n1gatd_nld100_sphv_10hv   = 1.01
+    n2gatd_nld100_sphv_10hv   = 1.72
+    nrgatd_nld100_sphv_10hv   = 6000.0
+    cjaread2_nld100_sphv_10hv = 0.000178
+    cjlstid2_nld100_sphv_10hv = 1e-18
+    vbiaread2_nld100_sphv_10hv = 0.5
+    vbistid2_nld100_sphv_10hv = 0.5
+    paread2_nld100_sphv_10hv  = 0.4
+    pstid2_nld100_sphv_10hv   = 0.4
+    is1aread2_nld100_sphv_10hv = 2.5e-08
+    ttaread2_nld100_sphv_10hv = 0.0
+    is2aread2_nld100_sphv_10hv = 1.5e-06
+    iraread2_nld100_sphv_10hv = 1.7e-06
+    stis1aread2_nld100_sphv_10hv = 1.0
+    stis2aread2_nld100_sphv_10hv = 3.0
+    stiraread2_nld100_sphv_10hv = 130000.0
+    n1aread2_nld100_sphv_10hv = 1.01
+    n2aread2_nld100_sphv_10hv = 1.72
+    nraread2_nld100_sphv_10hv = 6000.0
+    is1lstid2_nld100_sphv_10hv = 0
+    ttlstid2_nld100_sphv_10hv = 0.0
+    is2lstid2_nld100_sphv_10hv = 0.0
+    irlstid2_nld100_sphv_10hv = 5.4e-10
+    stis1stid2_nld100_sphv_10hv = 3.5
+    stis2stid2_nld100_sphv_10hv = 7.0
+    stirstid2_nld100_sphv_10hv = 130000.0
+    n1stid2_nld100_sphv_10hv  = 1.01
+    n2stid2_nld100_sphv_10hv  = 1.72
+    nrstid2_nld100_sphv_10hv  = 6000.0
+    aacc_nld100_sphv_10hv     = 36.0
+    ikfarea_nld100_sphv_10hv  = 0.0
+    stikfarea_nld100_sphv_10hv = 0.0
+    ikfaread_nld100_sphv_10hv = 10000000.0
+    dwikfaread_nld100_sphv_10hv = 0.0
+    stikfaread_nld100_sphv_10hv = 0.0
+    vdscale_nld100_sphv_10hv  = 1.45
+    vdscalew_nld100_sphv_10hv = 0.1
+    vdscaleb_nld100_sphv_10hv = 0.0
+    stvdscale_nld100_sphv_10hv = 0.0
+    stvdscalew_nld100_sphv_10hv = -0.7
+    dwecrit_nld100_sphv_10hv  = -1.1
+    dwecritw_nld100_sphv_10hv = 0.6
+    dwstis1_nld100_sphv_10hv  = 2.0
+    nom_delr_tox_pld45b_sphv_10hv = 1.0
+    nom_dela_dw_pld45b_sphv_10hv = 0.0326436
+    nom_dela_vfb_pld45b_sphv_10hv = -0.0195946
+    nom_delr_uch_pld45b_sphv_10hv = 1.03715
+    nom_delr_rshl_pld45b_sphv_10hv = 1.00984
+    nom_dela_vtwl_pld45b_sphv_10hv = -0.0267372
+    nom_dela_nwxw_pld45b_sphv_10hv = -0.0977086
+    nom_delr_cj_pld45b_sphv_10hv = 1.0
+    nom_delr_is_pld45b_sphv_10hv = 1.0
+    nom_delr_is2_pld45b_sphv_10hv = 1.0
+    nom_delr_ir_pld45b_sphv_10hv = 1.0
+    sig_delr_tox_pld45b_sphv_10hv = 0.012
+    sig_dela_dw_pld45b_sphv_10hv = 0.0316537
+    sig_dela_vfb_pld45b_sphv_10hv = 0.121364
+    sig_delr_uch_pld45b_sphv_10hv = 0.014952633
+    sig_delr_rshl_pld45b_sphv_10hv = 0.0567105
+    sig_dela_vtwl_pld45b_sphv_10hv = 0.0246114
+    sig_dela_nwxw_pld45b_sphv_10hv = 0.039239667
+    sig_delr_cj_pld45b_sphv_10hv = 0.0333
+    sig_delr_is_pld45b_sphv_10hv = 0.06
+    sig_delr_is2_pld45b_sphv_10hv = 0.0833
+    sig_delr_ir_pld45b_sphv_10hv = 0.768
+    fac_rth_pld45b_sphv_10hv  = 0.3
+    tc1_ecrit_pld45b_sphv_10hv = 0.0
+    tc2_ecrit_pld45b_sphv_10hv = 0.0
+    dwrjundo_pld45b_sphv_10hv = 0.0
+    dwrjunso_pld45b_sphv_10hv = 0.0
+    qmc_pld45b_sphv_10hv      = 0.0
+    lvaro_pld45b_sphv_10hv    = 0.0
+    lvarl_pld45b_sphv_10hv    = 0.0
+    lvarw_pld45b_sphv_10hv    = 0.0
+    lap_pld45b_sphv_10hv      = 0.0
+    wvaro_pld45b_sphv_10hv    = 0.0
+    wvarl_pld45b_sphv_10hv    = 0.0
+    wvarw_pld45b_sphv_10hv    = 0.0
+    wot_pld45b_sphv_10hv      = 0.0
+    dlq_pld45b_sphv_10hv      = 8.5e-08
+    dwq_pld45b_sphv_10hv      = 2e-07
+    vfbo_pld45b_sphv_10hv     = -0.74497
+    vfbl_pld45b_sphv_10hv     = 0.0
+    vfbw_pld45b_sphv_10hv     = 0.0
+    vfblw_pld45b_sphv_10hv    = 0.0
+    stvfbo_pld45b_sphv_10hv   = 0.0015
+    stvfbl_pld45b_sphv_10hv   = 0.0
+    stvfbw_pld45b_sphv_10hv   = 0.0
+    stvfblw_pld45b_sphv_10hv  = 0.0
+    toxo_pld45b_sphv_10hv     = 1.324e-08
+    epsroxo_pld45b_sphv_10hv  = 3.9
+    nsubo_pld45b_sphv_10hv    = 6.2e+23
+    nsubw_pld45b_sphv_10hv    = 0.0
+    wseg_pld45b_sphv_10hv     = 1e-09
+    npck_pld45b_sphv_10hv     = 1e+23
+    npckw_pld45b_sphv_10hv    = 0.0
+    wsegp_pld45b_sphv_10hv    = 2.474e-06
+    lpck_pld45b_sphv_10hv     = 0.0
+    lpckw_pld45b_sphv_10hv    = 0.0
+    fol1_pld45b_sphv_10hv     = 0.05
+    fol2_pld45b_sphv_10hv     = 0.0
+    facneffaco_pld45b_sphv_10hv = 0.105
+    facneffacl_pld45b_sphv_10hv = 0.0
+    facneffacw_pld45b_sphv_10hv = 0.0
+    facneffaclw_pld45b_sphv_10hv = 0.0
+    gfacnudo_pld45b_sphv_10hv = 1.0
+    gfacnudl_pld45b_sphv_10hv = 0.0
+    gfacnudlexp_pld45b_sphv_10hv = 1.0
+    gfacnudw_pld45b_sphv_10hv = 0.0
+    gfacnudlw_pld45b_sphv_10hv = 0.0
+    vsbnudo_pld45b_sphv_10hv  = 2.75
+    dvsbnudo_pld45b_sphv_10hv = 1.0
+    vnsubo_pld45b_sphv_10hv   = 0.0
+    nslpo_pld45b_sphv_10hv    = 0.05
+    dnsubo_pld45b_sphv_10hv   = 0.0
+    dphibo_pld45b_sphv_10hv   = -0.12
+    dphibl_pld45b_sphv_10hv   = 0.0
+    dphiblexp_pld45b_sphv_10hv = 1.0
+    dphibw_pld45b_sphv_10hv   = 0.0
+    dphiblw_pld45b_sphv_10hv  = 0.0
+    delvtaco_pld45b_sphv_10hv = -0.1
+    delvtacl_pld45b_sphv_10hv = 0.0
+    delvtaclexp_pld45b_sphv_10hv = 1.0
+    delvtacw_pld45b_sphv_10hv = 0.0
+    delvtaclw_pld45b_sphv_10hv = 0.0
+    npo_pld45b_sphv_10hv      = 1e+26
+    npl_pld45b_sphv_10hv      = 0.0
+    cto_pld45b_sphv_10hv      = 0.04
+    ctl_pld45b_sphv_10hv      = 0.0
+    ctlexp_pld45b_sphv_10hv   = 1.0
+    ctw_pld45b_sphv_10hv      = 0.0
+    ctlw_pld45b_sphv_10hv     = 0.0
+    toxovo_pld45b_sphv_10hv   = 1.324e-08
+    toxovdo_pld45b_sphv_10hv  = 1.324e-08
+    lov_pld45b_sphv_10hv      = 1e-08
+    dlovd_pld45b_sphv_10hv    = 2.5e-08
+    novo_pld45b_sphv_10hv     = 1e+23
+    novdo_pld45b_sphv_10hv    = 3.5e+22
+    cfl_pld45b_sphv_10hv      = 0.0003
+    cflexp_pld45b_sphv_10hv   = 2.0
+    cfw_pld45b_sphv_10hv      = 0.0
+    cfbo_pld45b_sphv_10hv     = 0.0
+    uo_pld45b_sphv_10hv       = 0.0226895
+    fbet1_pld45b_sphv_10hv    = 0.0
+    fbet1w_pld45b_sphv_10hv   = 0.0
+    lp1_pld45b_sphv_10hv      = 0.0
+    lp1w_pld45b_sphv_10hv     = 0.0
+    fbet2_pld45b_sphv_10hv    = 0.0
+    lp2_pld45b_sphv_10hv      = 0.0
+    betw1_pld45b_sphv_10hv    = -0.2
+    betw2_pld45b_sphv_10hv    = 0.0
+    wbet_pld45b_sphv_10hv     = 0.0
+    stbeto_pld45b_sphv_10hv   = 1.0
+    stbetl_pld45b_sphv_10hv   = 0.0
+    stbetw_pld45b_sphv_10hv   = 0.0
+    stbetlw_pld45b_sphv_10hv  = 0.0
+    mueo_pld45b_sphv_10hv     = 1.085
+    muew_pld45b_sphv_10hv     = 0.0
+    stmueo_pld45b_sphv_10hv   = 0.6
+    themuo_pld45b_sphv_10hv   = 3.0
+    stthemuo_pld45b_sphv_10hv = 0.7
+    cso_pld45b_sphv_10hv      = 0.0
+    csl_pld45b_sphv_10hv      = 0.0
+    cslexp_pld45b_sphv_10hv   = 0.0
+    csw_pld45b_sphv_10hv      = 0.0
+    cslw_pld45b_sphv_10hv     = 0.0
+    stcso_pld45b_sphv_10hv    = 0.0
+    xcoro_pld45b_sphv_10hv    = 0.0
+    xcorl_pld45b_sphv_10hv    = 0.0
+    xcorw_pld45b_sphv_10hv    = 0.0
+    xcorlw_pld45b_sphv_10hv   = 0.0
+    stxcoro_pld45b_sphv_10hv  = 0.0
+    fetao_pld45b_sphv_10hv    = 1.0
+    rsw1_pld45b_sphv_10hv     = 0.0
+    rsw2_pld45b_sphv_10hv     = 0.0
+    strso_pld45b_sphv_10hv    = 0.0
+    rsbo_pld45b_sphv_10hv     = 0.0
+    rsgo_pld45b_sphv_10hv     = 0.0
+    vdscale_pld45b_sphv_10hv  = 3.0
+    vdscalew_pld45b_sphv_10hv = 0.0
+    vdscaleb_pld45b_sphv_10hv = 0.0
+    stvdscale_pld45b_sphv_10hv = 0.0
+    thesato_pld45b_sphv_10hv  = 0.14
+    thesatl_pld45b_sphv_10hv  = 0.0
+    thesatlexp_pld45b_sphv_10hv = 1.0
+    thesatw_pld45b_sphv_10hv  = 0.0
+    thesatlw_pld45b_sphv_10hv = 0.0
+    stthesato_pld45b_sphv_10hv = 0.2
+    stthesatl_pld45b_sphv_10hv = 0.0
+    stthesatw_pld45b_sphv_10hv = 0.0
+    stthesatlw_pld45b_sphv_10hv = 0.0
+    thesatbo_pld45b_sphv_10hv = 0.0
+    thesatgo_pld45b_sphv_10hv = 35.0
+    thesatgl_pld45b_sphv_10hv = 0.0
+    thesatgw_pld45b_sphv_10hv = -20.0
+    axo_pld45b_sphv_10hv      = 2.0
+    axl_pld45b_sphv_10hv      = 0.0
+    alpl_pld45b_sphv_10hv     = 0.0
+    alplexp_pld45b_sphv_10hv  = 1.0
+    alpw_pld45b_sphv_10hv     = 0.0
+    alp1l1_pld45b_sphv_10hv   = 0.0
+    alp1lexp_pld45b_sphv_10hv = 0.5
+    alp1l2_pld45b_sphv_10hv   = 0.0
+    alp1w_pld45b_sphv_10hv    = 0.0
+    alp2l1_pld45b_sphv_10hv   = 0.0
+    alp2lexp_pld45b_sphv_10hv = 1.0
+    alp2l2_pld45b_sphv_10hv   = 0.0
+    alp2w_pld45b_sphv_10hv    = 0.0
+    vpo_pld45b_sphv_10hv      = 10.0
+    a1o_pld45b_sphv_10hv      = 0.0
+    a1l_pld45b_sphv_10hv      = 0.0
+    a1w_pld45b_sphv_10hv      = 0.0
+    a2o_pld45b_sphv_10hv      = 100.0
+    sta2o_pld45b_sphv_10hv    = 5.0
+    a3o_pld45b_sphv_10hv      = 150.0
+    a3l_pld45b_sphv_10hv      = 0.0
+    a3w_pld45b_sphv_10hv      = 0.0
+    a4o_pld45b_sphv_10hv      = 1.0
+    a4l_pld45b_sphv_10hv      = 0.0
+    a4w_pld45b_sphv_10hv      = 0.0
+    gcoo_pld45b_sphv_10hv     = 0.0
+    iginvlw_pld45b_sphv_10hv  = 0.0
+    igovw_pld45b_sphv_10hv    = 0.0
+    igovdw_pld45b_sphv_10hv   = 0.0
+    stigo_pld45b_sphv_10hv    = 2.0
+    gc2o_pld45b_sphv_10hv     = 0.375
+    gc3o_pld45b_sphv_10hv     = 0.063
+    chibo_pld45b_sphv_10hv    = 3.1
+    agidlw_pld45b_sphv_10hv   = 0.0
+    agidldw_pld45b_sphv_10hv  = 0.0
+    bgidlo_pld45b_sphv_10hv   = 10.0
+    bgidldo_pld45b_sphv_10hv  = 10.0
+    stbgidlo_pld45b_sphv_10hv = 0.0
+    stbgidldo_pld45b_sphv_10hv = 0.0
+    cgidlo_pld45b_sphv_10hv   = 1.0
+    cgidldo_pld45b_sphv_10hv  = 1.0
+    cgbovl_pld45b_sphv_10hv   = 0.0
+    cfrw_pld45b_sphv_10hv     = 0.0
+    cfrdw_pld45b_sphv_10hv    = 0.0
+    fnto_pld45b_sphv_10hv     = 1.0
+    nfalw_pld45b_sphv_10hv    = 4e+26
+    nfblw_pld45b_sphv_10hv    = 0.0
+    nfclw_pld45b_sphv_10hv    = 0.0
+    efo_pld45b_sphv_10hv      = 1.0
+    lintnoi_pld45b_sphv_10hv  = 0.0
+    alpnoi_pld45b_sphv_10hv   = 2.0
+    kvthoweo_pld45b_sphv_10hv = 0.0
+    kvthowel_pld45b_sphv_10hv = 0.0
+    kvthowew_pld45b_sphv_10hv = 0.0
+    kvthowelw_pld45b_sphv_10hv = 0.0
+    kuoweo_pld45b_sphv_10hv   = 0.0
+    kuowel_pld45b_sphv_10hv   = 0.0
+    kuowew_pld45b_sphv_10hv   = 0.0
+    kuowelw_pld45b_sphv_10hv  = 0.0
+    rgo_pld45b_sphv_10hv      = 0.0
+    rsh_pld45b_sphv_10hv      = 0.0
+    rbulko_pld45b_sphv_10hv   = 0.0
+    rwello_pld45b_sphv_10hv   = 0.0
+    rjunso_pld45b_sphv_10hv   = 200.0
+    rjundo_pld45b_sphv_10hv   = 300.0
+    rint_pld45b_sphv_10hv     = 0.0
+    rvpoly_pld45b_sphv_10hv   = 0.0
+    rshg_pld45b_sphv_10hv     = 0.0
+    dlsil_pld45b_sphv_10hv    = 0.0
+    saref_pld45b_sphv_10hv    = 1e-06
+    sbref_pld45b_sphv_10hv    = 1e-06
+    wlod_pld45b_sphv_10hv     = 0.0
+    kuo_pld45b_sphv_10hv      = 0.0
+    kvsat_pld45b_sphv_10hv    = 1.0
+    tkuo_pld45b_sphv_10hv     = 0.0
+    lkuo_pld45b_sphv_10hv     = 0.0
+    wkuo_pld45b_sphv_10hv     = 0.0
+    pkuo_pld45b_sphv_10hv     = 0.0
+    llodkuo_pld45b_sphv_10hv  = 0.0
+    wlodkuo_pld45b_sphv_10hv  = 0.0
+    kvtho_pld45b_sphv_10hv    = 0.0
+    lkvtho_pld45b_sphv_10hv   = 0.0
+    wkvtho_pld45b_sphv_10hv   = 0.0
+    pkvtho_pld45b_sphv_10hv   = 0.0
+    llodvth_pld45b_sphv_10hv  = 0.0
+    wlodvth_pld45b_sphv_10hv  = 0.0
+    stetao_pld45b_sphv_10hv   = 0.0
+    lodetao_pld45b_sphv_10hv  = 1.0
+    scref_pld45b_sphv_10hv    = 1e-05
+    web_pld45b_sphv_10hv      = 0.0
+    wec_pld45b_sphv_10hv      = 0.0
+    adr1o_pld45b_sphv_10hv    = 0.0
+    adr1l_pld45b_sphv_10hv    = 0.0
+    adr1w_pld45b_sphv_10hv    = 0.0
+    adr2o_pld45b_sphv_10hv    = 10.0
+    stadr2o_pld45b_sphv_10hv  = 1.0
+    adr3o_pld45b_sphv_10hv    = 0.0
+    adr3l_pld45b_sphv_10hv    = 0.0
+    adr3w_pld45b_sphv_10hv    = 0.0
+    adr4o_pld45b_sphv_10hv    = 0.0
+    adr4l_pld45b_sphv_10hv    = 0.0
+    adr4w_pld45b_sphv_10hv    = 0.0
+    adr5o_pld45b_sphv_10hv    = 0.0
+    adr5l_pld45b_sphv_10hv    = 0.0
+    adr5w_pld45b_sphv_10hv    = 0.0
+    bidr1o_pld45b_sphv_10hv   = 0.0
+    bidr1l_pld45b_sphv_10hv   = 0.0
+    bidr1w_pld45b_sphv_10hv   = 0.0
+    bidr2o_pld45b_sphv_10hv   = 0.0
+    bidr2w_pld45b_sphv_10hv   = 0.0
+    rtho_pld45b_sphv_10hv     = 750.0
+    rthl_pld45b_sphv_10hv     = 0.0
+    rthw_pld45b_sphv_10hv     = 0.0
+    rthlw_pld45b_sphv_10hv    = 0.0
+    strtho_pld45b_sphv_10hv   = 1.0
+    ctho_pld45b_sphv_10hv     = 0.0
+    cthl_pld45b_sphv_10hv     = 0.0
+    cthw_pld45b_sphv_10hv     = 0.0
+    cthlw_pld45b_sphv_10hv    = 0.0
+    rshldd_pld45b_sphv_10hv   = 22370.0
+    xw_pld45b_sphv_10hv       = 2.5e-07
+    nwxw_pld45b_sphv_10hv     = 0.0
+    xl_pld45b_sphv_10hv       = 0.0
+    xlw_pld45b_sphv_10hv      = 0.0
+    dxlsat_pld45b_sphv_10hv   = 4e-06
+    nst_pld45b_sphv_10hv      = 1.4
+    ats_pld45b_sphv_10hv      = 1.2
+    dfinf_pld45b_sphv_10hv    = 0.045
+    dfw_pld45b_sphv_10hv      = 0.0
+    dfl_pld45b_sphv_10hv      = 0.0
+    dflw_pld45b_sphv_10hv     = 0.0
+    dp_pld45b_sphv_10hv       = 1.0
+    ecrit_pld45b_sphv_10hv    = 1500000.0
+    ecorn_pld45b_sphv_10hv    = 50000.0
+    du_pld45b_sphv_10hv       = 0.4
+    tc1_pld45b_sphv_10hv      = 0.00525
+    tc2_pld45b_sphv_10hv      = 6e-06
+    tc1l_pld45b_sphv_10hv     = 0.0
+    tc2l_pld45b_sphv_10hv     = 0.0
+    tc1w_pld45b_sphv_10hv     = 0.0
+    tc2w_pld45b_sphv_10hv     = 0.0
+    theacc_pld45b_sphv_10hv   = 0.001
+    theacc2_pld45b_sphv_10hv  = 0.0285
+    aacc_pld45b_sphv_10hv     = 36.0
+    rva_pld45b_sphv_10hv      = 200.0
+    dta_pld45b_sphv_10hv      = 0.0
+    trj_pld45b_sphv_10hv      = 27.0
+    cjarea_pld45b_sphv_10hv   = 0.00015
+    cjlsti_pld45b_sphv_10hv   = 1.5e-10
+    cjlgat_pld45b_sphv_10hv   = 2.5e-10
+    vbiarea_pld45b_sphv_10hv  = 1.0
+    vbisti_pld45b_sphv_10hv   = 1.0
+    vbigat_pld45b_sphv_10hv   = 1.0
+    parea_pld45b_sphv_10hv    = 0.35
+    psti_pld45b_sphv_10hv     = 0.35
+    pgat_pld45b_sphv_10hv     = 0.35
+    is1area_pld45b_sphv_10hv  = 1e-11
+    ttarea_pld45b_sphv_10hv   = 5e-09
+    is2area_pld45b_sphv_10hv  = 1e-11
+    irarea_pld45b_sphv_10hv   = 1e-12
+    stis1area_pld45b_sphv_10hv = 3.0
+    stis2area_pld45b_sphv_10hv = 3.0
+    stirarea_pld45b_sphv_10hv = 3.0
+    n1area_pld45b_sphv_10hv   = 1.0
+    n2area_pld45b_sphv_10hv   = 3.0
+    nrarea_pld45b_sphv_10hv   = 100.0
+    is1lsti_pld45b_sphv_10hv  = 1e-16
+    ttlsti_pld45b_sphv_10hv   = 5e-09
+    is2lsti_pld45b_sphv_10hv  = 1e-16
+    irlsti_pld45b_sphv_10hv   = 1e-12
+    stis1sti_pld45b_sphv_10hv = 3.0
+    stis2sti_pld45b_sphv_10hv = 3.0
+    stirsti_pld45b_sphv_10hv  = 3.0
+    n1sti_pld45b_sphv_10hv    = 1.0
+    n2sti_pld45b_sphv_10hv    = 3.0
+    nrsti_pld45b_sphv_10hv    = 100.0
+    is1lgat_pld45b_sphv_10hv  = 1e-16
+    ttlgat_pld45b_sphv_10hv   = 5e-09
+    is2lgat_pld45b_sphv_10hv  = 1e-16
+    is2lgatd_pld45b_sphv_10hv = 8e-11
+    irlgat_pld45b_sphv_10hv   = 1e-12
+    stis1gat_pld45b_sphv_10hv = 3.0
+    stis2gat_pld45b_sphv_10hv = 3.0
+    stirgat_pld45b_sphv_10hv  = 3.0
+    n1gat_pld45b_sphv_10hv    = 1.0
+    n2gat_pld45b_sphv_10hv    = 3.0
+    nrgat_pld45b_sphv_10hv    = 100.0
+    cjaread_pld45b_sphv_10hv  = 0.000168
+    cjlstid_pld45b_sphv_10hv  = 0.00024
+    cjaread2_pld45b_sphv_10hv = 0.00025
+    cjlstid2_pld45b_sphv_10hv = 1e-10
+    cjlgatd_pld45b_sphv_10hv  = 0.0002
+    vbiaread_pld45b_sphv_10hv = 0.5
+    vbistid_pld45b_sphv_10hv  = 0.5
+    vbigatd_pld45b_sphv_10hv  = 0.5
+    paread_pld45b_sphv_10hv   = 0.35
+    pstid_pld45b_sphv_10hv    = 0.35
+    pgatd_pld45b_sphv_10hv    = 0.35
+    is1aread_pld45b_sphv_10hv = 8.5e-08
+    is1aread2_pld45b_sphv_10hv = 5e-08
+    is1lstid_pld45b_sphv_10hv = 3e-12
+    is1lstid2_pld45b_sphv_10hv = 3e-12
+    is1lgatd_pld45b_sphv_10hv = 2.451e-12
+    ttaread_pld45b_sphv_10hv  = 2e-08
+    is2aread_pld45b_sphv_10hv = 2e-07
+    is2aread2_pld45b_sphv_10hv = 0.0001
+    is2lstid2_pld45b_sphv_10hv = 0.0002
+    iraread_pld45b_sphv_10hv  = 0.00025
+    stis1aread_pld45b_sphv_10hv = 5.0
+    stis1aread2_pld45b_sphv_10hv = 5.0
+    stis2aread_pld45b_sphv_10hv = 3.0
+    stis2aread2_pld45b_sphv_10hv = 3.0
+    stiraread_pld45b_sphv_10hv = 48000.0
+    n1aread_pld45b_sphv_10hv  = 1.07
+    n2aread_pld45b_sphv_10hv  = 2.0
+    nraread_pld45b_sphv_10hv  = 2300.0
+    ttlstid_pld45b_sphv_10hv  = 2e-08
+    irlstid_pld45b_sphv_10hv  = 2e-09
+    stis1stid_pld45b_sphv_10hv = 5.0
+    stis2stid_pld45b_sphv_10hv = 3.0
+    stirstid_pld45b_sphv_10hv = 48000.0
+    n1stid_pld45b_sphv_10hv   = 1.07
+    n2stid_pld45b_sphv_10hv   = 2.0
+    nrstid_pld45b_sphv_10hv   = 2300.0
+    ttlgatd_pld45b_sphv_10hv  = 2e-08
+    irlgatd_pld45b_sphv_10hv  = 3.5e-09
+    stis1gatd_pld45b_sphv_10hv = 5.0
+    stis2gatd_pld45b_sphv_10hv = 3.0
+    stirgatd_pld45b_sphv_10hv = 48000.0
+    n1gatd_pld45b_sphv_10hv   = 1.07
+    n2gatd_pld45b_sphv_10hv   = 2.0
+    nrgatd_pld45b_sphv_10hv   = 2300.0
+    vbiaread2_pld45b_sphv_10hv = 0.5
+    vbistid2_pld45b_sphv_10hv = 0.5
+    paread2_pld45b_sphv_10hv  = 0.35
+    pstid2_pld45b_sphv_10hv   = 0.35
+    ttaread2_pld45b_sphv_10hv = 2e-08
+    iraread2_pld45b_sphv_10hv = 0.0
+    stiraread2_pld45b_sphv_10hv = 48000.0
+    n1aread2_pld45b_sphv_10hv = 1.07
+    n2aread2_pld45b_sphv_10hv = 2.0
+    nraread2_pld45b_sphv_10hv = 2300.0
+    ttlstid2_pld45b_sphv_10hv = 2e-08
+    irlstid2_pld45b_sphv_10hv = 0.0
+    stis1stid2_pld45b_sphv_10hv = 5.0
+    stis2stid2_pld45b_sphv_10hv = 3.0
+    stirstid2_pld45b_sphv_10hv = 48000.0
+    n1stid2_pld45b_sphv_10hv  = 1.07
+    n2stid2_pld45b_sphv_10hv  = 2.0
+    nrstid2_pld45b_sphv_10hv  = 2300.0
+    eais1area_pld45b_sphv_10hv = 1.12
+    eais2area_pld45b_sphv_10hv = 1.12
+    eairarea_pld45b_sphv_10hv = 1.12
+    eais1sti_pld45b_sphv_10hv = 1.12
+    eais2sti_pld45b_sphv_10hv = 1.12
+    eairsti_pld45b_sphv_10hv  = 1.12
+    eais1gat_pld45b_sphv_10hv = 1.12
+    eais2gat_pld45b_sphv_10hv = 1.12
+    eairgat_pld45b_sphv_10hv  = 1.12
+    eais1aread_pld45b_sphv_10hv = 1.12
+    eais2aread_pld45b_sphv_10hv = 1.12
+    eairaread_pld45b_sphv_10hv = 1.12
+    eais1stid_pld45b_sphv_10hv = 1.12
+    eais2stid_pld45b_sphv_10hv = 1.12
+    eairstid_pld45b_sphv_10hv = 1.12
+    eais1gatd_pld45b_sphv_10hv = 1.12
+    eais2gatd_pld45b_sphv_10hv = 1.12
+    eairgatd_pld45b_sphv_10hv = 1.12
+    eais1aread2_pld45b_sphv_10hv = 1.12
+    eais2aread2_pld45b_sphv_10hv = 1.12
+    eairaread2_pld45b_sphv_10hv = 1.12
+    eais1stid2_pld45b_sphv_10hv = 1.12
+    eais2stid2_pld45b_sphv_10hv = 1.12
+    eairstid2_pld45b_sphv_10hv = 1.12
+    xvsat_pld45b_sphv_10hv    = 0.0
+    ctgo_pld45b_sphv_10hv     = 0.13
+    ikfarea_pld45b_sphv_10hv  = 0.0
+    stikfarea_pld45b_sphv_10hv = 0.0
+    ikfaread_pld45b_sphv_10hv = 0.0
+    dwikfaread_pld45b_sphv_10hv = 7.0
+    stikfaread_pld45b_sphv_10hv = 0.0
+    nom_delr_tox_pld90b_sphv_10hv = 1.0
+    nom_dela_vfb_pld90b_sphv_10hv = 0.017099376476
+    nom_dela_vtw_pld90b_sphv_10hv = 0.0264265975403
+    nom_delr_uch_pld90b_sphv_10hv = 1.00040657886
+    nom_delr_res_pld90b_sphv_10hv = 0.997515497762
+    nom_dela_dwox_pld90b_sphv_10hv = -0.853629415331
+    nom_delr_cj_pld90b_sphv_10hv = 1.0
+    nom_delr_is_pld90b_sphv_10hv = 1.0
+    nom_delr_is2_pld90b_sphv_10hv = 1.0
+    nom_delr_ir_pld90b_sphv_10hv = 1.0
+    sig_delr_tox_pld90b_sphv_10hv = 0.012
+    sig_dela_vfb_pld90b_sphv_10hv = 0.01523
+    sig_dela_vtw_pld90b_sphv_10hv = 0.023607
+    sig_delr_uch_pld90b_sphv_10hv = 0.04072
+    sig_delr_res_pld90b_sphv_10hv = 0.05395
+    sig_dela_dwox_pld90b_sphv_10hv = 0.7352
+    sig_delr_cj_pld90b_sphv_10hv = 0.0333
+    sig_delr_is_pld90b_sphv_10hv = 0.055
+    sig_delr_is2_pld90b_sphv_10hv = 0.768
+    sig_delr_ir_pld90b_sphv_10hv = 0.768
+    fac_rth_pld90b_sphv_10hv  = 0.5
+    tc1_ecrit_pld90b_sphv_10hv = 0.0
+    tc2_ecrit_pld90b_sphv_10hv = 4e-06
+    dwrjundo_pld90b_sphv_10hv = 0.0
+    dwrjunso_pld90b_sphv_10hv = 8e-06
+    qmc_pld90b_sphv_10hv      = 0.0
+    lvaro_pld90b_sphv_10hv    = 0.0
+    lvarl_pld90b_sphv_10hv    = 0.0
+    lvarw_pld90b_sphv_10hv    = 0.0
+    lap_pld90b_sphv_10hv      = 0.0
+    wvaro_pld90b_sphv_10hv    = 7.888e-08
+    wvarl_pld90b_sphv_10hv    = 0.0
+    wvarw_pld90b_sphv_10hv    = 0.0
+    wot_pld90b_sphv_10hv      = 0.0
+    dlq_pld90b_sphv_10hv      = 0.0
+    dwq_pld90b_sphv_10hv      = -1e-07
+    vfbo_pld90b_sphv_10hv     = -0.8407
+    vfbl_pld90b_sphv_10hv     = 0.1
+    vfbw_pld90b_sphv_10hv     = 0.082
+    vfblw_pld90b_sphv_10hv    = 0.0
+    stvfbo_pld90b_sphv_10hv   = 0.00085
+    stvfbl_pld90b_sphv_10hv   = 0.0
+    stvfbw_pld90b_sphv_10hv   = -0.2413
+    stvfblw_pld90b_sphv_10hv  = 0.0
+    toxo_pld90b_sphv_10hv     = 1.3e-08
+    epsroxo_pld90b_sphv_10hv  = 3.9
+    nsubo_pld90b_sphv_10hv    = 1.5e+23
+    nsubw_pld90b_sphv_10hv    = 0.0
+    wseg_pld90b_sphv_10hv     = 1e-08
+    npck_pld90b_sphv_10hv     = 1e+23
+    npckw_pld90b_sphv_10hv    = 0.0
+    wsegp_pld90b_sphv_10hv    = 1e-08
+    lpck_pld90b_sphv_10hv     = 0.0
+    lpckw_pld90b_sphv_10hv    = 0.0
+    fol1_pld90b_sphv_10hv     = 0.0
+    fol2_pld90b_sphv_10hv     = 0.0
+    facneffaco_pld90b_sphv_10hv = 1.1
+    facneffacl_pld90b_sphv_10hv = 0.0
+    facneffacw_pld90b_sphv_10hv = -1.0
+    facneffaclw_pld90b_sphv_10hv = 0.0
+    gfacnudo_pld90b_sphv_10hv = 1.0
+    gfacnudl_pld90b_sphv_10hv = 0.0
+    gfacnudlexp_pld90b_sphv_10hv = 1.0
+    gfacnudw_pld90b_sphv_10hv = 0.0
+    gfacnudlw_pld90b_sphv_10hv = 0.0
+    vsbnudo_pld90b_sphv_10hv  = 0.0
+    dvsbnudo_pld90b_sphv_10hv = 1.0
+    vnsubo_pld90b_sphv_10hv   = 0.0
+    nslpo_pld90b_sphv_10hv    = 0.05
+    dnsubo_pld90b_sphv_10hv   = -0.01068
+    dphibo_pld90b_sphv_10hv   = 0.0
+    dphibl_pld90b_sphv_10hv   = 0.0
+    dphiblexp_pld90b_sphv_10hv = 1.0
+    dphibw_pld90b_sphv_10hv   = 0.0
+    dphiblw_pld90b_sphv_10hv  = 0.0
+    delvtaco_pld90b_sphv_10hv = -0.03
+    delvtacl_pld90b_sphv_10hv = 0.0
+    delvtaclexp_pld90b_sphv_10hv = 1.0
+    delvtacw_pld90b_sphv_10hv = 0.25
+    delvtaclw_pld90b_sphv_10hv = 0.0
+    npo_pld90b_sphv_10hv      = 5.7e+25
+    npl_pld90b_sphv_10hv      = 0.0
+    cto_pld90b_sphv_10hv      = 0.0
+    ctl_pld90b_sphv_10hv      = 0.0
+    ctlexp_pld90b_sphv_10hv   = 1.0
+    ctw_pld90b_sphv_10hv      = 0.2929
+    ctlw_pld90b_sphv_10hv     = 0.0
+    ctgo_pld90b_sphv_10hv     = 0.0
+    ctbo_pld90b_sphv_10hv     = 0.0
+    stcto_pld90b_sphv_10hv    = 1.0
+    toxovo_pld90b_sphv_10hv   = 1.3e-08
+    toxovdo_pld90b_sphv_10hv  = 1.3e-08
+    lov_pld90b_sphv_10hv      = 4e-08
+    dlovd_pld90b_sphv_10hv    = -1.05e-07
+    novo_pld90b_sphv_10hv     = 8e+25
+    novdo_pld90b_sphv_10hv    = 3e+21
+    cfl_pld90b_sphv_10hv      = 0.0
+    cflexp_pld90b_sphv_10hv   = 2.0
+    cfw_pld90b_sphv_10hv      = 0.0
+    cfbo_pld90b_sphv_10hv     = 1.0
+    uo_pld90b_sphv_10hv       = 0.02
+    fbet1_pld90b_sphv_10hv    = 0.0
+    fbet1w_pld90b_sphv_10hv   = 0.0
+    lp1_pld90b_sphv_10hv      = 1e-10
+    lp1w_pld90b_sphv_10hv     = 0.0
+    fbet2_pld90b_sphv_10hv    = 0.0
+    lp2_pld90b_sphv_10hv      = 1e-10
+    betw1_pld90b_sphv_10hv    = -0.4
+    betw2_pld90b_sphv_10hv    = 0.02
+    wbet_pld90b_sphv_10hv     = 1e-09
+    stbeto_pld90b_sphv_10hv   = 1.139
+    stbetl_pld90b_sphv_10hv   = 0.0
+    stbetw_pld90b_sphv_10hv   = -0.2398
+    stbetlw_pld90b_sphv_10hv  = 0.0
+    mueo_pld90b_sphv_10hv     = 2.3
+    muew_pld90b_sphv_10hv     = 30.0
+    stmueo_pld90b_sphv_10hv   = 0.01
+    themuo_pld90b_sphv_10hv   = 0.1
+    stthemuo_pld90b_sphv_10hv = 1.0
+    cso_pld90b_sphv_10hv      = 0.0
+    csl_pld90b_sphv_10hv      = 0.0
+    cslexp_pld90b_sphv_10hv   = 0.0
+    csw_pld90b_sphv_10hv      = 0.0
+    cslw_pld90b_sphv_10hv     = 0.0
+    stcso_pld90b_sphv_10hv    = 0.0
+    xcoro_pld90b_sphv_10hv    = 0.0
+    xcorl_pld90b_sphv_10hv    = 0.0
+    xcorw_pld90b_sphv_10hv    = 0.0
+    xcorlw_pld90b_sphv_10hv   = 0.0
+    stxcoro_pld90b_sphv_10hv  = 0.0
+    fetao_pld90b_sphv_10hv    = 1.0
+    rsw1_pld90b_sphv_10hv     = 0.0
+    rsw2_pld90b_sphv_10hv     = 0.0
+    strso_pld90b_sphv_10hv    = 1.0
+    rsbo_pld90b_sphv_10hv     = 0.0
+    rsgo_pld90b_sphv_10hv     = 1.0
+    thesato_pld90b_sphv_10hv  = 0.9
+    thesatl_pld90b_sphv_10hv  = 0.0
+    thesatlexp_pld90b_sphv_10hv = 1.0
+    thesatw_pld90b_sphv_10hv  = -0.68
+    thesatlw_pld90b_sphv_10hv = 0.0
+    stthesato_pld90b_sphv_10hv = 0.75
+    stthesatl_pld90b_sphv_10hv = 0.0
+    stthesatw_pld90b_sphv_10hv = 0.0
+    stthesatlw_pld90b_sphv_10hv = 0.0
+    thesatbo_pld90b_sphv_10hv = -0.065
+    thesatgo_pld90b_sphv_10hv = 1.9
+    thesatgl_pld90b_sphv_10hv = 0.0
+    thesatgw_pld90b_sphv_10hv = 0.0
+    vdscale_pld90b_sphv_10hv  = 1.235
+    vdscaleb_pld90b_sphv_10hv = 0.0
+    stvdscale_pld90b_sphv_10hv = 0.0
+    axo_pld90b_sphv_10hv      = 2.0
+    axl_pld90b_sphv_10hv      = 0.0
+    alpl_pld90b_sphv_10hv     = 0.012
+    alplexp_pld90b_sphv_10hv  = 1.0
+    alpw_pld90b_sphv_10hv     = 0.0
+    alp1l1_pld90b_sphv_10hv   = 1e-06
+    alp1lexp_pld90b_sphv_10hv = 1.0
+    alp1l2_pld90b_sphv_10hv   = 0.0
+    alp1w_pld90b_sphv_10hv    = 0.0
+    alp2l1_pld90b_sphv_10hv   = 0.0
+    alp2lexp_pld90b_sphv_10hv = 1.0
+    alp2l2_pld90b_sphv_10hv   = 0.0
+    alp2w_pld90b_sphv_10hv    = 0.0
+    vpo_pld90b_sphv_10hv      = 0.1
+    a1o_pld90b_sphv_10hv      = 0.000535
+    a1l_pld90b_sphv_10hv      = 0.0
+    a1w_pld90b_sphv_10hv      = -0.485
+    a2o_pld90b_sphv_10hv      = 73.75
+    sta2o_pld90b_sphv_10hv    = 0.45
+    a3o_pld90b_sphv_10hv      = 1.2
+    a3l_pld90b_sphv_10hv      = 0.0
+    a3w_pld90b_sphv_10hv      = 0.0
+    a4o_pld90b_sphv_10hv      = 0.0
+    a4l_pld90b_sphv_10hv      = 0.0
+    a4w_pld90b_sphv_10hv      = 0.0
+    gcoo_pld90b_sphv_10hv     = 0.0
+    iginvlw_pld90b_sphv_10hv  = 0.0
+    igovw_pld90b_sphv_10hv    = 0.0
+    igovdw_pld90b_sphv_10hv   = 0.0
+    stigo_pld90b_sphv_10hv    = 2.0
+    gc2o_pld90b_sphv_10hv     = 0.375
+    gc3o_pld90b_sphv_10hv     = 0.063
+    chibo_pld90b_sphv_10hv    = 3.1
+    agidlw_pld90b_sphv_10hv   = 0.0
+    agidldw_pld90b_sphv_10hv  = 0.0
+    bgidlo_pld90b_sphv_10hv   = 41.0
+    bgidldo_pld90b_sphv_10hv  = 41.0
+    stbgidlo_pld90b_sphv_10hv = 0.0
+    stbgidldo_pld90b_sphv_10hv = 0.0
+    cgidlo_pld90b_sphv_10hv   = 0.0
+    cgidldo_pld90b_sphv_10hv  = 0.0
+    cgbovl_pld90b_sphv_10hv   = 1e-15
+    cfrw_pld90b_sphv_10hv     = 3e-16
+    cfrdw_pld90b_sphv_10hv    = 0.0
+    fnto_pld90b_sphv_10hv     = 1.0
+    nfalw_pld90b_sphv_10hv    = 1.3e+25
+    nfblw_pld90b_sphv_10hv    = 0.0
+    nfclw_pld90b_sphv_10hv    = 0.0
+    efo_pld90b_sphv_10hv      = 1.18
+    lintnoi_pld90b_sphv_10hv  = 0.0
+    alpnoi_pld90b_sphv_10hv   = 2.0
+    kvthoweo_pld90b_sphv_10hv = 0.0
+    kvthowel_pld90b_sphv_10hv = 0.0
+    kvthowew_pld90b_sphv_10hv = 0.0
+    kvthowelw_pld90b_sphv_10hv = 0.0
+    kuoweo_pld90b_sphv_10hv   = 0.0
+    kuowel_pld90b_sphv_10hv   = 0.0
+    kuowew_pld90b_sphv_10hv   = 0.0
+    kuowelw_pld90b_sphv_10hv  = 0.0
+    rgo_pld90b_sphv_10hv      = 0.0
+    rsh_pld90b_sphv_10hv      = 0.0
+    rbulko_pld90b_sphv_10hv   = 0.0
+    rwello_pld90b_sphv_10hv   = 0.0
+    rjunso_pld90b_sphv_10hv   = 0.006
+    rjundo_pld90b_sphv_10hv   = 500.0
+    rint_pld90b_sphv_10hv     = 0.0
+    rvpoly_pld90b_sphv_10hv   = 0.0
+    rshg_pld90b_sphv_10hv     = 0.0
+    dlsil_pld90b_sphv_10hv    = 0.0
+    saref_pld90b_sphv_10hv    = 1e-06
+    sbref_pld90b_sphv_10hv    = 1e-06
+    wlod_pld90b_sphv_10hv     = 0.0
+    kuo_pld90b_sphv_10hv      = 0.0
+    kvsat_pld90b_sphv_10hv    = 0.0
+    tkuo_pld90b_sphv_10hv     = 0.0
+    lkuo_pld90b_sphv_10hv     = 0.0
+    wkuo_pld90b_sphv_10hv     = 0.0
+    pkuo_pld90b_sphv_10hv     = 0.0
+    llodkuo_pld90b_sphv_10hv  = 0.0
+    wlodkuo_pld90b_sphv_10hv  = 0.0
+    kvtho_pld90b_sphv_10hv    = 0.0
+    lkvtho_pld90b_sphv_10hv   = 0.0
+    wkvtho_pld90b_sphv_10hv   = 0.0
+    pkvtho_pld90b_sphv_10hv   = 0.0
+    llodvth_pld90b_sphv_10hv  = 0.0
+    wlodvth_pld90b_sphv_10hv  = 0.0
+    stetao_pld90b_sphv_10hv   = 0.0
+    lodetao_pld90b_sphv_10hv  = 1.0
+    scref_pld90b_sphv_10hv    = 1e-05
+    web_pld90b_sphv_10hv      = 0.0
+    wec_pld90b_sphv_10hv      = 0.0
+    adr1o_pld90b_sphv_10hv    = 2.5e-05
+    adr1l_pld90b_sphv_10hv    = 0.0
+    adr1w_pld90b_sphv_10hv    = 0.0002
+    adr2o_pld90b_sphv_10hv    = 160.0
+    stadr2o_pld90b_sphv_10hv  = -0.3
+    adr3o_pld90b_sphv_10hv    = 1.2
+    adr3l_pld90b_sphv_10hv    = 0.0
+    adr3w_pld90b_sphv_10hv    = 0.0
+    adr4o_pld90b_sphv_10hv    = 0.0
+    adr4l_pld90b_sphv_10hv    = 0.0
+    adr4w_pld90b_sphv_10hv    = 0.0
+    adr5o_pld90b_sphv_10hv    = 0.0
+    adr5l_pld90b_sphv_10hv    = 0.0
+    adr5w_pld90b_sphv_10hv    = 0.0
+    bidr1o_pld90b_sphv_10hv   = 0.0
+    bidr1l_pld90b_sphv_10hv   = 0.0
+    bidr1w_pld90b_sphv_10hv   = 0.0
+    bidr2o_pld90b_sphv_10hv   = 0.0
+    bidr2w_pld90b_sphv_10hv   = 0.0
+    rtho_pld90b_sphv_10hv     = 750.0
+    rthl_pld90b_sphv_10hv     = 0.0
+    rthw_pld90b_sphv_10hv     = 0.0
+    rthlw_pld90b_sphv_10hv    = 0.0
+    strtho_pld90b_sphv_10hv   = 0.0
+    strthao_pld90b_sphv_10hv  = 0.0
+    ctho_pld90b_sphv_10hv     = 0.0
+    cthl_pld90b_sphv_10hv     = 0.0
+    cthw_pld90b_sphv_10hv     = 0.0
+    cthlw_pld90b_sphv_10hv    = 0.0
+    rshldd_pld90b_sphv_10hv   = 13530.0
+    xw_pld90b_sphv_10hv       = 7e-07
+    nwxw_pld90b_sphv_10hv     = 4.25e-12
+    xl_pld90b_sphv_10hv       = 0.0
+    xlw_pld90b_sphv_10hv      = 0.0
+    dxlsat_pld90b_sphv_10hv   = -5e-08
+    nst_pld90b_sphv_10hv      = 2.0
+    ats_pld90b_sphv_10hv      = 0.0
+    dfinf_pld90b_sphv_10hv    = 0.07
+    dfw_pld90b_sphv_10hv      = 2e-08
+    dfl_pld90b_sphv_10hv      = 0.0
+    dflw_pld90b_sphv_10hv     = 0.0
+    dp_pld90b_sphv_10hv       = 2.0
+    ecrit_pld90b_sphv_10hv    = 4500000.0
+    ecorn_pld90b_sphv_10hv    = 50000.0
+    xvsat_pld90b_sphv_10hv    = 0.0
+    du_pld90b_sphv_10hv       = 0.01
+    tc1_pld90b_sphv_10hv      = 0.0052
+    tc2_pld90b_sphv_10hv      = 7e-06
+    tc1l_pld90b_sphv_10hv     = 0.0
+    tc2l_pld90b_sphv_10hv     = 0.0
+    tc1w_pld90b_sphv_10hv     = -8e-10
+    tc2w_pld90b_sphv_10hv     = -9e-12
+    theacc_pld90b_sphv_10hv   = 0.0
+    theacc2_pld90b_sphv_10hv  = 0.03
+    rva_pld90b_sphv_10hv      = 1000.0
+    dta_pld90b_sphv_10hv      = 0.0
+    trj_pld90b_sphv_10hv      = 27.0
+    cjarea_pld90b_sphv_10hv   = 0.00014
+    cjlsti_pld90b_sphv_10hv   = 1e-10
+    cjlgat_pld90b_sphv_10hv   = 5e-08
+    vbiarea_pld90b_sphv_10hv  = 0.7
+    vbisti_pld90b_sphv_10hv   = 0.7
+    vbigat_pld90b_sphv_10hv   = 0.7
+    parea_pld90b_sphv_10hv    = 0.2
+    psti_pld90b_sphv_10hv     = 0.2
+    pgat_pld90b_sphv_10hv     = 0.35
+    is1area_pld90b_sphv_10hv  = 1e-08
+    ttarea_pld90b_sphv_10hv   = 0.0
+    is2area_pld90b_sphv_10hv  = 0.0
+    irarea_pld90b_sphv_10hv   = 3e-09
+    stis1area_pld90b_sphv_10hv = 3.0
+    stis2area_pld90b_sphv_10hv = 3.0
+    stirarea_pld90b_sphv_10hv = 3.0
+    n1area_pld90b_sphv_10hv   = 1.0
+    n2area_pld90b_sphv_10hv   = 2.0
+    nrarea_pld90b_sphv_10hv   = 200.0
+    is1lsti_pld90b_sphv_10hv  = 0.0
+    ttlsti_pld90b_sphv_10hv   = 0.0
+    is2lsti_pld90b_sphv_10hv  = 0.0
+    irlsti_pld90b_sphv_10hv   = 3e-09
+    stis1sti_pld90b_sphv_10hv = 3.0
+    stis2sti_pld90b_sphv_10hv = 3.0
+    stirsti_pld90b_sphv_10hv  = 3.0
+    n1sti_pld90b_sphv_10hv    = 1.0
+    n2sti_pld90b_sphv_10hv    = 2.0
+    nrsti_pld90b_sphv_10hv    = 200.0
+    is1lgat_pld90b_sphv_10hv  = 0.0
+    ttlgat_pld90b_sphv_10hv   = 0.0
+    is2lgat_pld90b_sphv_10hv  = 0.0
+    irlgat_pld90b_sphv_10hv   = 0.0
+    stis1gat_pld90b_sphv_10hv = 3.0
+    stis2gat_pld90b_sphv_10hv = 3.0
+    stirgat_pld90b_sphv_10hv  = 3.0
+    n1gat_pld90b_sphv_10hv    = 1.0
+    n2gat_pld90b_sphv_10hv    = 2.0
+    nrgat_pld90b_sphv_10hv    = 200.0
+    cjaread_pld90b_sphv_10hv  = 0.000115
+    cjlstid_pld90b_sphv_10hv  = 0.0
+    cjlgatd_pld90b_sphv_10hv  = 1.15e-10
+    vbiaread_pld90b_sphv_10hv = 0.5
+    vbistid_pld90b_sphv_10hv  = 0.5
+    vbigatd_pld90b_sphv_10hv  = 0.5
+    paread_pld90b_sphv_10hv   = 0.4
+    pstid_pld90b_sphv_10hv    = 0.38
+    pgatd_pld90b_sphv_10hv    = 0.2
+    is1aread_pld90b_sphv_10hv = 1.6e-07
+    ttaread_pld90b_sphv_10hv  = 3.4e-08
+    is2aread_pld90b_sphv_10hv = 1e-05
+    iraread_pld90b_sphv_10hv  = 1e-09
+    stis1aread_pld90b_sphv_10hv = 4.0
+    stis2aread_pld90b_sphv_10hv = 10.0
+    stiraread_pld90b_sphv_10hv = 350000.0
+    n1aread_pld90b_sphv_10hv  = 1.2
+    n2aread_pld90b_sphv_10hv  = 2.0
+    nraread_pld90b_sphv_10hv  = 20000.0
+    is1lstid_pld90b_sphv_10hv = 0.0
+    ttlstid_pld90b_sphv_10hv  = 3.47e-08
+    is2lstid_pld90b_sphv_10hv = 0.0
+    irlstid_pld90b_sphv_10hv  = 0.0
+    stis1stid_pld90b_sphv_10hv = 4.0
+    stis2stid_pld90b_sphv_10hv = 10.0
+    stirstid_pld90b_sphv_10hv = 350000.0
+    n1stid_pld90b_sphv_10hv   = 1.0
+    n2stid_pld90b_sphv_10hv   = 2.0
+    nrstid_pld90b_sphv_10hv   = 20000.0
+    is1lgatd_pld90b_sphv_10hv = 0
+    ttlgatd_pld90b_sphv_10hv  = 3.4e-08
+    is2lgatd_pld90b_sphv_10hv = 0.0
+    irlgatd_pld90b_sphv_10hv  = 1e-07
+    stis1gatd_pld90b_sphv_10hv = 4.0
+    stis2gatd_pld90b_sphv_10hv = 10.0
+    stirgatd_pld90b_sphv_10hv = 350000.0
+    n1gatd_pld90b_sphv_10hv   = 1.0
+    n2gatd_pld90b_sphv_10hv   = 2.0
+    nrgatd_pld90b_sphv_10hv   = 20000.0
+    cjaread2_pld90b_sphv_10hv = 0.00024
+    cjlstid2_pld90b_sphv_10hv = 0.0
+    vbiaread2_pld90b_sphv_10hv = 0.5
+    vbistid2_pld90b_sphv_10hv = 0.5
+    paread2_pld90b_sphv_10hv  = 0.4
+    pstid2_pld90b_sphv_10hv   = 0.4
+    is1aread2_pld90b_sphv_10hv = 1e-07
+    ttaread2_pld90b_sphv_10hv = 3.47e-08
+    is2aread2_pld90b_sphv_10hv = 1e-05
+    iraread2_pld90b_sphv_10hv = 1e-09
+    stis1aread2_pld90b_sphv_10hv = 5.0
+    stis2aread2_pld90b_sphv_10hv = 10.0
+    stiraread2_pld90b_sphv_10hv = 350000.0
+    n1aread2_pld90b_sphv_10hv = 1.2
+    n2aread2_pld90b_sphv_10hv = 2.0
+    nraread2_pld90b_sphv_10hv = 20000.0
+    is1lstid2_pld90b_sphv_10hv = 1e-13
+    ttlstid2_pld90b_sphv_10hv = 3.47e-08
+    is2lstid2_pld90b_sphv_10hv = 0.0
+    irlstid2_pld90b_sphv_10hv = 0.0
+    stis1stid2_pld90b_sphv_10hv = 5.0
+    stis2stid2_pld90b_sphv_10hv = 10.0
+    stirstid2_pld90b_sphv_10hv = 350000.0
+    n1stid2_pld90b_sphv_10hv  = 1.0
+    n2stid2_pld90b_sphv_10hv  = 2.0
+    nrstid2_pld90b_sphv_10hv  = 20000.0
+    aacc_pld90b_sphv_10hv     = 36.0
+    eais1area_pld90b_sphv_10hv = 1.12
+    eais2area_pld90b_sphv_10hv = 1.12
+    eairarea_pld90b_sphv_10hv = 1.12
+    eais1sti_pld90b_sphv_10hv = 1.12
+    eais2sti_pld90b_sphv_10hv = 1.12
+    eairsti_pld90b_sphv_10hv  = 1.12
+    eais1gat_pld90b_sphv_10hv = 1.12
+    eais2gat_pld90b_sphv_10hv = 1.12
+    eairgat_pld90b_sphv_10hv  = 1.12
+    eais1aread_pld90b_sphv_10hv = 1.12
+    eais2aread_pld90b_sphv_10hv = 1.12
+    eairaread_pld90b_sphv_10hv = 1.12
+    eais1stid_pld90b_sphv_10hv = 1.12
+    eais2stid_pld90b_sphv_10hv = 1.12
+    eairstid_pld90b_sphv_10hv = 1.12
+    eais1gatd_pld90b_sphv_10hv = 1.12
+    eais2gatd_pld90b_sphv_10hv = 1.12
+    eairgatd_pld90b_sphv_10hv = 1.12
+    eais1aread2_pld90b_sphv_10hv = 1.12
+    eais2aread2_pld90b_sphv_10hv = 1.12
+    eairaread2_pld90b_sphv_10hv = 1.12
+    eais1stid2_pld90b_sphv_10hv = 1.12
+    eais2stid2_pld90b_sphv_10hv = 1.12
+    eairstid2_pld90b_sphv_10hv = 1.12
+    nom_delr_tox_nld65b_sphv_10hv = 1.0
+    nom_delr_uch_nld65b_sphv_10hv = 1.037
+    nom_delr_res_nld65b_sphv_10hv = 1.045
+    nom_dela_vfb_nld65b_sphv_10hv = 0.08793
+    nom_dela_vtw_nld65b_sphv_10hv = -0.03379
+    nom_dela_xw_nld65b_sphv_10hv = -0.2
+    nom_dela_thesatw_nld65b_sphv_10hv = -0.1
+    nom_delr_cj_nld65b_sphv_10hv = 1.0
+    nom_delr_is_nld65b_sphv_10hv = 1.0
+    nom_delr_is2_nld65b_sphv_10hv = 1.0
+    nom_delr_ir_nld65b_sphv_10hv = 1.0
+    sig_delr_tox_nld65b_sphv_10hv = 0.012
+    sig_delr_uch_nld65b_sphv_10hv = 0.05173
+    sig_delr_res_nld65b_sphv_10hv = 0.02543
+    sig_dela_vfb_nld65b_sphv_10hv = 0.05308
+    sig_dela_vtw_nld65b_sphv_10hv = 0.08286
+    sig_dela_xw_nld65b_sphv_10hv = 0.0976
+    sig_dela_thesatw_nld65b_sphv_10hv = 0.1493
+    sig_delr_cj_nld65b_sphv_10hv = 0.0333
+    sig_delr_is_nld65b_sphv_10hv = 0.055
+    sig_delr_is2_nld65b_sphv_10hv = 0.768
+    sig_delr_ir_nld65b_sphv_10hv = 0.768
+    fac_rth_nld65b_sphv_10hv  = 0.825
+    tc1_ecrit_nld65b_sphv_10hv = 0.0
+    tc2_ecrit_nld65b_sphv_10hv = 0
+    dwrjundo_nld65b_sphv_10hv = 2.5
+    dwrjunso_nld65b_sphv_10hv = 0.0
+    qmc_nld65b_sphv_10hv      = 0.0
+    lvaro_nld65b_sphv_10hv    = 0.0
+    lvarl_nld65b_sphv_10hv    = 0.0
+    lvarw_nld65b_sphv_10hv    = 0.0
+    lap_nld65b_sphv_10hv      = 0.0
+    wvaro_nld65b_sphv_10hv    = -4e-07
+    wvarl_nld65b_sphv_10hv    = 0.0
+    wvarw_nld65b_sphv_10hv    = 0.7
+    wot_nld65b_sphv_10hv      = 0.0
+    dlq_nld65b_sphv_10hv      = 1.35e-07
+    dwq_nld65b_sphv_10hv      = 2e-07
+    vfbo_nld65b_sphv_10hv     = -0.68
+    vfbl_nld65b_sphv_10hv     = 0.0
+    vfbw_nld65b_sphv_10hv     = -0.02
+    vfblw_nld65b_sphv_10hv    = 0.0
+    stvfbo_nld65b_sphv_10hv   = 0.0011
+    stvfbl_nld65b_sphv_10hv   = 0.0
+    stvfbw_nld65b_sphv_10hv   = -0.2
+    stvfblw_nld65b_sphv_10hv  = 0.0
+    toxo_nld65b_sphv_10hv     = 1.4e-08
+    epsroxo_nld65b_sphv_10hv  = 3.9
+    nsubo_nld65b_sphv_10hv    = 1.8e+23
+    nsubw_nld65b_sphv_10hv    = -0.015
+    wseg_nld65b_sphv_10hv     = 1e-09
+    npck_nld65b_sphv_10hv     = 1e+23
+    npckw_nld65b_sphv_10hv    = 0.0
+    wsegp_nld65b_sphv_10hv    = 2.474e-06
+    lpck_nld65b_sphv_10hv     = 0.0
+    lpckw_nld65b_sphv_10hv    = 0.0
+    fol1_nld65b_sphv_10hv     = 0.05
+    fol2_nld65b_sphv_10hv     = 0.0
+    facneffaco_nld65b_sphv_10hv = 1.0
+    facneffacl_nld65b_sphv_10hv = 0.0
+    facneffacw_nld65b_sphv_10hv = 0.0
+    facneffaclw_nld65b_sphv_10hv = 0.0
+    gfacnudo_nld65b_sphv_10hv = 1.0
+    gfacnudl_nld65b_sphv_10hv = 0.0
+    gfacnudlexp_nld65b_sphv_10hv = 1.0
+    gfacnudw_nld65b_sphv_10hv = 0.0
+    gfacnudlw_nld65b_sphv_10hv = 0.0
+    vsbnudo_nld65b_sphv_10hv  = 2.75
+    dvsbnudo_nld65b_sphv_10hv = 1.0
+    vnsubo_nld65b_sphv_10hv   = 0.0
+    nslpo_nld65b_sphv_10hv    = 0.05
+    dnsubo_nld65b_sphv_10hv   = 0.0
+    dphibo_nld65b_sphv_10hv   = -0.03
+    dphibl_nld65b_sphv_10hv   = 0.0
+    dphiblexp_nld65b_sphv_10hv = 1.0
+    dphibw_nld65b_sphv_10hv   = 0.0
+    dphiblw_nld65b_sphv_10hv  = 0.0
+    delvtaco_nld65b_sphv_10hv = -0.3
+    delvtacl_nld65b_sphv_10hv = 0.0
+    delvtaclexp_nld65b_sphv_10hv = 1.0
+    delvtacw_nld65b_sphv_10hv = 0.0
+    delvtaclw_nld65b_sphv_10hv = 0.0
+    npo_nld65b_sphv_10hv      = 1e+26
+    npl_nld65b_sphv_10hv      = 0.0
+    cto_nld65b_sphv_10hv      = 0.09
+    ctl_nld65b_sphv_10hv      = 0.0
+    ctlexp_nld65b_sphv_10hv   = 0.4772
+    ctw_nld65b_sphv_10hv      = -0.09186
+    ctlw_nld65b_sphv_10hv     = 0.0
+    toxovo_nld65b_sphv_10hv   = 1.4e-08
+    toxovdo_nld65b_sphv_10hv  = 1.4e-08
+    lov_nld65b_sphv_10hv      = 0.0
+    dlovd_nld65b_sphv_10hv    = 0.0
+    novo_nld65b_sphv_10hv     = 1.6e+23
+    novdo_nld65b_sphv_10hv    = 5.5e+22
+    cfl_nld65b_sphv_10hv      = 0.0
+    cflexp_nld65b_sphv_10hv   = 2.0
+    cfw_nld65b_sphv_10hv      = 0.0
+    cfbo_nld65b_sphv_10hv     = 0.0
+    uo_nld65b_sphv_10hv       = 0.066
+    fbet1_nld65b_sphv_10hv    = 0.0
+    fbet1w_nld65b_sphv_10hv   = 0.0
+    lp1_nld65b_sphv_10hv      = 0.0
+    lp1w_nld65b_sphv_10hv     = 0.0
+    fbet2_nld65b_sphv_10hv    = 0.0
+    lp2_nld65b_sphv_10hv      = 0.0
+    betw1_nld65b_sphv_10hv    = 0.45
+    betw2_nld65b_sphv_10hv    = 0.001
+    wbet_nld65b_sphv_10hv     = 0.0
+    stbeto_nld65b_sphv_10hv   = 1.0
+    stbetl_nld65b_sphv_10hv   = 0.0
+    stbetw_nld65b_sphv_10hv   = -0.1
+    stbetlw_nld65b_sphv_10hv  = 0.1
+    mueo_nld65b_sphv_10hv     = 1.1
+    muew_nld65b_sphv_10hv     = -0.2
+    stmueo_nld65b_sphv_10hv   = 0.0
+    themuo_nld65b_sphv_10hv   = 1.5
+    stthemuo_nld65b_sphv_10hv = 0.7
+    cso_nld65b_sphv_10hv      = 0.0
+    csl_nld65b_sphv_10hv      = 0.0
+    cslexp_nld65b_sphv_10hv   = 0.0
+    csw_nld65b_sphv_10hv      = 0.0
+    cslw_nld65b_sphv_10hv     = 0.0
+    stcso_nld65b_sphv_10hv    = 0.0
+    xcoro_nld65b_sphv_10hv    = 0.0
+    xcorl_nld65b_sphv_10hv    = 0.0
+    xcorw_nld65b_sphv_10hv    = 0.0
+    xcorlw_nld65b_sphv_10hv   = 0.0
+    stxcoro_nld65b_sphv_10hv  = 0.0
+    fetao_nld65b_sphv_10hv    = 0.8
+    rsw1_nld65b_sphv_10hv     = 0.0
+    rsw2_nld65b_sphv_10hv     = 0.0
+    strso_nld65b_sphv_10hv    = 0.0
+    rsbo_nld65b_sphv_10hv     = 0.0
+    rsgo_nld65b_sphv_10hv     = 0.0
+    thesato_nld65b_sphv_10hv  = 1.22
+    thesatl_nld65b_sphv_10hv  = 0.0
+    thesatlexp_nld65b_sphv_10hv = 1.0
+    thesatw_nld65b_sphv_10hv  = 0.75
+    thesatlw_nld65b_sphv_10hv = -0.25
+    stthesato_nld65b_sphv_10hv = 0.5
+    stthesatl_nld65b_sphv_10hv = 0.0
+    stthesatw_nld65b_sphv_10hv = 0.8
+    stthesatlw_nld65b_sphv_10hv = 0.3
+    thesatbo_nld65b_sphv_10hv = 0.0
+    thesatgo_nld65b_sphv_10hv = 0.0
+    thesatgl_nld65b_sphv_10hv = 0.0
+    thesatgw_nld65b_sphv_10hv = 0.0
+    axo_nld65b_sphv_10hv      = 3.0
+    axl_nld65b_sphv_10hv      = 0.0
+    alpl_nld65b_sphv_10hv     = 0.03
+    alplexp_nld65b_sphv_10hv  = 1.0
+    alpw_nld65b_sphv_10hv     = 0.0
+    alp1l1_nld65b_sphv_10hv   = 0.0
+    alp1lexp_nld65b_sphv_10hv = 0.5
+    alp1l2_nld65b_sphv_10hv   = 0.0
+    alp1w_nld65b_sphv_10hv    = 0.0
+    alp2l1_nld65b_sphv_10hv   = 0.0
+    alp2lexp_nld65b_sphv_10hv = 1.0
+    alp2l2_nld65b_sphv_10hv   = 0.0
+    alp2w_nld65b_sphv_10hv    = 0.0
+    vpo_nld65b_sphv_10hv      = 10.0
+    a1o_nld65b_sphv_10hv      = 0.01
+    a1l_nld65b_sphv_10hv      = 0.0
+    a1w_nld65b_sphv_10hv      = 0.0
+    a2o_nld65b_sphv_10hv      = 70.0
+    sta2o_nld65b_sphv_10hv    = 1.2
+    a3o_nld65b_sphv_10hv      = 20.0
+    a3l_nld65b_sphv_10hv      = 0.0
+    a3w_nld65b_sphv_10hv      = -1.0
+    a4o_nld65b_sphv_10hv      = 1.0
+    a4l_nld65b_sphv_10hv      = 0.0
+    a4w_nld65b_sphv_10hv      = 0.0
+    gcoo_nld65b_sphv_10hv     = 0.0
+    iginvlw_nld65b_sphv_10hv  = 0.0
+    igovw_nld65b_sphv_10hv    = 0.0
+    igovdw_nld65b_sphv_10hv   = 0.0
+    stigo_nld65b_sphv_10hv    = 2.0
+    gc2o_nld65b_sphv_10hv     = 0.375
+    gc3o_nld65b_sphv_10hv     = 0.063
+    chibo_nld65b_sphv_10hv    = 3.1
+    agidlw_nld65b_sphv_10hv   = 0.0
+    agidldw_nld65b_sphv_10hv  = 0.0
+    bgidlo_nld65b_sphv_10hv   = 10.0
+    bgidldo_nld65b_sphv_10hv  = 10.0
+    stbgidlo_nld65b_sphv_10hv = 0.0
+    stbgidldo_nld65b_sphv_10hv = 0.0
+    cgidlo_nld65b_sphv_10hv   = 1.0
+    cgidldo_nld65b_sphv_10hv  = 1.0
+    cgbovl_nld65b_sphv_10hv   = 1.06e-15
+    cfrw_nld65b_sphv_10hv     = 0.0
+    cfrdw_nld65b_sphv_10hv    = 0.0
+    fnto_nld65b_sphv_10hv     = 1.0
+    nfalw_nld65b_sphv_10hv    = 3.0e26
+    nfblw_nld65b_sphv_10hv    = 0
+    nfclw_nld65b_sphv_10hv    = 0
+    efo_nld65b_sphv_10hv      = 0.99
+    lintnoi_nld65b_sphv_10hv  = 0.0
+    alpnoi_nld65b_sphv_10hv   = 2.0
+    kvthoweo_nld65b_sphv_10hv = 0.0
+    kvthowel_nld65b_sphv_10hv = 0.0
+    kvthowew_nld65b_sphv_10hv = 0.0
+    kvthowelw_nld65b_sphv_10hv = 0.0
+    kuoweo_nld65b_sphv_10hv   = 0.0
+    kuowel_nld65b_sphv_10hv   = 0.0
+    kuowew_nld65b_sphv_10hv   = 0.0
+    kuowelw_nld65b_sphv_10hv  = 0.0
+    rgo_nld65b_sphv_10hv      = 0.0
+    rsh_nld65b_sphv_10hv      = 0.0
+    rbulko_nld65b_sphv_10hv   = 0.0
+    rwello_nld65b_sphv_10hv   = 0.0
+    rjunso_nld65b_sphv_10hv   = 200.0
+    rjundo_nld65b_sphv_10hv   = 300.0
+    rint_nld65b_sphv_10hv     = 0.0
+    rvpoly_nld65b_sphv_10hv   = 0.0
+    rshg_nld65b_sphv_10hv     = 0.0
+    dlsil_nld65b_sphv_10hv    = 0.0
+    saref_nld65b_sphv_10hv    = 1e-06
+    sbref_nld65b_sphv_10hv    = 1e-06
+    wlod_nld65b_sphv_10hv     = 0.0
+    kuo_nld65b_sphv_10hv      = 0.0
+    kvsat_nld65b_sphv_10hv    = 0.0
+    tkuo_nld65b_sphv_10hv     = 0.0
+    lkuo_nld65b_sphv_10hv     = 0.0
+    wkuo_nld65b_sphv_10hv     = 0.0
+    pkuo_nld65b_sphv_10hv     = 0.0
+    llodkuo_nld65b_sphv_10hv  = 0.0
+    wlodkuo_nld65b_sphv_10hv  = 0.0
+    kvtho_nld65b_sphv_10hv    = 0.0
+    lkvtho_nld65b_sphv_10hv   = 0.0
+    wkvtho_nld65b_sphv_10hv   = 0.0
+    pkvtho_nld65b_sphv_10hv   = 0.0
+    llodvth_nld65b_sphv_10hv  = 0.0
+    wlodvth_nld65b_sphv_10hv  = 0.0
+    stetao_nld65b_sphv_10hv   = 0.0
+    lodetao_nld65b_sphv_10hv  = 1.0
+    scref_nld65b_sphv_10hv    = 1e-05
+    web_nld65b_sphv_10hv      = 0.0
+    wec_nld65b_sphv_10hv      = 0.0
+    adr1o_nld65b_sphv_10hv    = 0.0
+    adr1l_nld65b_sphv_10hv    = 0.0
+    adr1w_nld65b_sphv_10hv    = 0.0
+    adr2o_nld65b_sphv_10hv    = 10.0
+    stadr2o_nld65b_sphv_10hv  = 1.0
+    adr3o_nld65b_sphv_10hv    = 0.0
+    adr3l_nld65b_sphv_10hv    = 0.0
+    adr3w_nld65b_sphv_10hv    = 0.0
+    adr4o_nld65b_sphv_10hv    = 0.0
+    adr4l_nld65b_sphv_10hv    = 0.0
+    adr4w_nld65b_sphv_10hv    = 0.0
+    adr5o_nld65b_sphv_10hv    = 0.0
+    adr5l_nld65b_sphv_10hv    = 0.0
+    adr5w_nld65b_sphv_10hv    = 0.0
+    bidr1o_nld65b_sphv_10hv   = 0.0
+    bidr1l_nld65b_sphv_10hv   = 0.0
+    bidr1w_nld65b_sphv_10hv   = 0.0
+    bidr2o_nld65b_sphv_10hv   = 0.0
+    bidr2w_nld65b_sphv_10hv   = 0.0
+    rtho_nld65b_sphv_10hv     = 750.0
+    rthl_nld65b_sphv_10hv     = 0.0
+    rthw_nld65b_sphv_10hv     = 0.0
+    rthlw_nld65b_sphv_10hv    = 0.0
+    strtho_nld65b_sphv_10hv   = 0.0
+    strthao_nld65b_sphv_10hv  = 0.55
+    ctho_nld65b_sphv_10hv     = 0.0
+    cthl_nld65b_sphv_10hv     = 0.0
+    cthw_nld65b_sphv_10hv     = 0.0
+    cthlw_nld65b_sphv_10hv    = 0.0
+    rshldd_nld65b_sphv_10hv   = 4200.0
+    xw_nld65b_sphv_10hv       = 1.2e-06
+    nwxw_nld65b_sphv_10hv     = 1.7e-12
+    xl_nld65b_sphv_10hv       = 0.0
+    xlw_nld65b_sphv_10hv      = 0.0
+    dxlsat_nld65b_sphv_10hv   = 5.62e-07
+    nst_nld65b_sphv_10hv      = 1.0
+    ats_nld65b_sphv_10hv      = 0.0
+    dfinf_nld65b_sphv_10hv    = 0.02
+    dfw_nld65b_sphv_10hv      = 1e-07
+    dfl_nld65b_sphv_10hv      = 0.0
+    dflw_nld65b_sphv_10hv     = 0.0
+    dp_nld65b_sphv_10hv       = 1.922
+    ecrit_nld65b_sphv_10hv    = 1100000.0
+    ecorn_nld65b_sphv_10hv    = 430000.0
+    xvsat_nld65b_sphv_10hv    = -0.5
+    du_nld65b_sphv_10hv       = 0.25
+    tc1_nld65b_sphv_10hv      = 0.0052
+    tc2_nld65b_sphv_10hv      = 1.6e-05
+    tc1l_nld65b_sphv_10hv     = 0.0
+    tc2l_nld65b_sphv_10hv     = 0.0
+    tc1w_nld65b_sphv_10hv     = -1e-09
+    tc2w_nld65b_sphv_10hv     = 0.0
+    theacc_nld65b_sphv_10hv   = 0.0
+    theacc2_nld65b_sphv_10hv  = 0.0285
+    aacc_nld65b_sphv_10hv     = 36.0
+    rva_nld65b_sphv_10hv      = 1000.0
+    dta_nld65b_sphv_10hv      = 0.0
+    trj_nld65b_sphv_10hv      = 25.0
+    cjarea_nld65b_sphv_10hv   = 2.5e-10
+    cjlsti_nld65b_sphv_10hv   = 2.5e-10
+    cjlgat_nld65b_sphv_10hv   = 2.5e-10
+    vbiarea_nld65b_sphv_10hv  = 1.0
+    vbisti_nld65b_sphv_10hv   = 1.0
+    vbigat_nld65b_sphv_10hv   = 1.0
+    parea_nld65b_sphv_10hv    = 0.35
+    psti_nld65b_sphv_10hv     = 0.48
+    pgat_nld65b_sphv_10hv     = 0.48
+    is1area_nld65b_sphv_10hv  = 0.0
+    ttarea_nld65b_sphv_10hv   = 2e-08
+    is2area_nld65b_sphv_10hv  = 0.0
+    irarea_nld65b_sphv_10hv   = 1e-12
+    stis1area_nld65b_sphv_10hv = 3.0
+    stis2area_nld65b_sphv_10hv = 3.0
+    stirarea_nld65b_sphv_10hv = 3.0
+    n1area_nld65b_sphv_10hv   = 1.0
+    n2area_nld65b_sphv_10hv   = 2.0
+    nrarea_nld65b_sphv_10hv   = 100.0
+    is1lsti_nld65b_sphv_10hv  = 0.0
+    ttlsti_nld65b_sphv_10hv   = 2e-08
+    is2lsti_nld65b_sphv_10hv  = 0.0
+    irlsti_nld65b_sphv_10hv   = 1e-12
+    stis1sti_nld65b_sphv_10hv = 3.0
+    stis2sti_nld65b_sphv_10hv = 3.0
+    stirsti_nld65b_sphv_10hv  = 3.0
+    n1sti_nld65b_sphv_10hv    = 1.0
+    n2sti_nld65b_sphv_10hv    = 2.0
+    nrsti_nld65b_sphv_10hv    = 100.0
+    is1lgat_nld65b_sphv_10hv  = 0.0
+    ttlgat_nld65b_sphv_10hv   = 2e-08
+    is2lgat_nld65b_sphv_10hv  = 0.0
+    is2lgatd_nld65b_sphv_10hv = 0.0
+    irlgat_nld65b_sphv_10hv   = 1e-12
+    stis1gat_nld65b_sphv_10hv = 3.0
+    stis2gat_nld65b_sphv_10hv = 3.0
+    stirgat_nld65b_sphv_10hv  = 3.0
+    n1gat_nld65b_sphv_10hv    = 1.0
+    n2gat_nld65b_sphv_10hv    = 2.0
+    nrgat_nld65b_sphv_10hv    = 100.0
+    cjaread_nld65b_sphv_10hv  = 0.00014
+    cjlstid_nld65b_sphv_10hv  = 0.0
+    cjaread2_nld65b_sphv_10hv = 0.0
+    cjlstid2_nld65b_sphv_10hv = 0.0
+    cjlgatd_nld65b_sphv_10hv  = 0.0
+    vbiaread_nld65b_sphv_10hv = 0.5
+    vbistid_nld65b_sphv_10hv  = 0.5
+    vbigatd_nld65b_sphv_10hv  = 0.5
+    paread_nld65b_sphv_10hv   = 0.4
+    pstid_nld65b_sphv_10hv    = 0.4
+    pgatd_nld65b_sphv_10hv    = 0.4
+    is1aread_nld65b_sphv_10hv = 4e-08
+    is1aread2_nld65b_sphv_10hv = 4e-08
+    is1lstid_nld65b_sphv_10hv = 0.0
+    is1lstid2_nld65b_sphv_10hv = 0.0
+    is1lgatd_nld65b_sphv_10hv = 0.0
+    ttaread_nld65b_sphv_10hv  = 2.8e-08
+    is2aread_nld65b_sphv_10hv = 3e-05
+    is2aread2_nld65b_sphv_10hv = 0.0
+    is2lstid2_nld65b_sphv_10hv = 0.0
+    iraread_nld65b_sphv_10hv  = 0.00018
+    stis1aread_nld65b_sphv_10hv = 4.5
+    stis1aread2_nld65b_sphv_10hv = 4.5
+    stis2aread_nld65b_sphv_10hv = 3.0
+    stis2aread2_nld65b_sphv_10hv = 3.0
+    stiraread_nld65b_sphv_10hv = 41000.0
+    n1aread_nld65b_sphv_10hv  = 1.0
+    n2aread_nld65b_sphv_10hv  = 1.8
+    nraread_nld65b_sphv_10hv  = 2000.0
+    ttlstid_nld65b_sphv_10hv  = 2.8e-08
+    irlstid_nld65b_sphv_10hv  = 0.0
+    stis1stid_nld65b_sphv_10hv = 4.5
+    stis2stid_nld65b_sphv_10hv = 3.0
+    stirstid_nld65b_sphv_10hv = 41000.0
+    n1stid_nld65b_sphv_10hv   = 1.0
+    n2stid_nld65b_sphv_10hv   = 2.0
+    nrstid_nld65b_sphv_10hv   = 2000.0
+    ttlgatd_nld65b_sphv_10hv  = 2.8e-08
+    irlgatd_nld65b_sphv_10hv  = 0.0
+    stis1gatd_nld65b_sphv_10hv = 4.5
+    stis2gatd_nld65b_sphv_10hv = 3.0
+    stirgatd_nld65b_sphv_10hv = 41000.0
+    n1gatd_nld65b_sphv_10hv   = 1.0
+    n2gatd_nld65b_sphv_10hv   = 2.0
+    nrgatd_nld65b_sphv_10hv   = 2000.0
+    vbiaread2_nld65b_sphv_10hv = 0.5
+    vbistid2_nld65b_sphv_10hv = 0.5
+    paread2_nld65b_sphv_10hv  = 0.4
+    pstid2_nld65b_sphv_10hv   = 0.4
+    ttaread2_nld65b_sphv_10hv = 2.8e-08
+    iraread2_nld65b_sphv_10hv = 0.0
+    stiraread2_nld65b_sphv_10hv = 41000.0
+    n1aread2_nld65b_sphv_10hv = 1.0
+    n2aread2_nld65b_sphv_10hv = 2.0
+    nraread2_nld65b_sphv_10hv = 2000.0
+    ttlstid2_nld65b_sphv_10hv = 2.8e-08
+    irlstid2_nld65b_sphv_10hv = 0.0
+    stis1stid2_nld65b_sphv_10hv = 4.5
+    stis2stid2_nld65b_sphv_10hv = 3.0
+    stirstid2_nld65b_sphv_10hv = 41000.0
+    n1stid2_nld65b_sphv_10hv  = 1.0
+    n2stid2_nld65b_sphv_10hv  = 2.0
+    nrstid2_nld65b_sphv_10hv  = 2000.0
+    eais1area_nld65b_sphv_10hv = 1.12
+    eais2area_nld65b_sphv_10hv = 1.12
+    eairarea_nld65b_sphv_10hv = 1.12
+    eais1sti_nld65b_sphv_10hv = 1.12
+    eais2sti_nld65b_sphv_10hv = 1.12
+    eairsti_nld65b_sphv_10hv  = 1.12
+    eais1gat_nld65b_sphv_10hv = 1.12
+    eais2gat_nld65b_sphv_10hv = 1.12
+    eairgat_nld65b_sphv_10hv  = 1.12
+    eais1aread_nld65b_sphv_10hv = 1.12
+    eais2aread_nld65b_sphv_10hv = 1.12
+    eairaread_nld65b_sphv_10hv = 1.12
+    eais1stid_nld65b_sphv_10hv = 1.12
+    eais2stid_nld65b_sphv_10hv = 1.12
+    eairstid_nld65b_sphv_10hv = 1.12
+    eais1gatd_nld65b_sphv_10hv = 1.12
+    eais2gatd_nld65b_sphv_10hv = 1.12
+    eairgatd_nld65b_sphv_10hv = 1.12
+    eais1aread2_nld65b_sphv_10hv = 1.12
+    eais2aread2_nld65b_sphv_10hv = 1.12
+    eairaread2_nld65b_sphv_10hv = 1.12
+    eais1stid2_nld65b_sphv_10hv = 1.12
+    eais2stid2_nld65b_sphv_10hv = 1.12
+    eairstid2_nld65b_sphv_10hv = 1.12
+    ikfarea_nld65b_sphv_10hv  = 0
+    stikfarea_nld65b_sphv_10hv = 0
+    ikfaread_nld65b_sphv_10hv = 1.1e7
+    dwikfaread_nld65b_sphv_10hv = 0
+    stikfaread_nld65b_sphv_10hv = 0
+    nom_delr_tox_pld30b_sphv_10hv = 1.0
+    nom_dela_vfbo_pld30b_sphv_10hv = 0.014
+    nom_dela_vfbw_pld30b_sphv_10hv = 0.0021
+    nom_delr_rshldd_pld30b_sphv_10hv = 1.0
+    nom_dela_nwxw_pld30b_sphv_10hv = -0.12
+    nom_dela_vdscale_pld30b_sphv_10hv = 0.04
+    nom_dela_vdscalew_pld30b_sphv_10hv = -0.002
+    nom_delr_cj_pld30b_sphv_10hv = 1.0
+    nom_delr_is_pld30b_sphv_10hv = 1.0
+    nom_delr_is2_pld30b_sphv_10hv = 1.0
+    nom_delr_ir_pld30b_sphv_10hv = 1.0
+    sig_delr_tox_pld30b_sphv_10hv = 0.012
+    sig_dela_vfbo_pld30b_sphv_10hv = 0.018
+    sig_dela_vfbw_pld30b_sphv_10hv = 0.001775
+    sig_delr_rshldd_pld30b_sphv_10hv = 0.0863
+    sig_dela_nwxw_pld30b_sphv_10hv = 0.04
+    sig_dela_vdscale_pld30b_sphv_10hv = 0.045
+    sig_dela_vdscalew_pld30b_sphv_10hv = 0.032
+    sig_delr_cj_pld30b_sphv_10hv = 0.0333
+    sig_delr_is_pld30b_sphv_10hv = 0.055
+    sig_delr_is2_pld30b_sphv_10hv = 0.768
+    sig_delr_ir_pld30b_sphv_10hv = 0.768
+    ecritw_pld30b_sphv_10hv   = 0.3
+    dwrjundo_pld30b_sphv_10hv = 0.3
+    fac_rth_pld30b_sphv_10hv  = 0.6
+    tc1_ecrit_pld30b_sphv_10hv = 0.0
+    tc2_ecrit_pld30b_sphv_10hv = 0.0
+    qmc_pld30b_sphv_10hv      = 0.0
+    lvaro_pld30b_sphv_10hv    = 0.0
+    lvarl_pld30b_sphv_10hv    = 0.0
+    lvarw_pld30b_sphv_10hv    = 0.0
+    lap_pld30b_sphv_10hv      = 0.0
+    wvaro_pld30b_sphv_10hv    = -3.5e-07
+    wvarl_pld30b_sphv_10hv    = 0.0
+    wvarw_pld30b_sphv_10hv    = 0.0
+    wot_pld30b_sphv_10hv      = 0.0
+    dlq_pld30b_sphv_10hv      = -2.2e-08
+    dwq_pld30b_sphv_10hv      = 4e-07
+    vfbo_pld30b_sphv_10hv     = -1.0
+    vfbl_pld30b_sphv_10hv     = 0.0
+    vfbw_pld30b_sphv_10hv     = 0.04
+    vfblw_pld30b_sphv_10hv    = 0.0
+    stvfbo_pld30b_sphv_10hv   = 0.0009
+    stvfbl_pld30b_sphv_10hv   = 0.0
+    stvfbw_pld30b_sphv_10hv   = 0.0
+    stvfblw_pld30b_sphv_10hv  = 0.0
+    toxo_pld30b_sphv_10hv     = 1.333e-08
+    epsroxo_pld30b_sphv_10hv  = 3.9
+    nsubo_pld30b_sphv_10hv    = 1.3e+23
+    nsubw_pld30b_sphv_10hv    = 0.0
+    wseg_pld30b_sphv_10hv     = 1e-08
+    npck_pld30b_sphv_10hv     = 1e+23
+    npckw_pld30b_sphv_10hv    = 0.0
+    wsegp_pld30b_sphv_10hv    = 1e-08
+    lpck_pld30b_sphv_10hv     = 1e-10
+    lpckw_pld30b_sphv_10hv    = 0.0
+    fol1_pld30b_sphv_10hv     = 0.0
+    fol2_pld30b_sphv_10hv     = 0.0
+    facneffaco_pld30b_sphv_10hv = 1.0
+    facneffacl_pld30b_sphv_10hv = 0.0
+    facneffacw_pld30b_sphv_10hv = 0.0
+    facneffaclw_pld30b_sphv_10hv = 0.0
+    gfacnudo_pld30b_sphv_10hv = 1.0
+    gfacnudl_pld30b_sphv_10hv = 0.0
+    gfacnudlexp_pld30b_sphv_10hv = 1.0
+    gfacnudw_pld30b_sphv_10hv = 0.0
+    gfacnudlw_pld30b_sphv_10hv = 0.0
+    vsbnudo_pld30b_sphv_10hv  = 0.0
+    dvsbnudo_pld30b_sphv_10hv = 1.0
+    vnsubo_pld30b_sphv_10hv   = 0.0
+    nslpo_pld30b_sphv_10hv    = 0.05
+    dnsubo_pld30b_sphv_10hv   = 0.0
+    dphibo_pld30b_sphv_10hv   = 0.0
+    dphibl_pld30b_sphv_10hv   = 0.0
+    dphiblexp_pld30b_sphv_10hv = 1.0
+    dphibw_pld30b_sphv_10hv   = 0.0
+    dphiblw_pld30b_sphv_10hv  = 0.0
+    delvtaco_pld30b_sphv_10hv = 0.0
+    delvtacl_pld30b_sphv_10hv = 0.0
+    delvtaclexp_pld30b_sphv_10hv = 1.0
+    delvtacw_pld30b_sphv_10hv = 0.0
+    delvtaclw_pld30b_sphv_10hv = 0.0
+    npo_pld30b_sphv_10hv      = 1e+26
+    npl_pld30b_sphv_10hv      = 0.0
+    cto_pld30b_sphv_10hv      = 0.0
+    ctl_pld30b_sphv_10hv      = 0.0
+    ctlexp_pld30b_sphv_10hv   = 1.0
+    ctw_pld30b_sphv_10hv      = 0.0
+    ctlw_pld30b_sphv_10hv     = 0.0
+    ctgo_pld30b_sphv_10hv     = 0.0
+    ctbo_pld30b_sphv_10hv     = 0.0
+    stcto_pld30b_sphv_10hv    = 1.0
+    toxovo_pld30b_sphv_10hv   = 1.333e-08
+    toxovdo_pld30b_sphv_10hv  = 1.333e-08
+    lov_pld30b_sphv_10hv      = 6e-08
+    dlovd_pld30b_sphv_10hv    = 0.0
+    novo_pld30b_sphv_10hv     = 1e+25
+    novdo_pld30b_sphv_10hv    = 2e+22
+    cfl_pld30b_sphv_10hv      = 5e-05
+    cflexp_pld30b_sphv_10hv   = 2.0
+    cfw_pld30b_sphv_10hv      = 0.0
+    cfbo_pld30b_sphv_10hv     = 0.0
+    uo_pld30b_sphv_10hv       = 0.018
+    fbet1_pld30b_sphv_10hv    = 0.0
+    fbet1w_pld30b_sphv_10hv   = 0.0
+    lp1_pld30b_sphv_10hv      = 1e-10
+    lp1w_pld30b_sphv_10hv     = 0.0
+    fbet2_pld30b_sphv_10hv    = 0.0
+    lp2_pld30b_sphv_10hv      = 1e-10
+    betw1_pld30b_sphv_10hv    = 0.0
+    betw2_pld30b_sphv_10hv    = 0.0
+    wbet_pld30b_sphv_10hv     = 1e-09
+    stbeto_pld30b_sphv_10hv   = 1.1
+    stbetl_pld30b_sphv_10hv   = 0.0
+    stbetw_pld30b_sphv_10hv   = 0.0
+    stbetlw_pld30b_sphv_10hv  = 0.0
+    mueo_pld30b_sphv_10hv     = 0.5
+    muew_pld30b_sphv_10hv     = 0.0
+    stmueo_pld30b_sphv_10hv   = 0.0
+    themuo_pld30b_sphv_10hv   = 1.5
+    stthemuo_pld30b_sphv_10hv = 1.0
+    cso_pld30b_sphv_10hv      = 0.0
+    csl_pld30b_sphv_10hv      = 0.0
+    cslexp_pld30b_sphv_10hv   = 0.0
+    csw_pld30b_sphv_10hv      = 0.0
+    cslw_pld30b_sphv_10hv     = 0.0
+    stcso_pld30b_sphv_10hv    = 0.0
+    xcoro_pld30b_sphv_10hv    = 0.0
+    xcorl_pld30b_sphv_10hv    = 0.0
+    xcorw_pld30b_sphv_10hv    = 0.0
+    xcorlw_pld30b_sphv_10hv   = 0.0
+    stxcoro_pld30b_sphv_10hv  = 0.0
+    fetao_pld30b_sphv_10hv    = 1.0
+    rsw1_pld30b_sphv_10hv     = 0.0
+    rsw2_pld30b_sphv_10hv     = 0.0
+    strso_pld30b_sphv_10hv    = 1.0
+    rsbo_pld30b_sphv_10hv     = 0.0
+    rsgo_pld30b_sphv_10hv     = 0.0
+    thesato_pld30b_sphv_10hv  = 0.018
+    thesatl_pld30b_sphv_10hv  = 0.0
+    thesatlexp_pld30b_sphv_10hv = 1.0
+    thesatw_pld30b_sphv_10hv  = -0.48
+    thesatlw_pld30b_sphv_10hv = 0.0
+    stthesato_pld30b_sphv_10hv = 1.5
+    stthesatl_pld30b_sphv_10hv = 0.0
+    stthesatw_pld30b_sphv_10hv = 0.0
+    stthesatlw_pld30b_sphv_10hv = 0.0
+    thesatbo_pld30b_sphv_10hv = 0.0
+    thesatgo_pld30b_sphv_10hv = 77.0
+    thesatgl_pld30b_sphv_10hv = 0.0
+    thesatgw_pld30b_sphv_10hv = 0.0
+    vdscale_pld30b_sphv_10hv  = 1.1
+    vdscalew_pld30b_sphv_10hv = 0.0
+    vdscaleb_pld30b_sphv_10hv = 0.0
+    stvdscale_pld30b_sphv_10hv = 0.0
+    axo_pld30b_sphv_10hv      = 2.0
+    axl_pld30b_sphv_10hv      = 0.0
+    alpl_pld30b_sphv_10hv     = 0.0005
+    alplexp_pld30b_sphv_10hv  = 1.0
+    alpw_pld30b_sphv_10hv     = 0.0
+    alp1l1_pld30b_sphv_10hv   = 0.0
+    alp1lexp_pld30b_sphv_10hv = 1.0
+    alp1l2_pld30b_sphv_10hv   = 0.0
+    alp1w_pld30b_sphv_10hv    = 0.0
+    alp2l1_pld30b_sphv_10hv   = 0.0
+    alp2lexp_pld30b_sphv_10hv = 1.0
+    alp2l2_pld30b_sphv_10hv   = 0.0
+    alp2w_pld30b_sphv_10hv    = 0.0
+    vpo_pld30b_sphv_10hv      = 0.1
+    a1o_pld30b_sphv_10hv      = 0.000535
+    a1l_pld30b_sphv_10hv      = 0.0
+    a1w_pld30b_sphv_10hv      = -0.485
+    a2o_pld30b_sphv_10hv      = 73.75
+    sta2o_pld30b_sphv_10hv    = 0.45
+    a3o_pld30b_sphv_10hv      = 1.2
+    a3l_pld30b_sphv_10hv      = 0.0
+    a3w_pld30b_sphv_10hv      = 0.0
+    a4o_pld30b_sphv_10hv      = 0.0
+    a4l_pld30b_sphv_10hv      = 0.0
+    a4w_pld30b_sphv_10hv      = 0.0
+    gcoo_pld30b_sphv_10hv     = 0.0
+    iginvlw_pld30b_sphv_10hv  = 0.0
+    igovw_pld30b_sphv_10hv    = 0.0
+    igovdw_pld30b_sphv_10hv   = 0.0
+    stigo_pld30b_sphv_10hv    = 2.0
+    gc2o_pld30b_sphv_10hv     = 0.375
+    gc3o_pld30b_sphv_10hv     = 0.063
+    chibo_pld30b_sphv_10hv    = 3.1
+    agidlw_pld30b_sphv_10hv   = 0.0
+    agidldw_pld30b_sphv_10hv  = 0.0
+    bgidlo_pld30b_sphv_10hv   = 41.0
+    bgidldo_pld30b_sphv_10hv  = 41.0
+    stbgidlo_pld30b_sphv_10hv = 0.0
+    stbgidldo_pld30b_sphv_10hv = 0.0
+    cgidlo_pld30b_sphv_10hv   = 0.0
+    cgidldo_pld30b_sphv_10hv  = 0.0
+    cgbovl_pld30b_sphv_10hv   = 1.55e-15
+    cfrw_pld30b_sphv_10hv     = 0.0
+    cfrdw_pld30b_sphv_10hv    = 8e-17
+    fnto_pld30b_sphv_10hv     = 1.0
+    nfalw_pld30b_sphv_10hv    = 5e+24
+    nfblw_pld30b_sphv_10hv    = 7000000000.0
+    nfclw_pld30b_sphv_10hv    = 6e-08
+    efo_pld30b_sphv_10hv      = 1.2
+    lintnoi_pld30b_sphv_10hv  = 0.0
+    alpnoi_pld30b_sphv_10hv   = 2.0
+    kvthoweo_pld30b_sphv_10hv = 0.0
+    kvthowel_pld30b_sphv_10hv = 0.0
+    kvthowew_pld30b_sphv_10hv = 0.0
+    kvthowelw_pld30b_sphv_10hv = 0.0
+    kuoweo_pld30b_sphv_10hv   = 0.0
+    kuowel_pld30b_sphv_10hv   = 0.0
+    kuowew_pld30b_sphv_10hv   = 0.0
+    kuowelw_pld30b_sphv_10hv  = 0.0
+    rgo_pld30b_sphv_10hv      = 0.0
+    rsh_pld30b_sphv_10hv      = 0.0
+    rbulko_pld30b_sphv_10hv   = 0.0
+    rwello_pld30b_sphv_10hv   = 0.0
+    rjunso_pld30b_sphv_10hv   = 0.0
+    rjundo_pld30b_sphv_10hv   = 220.0
+    rint_pld30b_sphv_10hv     = 0.0
+    rvpoly_pld30b_sphv_10hv   = 0.0
+    rshg_pld30b_sphv_10hv     = 0.0
+    dlsil_pld30b_sphv_10hv    = 0.0
+    saref_pld30b_sphv_10hv    = 1e-06
+    sbref_pld30b_sphv_10hv    = 1e-06
+    wlod_pld30b_sphv_10hv     = 0.0
+    kuo_pld30b_sphv_10hv      = 0.0
+    kvsat_pld30b_sphv_10hv    = 0.0
+    tkuo_pld30b_sphv_10hv     = 0.0
+    lkuo_pld30b_sphv_10hv     = 0.0
+    wkuo_pld30b_sphv_10hv     = 0.0
+    pkuo_pld30b_sphv_10hv     = 0.0
+    llodkuo_pld30b_sphv_10hv  = 0.0
+    wlodkuo_pld30b_sphv_10hv  = 0.0
+    kvtho_pld30b_sphv_10hv    = 0.0
+    lkvtho_pld30b_sphv_10hv   = 0.0
+    wkvtho_pld30b_sphv_10hv   = 0.0
+    pkvtho_pld30b_sphv_10hv   = 0.0
+    llodvth_pld30b_sphv_10hv  = 0.0
+    wlodvth_pld30b_sphv_10hv  = 0.0
+    stetao_pld30b_sphv_10hv   = 0.0
+    lodetao_pld30b_sphv_10hv  = 1.0
+    scref_pld30b_sphv_10hv    = 1e-05
+    web_pld30b_sphv_10hv      = 0.0
+    wec_pld30b_sphv_10hv      = 0.0
+    adr1o_pld30b_sphv_10hv    = 0.0
+    adr1l_pld30b_sphv_10hv    = 0.0
+    adr1w_pld30b_sphv_10hv    = 0.0
+    adr2o_pld30b_sphv_10hv    = 160.0
+    stadr2o_pld30b_sphv_10hv  = -0.3
+    adr3o_pld30b_sphv_10hv    = 1.2
+    adr3l_pld30b_sphv_10hv    = 0.0
+    adr3w_pld30b_sphv_10hv    = 0.0
+    adr4o_pld30b_sphv_10hv    = 0.0
+    adr4l_pld30b_sphv_10hv    = 0.0
+    adr4w_pld30b_sphv_10hv    = 0.0
+    adr5o_pld30b_sphv_10hv    = 0.0
+    adr5l_pld30b_sphv_10hv    = 0.0
+    adr5w_pld30b_sphv_10hv    = 0.0
+    bidr1o_pld30b_sphv_10hv   = 0.0
+    bidr1l_pld30b_sphv_10hv   = 0.0
+    bidr1w_pld30b_sphv_10hv   = 0.0
+    bidr2o_pld30b_sphv_10hv   = 0.0
+    bidr2w_pld30b_sphv_10hv   = 0.0
+    rthl_pld30b_sphv_10hv     = 0.0
+    rthw_pld30b_sphv_10hv     = 0.0
+    rthlw_pld30b_sphv_10hv    = 0.0
+    strtho_pld30b_sphv_10hv   = 0.3
+    strthao_pld30b_sphv_10hv  = 0.0
+    ctho_pld30b_sphv_10hv     = 0.0
+    cthl_pld30b_sphv_10hv     = 0.0
+    cthw_pld30b_sphv_10hv     = 0.0
+    cthlw_pld30b_sphv_10hv    = 0.0
+    rshldd_pld30b_sphv_10hv   = 38000.0
+    xw_pld30b_sphv_10hv       = 1.25e-07
+    nwxw_pld30b_sphv_10hv     = 0.0
+    xl_pld30b_sphv_10hv       = 0.0
+    xlw_pld30b_sphv_10hv      = 0.0
+    dxlsat_pld30b_sphv_10hv   = 0.0
+    nst_pld30b_sphv_10hv      = 1.0
+    ats_pld30b_sphv_10hv      = 0.0
+    dfinf_pld30b_sphv_10hv    = 0.01
+    dfw_pld30b_sphv_10hv      = 2e-08
+    dfl_pld30b_sphv_10hv      = 0.0
+    dflw_pld30b_sphv_10hv     = 0.0
+    dp_pld30b_sphv_10hv       = 2.0
+    ecrit_pld30b_sphv_10hv    = 7800000.0
+    ecorn_pld30b_sphv_10hv    = 100000.0
+    xvsat_pld30b_sphv_10hv    = -0.2
+    du_pld30b_sphv_10hv       = 0.02
+    tc1_pld30b_sphv_10hv      = 0.0043
+    tc2_pld30b_sphv_10hv      = 5e-06
+    tc1l_pld30b_sphv_10hv     = 0.0
+    tc2l_pld30b_sphv_10hv     = 0.0
+    tc1w_pld30b_sphv_10hv     = 0.0
+    tc2w_pld30b_sphv_10hv     = 0.0
+    theacc_pld30b_sphv_10hv   = 0.0
+    theacc2_pld30b_sphv_10hv  = 0.03
+    rva_pld30b_sphv_10hv      = 1000.0
+    dta_pld30b_sphv_10hv      = 0.0
+    trj_pld30b_sphv_10hv      = 27.0
+    cjarea_pld30b_sphv_10hv   = 0.0
+    cjlsti_pld30b_sphv_10hv   = 0.0
+    cjlgat_pld30b_sphv_10hv   = 0.0
+    vbiarea_pld30b_sphv_10hv  = 0.7
+    vbisti_pld30b_sphv_10hv   = 0.7
+    vbigat_pld30b_sphv_10hv   = 0.7
+    parea_pld30b_sphv_10hv    = 0.1
+    psti_pld30b_sphv_10hv     = 0.1
+    pgat_pld30b_sphv_10hv     = 0.1
+    is1area_pld30b_sphv_10hv  = 0.0
+    ttarea_pld30b_sphv_10hv   = 0.0
+    is2area_pld30b_sphv_10hv  = 0.0
+    irarea_pld30b_sphv_10hv   = 0.0
+    stis1area_pld30b_sphv_10hv = 0.0
+    stis2area_pld30b_sphv_10hv = 0.0
+    stirarea_pld30b_sphv_10hv = 0.0
+    n1area_pld30b_sphv_10hv   = 1.0
+    n2area_pld30b_sphv_10hv   = 2.0
+    nrarea_pld30b_sphv_10hv   = 200.0
+    is1lsti_pld30b_sphv_10hv  = 0.0
+    ttlsti_pld30b_sphv_10hv   = 0.0
+    is2lsti_pld30b_sphv_10hv  = 0.0
+    irlsti_pld30b_sphv_10hv   = 0.0
+    n1sti_pld30b_sphv_10hv    = 1.0
+    n2sti_pld30b_sphv_10hv    = 2.0
+    nrsti_pld30b_sphv_10hv    = 200.0
+    is1lgat_pld30b_sphv_10hv  = 0.0
+    ttlgat_pld30b_sphv_10hv   = 0.0
+    is2lgat_pld30b_sphv_10hv  = 0.0
+    irlgat_pld30b_sphv_10hv   = 0.0
+    n1gat_pld30b_sphv_10hv    = 1.0
+    n2gat_pld30b_sphv_10hv    = 2.0
+    nrgat_pld30b_sphv_10hv    = 200.0
+    cjaread_pld30b_sphv_10hv  = 0.00043
+    cjlstid_pld30b_sphv_10hv  = 0.0
+    cjlgatd_pld30b_sphv_10hv  = 1.1e-10
+    vbiaread_pld30b_sphv_10hv = 0.58
+    vbistid_pld30b_sphv_10hv  = 0.58
+    vbigatd_pld30b_sphv_10hv  = 0.58
+    paread_pld30b_sphv_10hv   = 0.41
+    pstid_pld30b_sphv_10hv    = 0.4
+    pgatd_pld30b_sphv_10hv    = 0.4
+    is1aread_pld30b_sphv_10hv = 1e-07
+    ttaread_pld30b_sphv_10hv  = 1.6e-08
+    is2aread_pld30b_sphv_10hv = 0.0
+    iraread_pld30b_sphv_10hv  = 0.0035
+    stis1aread_pld30b_sphv_10hv = 4.0
+    stis2aread_pld30b_sphv_10hv = 4.0
+    stiraread_pld30b_sphv_10hv = 160000.0
+    n1aread_pld30b_sphv_10hv  = 1.0
+    n2aread_pld30b_sphv_10hv  = 1.6
+    nraread_pld30b_sphv_10hv  = 8000.0
+    is1lstid_pld30b_sphv_10hv = 0.0
+    ttlstid_pld30b_sphv_10hv  = 0.0
+    is2lstid_pld30b_sphv_10hv = 0.0
+    irlstid_pld30b_sphv_10hv  = 0.0
+    n1stid_pld30b_sphv_10hv   = 1.0
+    n2stid_pld30b_sphv_10hv   = 1.6
+    nrstid_pld30b_sphv_10hv   = 8000.0
+    is1lgatd_pld30b_sphv_10hv = 3e-13
+    ttlgatd_pld30b_sphv_10hv  = 1.6e-08
+    is2lgatd_pld30b_sphv_10hv = 6e-11
+    irlgatd_pld30b_sphv_10hv  = 8.75e-09
+    n1gatd_pld30b_sphv_10hv   = 1.0
+    n2gatd_pld30b_sphv_10hv   = 1.6
+    nrgatd_pld30b_sphv_10hv   = 8000.0
+    cjaread2_pld30b_sphv_10hv = 0.00024
+    cjlstid2_pld30b_sphv_10hv = 0.0
+    vbiaread2_pld30b_sphv_10hv = 0.5
+    vbistid2_pld30b_sphv_10hv = 0.5
+    paread2_pld30b_sphv_10hv  = 0.4
+    pstid2_pld30b_sphv_10hv   = 0.4
+    is1aread2_pld30b_sphv_10hv = 1.3e-07
+    ttaread2_pld30b_sphv_10hv = 1.6e-08
+    is2aread2_pld30b_sphv_10hv = 0.0
+    iraread2_pld30b_sphv_10hv = 0.0
+    n1aread2_pld30b_sphv_10hv = 1.0
+    n2aread2_pld30b_sphv_10hv = 1.6
+    nraread2_pld30b_sphv_10hv = 8000.0
+    is1lstid2_pld30b_sphv_10hv = 0.0
+    ttlstid2_pld30b_sphv_10hv = 0.0
+    is2lstid2_pld30b_sphv_10hv = 0.0
+    irlstid2_pld30b_sphv_10hv = 0.0
+    n1stid2_pld30b_sphv_10hv  = 1.0
+    n2stid2_pld30b_sphv_10hv  = 1.6
+    nrstid2_pld30b_sphv_10hv  = 8000.0
+    aacc_pld30b_sphv_10hv     = 36.0
+    eais1area_pld30b_sphv_10hv = 1.12
+    eais2area_pld30b_sphv_10hv = 1.12
+    eairarea_pld30b_sphv_10hv = 1.12
+    eais1sti_pld30b_sphv_10hv = 1.12
+    eais2sti_pld30b_sphv_10hv = 1.12
+    eairsti_pld30b_sphv_10hv  = 1.12
+    eais1gat_pld30b_sphv_10hv = 1.12
+    eais2gat_pld30b_sphv_10hv = 1.12
+    eairgat_pld30b_sphv_10hv  = 1.12
+    eais1aread_pld30b_sphv_10hv = 1.12
+    eais2aread_pld30b_sphv_10hv = 1.12
+    eairaread_pld30b_sphv_10hv = 1.12
+    eais1stid_pld30b_sphv_10hv = 1.12
+    eais2stid_pld30b_sphv_10hv = 1.12
+    eairstid_pld30b_sphv_10hv = 1.12
+    eais1gatd_pld30b_sphv_10hv = 1.12
+    eais2gatd_pld30b_sphv_10hv = 1.12
+    eairgatd_pld30b_sphv_10hv = 1.12
+    eais1aread2_pld30b_sphv_10hv = 1.12
+    eais2aread2_pld30b_sphv_10hv = 1.12
+    eairaread2_pld30b_sphv_10hv = 1.12
+    eais1stid2_pld30b_sphv_10hv = 1.12
+    eais2stid2_pld30b_sphv_10hv = 1.12
+    eairstid2_pld30b_sphv_10hv = 1.12
+    ikfarea_pld30b_sphv_10hv  = 0.0
+    stikfarea_pld30b_sphv_10hv = 0.0
+    ikfaread_pld30b_sphv_10hv = 12500000.0
+    dwikfaread_pld30b_sphv_10hv = 8.0
+    stikfaread_pld30b_sphv_10hv = 0.0


// This file is used to define functions
// should not colide with those already defined in baseline lib

real smm_delr_gox_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(2.945e-06/(l*w))/sqrt(ng/1.0)) ;
}
real smm_dela_dw_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l))/sqrt(ng/1.0)) ;
}
real smm_dela_dl_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0/(w))/sqrt(ng/1.0)) ;
}
real smm_dela_vfb_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(3.072e-05/((l*w)))/sqrt(ng/1.0)) ;
}
real smm_dela_vtl_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(w))/sqrt(ng/1.0)) ;
}
real smm_delr_uch_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(1.642e-05/((l*w)))/sqrt(ng/1.0)) ;
}
real smm_delr_res_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(4.894e-05/(w))/sqrt(ng/1.0)) ;
}

real smm_dela_vtw_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l))/sqrt(ng/1.0)) ;
}
real smm_delr_nsub_pmos10_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w))/sqrt(ng/1.0)) ;
}



real smm_delr_tox_nmos10_sphv_10hv(real l, real w, real ng) {
    return (0/sqrt(l*w*ng)) ;
}

real smm_delr_uch_nmos10_sphv_10hv(real l, real w, real ng) {
    return ((4.3e-3/sqrt(l*w)+3e-4)/(sqrt(ng))) ;
}

real smm_delr_res_nmos10_sphv_10hv(real l, real w, real ng) {
    return (0.0/sqrt(w*ng)+0.0) ;
}
real smm_dela_vfb_nmos10_sphv_10hv(real l, real w, real ng) {
	return ((1.13e-2/sqrt(l*w)+2e-4)/(sqrt(ng))) ;
}

real smm_dela_vtw_nmos10_sphv_10hv(real l, real w, real ng) {
    return (0/sqrt(l*w*ng)) ;
}

real smm_dela_dw_nmos10_sphv_10hv(real l, real w, real ng) {
    return (0/sqrt(l*ng)) ;
}
real smm_delr_nsub_nmos10_sphv_10hv(real l, real w, real ng) {
    return (0/sqrt(l*w*ng)) ;
}


real smm_delr_tox_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_uch_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(7.787e-05/(l*w))) ;
}

real smm_delr_res_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(0.0002488/(w))) ;
}

real smm_dela_vfb_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(1.92e-05/(l*w))) ;
}

real smm_dela_vtw_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(0.0001452/(l))) ;
}

real smm_delr_nsub_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(0.0001005/(l*w))) ;
}

real smm_dela_dw_pmos90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}



real smm_delr_tox_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_uch_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(6.009e-05/(l*w*ng))) ;
}

real smm_delr_res_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(3.58e-05*0.6174/((w+3)*ng))) ;
}

real smm_dela_vfb_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0001123*3.4848/((l+2)*(w+2)*ng))) ;
}

real smm_dela_vtw_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_nsub_nmos90b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0/(l*w*ng))) ;
}


real smm_delr_tox_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_dw_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(5.223e-06/(l))) ;
}
real smm_dela_dl_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vfb_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(3.0e-05/(l*w))) ;
}
real smm_dela_vtl_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(w))) ;
}
real smm_dela_vtw_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(6e-05/(l))) ;
}

real smm_delr_mobref_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(9.48e-07/(l*w))) ;
}

real smm_delr_nsub_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(0.0001536/(l*w))) ;
}

real smm_delr_rshl_nmos45b_sphv_10hv(real l, real w) {
    return (sqrt(3.37e-05/(w))) ;
}


real smm_delr_tox_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng/2))) ;
}

real smm_delr_uch_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.000345/((l+2.0)*(w+5.4)*ng/2))) ;
}

real smm_delr_res_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0001121/(w+1.8)*ng/2)) ;
}

real smm_dela_vfb_pmoshs45b_sphv_10hv(real l, real w, real ng ) {
    return (sqrt(3.5e-05/(l*(w+0.8)*ng/2))) ;
}

real smm_dela_vtw_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng/2))) ;
}

real smm_delr_nsub_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng/2))) ;
}

real smm_dela_dw_pmoshs45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng/2))) ;
}


real smm_delr_tox_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng/2))) ;
}

real smm_delr_uch_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.000345/((l+2.0)*(w+5.4)*ng/2))) ;
}

real smm_delr_res_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0001121/((w+1.8)*ng/2))) ;
}

real smm_dela_vfb_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(3.5e-05/(l*(w+0.8)*ng/2))) ;
}

real smm_dela_vtw_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng/2))) ;
}

real smm_delr_nsub_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng/2))) ;
}

real smm_dela_dw_pmos45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng/2))) ;
}


real smm_delr_gox_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_uch_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtw_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(0.0006431/(l))) ;
}

real smm_delr_nsub_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_dxw_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(1.775e-05/(l))) ;
}

real smm_delr_res_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(1.382e-05/(w))) ;
}

real smm_dela_vfb_nld65b_sphv_10hv(real l, real w) {
    return (sqrt(0.0004514/(l*w))) ;
}



real smm_dela_dw_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}
real smm_delr_tox_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0.0006182/(l*w))) ;
}

real smm_delr_nsub_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_delr_mobref_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rshl_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(8.347e-06/(w))) ;
}

real smm_dela_vtw_nld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}



real smm_dela_dw_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}
real smm_delr_tox_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0.0006824/(l*w))) ;
}

real smm_delr_nsub_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_delr_mobref_nld100_sphv_10hv(real l, real w) {
    return (sqrt(4.495e-06/(l*w))) ;
}

real smm_delr_rshl_nld100_sphv_10hv(real l, real w) {
    return (sqrt(1.934e-05/(w))) ;
}

real smm_dela_vtw_nld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}


real smm_delr_gox_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_dw_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_dela_vfb_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(0.0003044/(l*w))) ;
}

real smm_delr_mobref_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(1.578e-06/(l*w))) ;
}

real smm_delr_rshl_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(8.013e-06/(l*w))) ;
}

real smm_delr_nsub_nld30b_sphv_10hv(real l, real w) {
    return (sqrt(0.0/(l*w))) ;
}


real smm_delr_gox_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_xw_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(1.262e-05/(l))) ;
}


real smm_dela_vfb_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0.0002587/(l*w))) ;
}

real smm_dela_vtw_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_mobref_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(6.595e-06/(w*l))) ;
}

real smm_delr_vdscale_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_delr_nsub_nld45b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}



real smm_delr_gox_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_xw_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}


real smm_dela_vfb_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.00065/(l*w*ng))) ;
}

real smm_dela_vtw_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_mobref_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.25e-04/(l*w*ng))) ;
}

real smm_delr_rsh_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.5e-04/(w*l*ng))) ;
}

real smm_delr_thesato_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_nsub_nld45b_he_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}



real smm_delr_gox_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_xw_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}


real smm_dela_vfb_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0014/(l*w*ng))) ;
}

real smm_dela_vtw_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_mobref_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_rsh_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.4e-04/(w*l*ng))) ;
}

real smm_delr_vdscale_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(w*ng))) ;
}

real smm_delr_thesato_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_nsub_nld45b_tlp_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}



real smm_dela_vfbo_pld30b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(6.684e-05*1.3/(l*(w+0.6)*ng))) ;
}

real smm_delr_uo_pld30b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(3.922e-05*0.5/(l*(w+1.0)*ng))) ;
}

real smm_delr_rshldd_pld30b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0002573/((w+0.6)*ng))) ;
}



real smm_delr_tox_pld65_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pld65_sphv_10hv(real l, real w) {
    return (sqrt(2.11392e-5/(l*(w+8)))) ;
}

real smm_dela_vtw_pld65_sphv_10hv(real l, real w) {
    return (sqrt(2.5e-5*(0.735+2.0/(w+1.25)))/(l)) ;
}

real smm_delr_uch_pld65_sphv_10hv(real l, real w) {
    return (sqrt(7.875e-6/(l*w))) ;
}

real smm_delr_res_pld65_sphv_10hv(real l, real w) {
    return (sqrt(2.176e-05/(w))) ;
}

real smm_dela_dwox_pld65_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nsub_pld65_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}



real smm_delr_tox_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(1.468e-05/(l*w))) ;
}

real smm_dela_vtw_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_uch_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(1.05e-05/(l*w))) ;
}

real smm_delr_res_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(3.626e-05/(w))) ;
}

real smm_dela_dwox_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(0.000156/(l))) ;
}

real smm_delr_nsub_pld90b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}


real smm_delr_tox_pld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pld100_sphv_10hv(real l, real w) {
    return (sqrt(6.606e-6/(l*w))) ;
}

real smm_dela_vtw_pld100_sphv_10hv(real l, real w) {
    return (sqrt(2.5e-5*(3.5+8/w))/(l)) ;
}

real smm_delr_uch_pld100_sphv_10hv(real l, real w) {
    return (sqrt(7.875e-6/(l*w))) ;
}

real smm_delr_res_pld100_sphv_10hv(real l, real w) {
    return (sqrt(2.720e-05/(w))) ;
}

real smm_dela_dwox_pld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nsub_pld100_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_gox_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_dw_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_dela_vfb_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0.0003459/(l*w))) ;
}

real smm_delr_mobref_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rshl_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0.002572/(l*w))) ;
}

real smm_delr_nsub_nld10_sphv_10hv(real l, real w) {
    return (sqrt(0.0/(l*w))) ;
}


real smm_delr_gox_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_uch_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_nsub_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_vfb_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(9.99648e-04/(l*w*ng)+1.4904e-04/(l*w*w*ng))) ;
}

real smm_dela_dw_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_rshl_pld45b_sphv_10hv(real l, real w, real ng) {
    return (sqrt(8.152e-05/(w*ng))) ;
}



real sum_sti_10hv(real a_r, real ng, real l, real sd) {
    return ((1/a_r+(ng>=2)/(a_r+1)+(ng>=3)*log((a_r+ng)*(a_r+abs(ng-1))/((a_r+2)*(a_r+1)))/2)/(l+sd)) ;
}

real sa_val_10hv(real sa, real l, real ng, real sd) {
    return ((ng+(ng==0))/sum_sti_10hv((sa+l/2)/(sd+l),ng,l,sd)-l/2) ;
}

real sum_iexpmi_10hv(real ng, real b) {
    return ((exp(-b)*(1-exp(-b*ng))-ng*exp(-b*ng)*(1-exp(-b)))/(1-exp(-b))**2) ;
}

real scl_int_10hv(real sclt, real scref_i, real nexp, real aa, real bb, real ng, real l, real sd) {
    return (sclt/nexp*exp(-aa)*(1-exp(-bb*ng))/(1-exp(-bb))+(l+sd)/nexp*exp(-aa)*sum_iexpmi_10hv(ng,bb)+scref_i/nexp**2*exp(-aa)*(1-exp(-bb*ng))/(1-exp(-bb))) ;
}

real scw_fa_int_10hv(real scw, real w, real scref_i) {
    return ((1/(scw)-1/(scw+w))*scref_i**2) ;
}

real scl_fa_int_10hv(real scl, real l, real scref_i, real sd_i, real ng) {
    return ((sum_sti_10hv((scl)/(l+sd_i),ng,l,sd_i)-sum_sti_10hv((scl+l)/(l+sd_i),ng,l,sd_i))/ng*scref_i**2) ;
}

real scw_fb_int_10hv(real scw, real w, real scref_i, real nexp) {
    return (((scw/nexp+scref_i/nexp**2)*exp(-nexp*scw/scref_i)-((scw+w)/nexp+scref_i/nexp**2)*exp(-nexp*(scw+w)/scref_i))) ;
}

real scl_fb_int_10hv(real scl, real l, real scref_i, real sd_i, real ng, real nexp) {
    return ((scl_int_10hv(scl,scref_i,nexp,nexp*scl/scref_i,nexp*(l+sd_i)/scref_i,ng,l,sd_i)-scl_int_10hv(scl+l,scref_i,nexp,nexp*(scl+l)/scref_i,nexp*(l+sd_i)/scref_i,ng,l,sd_i))/ng) ;
}

real sca_val_10hv(real wpe, real wpn, real wpw, real wps, real w, real l, real ng, real sd_i, real scref_i) {
    return ((scw_fa_int_10hv(wpn,w,scref_i)+scw_fa_int_10hv(wps,w,scref_i))/w+(scl_fa_int_10hv(wpw,l,scref_i,sd_i,ng)+scl_fa_int_10hv(wpe,l,scref_i,sd_i,ng))/l) ;
}

real scb_val_10hv(real wpe, real wpn, real wpw, real wps, real w, real l, real ng, real sd_i, real scref_i, real nexp) {
    return ((scw_fb_int_10hv(wpn,w,scref_i,nexp)+scw_fb_int_10hv(wps,w,scref_i,nexp))/w+(scl_fb_int_10hv(wpw,l,scref_i,sd_i,ng,nexp)+scl_fb_int_10hv(wpe,l,scref_i,sd_i,ng,nexp))/l) ;
}

real smm_dela_dta_dpldd_junc_10hv(real area) {
    return (14.45*sqrt(1.7127e-04/(area))) ;
}


real smm_delr_tox_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_uch_pld120_sphv_10hv(real l, real w) {
    return (sqrt(7.787e-05*0.8/(l*w))) ;
}

real smm_delr_res_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0.0002488*0.22/(w))) ;
}

real smm_dela_vfb_pld120_sphv_10hv(real l, real w) {
    return (sqrt(1.92e-05/(l*w))) ;
}

real smm_dela_vtw_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0.0001452/(l))) ;
}

real smm_delr_nsub_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0.0001005*0/(l*w))) ;
}

real smm_dela_dw_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_dela_dwox_pld120_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}


real smm_delr_tox_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_uch_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(6.009e-05*1.6/((l*w+10)*ng))) ;
}

real smm_delr_res_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(3.58e-05*0.6174*1.35/((w+3)*ng))) ;
}

real smm_dela_vfb_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0001123*3.4848*0.3/(l*w*ng))) ;
}

real smm_dela_vtw_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_nsub_nmos120_sphv_10hv(real l, real w, real ng) {
    return (sqrt(0.0/(l*w*ng))) ;
}




//***********************************************************
endsection process_params
section resistor
ahdl_include "./veriloga/antifuse_t_vlaver1p3_forspectre.va"

ahdl_include "./veriloga/shieldscale_ver1p1_forspectre.va"

//***********************************************************

real a1a2_rpoly0_10hv(real l, real w, real we, real sDOTmult, real lend_rpoly0_10hv, real ldogbone2body_rpoly0_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*w)+((((w*lend_rpoly0_10hv+ldogbone2body_rpoly0_10hv*(we-w))))))) ;
}

real p1p2_rpoly0_10hv(real l, real w, real we, real sDOTmult, real lend_rpoly0_10hv) {
    return ((sDOTmult*((l+(2*lend_rpoly0_10hv+2*we-w))))) ;
}

real a1a2_rpoly_10hv(real l, real w, real we, real lpe, real sDOTmult, real lend_rpoly_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*w)+((1-lpe)*(w*lend_rpoly_10hv+lend_rpoly_10hv*(we-w))))) ;
}

real p1p2_rpoly_10hv(real l, real w, real we, real lpe, real sDOTmult, real lend_rpoly_10hv) {
    return (sDOTmult*((l+(1-lpe)*(2*lend_rpoly_10hv+(2*we-w))))) ;
}

real a1a2_rhvpw_10hv(real l, real w, real we, real sDOTmult, real wext_rhvpw_10hv, real lend_nw_rhvpw_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*(we+2*wext_rhvpw_10hv))+(((((we+2*wext_rhvpw_10hv)*lend_nw_rhvpw_10hv)))))) ;
}

real p1p2_rhvpw_10hv(real l, real w, real we, real sDOTmult, real lend_nw_rhvpw_10hv, real wext_rhvpw_10hv) {
    return ((sDOTmult*(l+(2*lend_nw_rhvpw_10hv+(we+2*wext_rhvpw_10hv))))) ;
}

real a1a2_rphv_10hv(real l, real w, real we, real sDOTmult, real wext_rphv_10hv, real lend_nw_rphv_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*(we+2*wext_rphv_10hv))+(((((we+2*wext_rphv_10hv)*lend_nw_rphv_10hv)))))) ;
}

real p1p2_rphv_10hv(real l, real w, real we, real sDOTmult, real lend_nw_rphv_10hv, real wext_rphv_10hv) {
    return ((sDOTmult*(l+(2*lend_nw_rphv_10hv+(we+2*wext_rphv_10hv))))) ;
}

real a1a2_rpoly_1meg_10hv(real l, real w, real we, real lpe, real sDOTmult, real lend_rpoly_1meg_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*w)+((1-lpe)*(w*lend_rpoly_1meg_10hv+lend_rpoly_1meg_10hv*(we-w))))) ;
}

real p1p2_rpoly_1meg_10hv(real l, real w, real we, real lpe, real sDOTmult, real lend_rpoly_1meg_10hv) {
    return (sDOTmult*((l+(1-lpe)*(2*lend_rpoly_1meg_10hv+(2*we-w))))) ;
}

subckt rpoly0_10hv (d s well sub)

parameters
+    l                              = 0.96
+    w                              = 0.96
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly0_10hv_r3   = tmp_nsmm_delr_rsh_rpoly0_10hv_r3
+    we                             = (0.5*(wemin_rpoly0_10hv+w+sqrt((w-wemin_rpoly0_10hv)*(w-wemin_rpoly0_10hv))))
+    delr_rs_poly0_r3               = (nom_delr_rs_poly0_r3*(1.0+nsig_delr_rs_poly0_r3*sig_delr_rs_poly0_r3+nsmm_delr_rsh_rpoly0_10hv_r3*smm_delr_rpoly0_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_poly0_r3               = (nom_dela_dl_poly0_r3+nsig_dela_dl_poly0_r3*sig_dela_dl_poly0_r3)
+    dela_dw_poly0_r3               = (nom_dela_dw_poly0_r3+nsig_dela_dw_poly0_r3*sig_dela_dw_poly0_r3)
+    dela_dlw_poly0_r3              = (nom_dela_dlw_poly0_r3+nsig_dela_dlw_poly0_r3*sig_dela_dlw_poly0_r3)
+    a1_rpoly0_10hv                 = (a1a2_rpoly0_10hv(l,w,we,sDOTmult,lend_rpoly0_10hv,ldogbone2body_rpoly0_10hv))
+    p1_rpoly0_10hv                 = (p1p2_rpoly0_10hv(l,w,we,sDOTmult,lend_rpoly0_10hv))
+    a2_rpoly0_10hv                 = (a1a2_rpoly0_10hv(l,w,we,sDOTmult,lend_rpoly0_10hv,ldogbone2body_rpoly0_10hv))
+    p2_rpoly0_10hv                 = (p1p2_rpoly0_10hv(l,w,we,sDOTmult,lend_rpoly0_10hv))
+    ni                             = (np-1)
+    liso                           = (lr2iso_left_rpoly0_10hv+l+lr2iso_right_rpoly0_10hv)
+    wiso_i                         = (w*np+w_r2r_rpoly0_10hv*ni+wr2iso_np_rpoly0_10hv*2)
+    wiso                           = ((wiso_i)*(wiso_i>3)+3*(wiso_i<=3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    cn_rpoly0_10hv                 = (int((w-2*con_en_min_rpoly0_10hv+con_space_rpoly0_10hv)/(con_width_rpoly0_10hv+con_space_rpoly0_10hv)))
+    xw                             = (xw_poly0_r3+dela_dw_poly0_r3)
+    nwxw                           = (nwxw_poly0_r3)
+    xl                             = (xl_poly0_r3+dela_dl_poly0_r3)
+    xlw                            = (xlw_poly0_r3+dela_dlw_poly0_r3)
+    weff                           = (w+xw+nwxw/w)
+    leff                           = (l+xl+xlw/w)
+    wefflimit                      = log(1/(exp(-50)+exp(-1*weff)))
+    cpk_tcspread                   = (2.3)
+    dela_tc1_poly0_r3              = (0+(enable_res_tc_spread==1)*(nom_dela_tc1_poly0_r3+nsig_dela_tc1_poly0_r3*sig_dela_tc1_poly0_r3*cpk_tcspread))
+    dela_tc1la_poly0_r3            = (0+(enable_res_tc_spread==1)*(nom_dela_tc1la_poly0_r3+nsig_dela_tc1_poly0_r3*sig_dela_tc1la_poly0_r3*cpk_tcspread))
+    dela_tc1lb_poly0_r3            = (0+(enable_res_tc_spread==1)*(nom_dela_tc1lb_poly0_r3+nsig_dela_tc1_poly0_r3*sig_dela_tc1lb_poly0_r3*cpk_tcspread))
+    dela_tc1w_poly0_r3             = (0+(enable_res_tc_spread==1)*(nom_dela_tc1w_poly0_r3+nsig_dela_tc1_poly0_r3*sig_dela_tc1w_poly0_r3*cpk_tcspread))
+    dela_tc1area_poly0_r3          = (0+(enable_res_tc_spread==1)*(nom_dela_tc1area1_poly0_r3/(leff*weff+nom_dela_tc1area2_poly0_r3)+nsig_dela_tc1_poly0_r3*sig_dela_tc1area1_poly0_r3*cpk_tcspread/(leff*weff+sig_dela_tc1area2_poly0_r3)))
+    dela_tc1wlratio_poly0_r3       = (0+(enable_res_tc_spread==1)*((nom_dela_tc1wlratio_poly0_r3+nsig_dela_tc1_poly0_r3*sig_dela_tc1wlratio_poly0_r3*cpk_tcspread)*wefflimit/leff))
+    dela_tc2_poly0_r3              = (0+(enable_res_tc_spread==1)*(nom_dela_tc2_poly0_r3+nsig_dela_tc2_poly0_r3*sig_dela_tc2_poly0_r3*cpk_tcspread))
+    dela_tc2la_poly0_r3            = (0+(enable_res_tc_spread==1)*(nom_dela_tc2la_poly0_r3+nsig_dela_tc2_poly0_r3*sig_dela_tc2la_poly0_r3*cpk_tcspread))
+    dela_tc2lb_poly0_r3            = (0+(enable_res_tc_spread==1)*(nom_dela_tc2lb_poly0_r3+nsig_dela_tc2_poly0_r3*sig_dela_tc2lb_poly0_r3*cpk_tcspread))
+    dela_tc2w_poly0_r3             = (0+(enable_res_tc_spread==1)*(nom_dela_tc2w_poly0_r3+nsig_dela_tc2_poly0_r3*sig_dela_tc2w_poly0_r3*cpk_tcspread))
+    dela_tc2area_poly0_r3          = (0+(enable_res_tc_spread==1)*(nom_dela_tc2area1_poly0_r3/(leff*weff+nom_dela_tc2area2_poly0_r3)+nsig_dela_tc2_poly0_r3*sig_dela_tc2area1_poly0_r3*cpk_tcspread/(leff*weff-sig_dela_tc2area2_poly0_r3)))
+    dela_tc2wlratio_poly0_r3       = (0+(enable_res_tc_spread==1)*((nom_dela_tc2wlratio_poly0_r3+nsig_dela_tc2_poly0_r3*sig_dela_tc2wlratio_poly0_r3*cpk_tcspread)*wefflimit/leff))

model rpoly0_10hv r3
+ level    = (1003)
+ version  = (1)
+ shrink   = (0)
+ scale    = (1e-06)
+ type     = (-1)
+ tmin     = (-100)
+ tmax     = (900)
+ rthresh     = (0.001)
+ gmin     = (0)
+ imax     = (1)
+ tnom     = (27)
+ lmin     = (0)
+ lmax     = (9900000000)
+ wmin     = (0)
+ wmax     = (9900000000)
+ jmax     = (100)
+ vmax     = (9900000000)
+ tminclip = (-100)
+ tmaxclip = (900)
+ rsh      = (235.967880218066*delr_rs_poly0_r3)
+ xw       = (xw_poly0_r3+dela_dw_poly0_r3)
+ nwxw     = (nwxw_poly0_r3)
+ wexw     = (0)
+ fdrw     = (1)
+ fdxwinf  = (0)
+ xl       = (xl_poly0_r3+dela_dl_poly0_r3)
+ xlw      = (xlw_poly0_r3+dela_dlw_poly0_r3)
+ dxlsat   = (0)
+ nst      = (1)
+ ats      = (0)
+ dfinf    = (0.00799814)
+ dfw      = (-0.00256501)
+ dfl      = (-0.242154)
+ dfwl     = (0.145474)
+ sw_dfgeo = (1)
+ dp       = (max(0.1,999*(1.0+0/weff**1)*(1.0+0/leff**1)*(1.0+0/(weff**1*leff**1))))
+ ecrit    = (500)
+ ecorn    = (50)
+ du       = (0.001)
+ rc       = (5.3)
+ rcw      = (0)
+ fc       = (0.9)
+ isa      = (0)
+ na       = (1)
+ ca       = (cpp_ply0_fld)
+ cja      = (0)
+ pa       = (0.75)
+ ma       = (0.33)
+ aja      = (-0.5)
+ isp      = (0)
+ np       = (1)
+ cp       = (cfr_ply0_fld)
+ cjp      = (0)
+ pp       = (0.75)
+ mp       = (0.33)
+ ajp      = (-0.5)
+ vbv      = (0)
+ ibv      = (1e-06)
+ nbv      = (1)
+ kfn      = (8.5e-11)
+ afn      = (1.845)
+ bfn      = (0.895)
+ sw_fngeo = (0)
+ ea       = (1.12)
+ xis      = (3)
+ tc1      = (-1.17933513340083e-05+dela_tc1_poly0_r3+dela_tc1area_poly0_r3+dela_tc1wlratio_poly0_r3)
+ tc2      = (7.23302441531578e-07+dela_tc2_poly0_r3+dela_tc2area_poly0_r3+dela_tc2wlratio_poly0_r3)
+ tc1w     = (-0.000100476150787402+dela_tc1w_poly0_r3)
+ tc2w     = (1.09441641856104e-07+dela_tc2w_poly0_r3)
+ tc1l     = (-0.000234584584126402+dela_tc1la_poly0_r3+(8.77540472617905e-05+dela_tc1lb_poly0_r3)/weff)
+ tc2l     = (-2.04274277943378e-07+dela_tc2la_poly0_r3+(-2.08218097945929e-07+dela_tc2lb_poly0_r3)/weff)
+ tc1rc    = (0)
+ tc2rc    = (0)
+ tc1kfn   = (0)
+ tc1vbv   = (0)
+ tc2vbv   = (0)
+ tc1nbv   = (0)
+ gth0     = (4.49108e-07)
+ gthp     = (2.20701e-06)
+ gtha     = (2.18758e-07)
+ gthc     = (1.20176e-05)
+ cth0     = (4.49108e-07*1e-6)
+ cthp     = (2.20701e-06*1e-6)
+ ctha     = (2.18758e-07*1e-6)
+ cthc     = (1.20176e-05*1e-6)

zrpoly0_10hv (d well s) rpoly0_10hv l=(l) w=(w) a1=(a1_rpoly0_10hv) a2=(a2_rpoly0_10hv) p1=(p1_rpoly0_10hv) p2=(p2_rpoly0_10hv) c1=(cn_rpoly0_10hv) c2=(cn_rpoly0_10hv) m=(np)
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly0_10hv_dfrt
ends

subckt rpoly_10hv (d s well sub)

parameters
+    l                              = 1.5
+    w                              = 0.3
+    lpe                            = 0
+    np                             = 1
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly_10hv_r3    = tmp_nsmm_delr_rsh_rpoly_10hv_r3
+    we                             = (0.5*(wemin_rpoly_10hv+w+sqrt((w-wemin_rpoly_10hv)*(w-wemin_rpoly_10hv))))
+    delr_rs_poly_r3                = (nom_delr_rs_poly_r3*(1.0+nsig_delr_rs_poly_r3*sig_delr_rs_poly_r3+nsmm_delr_rsh_rpoly_10hv_r3*smm_delr_rpoly_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_poly_r3                = (nom_dela_dl_poly_r3+nsig_dela_dl_poly_r3*sig_dela_dl_poly_r3)
+    dela_dw_poly_r3                = (nom_dela_dw_poly_r3+nsig_dela_dw_poly_r3*sig_dela_dw_poly_r3)
+    ca_rpoly_10hv                  = (cpp_ply_fld)
+    cp_rpoly_10hv                  = (cfr_ply_fld)
+    a1_rpoly_10hv                  = (a1a2_rpoly_10hv(l,w,we,lpe,sDOTmult,lend_rpoly_10hv))
+    p1_rpoly_10hv                  = (p1p2_rpoly_10hv(l,w,we,lpe,sDOTmult,lend_rpoly_10hv))
+    cild_val                       = (a1_rpoly_10hv*ca_rpoly_10hv+p1_rpoly_10hv*cp_rpoly_10hv)
+    csddist                        = ((l*(w+2.0*(0.3+0.6))*cpp_m1_ply+2.0*l*cfr_m1_ply)/3.0)
+    ni                             = (np-1)
+    liso                           = (lr2iso_left_rpoly_10hv+l+lr2iso_right_rpoly_10hv)
+    wiso_i                         = (w*np+w_r2r_rpoly_10hv*ni+wr2iso_rpoly_10hv*(np==1)*2+wr2iso_np_rpoly_10hv*(np>1)*2)
+    wiso                           = ((wiso_i)*(wiso_i>3)+3*(wiso_i<=3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    cn_rpoly_10hv                  = (int((w-2*con_en_min_rpoly_10hv+con_space_rpoly_10hv)/(con_width_rpoly_10hv+con_space_rpoly_10hv)))
+    xw                             = (xw_poly_r3+dela_dw_poly_r3)
+    nwxw                           = (nwxw_poly_r3)
+    xl                             = (xl_poly_r3+dela_dl_poly_r3)
+    xlw                            = (xlw_poly_r3)
+    weff                           = (w+xw+nwxw/w)
+    leff                           = (l+xl+xlw/w)

model rpoly_10hv r3
+ level    = (1003)
+ version  = (1)
+ shrink   = (0)
+ scale    = (1e-06)
+ type     = (1)
+ tmin     = (-100)
+ tmax     = (900)
+ rthresh     = (0.001)
+ gmin     = (0)
+ imax     = (1)
+ tnom     = (27)
+ lmin     = (0)
+ lmax     = (9900000000)
+ wmin     = (0)
+ wmax     = (9900000000)
+ jmax     = (100)
+ vmax     = (9900000000)
+ tminclip = (-100)
+ tmaxclip = (900)
+ rsh      = (4400.22916001516*delr_rs_poly_r3)
+ xw       = (xw_poly_r3+dela_dw_poly_r3)
+ nwxw     = (nwxw_poly_r3)
+ wexw     = (0)
+ fdrw     = (1)
+ fdxwinf  = (0)
+ xl       = (xl_poly_r3+dela_dl_poly_r3)
+ xlw      = (xlw_poly_r3)
+ dxlsat   = (0)
+ nst      = (1)
+ ats      = (0)
+ dfinf    = (0.00966142)
+ dfw      = (0.00201341)
+ dfl      = (-6.05595e-05)
+ dfwl     = (2.8834e-06)
+ sw_dfgeo = (1)
+ dp       = (max(0.1,999*(1.0+0/weff**1)*(1.0+0/leff**1)*(1.0+0/(weff**1*leff**1))))
+ ecrit    = (500)
+ ecorn    = (50)
+ du       = (0.001)
+ rc       = (5.7)
+ rcw      = (0)
+ fc       = (0.9)
+ isa      = (0)
+ na       = (1)
+ ca       = (cpp_ply_fld)
+ cja      = (0)
+ pa       = (0.75)
+ ma       = (0.33)
+ aja      = (-0.5)
+ isp      = (0)
+ np       = (1)
+ cp       = (cfr_ply_fld)
+ cjp      = (0)
+ pp       = (0.75)
+ mp       = (0.33)
+ ajp      = (-0.5)
+ vbv      = (0)
+ ibv      = (1e-06)
+ nbv      = (1)
+ kfn      = (1.350e-9)
+ afn      = (1.920)
+ bfn      = (1.019)
+ sw_fngeo = (0)
+ ea       = (1.12)
+ xis      = (3)
+ tc1      = (-0.00220419964145861)
+ tc2      = (5.14250250822309e-06)
+ tc1w     = (-5.12935557538371e-05)
+ tc2w     = (1.50634353994326e-07)
+ tc1l     = (6.76169982169713e-05-3.31627466855461e-05/weff)
+ tc2l     = (-1.79260358710712e-07+1.06647113936975e-07/weff)
+ tc1rc    = (0)
+ tc2rc    = (0)
+ tc1kfn   = (0)
+ tc1vbv   = (0)
+ tc2vbv   = (0)
+ tc1nbv   = (0)
+ gth0     = (1e-07)
+ gthp     = (1.33967e-06)
+ gtha     = (1.8772e-06)
+ gthc     = (1.00437e-06)
+ cth0     = (1e-07*1e-6)
+ cthp     = (1.33967e-06*1e-6)
+ ctha     = (1.8772e-06*1e-6)
+ cthc     = (1.00437e-06*1e-6)

esic (si well s well) vcvs gain=(1.0)
edic (di well d well) vcvs gain=(1.0)
ascale (d s di dx) shieldscale
+ l=(l)
+ w=(w)
+ type=(1)
+ vc1inf=(-0.00040981)
+ vc1w=(-0.000219926)
+ vc1l=(0.000100415)
+ vc1wl=(0.000191675)
zrpoly_10hv (dx well si) rpoly_10hv l=(l) w=(w) a1=(0.0) a2=(0.0) p1=(0.0) p2=(0.0) c1=(cn_rpoly_10hv) c2=(cn_rpoly_10hv) m=(np)
cdw (d well) capacitor c=(cild_val) m=(np)
csw (s well) capacitor c=(cild_val) m=(np)
csd (s d) capacitor c=(csddist) m=(np)
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly_10hv_dfrt
ends

subckt rhvpw_10hv (d s nw sub)

parameters
+    l                              = 1.2
+    w                              = 1.2
+    lpe                            = 0
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_rsh_rhvpw_10hv_r3    = tmp_nsmm_delr_rsh_rhvpw_10hv_r3
+    ring                           = (1)
+    we                             = (0.5*(wemin_rhvpw_10hv+w+sqrt((w-wemin_rhvpw_10hv)*(w-wemin_rhvpw_10hv))))
+    delr_rs_hvpw_nbl_r3            = (nom_delr_rs_hvpw_nbl_r3*(1.0+nsig_delr_rs_hvpw_nbl_r3*sig_delr_rs_hvpw_nbl_r3+nsmm_delr_rsh_rhvpw_10hv_r3*smm_delr_rhvpw_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_hvpw_nbl_r3            = (nom_dela_dl_hvpw_nbl_r3+nsig_dela_dl_hvpw_nbl_r3*sig_dela_dl_hvpw_nbl_r3)
+    dela_dw_hvpw_nbl_r3            = (nom_dela_dw_hvpw_nbl_r3+nsig_dela_dw_hvpw_nbl_r3*sig_dela_dw_hvpw_nbl_r3)
+    a1_rhvpw_10hv                  = (a1a2_rhvpw_10hv(l,w,we,sDOTmult,wext_rhvpw_10hv,lend_nw_rhvpw_10hv))
+    p1_rhvpw_10hv                  = (p1p2_rhvpw_10hv(l,w,we,sDOTmult,lend_nw_rhvpw_10hv,wext_rhvpw_10hv))
+    a2_rhvpw_10hv                  = (a1a2_rhvpw_10hv(l,w,we,sDOTmult,wext_rhvpw_10hv,lend_nw_rhvpw_10hv))
+    p2_rhvpw_10hv                  = (p1p2_rhvpw_10hv(l,w,we,sDOTmult,lend_nw_rhvpw_10hv,wext_rhvpw_10hv))
+    csddist                        = ((l*(w+2.0*(0.3+0.6))*cpp_m1_sd+2.0*l*cfr_m1_sd)/3.0)
+    ni                             = (np-1)
+    liso                           = ((np==1)*lr2iso_left_rhvpw_10hv+(np>1)*lr2iso_left_np_rhvpw_10hv+l+lr2iso_right_rhvpw_10hv)
+    wiso_i                         = (w*np+w_r2r_rhvpw_10hv*ni+wr2iso_rhvpw_10hv*2)
+    wiso                           = (w*np+w_r2r_rhvpw_10hv*ni+wr2iso_rhvpw_10hv*2)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    cn_rhvpw_10hv                  = (int((w-2*con_en_min_rhvpw_10hv+con_space_rhvpw_10hv)/(con_width_rhvpw_10hv+con_space_rhvpw_10hv)))
+    xw                             = (xw_hvpw_nbl_r3+dela_dw_hvpw_nbl_r3)
+    nwxw                           = (nwxw_hvpw_nbl_r3)
+    xl                             = (xl_hvpw_nbl_r3+dela_dl_hvpw_nbl_r3)
+    xlw                            = (xlw_hvpw_nbl_r3)
+    weff                           = (w+xw+nwxw/w)
+    leff                           = (l+xl+xlw/w)
+    aphi_tnom                      = (aphi_junc_pepi_nbl)
+    aphi_t                         = (aphi_tnom-pta_junc_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    pphi_tnom                      = (pphi_junc_pepi_nbl)
+    pphi_t                         = (pphi_tnom-ptp_junc_pepi_nbl*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)

model rhvpw_10hv r3
+ level    = (1003)
+ version  = (1)
+ shrink   = (0)
+ scale    = (1e-06)
+ type     = (1)
+ tmin     = (-100)
+ tmax     = (900)
+ rthresh     = (0.001)
+ gmin     = (0)
+ imax     = (1)
+ tnom     = (27)
+ lmin     = (0)
+ lmax     = (9900000000)
+ wmin     = (0)
+ wmax     = (9900000000)
+ jmax     = (100)
+ vmax     = (9900000000)
+ tminclip = (-100)
+ tmaxclip = (900)
+ rsh      = (2834.37097079732*delr_rs_hvpw_nbl_r3)
+ xw       = (xw_hvpw_nbl_r3+dela_dw_hvpw_nbl_r3)
+ nwxw     = (nwxw_hvpw_nbl_r3)
+ wexw     = (0)
+ fdrw     = (1)
+ fdxwinf  = (0)
+ xl       = (xl_hvpw_nbl_r3+dela_dl_hvpw_nbl_r3)
+ xlw      = (xlw_hvpw_nbl_r3)
+ dxlsat   = (0.309564)
+ nst      = (1)
+ ats      = (0)
+ dfinf    = (0.0340738)
+ dfw      = (0.073775)
+ dfl      = (0.0109919)
+ dfwl     = (-0.0506166)
+ sw_dfgeo = (1)
+ dp       = (max(0.1,9.8*(1.0-0.635509/weff**0.712506)*(1.0-0.104221/leff**1.43638)*(1.0+19.6779/(weff**0.712506*leff**1.43638))))
+ ecrit    = (3.91093)
+ ecorn    = (0.198453)
+ du       = (0.01)
+ rc       = (8.2)
+ rcw      = (0)
+ fc       = (0.9)
+ isa      = (0)
+ na       = (1)
+ ca       = (0)
+ cja      = (0)
+ pa       = (0.75)
+ ma       = (0.33)
+ aja      = (-0.5)
+ isp      = (0)
+ np       = (1)
+ cp       = (0)
+ cjp      = (0)
+ pp       = (0.75)
+ mp       = (0.33)
+ ajp      = (-0.5)
+ vbv      = (0)
+ ibv      = (1e-06)
+ nbv      = (1)
+ kfn      = (1.110e-8/(1+85.0/(w*l+3))*(1+24.0/(w-0.6)))
+ afn      = (2.808/(1+0.075/l))
+ bfn      = (0.9845)
+ sw_fngeo = (0)
+ ea       = (1.12)
+ xis      = (3)
+ tc1      = (0.0055279312401152)
+ tc2      = (8.52679109098909e-06)
+ tc1w     = (-0.000260296580885473)
+ tc2w     = (-2.23168095469087e-06)
+ tc1l     = (-0.000254521323504127-0.000622071101824284/weff)
+ tc2l     = (5.50084934989864e-07+4.29125605520816e-07/weff)
+ tc1rc    = (0)
+ tc2rc    = (0)
+ tc1kfn   = (0)
+ tc1vbv   = (0)
+ tc2vbv   = (0)
+ tc1nbv   = (0)
+ gth0     = (1e-06)
+ gthp     = (3.15534e-05)
+ gtha     = (1.17203e-06)
+ gthc     = (0)
+ cth0     = (1e-06*1e-6)
+ cthp     = (3.15534e-05*1e-6)
+ ctha     = (1.17203e-06*1e-6)
+ cthc     = (0*1e-6)

model areadiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((ajs_junc_pepi_nbl))*1.0e12)
+ n             = (ajnd_junc_pepi_nbl)
+ cj            = ((((acj0_junc_pepi_nbl)*(aphi_tf**aexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

model perimdiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((pjs_junc_pepi_nbl))*1.0e12)
+ n             = (pjnd_junc_pepi_nbl)
+ cj            = ((((pcj0_junc_pepi_nbl)*(pphi_tf**pexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

esic (si nw s nw) vcvs gain=(1.0)
edic (di nw d nw) vcvs gain=(1.0)
ascale (d s di dx) shieldscale
+ l=(l)
+ w=(w)
+ type=(1)
+ vc1inf=(-0.00285538299509717)
+ vc1w=(-0.00195142195465318)
+ vc1l=(0.000115462405566009)
+ vc1wl=(0.00083303296867281)
csd (s d) capacitor c=(csddist) m=(np)
zrhvpw_10hv (dx nw si) rhvpw_10hv l=(l) w=(w) a1=(0.0) a2=(0.0) p1=(0.0) p2=(0.0) c1=(cn_rhvpw_10hv) c2=(cn_rhvpw_10hv) m=(np)
dda (d nw) areadiode area=(a1_rhvpw_10hv) m=(np)
ddp (d nw) perimdiode area=(p1_rhvpw_10hv) m=(np)
dsa (s nw) areadiode area=(a2_rhvpw_10hv) m=(np)
dsp (s nw) perimdiode area=(p2_rhvpw_10hv) m=(np)
xcdgoptub_sub (nw sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rhvpw_10hv_dfrt
ends

subckt rphv_10hv (d s nw sub)

parameters
+    l                              = 1.2
+    w                              = 1.2
+    lpe                            = 0
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_rsh_rphv_10hv_r3     = tmp_nsmm_delr_rsh_rphv_10hv_r3
+    ring                           = (1)
+    we                             = (0.5*(wemin_rphv_10hv+w+sqrt((w-wemin_rphv_10hv)*(w-wemin_rphv_10hv))))
+    delr_rs_phv_nbl_r3             = (nom_delr_rs_phv_nbl_r3*(1.0+nsig_delr_rs_phv_nbl_r3*sig_delr_rs_phv_nbl_r3+nsmm_delr_rsh_rphv_10hv_r3*smm_delr_rphv_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_phv_nbl_r3             = (nom_dela_dl_phv_nbl_r3+nsig_dela_dl_phv_nbl_r3*sig_dela_dl_phv_nbl_r3)
+    dela_dw_phv_nbl_r3             = (nom_dela_dw_phv_nbl_r3+nsig_dela_dw_phv_nbl_r3*sig_dela_dw_phv_nbl_r3)
+    a1_rphv_10hv                   = (a1a2_rphv_10hv(l,w,we,sDOTmult,wext_rphv_10hv,lend_nw_rphv_10hv))
+    p1_rphv_10hv                   = (p1p2_rphv_10hv(l,w,we,sDOTmult,lend_nw_rphv_10hv,wext_rphv_10hv))
+    a2_rphv_10hv                   = (a1a2_rphv_10hv(l,w,we,sDOTmult,wext_rphv_10hv,lend_nw_rphv_10hv))
+    p2_rphv_10hv                   = (p1p2_rphv_10hv(l,w,we,sDOTmult,lend_nw_rphv_10hv,wext_rphv_10hv))
+    csddist                        = ((l*(w+2.0*(0.3+0.6))*cpp_m1_sd+2.0*l*cfr_m1_sd)/3.0)
+    ni                             = (np-1)
+    liso                           = ((np==1)*lr2iso_left_rphv_10hv+(np>1)*lr2iso_left_np_rphv_10hv+l+lr2iso_right_rphv_10hv)
+    wiso_i                         = (w*np+w_r2r_rphv_10hv*ni+wr2iso_rphv_10hv*2)
+    wiso                           = (w*np+w_r2r_rphv_10hv*ni+wr2iso_rphv_10hv*2)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    cn_rphv_10hv                   = (int((w-2*con_en_min_rphv_10hv+con_space_rphv_10hv)/(con_width_rphv_10hv+con_space_rphv_10hv)))
+    xw                             = (xw_phv_nbl_r3+dela_dw_phv_nbl_r3)
+    nwxw                           = (nwxw_phv_nbl_r3)
+    xl                             = (xl_phv_nbl_r3+dela_dl_phv_nbl_r3)
+    xlw                            = (xlw_phv_nbl_r3)
+    weff                           = (w+xw+nwxw/w)
+    leff                           = (l+xl+xlw/w)
+    aphi_tnom                      = (aphi_junc_pepi_nbl)
+    aphi_t                         = (aphi_tnom-pta_junc_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    pphi_tnom                      = (pphi_junc_pepi_nbl)
+    pphi_t                         = (pphi_tnom-ptp_junc_pepi_nbl*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    afn_f                          = (1.989*(1+2.0/(w*l+1.2)))
+    jref                           = 3.0e-4//a/um

model rphv_10hv r3
+ level    = (1003)
+ version  = (1)
+ shrink   = (0)
+ scale    = (1e-06)
+ type     = (1)
+ tmin     = (-100)
+ tmax     = (900)
+ rthresh     = (0.001)
+ gmin     = (0)
+ imax     = (1)
+ tnom     = (27)
+ lmin     = (0)
+ lmax     = (9900000000)
+ wmin     = (0)
+ wmax     = (9900000000)
+ jmax     = (100)
+ vmax     = (9900000000)
+ tminclip = (-100)
+ tmaxclip = (900)
+ rsh      = (672.050276102161*delr_rs_phv_nbl_r3)
+ xw       = (xw_phv_nbl_r3+dela_dw_phv_nbl_r3)
+ nwxw     = (nwxw_phv_nbl_r3)
+ wexw     = (0)
+ fdrw     = (1)
+ fdxwinf  = (0)
+ xl       = (xl_phv_nbl_r3+dela_dl_phv_nbl_r3)
+ xlw      = (xlw_phv_nbl_r3)
+ dxlsat   = (1)
+ nst      = (1)
+ ats      = (0)
+ dfinf    = (0.00570068)
+ dfw      = (0.0227775)
+ dfl      = (-0.00829114)
+ dfwl     = (-0.00420771)
+ sw_dfgeo = (1)
+ dp       = (max(0.1,3.29162*(1.0+0.244566/weff**1.74277)*(1.0-66.005/leff**1.09827)*(1.0-9.19984/(weff**1.74277*leff**1.09827))))
+ ecrit    = (353.594)
+ ecorn    = (2)
+ du       = (1.2)
+ rc       = (8.2)
+ rcw      = (0)
+ fc       = (0.9)
+ isa      = (0)
+ na       = (1)
+ ca       = (0)
+ cja      = (0)
+ pa       = (0.75)
+ ma       = (0.33)
+ aja      = (-0.5)
+ isp      = (0)
+ np       = (1)
+ cp       = (0)
+ cjp      = (0)
+ pp       = (0.75)
+ mp       = (0.33)
+ ajp      = (-0.5)
+ vbv      = (0)
+ ibv      = (1e-06)
+ nbv      = (1)
+ kfn      = (1.0e-18/(jref**afn_f)/(1+20/(w+2.0))*(1+2/w/l))
+ afn      = (1.989*(1+2.0/(w*l+1.2)))
+ bfn      = (1.0857)
+ sw_fngeo = (0)
+ ea       = (1.12)
+ xis      = (3)
+ tc1      = (0.00338757730568491)
+ tc2      = (5.77571957516523e-06)
+ tc1w     = (-2.57728694819426e-05)
+ tc2w     = (-3.02209511768129e-07)
+ tc1l     = (-5.83461613263245e-05-0.00248355078830866/weff)
+ tc2l     = (1.10929929114716e-06-2.0461873508285e-06/weff)
+ tc1rc    = (0)
+ tc2rc    = (0)
+ tc1kfn   = (0)
+ tc1vbv   = (0)
+ tc2vbv   = (0)
+ tc1nbv   = (0)
+ gth0     = (1e-06)
+ gthp     = (2.2869e-05)
+ gtha     = (1.58333e-06)
+ gthc     = (0)
+ cth0     = (1e-06*1e-6)
+ cthp     = (2.2869e-05*1e-6)
+ ctha     = (1.58333e-06*1e-6)
+ cthc     = (0*1e-6)

model areadiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((ajs_junc_pepi_nbl))*1.0e12)
+ n             = (ajnd_junc_pepi_nbl)
+ cj            = ((((acj0_junc_pepi_nbl)*(aphi_tf**aexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

model perimdiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((pjs_junc_pepi_nbl))*1.0e12)
+ n             = (pjnd_junc_pepi_nbl)
+ cj            = ((((pcj0_junc_pepi_nbl)*(pphi_tf**pexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

esic (si nw s nw) vcvs gain=(1.0)
edic (di nw d nw) vcvs gain=(1.0)
ascale (d s di dx) shieldscale
+ l=(l)
+ w=(w)
+ type=(1)
+ vc1inf=(-0.000562917)
+ vc1w=(0.000532846)
+ vc1l=(-0.00276728)
+ vc1wl=(-0.0160256)
zrphv_10hv (dx nw si) rphv_10hv l=(l) w=(w) a1=(0.0) a2=(0.0) p1=(0.0) p2=(0.0) c1=(cn_rphv_10hv) c2=(cn_rphv_10hv) m=(np)
dda (d nw) areadiode area=(a1_rphv_10hv) m=(np)
ddp (d nw) perimdiode area=(p1_rphv_10hv) m=(np)
dsa (s nw) areadiode area=(a2_rphv_10hv) m=(np)
dsp (s nw) perimdiode area=(p2_rphv_10hv) m=(np)
csd (s d) capacitor c=(csddist) m=(np)
xcdgoptub_sub (nw sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rphv_10hv_dfrt
ends

subckt antifuse_t_10hv (wr s sub)

parameters
+    blown                          = 0
+    ring                           = 0
+    soa                            = 1
+    ron1min                        = (1000)
+    roff1min                       = (0.25e+13)
+    ron1_calc                      = (nom_on_antifuse_t+(nsig_on_antifuse_t)*(sig_on_antifuse_t))
+    roff1_calc                     = (nom_off_antifuse_t+(nsig_off_antifuse_t)*(sig_off_antifuse_t))
+    ron1                           = (maxmodels(ron1min,ron1_calc))
+    roff1                          = (maxmodels(roff1min,roff1_calc))
+    w_well                         = (4.155)
+    l_well                         = (3)
+    apepisub                       = (w_well*l_well)
+    ppepisub                       = (2*(w_well+l_well))

aantifuse_t_10hv (wr s) antifuse_t_vla
+ blownid=(blown)
+ gcold=(1/ron1)
+ ginitial=(1/roff1)
xcsub_antifuse_t_10hv (s sub) cnwtub_box_sub_10hv area=(ring*apepisub+0.001) perim=(ring*ppepisub+0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=antifuse_t_10hv_dfrt
ends

subckt antifuse_10hv (wr s sub)

parameters
+    blown                          = 0
+    ring                           = 0
+    soa                            = 1
+    l                              = (0.18)
+    w                              = (0.21)
+    delr_cpp_ply_fld               = (nom_delr_cpp_ply_fld*(1.0+nsig_delr_cpp_ply_fld*sig_delr_cpp_ply_fld))
+    delr_cfr_ply_fld               = (nom_delr_cfr_ply_fld*(1.0+nsig_delr_cfr_ply_fld*sig_delr_cfr_ply_fld))
+    ca_fld                         = (nom_cpp_ply_fld*delr_cpp_ply_fld)
+    cp_fld                         = (nom_cfr_ply_fld*delr_cfr_ply_fld)
+    delr_cpp_ply_sd                = (nom_delr_cpp_ply_sd*(1.0+nsig_delr_cpp_ply_sd*sig_delr_cpp_ply_sd))
+    delr_cfr_ply_sd                = (nom_delr_cfr_ply_sd*(1.0+nsig_delr_cfr_ply_sd*sig_delr_cfr_ply_sd))
+    ca_sd                          = (nom_cpp_ply_sd*delr_cpp_ply_sd)
+    cp_sd                          = (nom_cfr_ply_sd*delr_cfr_ply_sd)
+    arm_area                       = ((0.63*0.585-0.21*0.18)*sDOTmult*sDOTmult)
+    arm_perim                      = ((2*(0.63+0.585)-0.18)*sDOTmult)
+    val_tag_fld                    = (ca_fld*arm_area+cp_fld*arm_perim)
+    cap_area                       = (l*sDOTmult*w*sDOTmult)
+    cap_perim                      = (w*sDOTmult)
+    cap_total                      = (ca_sd*cap_area+cp_sd*cap_perim)
+    w_well                         = (4.155)
+    l_well                         = (3)
+    apepisub                       = (w_well*l_well)
+    ppepisub                       = (2*(w_well+l_well))

cpara (wr s) capacitor c=(val_tag_fld)
cantifuse_10hv (wr s) capacitor c=cap_total
xcsub_antifuse_10hv (s sub) cnwtub_box_sub_10hv area=(ring*apepisub+0.001) perim=(ring*ppepisub+0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=antifuse_10hv_dfrt
ends

subckt vms_15_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_15_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_15_10hv_dfrt
ends

subckt vms_30_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_30_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_30_10hv_dfrt
ends

subckt vms_45_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_45_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_45_10hv_dfrt
ends

subckt vms_60_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_60_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_60_10hv_dfrt
ends

subckt vms_105_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_105_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_105_10hv_dfrt
ends

subckt vms_115_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_115_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_115_10hv_dfrt
ends

subckt vms_165_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_165_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_165_10hv_dfrt
ends

subckt rpoly_1meg_10hv (d s well sub)

parameters
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly_1meg_10hv_r3 = tmp_nsmm_delr_rsh_rpoly_1meg_10hv_r3
+    l                              = (25)
+    w                              = (0.15)
+    we                             = (0.5*(wemin_rpoly_1meg_10hv+w+sqrt((w-wemin_rpoly_1meg_10hv)*(w-wemin_rpoly_1meg_10hv))))
+    delr_rs_poly_1meg_r3           = (nom_delr_rs_poly_1meg_r3*(1.0+nsig_delr_rs_poly_1meg_r3*sig_delr_rs_poly_1meg_r3+nsmm_delr_rsh_rpoly_1meg_10hv_r3*smm_delr_rpoly_1meg_10hv_r3(l,w)/sqrt(1)))
+    dela_dl_poly_1meg_r3           = (0)
+    dela_dw_poly_1meg_r3           = (0)
+    ca_rpoly_1meg_10hv             = (cpp_ply_fld)
+    cp_rpoly_1meg_10hv             = (cfr_ply_fld)
+    a1_rpoly_1meg_10hv             = (a1a2_rpoly_1meg_10hv(l,w,we,lpe,sDOTmult,lend_rpoly_1meg_10hv))
+    p1_rpoly_1meg_10hv             = (p1p2_rpoly_1meg_10hv(l,w,we,lpe,sDOTmult,lend_rpoly_1meg_10hv))
+    cild_val                       = (a1_rpoly_1meg_10hv*ca_rpoly_1meg_10hv+p1_rpoly_1meg_10hv*cp_rpoly_1meg_10hv)
+    csddist                        = ((l*(w+2.0*(0.3+0.6))*cpp_m1_ply+2.0*l*cfr_m1_ply)/3.0)
+    liso                           = (liso_rpoly_1meg_10hv)
+    wiso                           = (wiso_rpoly_1meg_10hv)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    cn_rpoly_1meg_10hv             = (1)
+    xw                             = (xw_poly_1meg_r3+dela_dw_poly_1meg_r3)
+    nwxw                           = (nwxw_poly_1meg_r3)
+    xl                             = (xl_poly_1meg_r3+dela_dl_poly_1meg_r3)
+    xlw                            = (xlw_poly_1meg_r3)
+    weff                           = (w+xw+nwxw/w)
+    leff                           = (l+xl+xlw/w)

model rpoly_1meg_10hv r3
+ level    = (1003)
+ version  = (1)
+ shrink   = (0)
+ scale    = (1e-06)
+ type     = (1)
+ tmin     = (-100)
+ tmax     = (900)
+ rthresh     = (0.001)
+ gmin     = (0)
+ imax     = (1)
+ tnom     = (27)
+ lmin     = (0)
+ lmax     = (9900000000)
+ wmin     = (0)
+ wmax     = (9900000000)
+ jmax     = (100)
+ vmax     = (9900000000)
+ tminclip = (-100)
+ tmaxclip = (900)
+ rsh      = (6750.37508806862*delr_rs_poly_1meg_r3)
+ xw       = (xw_poly_1meg_r3+dela_dw_poly_1meg_r3)
+ nwxw     = (nwxw_poly_1meg_r3)
+ wexw     = (0)
+ fdrw     = (1)
+ fdxwinf  = (0)
+ xl       = (xl_poly_1meg_r3+dela_dl_poly_1meg_r3)
+ xlw      = (xlw_poly_1meg_r3)
+ dxlsat   = (0)
+ nst      = (1)
+ ats      = (0)
+ dfinf    = (0.0208097)
+ dfw      = (0)
+ dfl      = (0)
+ dfwl     = (0)
+ sw_dfgeo = (1)
+ dp       = (max(0.1,999*(1.0+0/weff**1)*(1.0+0/leff**1)*(1.0+0/(weff**1*leff**1))))
+ ecrit    = (500)
+ ecorn    = (50)
+ du       = (0.001)
+ rc       = (5.7)
+ rcw      = (0)
+ fc       = (0.9)
+ isa      = (0)
+ na       = (1)
+ ca       = (cpp_ply_fld)
+ cja      = (0)
+ pa       = (0.75)
+ ma       = (0.33)
+ aja      = (-0.5)
+ isp      = (0)
+ np       = (1)
+ cp       = (cfr_ply_fld)
+ cjp      = (0)
+ pp       = (0.75)
+ mp       = (0.33)
+ ajp      = (-0.5)
+ vbv      = (0)
+ ibv      = (1e-06)
+ nbv      = (1)
+ kfn      = (kf_poly_1meg)
+ afn      = (af_poly_1meg)
+ bfn      = (fexp_poly_1meg)
+ sw_fngeo = (0)
+ ea       = (1.12)
+ xis      = (3)
+ tc1      = (-0.00270656138368973)
+ tc2      = (6.67739801825248e-06)
+ tc1w     = (0)
+ tc2w     = (0)
+ tc1l     = (0+0/weff)
+ tc2l     = (0+0/weff)
+ tc1rc    = (0)
+ tc2rc    = (0)
+ tc1kfn   = (0)
+ tc1vbv   = (0)
+ tc2vbv   = (0)
+ tc1nbv   = (0)
+ gth0     = (2e-07)
+ gthp     = (0)
+ gtha     = (6.86398e-06)
+ gthc     = (0)
+ cth0     = (2e-07*1e-6)
+ cthp     = (0*1e-6)
+ ctha     = (6.86398e-06*1e-6)
+ cthc     = (0*1e-6)

esic (si well s well) vcvs gain=(1.0)
edic (di well d well) vcvs gain=(1.0)
ascale (d s di dx) shieldscale
+ l=(l)
+ w=(w)
+ type=(1)
+ vc1inf=(-0.00162013)
+ vc1w=(0)
+ vc1l=(0)
+ vc1wl=(0)
zrpoly_1meg_10hv (dx well si) rpoly_1meg_10hv l=(l) w=(w) a1=(0) a2=(0) p1=(0) p2=(0) c1=(cn_rpoly_1meg_10hv) c2=(cn_rpoly_1meg_10hv)
cdw (d well) capacitor c=cild_val
csw (s well) capacitor c=cild_val
csd (s d) capacitor c=(csddist)
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly_1meg_10hv_dfrt
ends

subckt rm1_10hv (d s)

parameters
+    l                              = 0.18
+    w                              = 0.18
+    soa                            = 1
+    nsmm_delr_rsh_rm1_10hv         = tmp_nsmm_delr_rsh_rm1_10hv
+    factor_m1                      = (1.0+nsig_delr_rs_m1*sig_delr_rs_m1+nsmm_delr_rsh_rm1_10hv*smm_delr_rm1_10hv(l,w))
+    delr_rs_m1                     = (nom_delr_rs_m1*maxmodels(1e-06,factor_m1))
+    dela_dl_m1                     = (nom_dela_dl_m1+nsig_dela_dl_m1*sig_dela_dl_m1)
+    dela_dw_m1                     = (nom_dela_dw_m1+nsig_dela_dw_m1*sig_dela_dw_m1)
+    dl_m1                          = (nom_dl_m1+dela_dl_m1+1e-09)
+    dw_m1                          = (nom_dw_m1+dela_dw_m1+1e-09)
+    dw_um                          = (dw_m1+(0)+(0.00377915)/(w*sDOTmult+1e-09))

model rm1_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m1*delr_rs_m1)
+ etchl = (-0.50e-06*(dl_m1))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m1)
+ tc2   = (tcr2_m1)

rrm1_10hv (d s) rm1_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm1_10hv_dfrt
ends

subckt rm2_10hv (d s)

parameters
+    l                              = 0.18
+    w                              = 0.18
+    soa                            = 1
+    nsmm_delr_rsh_rm2_10hv         = tmp_nsmm_delr_rsh_rm2_10hv
+    factor_m2                      = (1.0+nsig_delr_rs_m2*sig_delr_rs_m2+nsmm_delr_rsh_rm2_10hv*smm_delr_rm2_10hv(l,w))
+    delr_rs_m2                     = (nom_delr_rs_m2*maxmodels(1e-06,factor_m2))
+    dela_dl_m2                     = (nom_dela_dl_m2+nsig_dela_dl_m2*sig_dela_dl_m2)
+    dela_dw_m2                     = (nom_dela_dw_m2+nsig_dela_dw_m2*sig_dela_dw_m2)
+    dl_m2                          = (nom_dl_m2+dela_dl_m2+1e-09)
+    dw_m2                          = (nom_dw_m2+dela_dw_m2+1e-09)
+    dw_um                          = (dw_m2+(0)+(0.000828035)/(w*sDOTmult+1e-09))

model rm2_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m2*delr_rs_m2)
+ etchl = (-0.50e-06*(dl_m2))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m2)
+ tc2   = (tcr2_m2)

rrm2_10hv (d s) rm2_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm2_10hv_dfrt
ends

subckt rm3_10hv (d s)

parameters
+    l                              = 0.21
+    w                              = 0.21
+    soa                            = 1
+    nsmm_delr_rsh_rm3_10hv         = tmp_nsmm_delr_rsh_rm3_10hv
+    factor_m3                      = (1.0+nsig_delr_rs_m3*sig_delr_rs_m3+nsmm_delr_rsh_rm3_10hv*smm_delr_rm3_10hv(l,w))
+    delr_rs_m3                     = (nom_delr_rs_m3*maxmodels(1e-06,factor_m3))
+    dela_dl_m3                     = (nom_dela_dl_m3+nsig_dela_dl_m3*sig_dela_dl_m3)
+    dela_dw_m3                     = (nom_dela_dw_m3+nsig_dela_dw_m3*sig_dela_dw_m3)
+    dl_m3                          = (nom_dl_m3+dela_dl_m3+1e-09)
+    dw_m3                          = (nom_dw_m3+dela_dw_m3+1e-09)
+    dw_um                          = (dw_m3+(0)+(0.0168)/(w*sDOTmult+1e-09))

model rm3_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m3*delr_rs_m3)
+ etchl = (-0.50e-06*(dl_m3))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m3)
+ tc2   = (tcr2_m3)

rrm3_10hv (d s) rm3_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm3_10hv_dfrt
ends

subckt rm4_10hv (d s)

parameters
+    l                              = 0.21
+    w                              = 0.21
+    soa                            = 1
+    nsmm_delr_rsh_rm4_10hv         = tmp_nsmm_delr_rsh_rm4_10hv
+    factor_m4                      = (1.0+nsig_delr_rs_m4*sig_delr_rs_m4+nsmm_delr_rsh_rm4_10hv*smm_delr_rm4_10hv(l,w))
+    delr_rs_m4                     = (nom_delr_rs_m4*maxmodels(1e-06,factor_m4))
+    dela_dl_m4                     = (nom_dela_dl_m4+nsig_dela_dl_m4*sig_dela_dl_m4)
+    dela_dw_m4                     = (nom_dela_dw_m4+nsig_dela_dw_m4*sig_dela_dw_m4)
+    dl_m4                          = (nom_dl_m4+dela_dl_m4+1e-09)
+    dw_m4                          = (nom_dw_m4+dela_dw_m4+1e-09)
+    dw_um                          = (dw_m4+(0)+(0.0252)/(w*sDOTmult+1e-09))

model rm4_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m4*delr_rs_m4)
+ etchl = (-0.50e-06*(dl_m4))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m4)
+ tc2   = (tcr2_m4)

rrm4_10hv (d s) rm4_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm4_10hv_dfrt
ends

subckt ralcap_10hv (d s)

parameters
+    l                              = 3
+    w                              = 3
+    soa                            = 1
+    nsmm_delr_rsh_ralcap_10hv      = tmp_nsmm_delr_rsh_ralcap_10hv
+    factor_alcap                   = (1.0+nsig_delr_rs_alcap*sig_delr_rs_alcap+nsmm_delr_rsh_ralcap_10hv*smm_delr_ralcap_10hv(l,w))
+    delr_rs_alcap                  = (nom_delr_rs_alcap*maxmodels(1e-06,factor_alcap))
+    dela_dl_alcap                  = (nom_dela_dl_alcap+nsig_dela_dl_alcap*sig_dela_dl_alcap)
+    dela_dw_alcap                  = (nom_dela_dw_alcap+nsig_dela_dw_alcap*sig_dela_dw_alcap)
+    dl_alcap                       = (nom_dl_alcap+dela_dl_alcap+1e-09)
+    dw_alcap                       = (nom_dw_alcap+dela_dw_alcap+1e-09)
+    dw_um                          = (dw_alcap+(0)+(0)/(w*sDOTmult+1e-09))

model ralcap_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_alcap*delr_rs_alcap)
+ etchl = (-0.50e-06*(dl_alcap))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_alcap)
+ tc2   = (tcr2_alcap)

rralcap_10hv (d s) ralcap_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=ralcap_10hv_dfrt
ends

subckt rulm_10hv (d s)

parameters
+    l                              = 2
+    w                              = 2
+    soa                            = 1
+    nsmm_delr_rsh_rulm_10hv        = tmp_nsmm_delr_rsh_rulm_10hv
+    factor_ulm                     = (1.0+nsig_delr_rs_ulm*sig_delr_rs_ulm+nsmm_delr_rsh_rulm_10hv*smm_delr_rulm_10hv(l,w))
+    delr_rs_ulm                    = (nom_delr_rs_ulm*maxmodels(1e-06,factor_ulm))
+    dela_dl_ulm                    = (nom_dela_dl_ulm+nsig_dela_dl_ulm*sig_dela_dl_ulm)
+    dela_dw_ulm                    = (nom_dela_dw_ulm+nsig_dela_dw_ulm*sig_dela_dw_ulm)
+    dl_ulm                         = (nom_dl_ulm+dela_dl_ulm+1e-09)
+    dw_ulm                         = (nom_dw_ulm+dela_dw_ulm+1e-09)
+    dw_um                          = (dw_ulm+(0)+(0)/(w*sDOTmult+1e-09))

model rulm_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_ulm*delr_rs_ulm)
+ etchl = (-0.50e-06*(dl_ulm))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_ulm)
+ tc2   = (tcr2_ulm)

rrulm_10hv (d s) rulm_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rulm_10hv_dfrt
ends

//***********************************************************
endsection resistor
//***********************************************************

//***********************************************************
section resistor_simple
//***********************************************************

real a1a2_rhvpw_10hv(real l, real w, real we, real sDOTmult, real wext_rhvpw_10hv, real lend_nw_rhvpw_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*(we+2*wext_rhvpw_10hv))+(((((we+2*wext_rhvpw_10hv)*lend_nw_rhvpw_10hv)))))) ;
}

real p1p2_rhvpw_10hv(real l, real w, real we, real sDOTmult, real lend_nw_rhvpw_10hv, real wext_rhvpw_10hv) {
    return ((sDOTmult*(l+(2*lend_nw_rhvpw_10hv+(we+2*wext_rhvpw_10hv))))) ;
}

real a1a2_rphv_10hv(real l, real w, real we, real sDOTmult, real wext_rphv_10hv, real lend_nw_rphv_10hv) {
    return (sDOTmult*sDOTmult*(((l/2)*(we+2*wext_rphv_10hv))+(((((we+2*wext_rphv_10hv)*lend_nw_rphv_10hv)))))) ;
}

real p1p2_rphv_10hv(real l, real w, real we, real sDOTmult, real lend_nw_rphv_10hv, real wext_rphv_10hv) {
    return ((sDOTmult*(l+(2*lend_nw_rphv_10hv+(we+2*wext_rphv_10hv))))) ;
}

subckt rpoly0_10hv (d s well sub)

parameters
+    l                              = 0.96
+    w                              = 0.96
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly0_10hv_r3   = tmp_nsmm_delr_rsh_rpoly0_10hv_r3
+    we                             = (0.5*(wemin_rpoly0_10hv+w+sqrt((w-wemin_rpoly0_10hv)*(w-wemin_rpoly0_10hv))))
+    delr_rs_poly0_r3               = (nom_delr_rs_poly0_r3*(1.0+nsig_delr_rs_poly0_r3*sig_delr_rs_poly0_r3+nsmm_delr_rsh_rpoly0_10hv_r3*smm_delr_rpoly0_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_poly0_r3               = (nom_dela_dl_poly0_r3+nsig_dela_dl_poly0_r3*sig_dela_dl_poly0_r3)
+    dela_dw_poly0_r3               = (nom_dela_dw_poly0_r3+nsig_dela_dw_poly0_r3*sig_dela_dw_poly0_r3)
+    dela_dlw_poly0_r3              = (nom_dela_dlw_poly0_r3+nsig_dela_dlw_poly0_r3*sig_dela_dlw_poly0_r3)
+    ca_rpoly0_10hv                 = (cpp_ply0_fld*(w*l))
+    cp_rpoly0_10hv                 = (cfr_ply0_fld*(w+l)*2)
+    cplyfld_rpoly0_10hv            = (ca_rpoly0_10hv+cp_rpoly0_10hv)
+    ni                             = (np-1)
+    liso                           = (lr2iso_left_rpoly0_10hv+l+lr2iso_right_rpoly0_10hv)
+    wiso_i                         = (w*np+w_r2r_rpoly0_10hv*ni+wr2iso_np_rpoly0_10hv*2)
+    wiso                           = ((wiso_i)*(wiso_i>3)+3*(wiso_i<=3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    xw                             = (xw_poly0_r3+dela_dw_poly0_r3)
+    nwxw                           = (nwxw_poly0_r3)
+    xl                             = (xl_poly0_r3+dela_dl_poly0_r3)
+    xlw                            = (xlw_poly0_r3+dela_dlw_poly0_r3)
+    rsh0                           = (235.967880218066*delr_rs_poly0_r3)
+    dl_um                          = (xl+xlw/w)
+    dw_um                          = (1.04*(xw+nwxw/w))

model rpoly0_10hv resistor
+ tnom  = (27)
+ rsh   = (rsh0*1.0)
+ etchl = (-0.250*1e-06*dl_um)
+ etch  = (-0.500*1e-06*dw_um)
+ tc1   = (-1.99261e-05)
+ tc2   = (7.25315e-07)
+ kf    = (8.5e-11*1e-12)
+ af    = (1.845)
+ fexp  = (0.895)

rrpoly0_10hvd (d i) rpoly0_10hv l=(0.5*l) w=(w) m=(np)
rrpoly0_10hvs (i s) rpoly0_10hv l=(0.5*l) w=(w) m=(np)
ccdrpoly0_10hv (d well) capacitor c=0.5*cplyfld_rpoly0_10hv m=(np)
ccsrpoly0_10hv (s well) capacitor c=0.5*cplyfld_rpoly0_10hv m=(np)
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly0_10hv_dfrt_simple
ends

subckt rpoly_10hv (d s well sub)

parameters
+    l                              = 1.5
+    w                              = 0.3
+    lpe                            = 0
+    np                             = 1
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly_10hv_r3    = tmp_nsmm_delr_rsh_rpoly_10hv_r3
+    we                             = (0.5*(wemin_rpoly_10hv+w+sqrt((w-wemin_rpoly_10hv)*(w-wemin_rpoly_10hv))))
+    delr_rs_poly_r3                = (nom_delr_rs_poly_r3*(1.0+nsig_delr_rs_poly_r3*sig_delr_rs_poly_r3+nsmm_delr_rsh_rpoly_10hv_r3*smm_delr_rpoly_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_poly_r3                = (nom_dela_dl_poly_r3+nsig_dela_dl_poly_r3*sig_dela_dl_poly_r3)
+    dela_dw_poly_r3                = (nom_dela_dw_poly_r3+nsig_dela_dw_poly_r3*sig_dela_dw_poly_r3)
+    ca_rpoly_10hv                  = (cpp_ply_fld*(w*l))
+    cp_rpoly_10hv                  = (cfr_ply_fld*(w+l)*2)
+    cplyfld_rpoly_10hv             = (ca_rpoly_10hv+cp_rpoly_10hv)
+    ni                             = (np-1)
+    liso                           = (lr2iso_left_rpoly_10hv+l+lr2iso_right_rpoly_10hv)
+    wiso_i                         = (w*np+w_r2r_rpoly_10hv*ni+wr2iso_rpoly_10hv*(np==1)*2+wr2iso_np_rpoly_10hv*(np>1)*2)
+    wiso                           = ((wiso_i)*(wiso_i>3)+3*(wiso_i<=3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    xw                             = (xw_poly_r3+dela_dw_poly_r3)
+    nwxw                           = (nwxw_poly_r3)
+    xl                             = (xl_poly_r3+dela_dl_poly_r3)
+    xlw                            = (xlw_poly_r3)
+    rsh0                           = (4289.0830796316*delr_rs_poly_r3)
+    dl_um                          = (xl+xlw/w)
+    dw_um                          = (xw+nwxw/w)

model rpoly_10hv resistor
+ tnom  = (27)
+ rsh   = (rsh0*1.0)
+ etchl = (-0.25*1e-06*dl_um)
+ etch  = (-0.50*1e-06*dw_um)
+ tc1   = (-0.002131219)
+ tc2   = (4.88236e-06)
+ kf    = (1.350e-9*1e-12)
+ af    = (1.920)
+ fexp  = (1.019)

rrpoly_10hvd (d i) rpoly_10hv l=(0.5*l) w=(w) m=(np)
rrpoly_10hvs (i s) rpoly_10hv l=(0.5*l) w=(w) m=(np)
ccdrpoly_10hv (d well) capacitor c=0.5*cplyfld_rpoly_10hv m=(np)
ccsrpoly_10hv (s well) capacitor c=0.5*cplyfld_rpoly_10hv m=(np)
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly_10hv_dfrt_simple
ends

subckt rhvpw_10hv (d s nw sub)

parameters
+    l                              = 1.2
+    w                              = 1.2
+    lpe                            = 0
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_rsh_rhvpw_10hv_r3    = tmp_nsmm_delr_rsh_rhvpw_10hv_r3
+    ring                           = (1)
+    we                             = (0.5*(wemin_rhvpw_10hv+w+sqrt((w-wemin_rhvpw_10hv)*(w-wemin_rhvpw_10hv))))
+    delr_rs_hvpw_nbl_r3            = (nom_delr_rs_hvpw_nbl_r3*(1.0+nsig_delr_rs_hvpw_nbl_r3*sig_delr_rs_hvpw_nbl_r3+nsmm_delr_rsh_rhvpw_10hv_r3*smm_delr_rhvpw_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_hvpw_nbl_r3            = (nom_dela_dl_hvpw_nbl_r3+nsig_dela_dl_hvpw_nbl_r3*sig_dela_dl_hvpw_nbl_r3)
+    dela_dw_hvpw_nbl_r3            = (nom_dela_dw_hvpw_nbl_r3+nsig_dela_dw_hvpw_nbl_r3*sig_dela_dw_hvpw_nbl_r3)
+    a1_rhvpw_10hv                  = (a1a2_rhvpw_10hv(l,w,we,sDOTmult,wext_rhvpw_10hv,lend_nw_rhvpw_10hv))
+    p1_rhvpw_10hv                  = (p1p2_rhvpw_10hv(l,w,we,sDOTmult,lend_nw_rhvpw_10hv,wext_rhvpw_10hv))
+    a2_rhvpw_10hv                  = (a1a2_rhvpw_10hv(l,w,we,sDOTmult,wext_rhvpw_10hv,lend_nw_rhvpw_10hv))
+    p2_rhvpw_10hv                  = (p1p2_rhvpw_10hv(l,w,we,sDOTmult,lend_nw_rhvpw_10hv,wext_rhvpw_10hv))
+    ni                             = (np-1)
+    liso                           = ((np==1)*lr2iso_left_rhvpw_10hv+(np>1)*lr2iso_left_np_rhvpw_10hv+l+lr2iso_right_rhvpw_10hv)
+    wiso_i                         = (w*np+w_r2r_rhvpw_10hv*ni+wr2iso_rhvpw_10hv*2)
+    wiso                           = (w*np+w_r2r_rhvpw_10hv*ni+wr2iso_rhvpw_10hv*2)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    xw                             = (xw_hvpw_nbl_r3+dela_dw_hvpw_nbl_r3)
+    nwxw                           = (nwxw_hvpw_nbl_r3)
+    xl                             = (xl_hvpw_nbl_r3+dela_dl_hvpw_nbl_r3)
+    xlw                            = (xlw_hvpw_nbl_r3)
+    aphi_tnom                      = (aphi_junc_pepi_nbl)
+    aphi_t                         = (aphi_tnom-pta_junc_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    pphi_tnom                      = (pphi_junc_pepi_nbl)
+    pphi_t                         = (pphi_tnom-ptp_junc_pepi_nbl*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)

model rhvpw_10hv resistor
+ tnom  = (27)
+ rsh   = (2834.37097079732*delr_rs_hvpw_nbl_r3)
+ etchl = (-0.255*1e-06*(xl+xlw/w))
+ etch  = (-0.490*1e-06*(xw+nwxw/w))
+ tc1   = (0.00551789668)
+ tc2   = (8.4671278e-06)
+ kf    = (2.5e-11*1e-12)
+ af    = (1.95)
+ fexp  = (0.895)

model areadiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((ajs_junc_pepi_nbl))*1.0e12)
+ n             = (ajnd_junc_pepi_nbl)
+ cj            = ((((acj0_junc_pepi_nbl)*(aphi_tf**aexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

model perimdiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((pjs_junc_pepi_nbl))*1.0e12)
+ n             = (pjnd_junc_pepi_nbl)
+ cj            = ((((pcj0_junc_pepi_nbl)*(pphi_tf**pexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

rrhvpw_10hvd (d i) rhvpw_10hv l=(0.5*l) w=(w) m=(np)
rrhvpw_10hvs (i s) rhvpw_10hv l=(0.5*l) w=(w) m=(np)
ddarhvpw_10hv (d nw) areadiode area=(a1_rhvpw_10hv) m=(np)
ddprhvpw_10hv (d nw) perimdiode area=(p1_rhvpw_10hv) m=(np)
dsarhvpw_10hv (s nw) areadiode area=(a2_rhvpw_10hv) m=(np)
dsprhvpw_10hv (s nw) perimdiode area=(p2_rhvpw_10hv) m=(np)
xcdgoptub_sub (nw sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rhvpw_10hv_dfrt
ends

subckt rphv_10hv (d s nw sub)

parameters
+    l                              = 1.2
+    w                              = 1.2
+    lpe                            = 0
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_rsh_rphv_10hv_r3     = tmp_nsmm_delr_rsh_rphv_10hv_r3
+    ring                           = (1)
+    we                             = (0.5*(wemin_rphv_10hv+w+sqrt((w-wemin_rphv_10hv)*(w-wemin_rphv_10hv))))
+    delr_rs_phv_nbl_r3             = (nom_delr_rs_phv_nbl_r3*(1.0+nsig_delr_rs_phv_nbl_r3*sig_delr_rs_phv_nbl_r3+nsmm_delr_rsh_rphv_10hv_r3*smm_delr_rphv_10hv_r3(l,w)/sqrt(np)))
+    dela_dl_phv_nbl_r3             = (nom_dela_dl_phv_nbl_r3+nsig_dela_dl_phv_nbl_r3*sig_dela_dl_phv_nbl_r3)
+    dela_dw_phv_nbl_r3             = (nom_dela_dw_phv_nbl_r3+nsig_dela_dw_phv_nbl_r3*sig_dela_dw_phv_nbl_r3)
+    a1_rphv_10hv                   = (a1a2_rphv_10hv(l,w,we,sDOTmult,wext_rphv_10hv,lend_nw_rphv_10hv))
+    p1_rphv_10hv                   = (p1p2_rphv_10hv(l,w,we,sDOTmult,lend_nw_rphv_10hv,wext_rphv_10hv))
+    a2_rphv_10hv                   = (a1a2_rphv_10hv(l,w,we,sDOTmult,wext_rphv_10hv,lend_nw_rphv_10hv))
+    p2_rphv_10hv                   = (p1p2_rphv_10hv(l,w,we,sDOTmult,lend_nw_rphv_10hv,wext_rphv_10hv))
+    ni                             = (np-1)
+    liso                           = ((np==1)*lr2iso_left_rphv_10hv+(np>1)*lr2iso_left_np_rphv_10hv+l+lr2iso_right_rphv_10hv)
+    wiso_i                         = (w*np+w_r2r_rphv_10hv*ni+wr2iso_rphv_10hv*2)
+    wiso                           = (w*np+w_r2r_rphv_10hv*ni+wr2iso_rphv_10hv*2)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    xw                             = (xw_phv_nbl_r3+dela_dw_phv_nbl_r3)
+    nwxw                           = (nwxw_phv_nbl_r3)
+    xl                             = (xl_phv_nbl_r3+dela_dl_phv_nbl_r3)
+    xlw                            = (xlw_phv_nbl_r3)
+    aphi_tnom                      = (aphi_junc_pepi_nbl)
+    aphi_t                         = (aphi_tnom-pta_junc_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    pphi_tnom                      = (pphi_junc_pepi_nbl)
+    pphi_t                         = (pphi_tnom-ptp_junc_pepi_nbl*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)

model rphv_10hv resistor
+ tnom  = (27)
+ rsh   = (668.35515481556*delr_rs_phv_nbl_r3)
+ etchl = (-0.252*1e-06*(xl+xlw/w))
+ etch  = (-0.500*1e-06*(xw+nwxw/w))
+ tc1   = (0.003463145)
+ tc2   = (5.84887e-06)
+ kf    = (1.01e-11*1e-12)
+ af    = (2.05)
+ fexp  = (0.987)

model areadiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((ajs_junc_pepi_nbl))*1.0e12)
+ n             = (ajnd_junc_pepi_nbl)
+ cj            = ((((acj0_junc_pepi_nbl)*(aphi_tf**aexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

model perimdiode diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ level         = (1)
+ tnom  = (27.0)
+ fc            = (0.9)
+ is            = (((pjs_junc_pepi_nbl))*1.0e12)
+ n             = (pjnd_junc_pepi_nbl)
+ cj            = ((((pcj0_junc_pepi_nbl)*(pphi_tf**pexm_junc_pepi_nbl)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_pepi_nbl)
+ xti           = (3)
+ eg            = (1.12)
+ tlev          = (2)
+ gap1          = (0.0)
+ gap2          = (636)

rrphv_10hvd (d i) rphv_10hv l=(0.5*l) w=(w) m=(np)
rrphv_10hvs (i s) rphv_10hv l=(0.5*l) w=(w) m=(np)
ddarphv_10hv (d nw) areadiode area=(a1_rphv_10hv) m=(np)
ddprphv_10hv (d nw) perimdiode area=(p1_rphv_10hv) m=(np)
dsarphv_10hv (s nw) areadiode area=(a2_rphv_10hv) m=(np)
dsprphv_10hv (s nw) perimdiode area=(p2_rphv_10hv) m=(np)
xcdgoptub_sub (nw sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rphv_10hv_dfrt
ends

subckt antifuse_10hv (wr s sub)

parameters
+    blown                          = 0
+    ring                           = 0
+    soa                            = 1
+    l                              = (0.18)
+    w                              = (0.21)
+    delr_cpp_ply_fld               = (nom_delr_cpp_ply_fld*(1.0+nsig_delr_cpp_ply_fld*sig_delr_cpp_ply_fld))
+    delr_cfr_ply_fld               = (nom_delr_cfr_ply_fld*(1.0+nsig_delr_cfr_ply_fld*sig_delr_cfr_ply_fld))
+    ca_fld                         = (nom_cpp_ply_fld*delr_cpp_ply_fld)
+    cp_fld                         = (nom_cfr_ply_fld*delr_cfr_ply_fld)
+    delr_cpp_ply_sd                = (nom_delr_cpp_ply_sd*(1.0+nsig_delr_cpp_ply_sd*sig_delr_cpp_ply_sd))
+    delr_cfr_ply_sd                = (nom_delr_cfr_ply_sd*(1.0+nsig_delr_cfr_ply_sd*sig_delr_cfr_ply_sd))
+    ca_sd                          = (nom_cpp_ply_sd*delr_cpp_ply_sd)
+    cp_sd                          = (nom_cfr_ply_sd*delr_cfr_ply_sd)
+    arm_area                       = ((0.63*0.585-0.21*0.18)*sDOTmult*sDOTmult)
+    arm_perim                      = ((2*(0.63+0.585)-0.18)*sDOTmult)
+    val_tag_fld                    = (ca_fld*arm_area+cp_fld*arm_perim)
+    cap_area                       = (l*sDOTmult*w*sDOTmult)
+    cap_perim                      = (w*sDOTmult)
+    cap_total                      = (ca_sd*cap_area+cp_sd*cap_perim)
+    w_well                         = (4.155)
+    l_well                         = (3)
+    apepisub                       = (w_well*l_well)
+    ppepisub                       = (2*(w_well+l_well))

cpara (wr s) capacitor c=(val_tag_fld)
cantifuse_10hv (wr s) capacitor c=cap_total
xcsub_antifuse_10hv (s sub) cnwtub_box_sub_10hv area=(ring*apepisub+0.001) perim=(ring*ppepisub+0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=antifuse_10hv_dfrt
ends

subckt vms_15_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_15_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_15_10hv_dfrt
ends

subckt vms_30_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_30_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_30_10hv_dfrt
ends

subckt vms_45_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_45_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_45_10hv_dfrt
ends

subckt vms_60_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_60_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_60_10hv_dfrt
ends

subckt vms_105_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_105_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_105_10hv_dfrt
ends

subckt vms_115_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_115_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_115_10hv_dfrt
ends

subckt vms_165_10hv (d s)

parameters
+    soa                            = 1
+    rvalue                         = (1e18)

rvms_165_10hv (d s) resistor r=rvalue

include "./smos10hv_ade_dfrt.scs" section=vms_165_10hv_dfrt
ends

subckt rpoly_1meg_10hv (d s well sub)

parameters
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_rsh_rpoly_1meg_10hv_r3 = tmp_nsmm_delr_rsh_rpoly_1meg_10hv_r3
+    l                              = (25)
+    w                              = (0.15)
+    we                             = (0.5*(wemin_rpoly_1meg_10hv+w+sqrt((w-wemin_rpoly_1meg_10hv)*(w-wemin_rpoly_1meg_10hv))))
+    cbodyc_rpoly_1meg_10hvc        = (sDOTmult*((sDOTmult*l*w)*cpp_ply_fld+(1-lpe)*2*l*cfr_ply_fld))
+    cconc_rpoly_1meg_10hvc         = ((1-lpe)*(sDOTmult*(sDOTmult*(we*lend_rpoly_1meg_10hv+ldogbone2body_rpoly_1meg_10hv*(we-w))*cpp_ply_fld+(2*lend_rpoly_1meg_10hv+2*we-w)*cfr_ply_fld)))
+    cend_x                         = (cconc_rpoly_1meg_10hvc+cbodyc_rpoly_1meg_10hvc/6)
+    cmid_x                         = (2*cbodyc_rpoly_1meg_10hvc/3)
+    halfl                          = (0.5*l)
+    liso                           = (liso_rpoly_1meg_10hv)
+    wiso                           = (wiso_rpoly_1meg_10hv)
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    rsh0                           = (nom_rs_poly_1meg*(nom_delr_rs_poly_1meg_r3*(1.0+nsig_delr_rs_poly_1meg_r3*sig_delr_rs_poly_1meg_r3+nsmm_delr_rsh_rpoly_1meg_10hv_r3*smm_delr_rpoly_1meg_10hv_r3(l,w)/sqrt(1))))

model rpoly_1meg_10hv resistor
+ tnom  = (27)
+ rsh   = (rsh0*1.0)
+ etchl = (0)
+ etch  = (0)
+ tc1   = (tcr_poly_1meg)
+ tc2   = (tcr2_poly_1meg)
+ kf    = (kf_poly_1meg*1e-12)
+ af    = (af_poly_1meg)
+ fexp  = (fexp_poly_1meg)
+ ldexp  = (ldexp_poly_1meg)
+ wdexp  = (wdexp_poly_1meg)
+ leexp  = (leexp_poly_1meg)
+ weexp  = (weexp_poly_1meg)

rrpoly_1meg_10hvd (d i) rpoly_1meg_10hv l=(halfl) w=(w)
rrpoly_1meg_10hvs (i s) rpoly_1meg_10hv l=(halfl) w=(w)
ccdrpoly_1meg_10hv (d well) capacitor c=cend_x
ccirpoly_1meg_10hv (i well) capacitor c=cmid_x
ccsrpoly_1meg_10hv (s well) capacitor c=cend_x
xcpwtub_sub (well sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=rpoly_1meg_10hv_dfrt_simple
ends

subckt rm1_10hv (d s)

parameters
+    l                              = 0.18
+    w                              = 0.18
+    soa                            = 1
+    nsmm_delr_rsh_rm1_10hv         = tmp_nsmm_delr_rsh_rm1_10hv
+    factor_m1                      = (1.0+nsig_delr_rs_m1*sig_delr_rs_m1+nsmm_delr_rsh_rm1_10hv*smm_delr_rm1_10hv(l,w))
+    delr_rs_m1                     = (nom_delr_rs_m1*maxmodels(1e-06,factor_m1))
+    dela_dl_m1                     = (nom_dela_dl_m1+nsig_dela_dl_m1*sig_dela_dl_m1)
+    dela_dw_m1                     = (nom_dela_dw_m1+nsig_dela_dw_m1*sig_dela_dw_m1)
+    dl_m1                          = (nom_dl_m1+dela_dl_m1+1e-09)
+    dw_m1                          = (nom_dw_m1+dela_dw_m1+1e-09)
+    dw_um                          = (dw_m1+(0)+(0.00377915)/(w*sDOTmult+1e-09))

model rm1_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m1*delr_rs_m1)
+ etchl = (-0.50e-06*(dl_m1))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m1)
+ tc2   = (tcr2_m1)

rrm1_10hv (d s) rm1_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm1_10hv_dfrt
ends

subckt rm2_10hv (d s)

parameters
+    l                              = 0.18
+    w                              = 0.18
+    soa                            = 1
+    nsmm_delr_rsh_rm2_10hv         = tmp_nsmm_delr_rsh_rm2_10hv
+    factor_m2                      = (1.0+nsig_delr_rs_m2*sig_delr_rs_m2+nsmm_delr_rsh_rm2_10hv*smm_delr_rm2_10hv(l,w))
+    delr_rs_m2                     = (nom_delr_rs_m2*maxmodels(1e-06,factor_m2))
+    dela_dl_m2                     = (nom_dela_dl_m2+nsig_dela_dl_m2*sig_dela_dl_m2)
+    dela_dw_m2                     = (nom_dela_dw_m2+nsig_dela_dw_m2*sig_dela_dw_m2)
+    dl_m2                          = (nom_dl_m2+dela_dl_m2+1e-09)
+    dw_m2                          = (nom_dw_m2+dela_dw_m2+1e-09)
+    dw_um                          = (dw_m2+(0)+(0.000828035)/(w*sDOTmult+1e-09))

model rm2_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m2*delr_rs_m2)
+ etchl = (-0.50e-06*(dl_m2))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m2)
+ tc2   = (tcr2_m2)

rrm2_10hv (d s) rm2_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm2_10hv_dfrt
ends

subckt rm3_10hv (d s)

parameters
+    l                              = 0.21
+    w                              = 0.21
+    soa                            = 1
+    nsmm_delr_rsh_rm3_10hv         = tmp_nsmm_delr_rsh_rm3_10hv
+    factor_m3                      = (1.0+nsig_delr_rs_m3*sig_delr_rs_m3+nsmm_delr_rsh_rm3_10hv*smm_delr_rm3_10hv(l,w))
+    delr_rs_m3                     = (nom_delr_rs_m3*maxmodels(1e-06,factor_m3))
+    dela_dl_m3                     = (nom_dela_dl_m3+nsig_dela_dl_m3*sig_dela_dl_m3)
+    dela_dw_m3                     = (nom_dela_dw_m3+nsig_dela_dw_m3*sig_dela_dw_m3)
+    dl_m3                          = (nom_dl_m3+dela_dl_m3+1e-09)
+    dw_m3                          = (nom_dw_m3+dela_dw_m3+1e-09)
+    dw_um                          = (dw_m3+(0)+(0.0168)/(w*sDOTmult+1e-09))

model rm3_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m3*delr_rs_m3)
+ etchl = (-0.50e-06*(dl_m3))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m3)
+ tc2   = (tcr2_m3)

rrm3_10hv (d s) rm3_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm3_10hv_dfrt
ends

subckt rm4_10hv (d s)

parameters
+    l                              = 0.21
+    w                              = 0.21
+    soa                            = 1
+    nsmm_delr_rsh_rm4_10hv         = tmp_nsmm_delr_rsh_rm4_10hv
+    factor_m4                      = (1.0+nsig_delr_rs_m4*sig_delr_rs_m4+nsmm_delr_rsh_rm4_10hv*smm_delr_rm4_10hv(l,w))
+    delr_rs_m4                     = (nom_delr_rs_m4*maxmodels(1e-06,factor_m4))
+    dela_dl_m4                     = (nom_dela_dl_m4+nsig_dela_dl_m4*sig_dela_dl_m4)
+    dela_dw_m4                     = (nom_dela_dw_m4+nsig_dela_dw_m4*sig_dela_dw_m4)
+    dl_m4                          = (nom_dl_m4+dela_dl_m4+1e-09)
+    dw_m4                          = (nom_dw_m4+dela_dw_m4+1e-09)
+    dw_um                          = (dw_m4+(0)+(0.0252)/(w*sDOTmult+1e-09))

model rm4_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_m4*delr_rs_m4)
+ etchl = (-0.50e-06*(dl_m4))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_m4)
+ tc2   = (tcr2_m4)

rrm4_10hv (d s) rm4_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rm4_10hv_dfrt
ends

subckt ralcap_10hv (d s)

parameters
+    l                              = 3
+    w                              = 3
+    soa                            = 1
+    nsmm_delr_rsh_ralcap_10hv      = tmp_nsmm_delr_rsh_ralcap_10hv
+    factor_alcap                   = (1.0+nsig_delr_rs_alcap*sig_delr_rs_alcap+nsmm_delr_rsh_ralcap_10hv*smm_delr_ralcap_10hv(l,w))
+    delr_rs_alcap                  = (nom_delr_rs_alcap*maxmodels(1e-06,factor_alcap))
+    dela_dl_alcap                  = (nom_dela_dl_alcap+nsig_dela_dl_alcap*sig_dela_dl_alcap)
+    dela_dw_alcap                  = (nom_dela_dw_alcap+nsig_dela_dw_alcap*sig_dela_dw_alcap)
+    dl_alcap                       = (nom_dl_alcap+dela_dl_alcap+1e-09)
+    dw_alcap                       = (nom_dw_alcap+dela_dw_alcap+1e-09)
+    dw_um                          = (dw_alcap+(0)+(0)/(w*sDOTmult+1e-09))

model ralcap_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_alcap*delr_rs_alcap)
+ etchl = (-0.50e-06*(dl_alcap))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_alcap)
+ tc2   = (tcr2_alcap)

rralcap_10hv (d s) ralcap_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=ralcap_10hv_dfrt
ends

subckt rulm_10hv (d s)

parameters
+    l                              = 2
+    w                              = 2
+    soa                            = 1
+    nsmm_delr_rsh_rulm_10hv        = tmp_nsmm_delr_rsh_rulm_10hv
+    factor_ulm                     = (1.0+nsig_delr_rs_ulm*sig_delr_rs_ulm+nsmm_delr_rsh_rulm_10hv*smm_delr_rulm_10hv(l,w))
+    delr_rs_ulm                    = (nom_delr_rs_ulm*maxmodels(1e-06,factor_ulm))
+    dela_dl_ulm                    = (nom_dela_dl_ulm+nsig_dela_dl_ulm*sig_dela_dl_ulm)
+    dela_dw_ulm                    = (nom_dela_dw_ulm+nsig_dela_dw_ulm*sig_dela_dw_ulm)
+    dl_ulm                         = (nom_dl_ulm+dela_dl_ulm+1e-09)
+    dw_ulm                         = (nom_dw_ulm+dela_dw_ulm+1e-09)
+    dw_um                          = (dw_ulm+(0)+(0)/(w*sDOTmult+1e-09))

model rulm_10hv resistor
+ tnom  = (27)
+ rsh   = (nom_rs_ulm*delr_rs_ulm)
+ etchl = (-0.50e-06*(dl_ulm))
+ etch  = (-0.50e-06*(dw_um))
+ tc1   = (tcr_ulm)
+ tc2   = (tcr2_ulm)

rrulm_10hv (d s) rulm_10hv l=(l) w=(w)

include "./smos10hv_ade_dfrt.scs" section=rulm_10hv_dfrt
ends

//***********************************************************
endsection resistor_simple
//***********************************************************

endlibrary models

