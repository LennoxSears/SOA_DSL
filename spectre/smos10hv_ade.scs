+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}

include "./smos10hv_ade_dfrt.scs" section=pld65_10hv_dfrt
ends

// pld120_10hv



subckt pld120_10hv (d g s sub)
parameters
+ l=0.5
+ w=10.0
+ ng=2
+ sti_dummy=0
+ fem=0
+ lpe=0
+ soa=1
+ selfheat=1
+ mode_rthcth=1


parameters
//+ nde=(fmod(ng,2))
+ nde              = (0)
+ nse              = (2-nde)
+ nd               = ((ng+nde)/2)
+ ns               = (1-nde+nd)
+ ndi              = (nd-nde)
+ nsi              = (ns-nse)

//dummy parameters
+ ng_dmy           = (2*sti_dummy)
+ ngeff            = (ng+ng_dmy)
+ ndi_eff          = (ngeff/2)
+ nsi_eff          = ((ngeff-2)/2)


//reliability parameters
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld120_vthratio         = 1.0*(-0.0091*pow(1/l,2)+0.0634*1/l+0.9953)
+    presto_pld120_ronratio         = 0.01/1.0/(0.1652*l+0.9967)


//calculation of junction instance parameters
+    lacts    = 0.3
+    ldrift   = 8.4
+    wdrift   = (w)
+    w2nhv    = (13.4)
+    lactd    = 1.32
+    lsplit   = 0.35

+    ldr1=0.45
+    as_i=(lacts*w)*0
+    ps_i=2*(lacts+w)*0
+    ad_i=(((ldr1+lsplit)+ldrift/2)*(w+2*w2nhv*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)/2)
+    pd_i=(2*((ldr1+lsplit)+ldrift/2)*(1-fem)+w+2*w2nhv*(1-fem)+1.44*(1-fem)*(3.14159265358979323846-4))
+    ad2_i=(lactd/2+ldrift/2)*(w+2*w2nhv*(1-fem))
+    pd2_i=(lactd+ldrift)*(1-fem)

//calculation for lnbl/psub junction
+    lg2pepi_s    = 5.66     // dt to poly end
+    lp2p_d       = 19.72    // drain nhv end to nhv end
+    lb2b_s       = 0.99     // poly end to ploy at internal source
+    wg2pepi      = 19.9     // width active side to nhv end
+    xbody        = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody        = (wg2pepi*2*(1-fem)+w)
+    abody        = (xbody*ybody)
+    pbody        = (2*(xbody*(1-fem)+ybody))

//calculation of parasitic cap.
//+    aplyfld_d  		    = (lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)-14.12*(w+9.3*2*(1-fem))-0.7*(w+3.2*2*(1-fem))*2-ldr1*w*2+(w-1*2)*0.6*2)/2*ng
+    aplyfld_b  		    = ((lp2p_d+2*l)*(w+2*15.4*(1-fem))-(lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4))-2*w*l)/2*ng

//parasitic field c for dummy
//+    aplyfld_d_dmy  		    = (lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)-14.12*(w+9.3*2*(1-fem))-0.7*(w+3.2*2*(1-fem))*2-ldr1*w*2)/2*ng_dmy
+    aplyfld_b_dmy  		    = ((lp2p_d+2*l)*(w+2*15.4*(1-fem))-(lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4))-2*w*l)/2*ng_dmy

//--------------moscap for cgd & cgs
// calculation for poly over field parasitic capaciance
+ cgd_ply_fld_pp   = 2.7e-17*2.6
+ dwcgdfldmoscap   = 37.7*(1-fem)
+ dwcgd_ply_fld    = 37.4667*(1-fem)
+ cgd_ply_fld      = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng

// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy  = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld120_10hv   = (32+4)
+ dvp_pld120_10hv  = (4.5+3)
+ type_pld120_10hv = (-1)


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_pld120_sphv_10hv+tc2_ecrit_pld120_sphv_10hv*(temp-tnom))*(temp-tnom)

//**parameters for multi ng

+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*0.73*(l+0.9)/l)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+1.0*(1-(fem>0)))-2/(2+1.0))*(-0.0052))
+ fac_r_ng_uo=(1+(ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*(0.459)*(l-5)/l)
+ fac_r_ng_thesato=(1+(ngeff/(ngeff+2*(1-(fem>0)))-2/(2+2))*(0.16)*(l-5)/l)
+ fac_a_ng_vdscale= ((ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*(-0.47)*((l-4.2)/l)*((w+1.7*(1-fem))/w))




//**thermal res/cap calculation
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld120_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld120_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

//parasitic rgate calcultion
+ delt             = (temp+273.15-(27+273.15))
+ lflap 	   = (1.65)
+ length 	   = (l+ldr1+lflap)
+ w_ploycont2act   = (15.175)
+ rs_poly_gate     = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply             = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ r_gate           = (rply*((w+2*w_ploycont2act*(1-fem))/(length*3*ng)))

// parameters for process variations
+ nsmm_delr_tox_pld120_sphv_10hv  = tmp_nsmm_delr_tox_pld120_sphv_10hv
+ nsmm_delr_uch_pld120_sphv_10hv  = tmp_nsmm_delr_uch_pld120_sphv_10hv
+ nsmm_delr_res_pld120_sphv_10hv  = tmp_nsmm_delr_res_pld120_sphv_10hv
+ nsmm_dela_vfb_pld120_sphv_10hv  = tmp_nsmm_dela_vfb_pld120_sphv_10hv
+ nsmm_dela_vtw_pld120_sphv_10hv  = tmp_nsmm_dela_vtw_pld120_sphv_10hv
+ nsmm_delr_nsub_pld120_sphv_10hv = tmp_nsmm_delr_nsub_pld120_sphv_10hv
+ nsmm_dela_dw_pld120_sphv_10hv = tmp_nsmm_dela_dw_pld120_sphv_10hv
+ nsmm_dela_dwox_pld120_sphv_10hv = tmp_nsmm_dela_dwox_pld120_sphv_10hv

+ delr_tox_pld120_sphv_10hv  = (nom_delr_tox_pld120_sphv_10hv*(1+sig_delr_tox_pld120_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld120_sphv_10hv*smm_delr_tox_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_uch_pld120_sphv_10hv  = (nom_delr_uch_pld120_sphv_10hv*(1+sig_delr_uch_pld120_sphv_10hv*nsig_delr_uch_pld120_sphv_10hv+nsmm_delr_uch_pld120_sphv_10hv*smm_delr_uch_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld120_sphv_10hv  = (nom_delr_res_pld120_sphv_10hv*(1+sig_delr_res_pld120_sphv_10hv*nsig_delr_res_pld120_sphv_10hv+nsmm_delr_res_pld120_sphv_10hv*smm_delr_res_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld120_sphv_10hv  = (nom_dela_vfb_pld120_sphv_10hv+(sig_dela_vfb_pld120_sphv_10hv*nsig_dela_vfb_pld120_sphv_10hv)+nsmm_dela_vfb_pld120_sphv_10hv*smm_dela_vfb_pld120_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld120_sphv_10hv  = (nom_dela_vtw_pld120_sphv_10hv+(sig_dela_vtw_pld120_sphv_10hv*nsig_dela_vtw_pld120_sphv_10hv)+nsmm_dela_vtw_pld120_sphv_10hv*smm_dela_vtw_pld120_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtl_pld120_sphv_10hv  = (nom_dela_vtl_pld120_sphv_10hv+(sig_dela_vtl_pld120_sphv_10hv*nsig_dela_vtl_pld120_sphv_10hv))
+ dela_dw_pld120_sphv_10hv   = (nom_dela_dw_pld120_sphv_10hv+(sig_dela_dw_pld120_sphv_10hv*nsig_dela_dw_pld120_sphv_10hv)+(nsmm_dela_dw_pld120_sphv_10hv*smm_dela_dw_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld120_sphv_10hv = (nom_dela_dwox_pld120_sphv_10hv+(sig_dela_dwox_pld120_sphv_10hv*nsig_dela_dwox_pld120_sphv_10hv)+(nsmm_dela_dwox_pld120_sphv_10hv*smm_dela_dwox_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_mueo_pld120_sphv_10hv = (nom_dela_mueo_pld120_sphv_10hv+(sig_dela_mueo_pld120_sphv_10hv*nsig_dela_mueo_pld120_sphv_10hv))
+ delr_nsub_pld120_sphv_10hv = (1+nsmm_delr_nsub_pld120_sphv_10hv*smm_delr_nsub_pld120_sphv_10hv(l,w)/sqrt(ng/2))

+ dela_vdscale_pld120_sphv_10hv   =(nom_dela_vdscale_pld120_sphv_10hv+(sig_dela_vdscale_pld120_sphv_10hv*nsig_dela_vdscale_pld120_sphv_10hv))
+ dela_vdscalel_pld120_sphv_10hv  =(nom_dela_vdscalel_pld120_sphv_10hv+(sig_dela_vdscalel_pld120_sphv_10hv*nsig_dela_vdscalel_pld120_sphv_10hv))
+ dela_vdscalew_pld120_sphv_10hv  =(nom_dela_vdscalew_pld120_sphv_10hv+(sig_dela_vdscalew_pld120_sphv_10hv*nsig_dela_vdscalew_pld120_sphv_10hv))
+ dela_vdscalelw_pld120_sphv_10hv =(nom_dela_vdscalelw_pld120_sphv_10hv+(sig_dela_vdscalelw_pld120_sphv_10hv*nsig_dela_vdscalelw_pld120_sphv_10hv))

+ delr_cj_pld120_sphv_10hv   = (nom_delr_cj_pld120_sphv_10hv*(1+sig_delr_cj_pld120_sphv_10hv*nsig_delr_cj_pld120_sphv_10hv))
+ delr_is_pld120_sphv_10hv   = (nom_delr_is_pld120_sphv_10hv*exp(sig_delr_is_pld120_sphv_10hv*nsig_delr_is_pld120_sphv_10hv))
+ delr_is2_pld120_sphv_10hv  = (nom_delr_is2_pld120_sphv_10hv*exp(sig_delr_is2_pld120_sphv_10hv*nsig_delr_is2_pld120_sphv_10hv))
+ delr_ir_pld120_sphv_10hv   = (nom_delr_ir_pld120_sphv_10hv*exp(sig_delr_ir_pld120_sphv_10hv*nsig_delr_ir_pld120_sphv_10hv))


+    epsox         = (3.9*8.85e-12)
+    tox           = (1.316e-08*delr_tox_pld120_sphv_10hv)
+    cox           = (epsox/tox)
+    tn            = (27.0)
+    tkr           = (tn+273.15)
+    tkd           = (temp+273.15)

// simple model factor
+ swdrlin  = (2)  
+ fac_rshldd       = ((swdrlin==0)+(swdrlin==2)*0.75)

// parameters for the BV diode
+ dcbv_pld120_10hv = (155)

model dbodyBV diode
+ allow_scaling    = (yes)
+ jmax  	   = (1e12)
+ jmelt 	   = (1e12)
+ tnom  	   = (27)
+ is		   = (1e-30)
+ n		   = (1.0)
+ cj		   = (1e-30)
+ pta		   = (0)
+ tlevc 	   = (2)
+ tlev  	   = (2)
+ bv		   = (dcbv_pld120_10hv+bvdss_shift)
+ ibv		   = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rd s) resistor r=0.01

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr    = 27
//+    toxo  = 320e-9
+    toxo  = 160e-9
+    vfbo  = 0
+    nsubo = 1.4e23
+    npck  = 1e21
+    lpck  = 1e-6
+    rtho  = 1e18
+    ctho  = 0
+    uo    = 0


cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cpp_ply_fld*aplyfld_b + 5e-15*ng)
rgate (g gi)   resistor  r=(r_gate)
xcdgoptub_box_sub_10hv (s sub) cdgoptub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

mamost (d gi s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

if (ng_dmy >= 2) {

cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


}


model sphvt_simkit sphvt
+ type           = p
+ tr             = 27
+ vdscale        = (vdscale_pld120_sphv_10hv+dela_vdscale_pld120_sphv_10hv+fac_a_ng_vdscale+(vdscalel_pld120_sphv_10hv+dela_vdscalel_pld120_sphv_10hv)/l+(vdscalew_pld120_sphv_10hv+dela_vdscalew_pld120_sphv_10hv)*(1-fem)/w+(vdscalelw_pld120_sphv_10hv+dela_vdscalelw_pld120_sphv_10hv)*(1-fem)/w/l)
+ vdscaleb       = (vdscaleb_pld120_sphv_10hv*(l+vdscalebl_pld120_sphv_10hv)/l)
+ stvdscale      = stvdscale_pld120_sphv_10hv
+ ctgo           = ctgo_pld120_sphv_10hv
+ ctbo           = ctbo_pld120_sphv_10hv
+ stcto          = stcto_pld120_sphv_10hv
+ mumb           = mumb_pld120_sphv_10hv
+ mumbexp        = mumbexp_pld120_sphv_10hv
+ mumbvclmp      = mumbvclmp_pld120_sphv_10hv
+ swdrlin        = (swdrlin)
+ swgeo        	 = 1
+ swigate      	 = 0
+ swimpact     	 = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	 = 1
+ swshe        	 = selfheat*enable_selfheat
+ swtcec      	 = 1
+ swimpdr      	 = 1
+ swexp        	 = 0
+ swdelvtac    	 = 1
+ swnud        	 = 0
+ swptest      	 = 0
+ swgedi      	 = 1
+ xvsat          = xvsat_pld120_sphv_10hv
+ qmc            = qmc_pld120_sphv_10hv
+ lvaro        	 = lvaro_pld120_sphv_10hv
+ lvarl        	 = lvarl_pld120_sphv_10hv
+ lvarw        	 = lvarw_pld120_sphv_10hv*(1-fem)
+ lap            = lap_pld120_sphv_10hv
+ wvaro        	 = (wvaro_pld120_sphv_10hv+1e-6*dela_dw_pld120_sphv_10hv)*(1-fem)
+ wvarl        	 = (wvarl_pld120_sphv_10hv)*(1-fem)
+ wvarw        	 = (wvarw_pld120_sphv_10hv)*(1-fem)
+ wot            = wot_pld120_sphv_10hv*(1-fem)
+ dlq            = dlq_pld120_sphv_10hv
+ dwq            = dwq_pld120_sphv_10hv*(1-fem)
+ vfbo           = (vfbo_pld120_sphv_10hv+fac_a_ng_vfbo+dela_vfb_pld120_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld120_vthratio)
+ vfbl           = (vfbl_pld120_sphv_10hv+36e-3/l+dela_vtl_pld120_sphv_10hv)
+ vfbw           = (vfbw_pld120_sphv_10hv+dela_vtw_pld120_sphv_10hv)*(1-fem)
+ vfblw        	 = (vfblw_pld120_sphv_10hv)*(1-fem)
+ stvfbo       	 = stvfbo_pld120_sphv_10hv
+ stvfbl       	 = stvfbl_pld120_sphv_10hv
+ stvfbw       	 = stvfbw_pld120_sphv_10hv*(1-fem)
+ stvfblw      	 = stvfblw_pld120_sphv_10hv*(1-fem)
+ toxo           = toxo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ epsroxo      	 = epsroxo_pld120_sphv_10hv
+ nsubo        	 = nsubo_pld120_sphv_10hv*delr_nsub_pld120_sphv_10hv
+ nsubw        	 = nsubw_pld120_sphv_10hv*(1-fem)
+ wseg           = wseg_pld120_sphv_10hv
+ npck           = npck_pld120_sphv_10hv
+ npckw        	 = npckw_pld120_sphv_10hv*(1-fem)
+ wsegp        	 = wsegp_pld120_sphv_10hv
+ lpck           = lpck_pld120_sphv_10hv
+ lpckw        	 = lpckw_pld120_sphv_10hv*(1-fem)
+ fol1           = fol1_pld120_sphv_10hv
+ fol2           = fol2_pld120_sphv_10hv
+ facneffaco   	 = facneffaco_pld120_sphv_10hv
+ facneffacl   	 = facneffacl_pld120_sphv_10hv
+ facneffacw   	 = facneffacw_pld120_sphv_10hv*(1-fem)
+ facneffaclw  	 = facneffaclw_pld120_sphv_10hv*(1-fem)
+ gfacnudo     	 = gfacnudo_pld120_sphv_10hv
+ gfacnudl     	 = gfacnudl_pld120_sphv_10hv
+ gfacnudlexp  	 = gfacnudlexp_pld120_sphv_10hv
+ gfacnudw     	 = gfacnudw_pld120_sphv_10hv*(1-fem)
+ gfacnudlw    	 = gfacnudlw_pld120_sphv_10hv*(1-fem)
+ vsbnudo      	 = vsbnudo_pld120_sphv_10hv
+ dvsbnudo     	 = dvsbnudo_pld120_sphv_10hv
+ vnsubo       	 = vnsubo_pld120_sphv_10hv
+ nslpo        	 = nslpo_pld120_sphv_10hv
+ dnsubo       	 = dnsubo_pld120_sphv_10hv
+ dphibo       	 = dphibo_pld120_sphv_10hv
+ dphibl       	 = dphibl_pld120_sphv_10hv
+ dphiblexp    	 = dphiblexp_pld120_sphv_10hv
+ dphibw       	 = (dphibw_pld120_sphv_10hv)*(1-fem)
+ dphiblw      	 = (dphiblw_pld120_sphv_10hv)*(1-fem)
+ delvtaco     	 = delvtaco_pld120_sphv_10hv
+ delvtacl     	 = delvtacl_pld120_sphv_10hv
+ delvtaclexp  	 = delvtaclexp_pld120_sphv_10hv
+ delvtacw     	 = delvtacw_pld120_sphv_10hv*(1-fem)
+ delvtaclw    	 = delvtaclw_pld120_sphv_10hv*(1-fem)
+ npo            = npo_pld120_sphv_10hv
+ npl            = npl_pld120_sphv_10hv
+ cto            = cto_pld120_sphv_10hv
+ ctl            = ctl_pld120_sphv_10hv
+ ctlexp       	 = ctlexp_pld120_sphv_10hv
+ ctw            = ctw_pld120_sphv_10hv*(1-fem)
+ ctlw           = ctlw_pld120_sphv_10hv*(1-fem)
+ toxovo       	 = toxovo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ toxovdo      	 = toxovdo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ lov            = lov_pld120_sphv_10hv
+ dlovd        	 = dlovd_pld120_sphv_10hv
+ novo           = novo_pld120_sphv_10hv
+ novdo        	 = novdo_pld120_sphv_10hv
+ cfl            = cfl_pld120_sphv_10hv
+ cflexp       	 = cflexp_pld120_sphv_10hv
+ cfw            = cfw_pld120_sphv_10hv*(1-fem)
+ cfbo           = cfbo_pld120_sphv_10hv
+ uo             = (uo_pld120_sphv_10hv*delr_uch_pld120_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1        	 = fbet1_pld120_sphv_10hv
+ fbet1w       	 = fbet1w_pld120_sphv_10hv*(1-fem)
+ lp1            = lp1_pld120_sphv_10hv
+ lp1w           = lp1w_pld120_sphv_10hv*(1-fem)
+ fbet2        	 = fbet2_pld120_sphv_10hv
+ lp2            = lp2_pld120_sphv_10hv
+ betw1        	 = betw1_pld120_sphv_10hv*(1-fem)
+ betw2        	 = betw2_pld120_sphv_10hv*(1-fem)
+ wbet           = wbet_pld120_sphv_10hv
+ stbeto       	 = stbeto_pld120_sphv_10hv
+ stbetl       	 = stbetl_pld120_sphv_10hv
+ stbetw       	 = stbetw_pld120_sphv_10hv*(1-fem)
+ stbetlw      	 = stbetlw_pld120_sphv_10hv*(1-fem)
+ mueo           = (mueo_pld120_sphv_10hv+dela_mueo_pld120_sphv_10hv)
+ muew           = muew_pld120_sphv_10hv*(1-fem)
+ stmueo       	 = stmueo_pld120_sphv_10hv
+ themuo       	 = themuo_pld120_sphv_10hv
+ stthemuo     	 = stthemuo_pld120_sphv_10hv
+ cso            = cso_pld120_sphv_10hv
+ csl            = csl_pld120_sphv_10hv
+ cslexp       	 = cslexp_pld120_sphv_10hv
+ csw            = csw_pld120_sphv_10hv*(1-fem)
+ cslw           = cslw_pld120_sphv_10hv*(1-fem)
+ stcso        	 = stcso_pld120_sphv_10hv
+ xcoro        	 = xcoro_pld120_sphv_10hv
+ xcorl        	 = xcorl_pld120_sphv_10hv
+ xcorw        	 = xcorw_pld120_sphv_10hv*(1-fem)
+ xcorlw       	 = xcorlw_pld120_sphv_10hv*(1-fem)
+ stxcoro      	 = stxcoro_pld120_sphv_10hv
+ fetao        	 = fetao_pld120_sphv_10hv
+ rsw1           = rsw1_pld120_sphv_10hv
+ rsw2           = rsw2_pld120_sphv_10hv*(1-fem)
+ strso        	 = strso_pld120_sphv_10hv
+ rsbo           = rsbo_pld120_sphv_10hv
+ rsgo           = rsgo_pld120_sphv_10hv
+ thesato      	 = (thesato_pld120_sphv_10hv)*fac_r_ng_thesato
+ thesatl      	 = thesatl_pld120_sphv_10hv
+ thesatlexp   	 = thesatlexp_pld120_sphv_10hv
+ thesatw      	 = (thesatw_pld120_sphv_10hv*(1-fem))
+ thesatlw     	 = thesatlw_pld120_sphv_10hv*(1-fem)
+ stthesato    	 = stthesato_pld120_sphv_10hv
+ stthesatl    	 = stthesatl_pld120_sphv_10hv
+ stthesatw    	 = stthesatw_pld120_sphv_10hv*(1-fem)
+ stthesatlw   	 = stthesatlw_pld120_sphv_10hv*(1-fem)
+ thesatbo     	 = thesatbo_pld120_sphv_10hv
+ thesatgo     	 = thesatgo_pld120_sphv_10hv
+ thesatgl     	 = thesatgl_pld120_sphv_10hv
+ thesatgw     	 = thesatgw_pld120_sphv_10hv*(1-fem)
+ axo            = axo_pld120_sphv_10hv
+ axl            = axl_pld120_sphv_10hv
+ alpl           = alpl_pld120_sphv_10hv
+ alplexp      	 = alplexp_pld120_sphv_10hv
+ alpw           = alpw_pld120_sphv_10hv*(1-fem)
+ alp1l1       	 = alp1l1_pld120_sphv_10hv
+ alp1lexp     	 = alp1lexp_pld120_sphv_10hv
+ alp1l2       	 = alp1l2_pld120_sphv_10hv
+ alp1w        	 = alp1w_pld120_sphv_10hv*(1-fem)
+ alp2l1       	 = alp2l1_pld120_sphv_10hv
+ alp2lexp     	 = alp2lexp_pld120_sphv_10hv
+ alp2l2       	 = alp2l2_pld120_sphv_10hv
+ alp2w        	 = alp2w_pld120_sphv_10hv*(1-fem)
+ vpo            = vpo_pld120_sphv_10hv
+ a1o            = a1o_pld120_sphv_10hv
+ a1l            = a1l_pld120_sphv_10hv
+ a1w            = a1w_pld120_sphv_10hv*(1-fem)
+ a2o            = a2o_pld120_sphv_10hv
+ sta2o        	 = sta2o_pld120_sphv_10hv
+ a3o            = a3o_pld120_sphv_10hv
+ a3l            = a3l_pld120_sphv_10hv
+ a3w            = a3w_pld120_sphv_10hv*(1-fem)
+ a4o            = a4o_pld120_sphv_10hv
+ a4l            = a4l_pld120_sphv_10hv
+ a4w            = a4w_pld120_sphv_10hv*(1-fem)
+ gcoo           = gcoo_pld120_sphv_10hv
+ iginvlw      	 = iginvlw_pld120_sphv_10hv
+ igovw        	 = igovw_pld120_sphv_10hv
+ igovdw       	 = igovdw_pld120_sphv_10hv
+ stigo        	 = stigo_pld120_sphv_10hv
+ gc2o           = gc2o_pld120_sphv_10hv
+ gc3o           = gc3o_pld120_sphv_10hv
+ chibo        	 = chibo_pld120_sphv_10hv
+ agidlw       	 = agidlw_pld120_sphv_10hv
+ agidldw      	 = agidldw_pld120_sphv_10hv
+ bgidlo       	 = bgidlo_pld120_sphv_10hv
+ bgidldo      	 = bgidldo_pld120_sphv_10hv
+ stbgidlo     	 = stbgidlo_pld120_sphv_10hv
+ stbgidldo    	 = stbgidldo_pld120_sphv_10hv
+ cgidlo       	 = cgidlo_pld120_sphv_10hv
+ cgidldo      	 = cgidldo_pld120_sphv_10hv
+ cgbovl       	 = cgbovl_pld120_sphv_10hv
+ cfrw           = cfrw_pld120_sphv_10hv*(1-fem)
+ cfrdw        	 = cfrdw_pld120_sphv_10hv*(1-fem)
+ fnto           = fnto_pld120_sphv_10hv
+ nfalw        	 = nfalw_pld120_sphv_10hv
+ nfblw        	 = nfblw_pld120_sphv_10hv
+ nfclw        	 = nfclw_pld120_sphv_10hv
+ efo            = efo_pld120_sphv_10hv
+ lintnoi      	 = lintnoi_pld120_sphv_10hv
+ alpnoi       	 = alpnoi_pld120_sphv_10hv
+ kvthoweo     	 = kvthoweo_pld120_sphv_10hv
+ kvthowel     	 = kvthowel_pld120_sphv_10hv
+ kvthowew     	 = kvthowew_pld120_sphv_10hv*(1-fem)
+ kvthowelw    	 = kvthowelw_pld120_sphv_10hv*(1-fem)
+ kuoweo       	 = kuoweo_pld120_sphv_10hv
+ kuowel       	 = kuowel_pld120_sphv_10hv
+ kuowew       	 = kuowew_pld120_sphv_10hv*(1-fem)
+ kuowelw      	 = kuowelw_pld120_sphv_10hv*(1-fem)
+ rgo            = rgo_pld120_sphv_10hv
+ rsh            = rsh_pld120_sphv_10hv
+ rbulko       	 = rbulko_pld120_sphv_10hv
+ rwello       	 = rwello_pld120_sphv_10hv
+ rjunso       	 = rjunso_pld120_sphv_10hv/(w+dwrjunso_pld120_sphv_10hv*(1-fem))
+ rjundo       	 = rjundo_pld120_sphv_10hv/(w+dwrjundo_pld120_sphv_10hv*(1-fem))*sqrt(l)/(sqrt(l)+0.2)*(1+1.0e-3*(temp-27))
+ rint           = rint_pld120_sphv_10hv
+ rvpoly       	 = rvpoly_pld120_sphv_10hv
+ rshg           = rshg_pld120_sphv_10hv
+ dlsil        	 = dlsil_pld120_sphv_10hv
+ saref        	 = saref_pld120_sphv_10hv
+ sbref        	 = sbref_pld120_sphv_10hv
+ wlod           = wlod_pld120_sphv_10hv
+ kuo            = kuo_pld120_sphv_10hv
+ kvsat        	 = kvsat_pld120_sphv_10hv
+ tkuo           = tkuo_pld120_sphv_10hv
+ lkuo           = lkuo_pld120_sphv_10hv
+ wkuo           = wkuo_pld120_sphv_10hv*(1-fem)
+ pkuo           = pkuo_pld120_sphv_10hv*(1-fem)
+ llodkuo      	 = llodkuo_pld120_sphv_10hv
+ wlodkuo      	 = wlodkuo_pld120_sphv_10hv
+ kvtho        	 = kvtho_pld120_sphv_10hv
+ lkvtho       	 = lkvtho_pld120_sphv_10hv
+ wkvtho       	 = wkvtho_pld120_sphv_10hv*(1-fem)
+ pkvtho       	 = pkvtho_pld120_sphv_10hv*(1-fem)
+ llodvth      	 = llodvth_pld120_sphv_10hv
+ wlodvth      	 = wlodvth_pld120_sphv_10hv
+ stetao       	 = stetao_pld120_sphv_10hv
+ lodetao      	 = lodetao_pld120_sphv_10hv
+ scref        	 = scref_pld120_sphv_10hv
+ web            = web_pld120_sphv_10hv
+ wec            = wec_pld120_sphv_10hv
+ adr1o        	 = adr1o_pld120_sphv_10hv
+ adr1l        	 = adr1l_pld120_sphv_10hv
+ adr1w        	 = adr1w_pld120_sphv_10hv*(1-fem)
+ adr2o        	 = adr2o_pld120_sphv_10hv
+ stadr2o      	 = stadr2o_pld120_sphv_10hv
+ adr3o        	 = adr3o_pld120_sphv_10hv
+ adr3l        	 = adr3l_pld120_sphv_10hv
+ adr3w        	 = adr3w_pld120_sphv_10hv*(1-fem)
+ adr4o        	 = adr4o_pld120_sphv_10hv
+ adr4l        	 = adr4l_pld120_sphv_10hv
+ adr4w        	 = adr4w_pld120_sphv_10hv*(1-fem)
+ adr5o        	 = adr5o_pld120_sphv_10hv
+ adr5l        	 = adr5l_pld120_sphv_10hv
+ adr5w        	 = adr5w_pld120_sphv_10hv*(1-fem)
+ bidr1o       	 = bidr1o_pld120_sphv_10hv
+ bidr1l       	 = bidr1l_pld120_sphv_10hv
+ bidr1w       	 = bidr1w_pld120_sphv_10hv*(1-fem)
+ bidr2o       	 = bidr2o_pld120_sphv_10hv
+ bidr2w       	 = bidr2w_pld120_sphv_10hv*(1-fem)
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	 = 0
+ strtho       	 = strtho_pld120_sphv_10hv
+ strthao        = strthao_pld120_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	 = 0
+ rshldd       	 = (rshldd_pld120_sphv_10hv*fac_r_ng_rshldd*delr_res_pld120_sphv_10hv*fac_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld120_ronratio))
+ xw             = (xw_pld120_sphv_10hv*(1-fem))
+ nwxw           = ((nwxw_pld120_sphv_10hv+1e-12*dela_dwox_pld120_sphv_10hv)*(1-fem))
+ xl             = xl_pld120_sphv_10hv
+ xlw            = xlw_pld120_sphv_10hv*(1-fem)
+ dxlsat       	 = dxlsat_pld120_sphv_10hv
+ nst            = nst_pld120_sphv_10hv
+ ats            = ats_pld120_sphv_10hv
+ dfinf        	 = dfinf_pld120_sphv_10hv
+ dfw            = dfw_pld120_sphv_10hv*(1-fem)
+ dfl            = dfl_pld120_sphv_10hv
+ dflw           = dflw_pld120_sphv_10hv*(1-fem)
+ dp             = dp_pld120_sphv_10hv
+ ecrit        	 = ecrit_pld120_sphv_10hv*tfact_ecrit*(1+1*(1-fem)/w)
+ ecorn        	 = ecorn_pld120_sphv_10hv*tfact_ecrit*(1+1*(1-fem)/w)
+ du             = du_pld120_sphv_10hv
+ tc1            = tc1_pld120_sphv_10hv
+ tc2            = tc2_pld120_sphv_10hv
+ tc1l           = tc1l_pld120_sphv_10hv
+ tc2l           = tc2l_pld120_sphv_10hv
+ tc1w           = tc1w_pld120_sphv_10hv*(1-fem)
+ tc2w           = tc2w_pld120_sphv_10hv*(1-fem)
+ theacc       	 = theacc_pld120_sphv_10hv
+ theacc2      	 = theacc2_pld120_sphv_10hv
+ rva            = rva_pld120_sphv_10hv
+ dta            = dta_pld120_sphv_10hv
+ trj            = trj_pld120_sphv_10hv
+ cjarea       	 = cjarea_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlsti       	 = cjlsti_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlgat       	 = cjlgat_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiarea      	 = vbiarea_pld120_sphv_10hv
+ vbisti       	 = vbisti_pld120_sphv_10hv
+ vbigat       	 = vbigat_pld120_sphv_10hv
+ parea        	 = parea_pld120_sphv_10hv
+ psti           = psti_pld120_sphv_10hv
+ pgat           = pgat_pld120_sphv_10hv
+ is1area      	 = is1area_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttarea       	 = ttarea_pld120_sphv_10hv
+ is2area      	 = is2area_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irarea       	 = irarea_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1area    	 = stis1area_pld120_sphv_10hv
+ stis2area    	 = stis2area_pld120_sphv_10hv
+ stirarea     	 = stirarea_pld120_sphv_10hv
+ n1area       	 = n1area_pld120_sphv_10hv
+ n2area       	 = n2area_pld120_sphv_10hv
+ nrarea       	 = nrarea_pld120_sphv_10hv
+ is1lsti      	 = is1lsti_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttlsti       	 = ttlsti_pld120_sphv_10hv
+ is2lsti      	 = is2lsti_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irlsti       	 = irlsti_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1sti     	 = stis1sti_pld120_sphv_10hv
+ stis2sti     	 = stis2sti_pld120_sphv_10hv
+ stirsti      	 = stirsti_pld120_sphv_10hv
+ n1sti        	 = n1sti_pld120_sphv_10hv
+ n2sti        	 = n2sti_pld120_sphv_10hv
+ nrsti        	 = nrsti_pld120_sphv_10hv
+ is1lgat      	 = is1lgat_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttlgat       	 = ttlgat_pld120_sphv_10hv
+ is2lgat      	 = is2lgat_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irlgat       	 = irlgat_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1gat     	 = stis1gat_pld120_sphv_10hv
+ stis2gat     	 = stis2gat_pld120_sphv_10hv
+ stirgat      	 = stirgat_pld120_sphv_10hv
+ n1gat        	 = n1gat_pld120_sphv_10hv
+ n2gat        	 = n2gat_pld120_sphv_10hv
+ nrgat        	 = nrgat_pld120_sphv_10hv
+ cjaread      	 = cjaread_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlstid      	 = cjlstid_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlgatd      	 = cjlgatd_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiaread     	 = vbiaread_pld120_sphv_10hv
+ vbistid      	 = vbistid_pld120_sphv_10hv
+ vbigatd      	 = vbigatd_pld120_sphv_10hv
+ paread       	 = paread_pld120_sphv_10hv
+ pstid        	 = pstid_pld120_sphv_10hv
+ pgatd        	 = pgatd_pld120_sphv_10hv
+ is1aread     	 = is1aread_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttaread      	 = ttaread_pld120_sphv_10hv
+ is2aread     	 = is2aread_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ iraread      	 = iraread_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1aread   	 = stis1aread_pld120_sphv_10hv
+ stis2aread   	 = stis2aread_pld120_sphv_10hv
+ stiraread    	 = stiraread_pld120_sphv_10hv
+ n1aread      	 = n1aread_pld120_sphv_10hv
+ n2aread      	 = n2aread_pld120_sphv_10hv
+ nraread      	 = nraread_pld120_sphv_10hv
+ is1lstid     	 = is1aread_pld120_sphv_10hv*djunc*1e-10*delr_is_pld120_sphv_10hv
+ ttlstid      	 = ttlstid_pld120_sphv_10hv
+ is2lstid     	 = is2aread_pld120_sphv_10hv*djunc*1e-10*delr_is2_pld120_sphv_10hv
+ irlstid      	 = irlstid_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1stid    	 = stis1stid_pld120_sphv_10hv
+ stis2stid    	 = stis2stid_pld120_sphv_10hv
+ stirstid     	 = stirstid_pld120_sphv_10hv
+ n1stid       	 = n1stid_pld120_sphv_10hv
+ n2stid       	 = n2stid_pld120_sphv_10hv
+ nrstid       	 = nrstid_pld120_sphv_10hv
+ is1lgatd     	 = is1aread_pld120_sphv_10hv*djunc*delr_is_pld120_sphv_10hv
+ ttlgatd      	 = ttlgatd_pld120_sphv_10hv
+ is2lgatd     	 = is2aread_pld120_sphv_10hv*djunc*delr_is2_pld120_sphv_10hv
+ irlgatd      	 = irlgatd_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1gatd    	 = stis1gatd_pld120_sphv_10hv
+ stis2gatd    	 = stis2gatd_pld120_sphv_10hv
+ stirgatd     	 = stirgatd_pld120_sphv_10hv
+ n1gatd       	 = n1gatd_pld120_sphv_10hv
+ n2gatd       	 = n2gatd_pld120_sphv_10hv
+ nrgatd       	 = nrgatd_pld120_sphv_10hv
+ cjaread2     	 = cjaread_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlstid2     	 = cjlstid_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiaread2    	 = vbiaread2_pld120_sphv_10hv
+ vbistid2     	 = vbistid2_pld120_sphv_10hv
+ paread2      	 = paread2_pld120_sphv_10hv
+ pstid2       	 = pstid2_pld120_sphv_10hv
+ is1aread2    	 = is1aread_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttaread2     	 = ttaread2_pld120_sphv_10hv
+ is2aread2    	 = is2aread_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ iraread2     	 = iraread2_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1aread2  	 = stis1aread_pld120_sphv_10hv
+ stis2aread2  	 = stis2aread_pld120_sphv_10hv
+ stiraread2   	 = stiraread2_pld120_sphv_10hv
+ n1aread2     	 = n1aread2_pld120_sphv_10hv
+ n2aread2     	 = n2aread2_pld120_sphv_10hv
+ nraread2     	 = nraread2_pld120_sphv_10hv
+ is1lstid2    	 = is1aread_pld120_sphv_10hv*djunc*delr_is_pld120_sphv_10hv
+ ttlstid2     	 = ttlstid2_pld120_sphv_10hv
+ is2lstid2    	 = is2aread_pld120_sphv_10hv*djunc*delr_is2_pld120_sphv_10hv
+ irlstid2     	 = irlstid2_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1stid2   	 = stis1stid2_pld120_sphv_10hv
+ stis2stid2   	 = stis2stid2_pld120_sphv_10hv
+ stirstid2    	 = stirstid2_pld120_sphv_10hv
+ n1stid2      	 = n1stid2_pld120_sphv_10hv
+ n2stid2      	 = n2stid2_pld120_sphv_10hv
+ nrstid2      	 = nrstid2_pld120_sphv_10hv
+ aacc           = aacc_pld120_sphv_10hv
+ eais1area      = eais1area_pld120_sphv_10hv
+ eais2area      = eais2area_pld120_sphv_10hv
+ eairarea       = eairarea_pld120_sphv_10hv
+ eais1sti       = eais1sti_pld120_sphv_10hv
+ eais2sti       = eais2sti_pld120_sphv_10hv
+ eairsti        = eairsti_pld120_sphv_10hv
+ eais1gat       = eais1gat_pld120_sphv_10hv
+ eais2gat       = eais2gat_pld120_sphv_10hv
+ eairgat        = eairgat_pld120_sphv_10hv
+ eais1aread     = eais1aread_pld120_sphv_10hv
+ eais2aread     = eais2aread_pld120_sphv_10hv
+ eairaread      = eairaread_pld120_sphv_10hv
+ eais1stid      = eais1stid_pld120_sphv_10hv
+ eais2stid      = eais2stid_pld120_sphv_10hv
+ eairstid       = eairstid_pld120_sphv_10hv
+ eais1gatd      = eais1gatd_pld120_sphv_10hv
+ eais2gatd      = eais2gatd_pld120_sphv_10hv
+ eairgatd       = eairgatd_pld120_sphv_10hv
+ eais1aread2    = eais1aread2_pld120_sphv_10hv
+ eais2aread2    = eais2aread2_pld120_sphv_10hv
+ eairaread2     = eairaread2_pld120_sphv_10hv
+ eais1stid2     = eais1stid2_pld120_sphv_10hv
+ eais2stid2     = eais2stid2_pld120_sphv_10hv
+ eairstid2      = eairstid2_pld120_sphv_10hv
+ ikfarea        = ikfarea_pld120_sphv_10hv
+ ikflsti        = ikfarea_pld120_sphv_10hv*djunc
+ ikflgat        = ikfarea_pld120_sphv_10hv*djunc
+ stikfarea      = stikfarea_pld120_sphv_10hv
+ stikfsti       = stikfarea_pld120_sphv_10hv
+ stikfgat       = stikfarea_pld120_sphv_10hv
+ ikfaread       = ikfaread_pld120_sphv_10hv*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflstid       = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflgatd       = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikfaread2      = ikfaread_pld120_sphv_10hv*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflstid2      = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ stikfaread     = stikfaread_pld120_sphv_10hv
+ stikfstid      = stikfaread_pld120_sphv_10hv
+ stikfgatd      = stikfaread_pld120_sphv_10hv
+ stikfaread2    = stikfaread_pld120_sphv_10hv
+ stikfstid2     = stikfaread_pld120_sphv_10hv

include "./smos10hv_ade_dfrt.scs" section=pld120_10hv_dfrt
ends

// pld90b_10hv

subckt pld90b_10hv (d g s sub)

parameters
+ w				 = (5)
+ ng				 = (2)
+ lpe				 = (0)
+ sti_dummy			 = (0)
+ fem				 = (0)
+ soa				 = (1)
+ selfheat			 = (1)
+ mode_rthcth			 = (1)
+ dela_vth_relimo		 = (0)
+ dela_vth_relimo_mod		 = (0)
+ delr_u0_relimo		 = (1)
+ delr_rdsw_relimo		 = (1)
+ delr_a0_relimo		 = (1)
+ presto_device_active           = (1)
+ nbtidamage		         = (0.0)
+ nbtivthdegr		         = (0.0)
+ pbtidamage		         = (0.0)
+ pbtivthdegr		         = (0.0)
+ hcirondegrfac 	         = (0.0)
+ offrondegrfac 	         = (0.0)
+ hvgsvthdegr		         = (0.0)
+ hcidamage1		         = (0.0)
+ hcidamage2		         = (0.0)
+ offdamage1		         = (0.0)
+ offdamage2		         = (0.0)
+ hvgsdamage		         = (0.0)
+ presto_pld90b_vthratio         = 1.0*(1.0/1.2052)
+ presto_pld90b_ronratio         = 0.01/1.0/1.0636
+ l				 = (0.5)
+ lovlap 			 = (0.5+0.55-0.913-0.078)
+ length 			 = (0.913+0.078+lovlap+2.65)
+ tn                             = (27+273.15)
+ delt                           = (temp+273.15-tn)
+ rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ nsmm_delr_tox_pld90b_sphv_10hv    = tmp_nsmm_delr_tox_pld90b_sphv_10hv
+ nsmm_dela_vfb_pld90b_sphv_10hv    = tmp_nsmm_dela_vfb_pld90b_sphv_10hv
+ nsmm_dela_vtw_pld90b_sphv_10hv    = tmp_nsmm_dela_vtw_pld90b_sphv_10hv
+ nsmm_delr_uch_pld90b_sphv_10hv    = tmp_nsmm_delr_uch_pld90b_sphv_10hv
+ nsmm_delr_res_pld90b_sphv_10hv    = tmp_nsmm_delr_res_pld90b_sphv_10hv
+ nsmm_dela_dwox_pld90b_sphv_10hv   = tmp_nsmm_dela_dwox_pld90b_sphv_10hv
+ nsmm_delr_nsub_pld90b_sphv_10hv   = tmp_nsmm_delr_nsub_pld90b_sphv_10hv

//process parameters
//+ delr_tox_pld90b_sphv_10hv    = (nom_delr_tox_pld90b_sphv_10hv*(1+sig_delr_tox_pld90b_sphv_10hv*nsig_delr_tox_pld90b_sphv_10hv+nsmm_delr_tox_pld90b_sphv_10hv*smm_delr_tox_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_tox_pld90b_sphv_10hv      = (nom_delr_tox_pld90b_sphv_10hv*(1+sig_delr_tox_pld90b_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld90b_sphv_10hv*smm_delr_tox_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld90b_sphv_10hv      = (nom_dela_vfb_pld90b_sphv_10hv+(sig_dela_vfb_pld90b_sphv_10hv*nsig_dela_vfb_pld90b_sphv_10hv)+nsmm_dela_vfb_pld90b_sphv_10hv*smm_dela_vfb_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld90b_sphv_10hv      = (nom_dela_vtw_pld90b_sphv_10hv+(sig_dela_vtw_pld90b_sphv_10hv*nsig_dela_vtw_pld90b_sphv_10hv)+nsmm_dela_vtw_pld90b_sphv_10hv*smm_dela_vtw_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld90b_sphv_10hv      = (nom_delr_uch_pld90b_sphv_10hv*(1+sig_delr_uch_pld90b_sphv_10hv*nsig_delr_uch_pld90b_sphv_10hv+nsmm_delr_uch_pld90b_sphv_10hv*smm_delr_uch_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld90b_sphv_10hv      = (nom_delr_res_pld90b_sphv_10hv*(1+sig_delr_res_pld90b_sphv_10hv*nsig_delr_res_pld90b_sphv_10hv+nsmm_delr_res_pld90b_sphv_10hv*smm_delr_res_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld90b_sphv_10hv     = (nom_dela_dwox_pld90b_sphv_10hv+(sig_dela_dwox_pld90b_sphv_10hv*nsig_dela_dwox_pld90b_sphv_10hv)+nsmm_dela_dwox_pld90b_sphv_10hv*smm_dela_dwox_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld90b_sphv_10hv     = (1+nsmm_delr_nsub_pld90b_sphv_10hv*smm_delr_nsub_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld90b_sphv_10hv	 = (nom_delr_cj_pld90b_sphv_10hv*(1.0+nsig_delr_cj_pld90b_sphv_10hv*sig_delr_cj_pld90b_sphv_10hv))
+ delr_is_pld90b_sphv_10hv	 = (nom_delr_is_pld90b_sphv_10hv*exp(nsig_delr_is_pld90b_sphv_10hv*sig_delr_is_pld90b_sphv_10hv))
+ delr_is2_pld90b_sphv_10hv	 = (nom_delr_is2_pld90b_sphv_10hv*exp(nsig_delr_is2_pld90b_sphv_10hv*sig_delr_is2_pld90b_sphv_10hv))
+ delr_ir_pld90b_sphv_10hv	 = (nom_delr_ir_pld90b_sphv_10hv*exp(nsig_delr_ir_pld90b_sphv_10hv*sig_delr_ir_pld90b_sphv_10hv))

parameters
//+ nde=(fmod(ng,2))
+ nde=(0)
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+ ng_dmy=(2*sti_dummy)
+ ng_eff=(ng+ng_dmy)
+ ndi_eff=(ng_eff/2)
+ nsi_eff=((ng_eff-2)/2)

+ wdrift=(w)
+ ldrift=(6)
+ ldr1=(0.55)
+ lacts=(0.3)
+ lactd=(1.32)
+ lactg=(0.35)

// junction calculation
+ as=(w*lacts)
+ ps=((w+lacts)*2)
+ w2nhv=(9.9)*(1-fem)
+ rnhv=(1.6)
+ ad=((ldr1+lactg+ldrift/2-rnhv)*(w+2*w2nhv)+rnhv*(w+2*w2nhv-2*rnhv*(1-fem))+rnhv*rnhv*pi4models/2*(1-fem))
+ pd=(w+2*w2nhv-2*rnhv*(1-fem)+2*(ldr1+lactg+ldrift/2-rnhv)+rnhv*pi4models*(1-fem))
+ ad2=((ldrift/2+lactd/2)*(w+2*w2nhv))
+ pd2=(ldrift+lactd)

+ lb2b_d=(15.12)
+ lp2p_s=(0.99)
+ l2dt_s=(3.66)
+ w2dt=(13.4)*(1-fem)
+ xlnbl=(l2dt_s*nse+l*ng_eff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl=(w+2*w2dt)
+ alnbl=(xlnbl*ylnbl)
+ plnbl=(2*(xlnbl+ylnbl))

+ w_heat=(w)
+ l_heat=(lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld90b_sphv_10hv)*ng_eff
+ cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff
+ djunc=(2.5*1e-06)
+ tfact_ecrit=1+(tc1_ecrit_pld90b_sphv_10hv+tc2_ecrit_pld90b_sphv_10hv*(temp-tnom))*(temp-tnom)

// calculation for poly over field parasitic capaciance
+ dwcgdfldmoscap=34*(1-fem)
+ dwcgd_ply_fld=20*(1-fem)
+ cgd_ply_fld=6.0e-17*(w+dwcgd_ply_fld)*ng
+ cgs_ply_fld=6.0e-15*(1-fem)*ng

// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy=6.0e-17*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld90b_10hv = (32)
+ dvp_pld90b_10hv = (4)
+ type_pld90b_10hv = (-1)

// simple model factor
+ swdrlin  = (2)  
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.9255)


// parameters for the BV diode
+ dcbv_pld90b_10hv = (112)

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax  	= (1e12)
+ jmelt 	= (1e12)
+ tnom  	= (27)
+ is		= (1e-30)
+ n		= (1.0)
+ cj		= (1e-30)
+ pta		= (0)
+ tlevc 	= (2)
+ tlev  	= (2)
+ bv		= (dcbv_pld90b_10hv+bvdss_shift)
+ ibv		= (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (rd s) resistor r=0.01


// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec      = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi	     = 1
+ swdrlin	     = swdrlin
+ xvsat        = xvsat_pld90b_sphv_10hv
+ qmc          = qmc_pld90b_sphv_10hv
+ lvaro        = lvaro_pld90b_sphv_10hv
+ lvarl        = lvarl_pld90b_sphv_10hv
+ lvarw        = lvarw_pld90b_sphv_10hv*(1-fem)
+ lap          = lap_pld90b_sphv_10hv
+ wvaro        = wvaro_pld90b_sphv_10hv*(1-fem)
+ wvarl        = wvarl_pld90b_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld90b_sphv_10hv*(1-fem)
+ wot          = wot_pld90b_sphv_10hv*(1-fem)
+ dlq          = dlq_pld90b_sphv_10hv
+ dwq          = dwq_pld90b_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld90b_sphv_10hv+dela_vfb_pld90b_sphv_10hv+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*(0.028)+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld90b_vthratio
+ vfbl         = vfbl_pld90b_sphv_10hv
+ vfbw         = (vfbw_pld90b_sphv_10hv+dela_vtw_pld90b_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld90b_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld90b_sphv_10hv
+ stvfbl       = stvfbl_pld90b_sphv_10hv
+ stvfbw       = stvfbw_pld90b_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld90b_sphv_10hv*(1-fem)
+ toxo         = toxo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ epsroxo      = epsroxo_pld90b_sphv_10hv
+ nsubo        = nsubo_pld90b_sphv_10hv*delr_nsub_pld90b_sphv_10hv
+ nsubw        = nsubw_pld90b_sphv_10hv*(1-fem)
+ wseg         = wseg_pld90b_sphv_10hv
+ npck         = npck_pld90b_sphv_10hv
+ npckw        = npckw_pld90b_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld90b_sphv_10hv
+ lpck         = lpck_pld90b_sphv_10hv
+ lpckw        = lpckw_pld90b_sphv_10hv*(1-fem)
+ fol1         = fol1_pld90b_sphv_10hv
+ fol2         = fol2_pld90b_sphv_10hv
+ facneffaco   = facneffaco_pld90b_sphv_10hv
+ facneffacl   = facneffacl_pld90b_sphv_10hv
+ facneffacw   = facneffacw_pld90b_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld90b_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld90b_sphv_10hv
+ gfacnudl     = gfacnudl_pld90b_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld90b_sphv_10hv
+ gfacnudw     = gfacnudw_pld90b_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld90b_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld90b_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld90b_sphv_10hv
+ vnsubo       = vnsubo_pld90b_sphv_10hv
+ nslpo        = nslpo_pld90b_sphv_10hv
+ dnsubo       = dnsubo_pld90b_sphv_10hv
+ dphibo       = dphibo_pld90b_sphv_10hv
+ dphibl       = dphibl_pld90b_sphv_10hv
+ dphiblexp    = dphiblexp_pld90b_sphv_10hv
+ dphibw       = dphibw_pld90b_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld90b_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld90b_sphv_10hv
+ delvtacl     = delvtacl_pld90b_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld90b_sphv_10hv
+ delvtacw     = delvtacw_pld90b_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld90b_sphv_10hv*(1-fem)
+ npo          = npo_pld90b_sphv_10hv
+ npl          = npl_pld90b_sphv_10hv
+ cto          = cto_pld90b_sphv_10hv
+ ctl          = ctl_pld90b_sphv_10hv
+ ctlexp       = ctlexp_pld90b_sphv_10hv
+ ctw          = ctw_pld90b_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld90b_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld90b_sphv_10hv
+ ctbo         = ctbo_pld90b_sphv_10hv
+ stcto        = stcto_pld90b_sphv_10hv
+ toxovo       = toxovo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ toxovdo      = toxovdo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ lov          = lov_pld90b_sphv_10hv
+ dlovd        = dlovd_pld90b_sphv_10hv
+ novo         = novo_pld90b_sphv_10hv
+ novdo        = novdo_pld90b_sphv_10hv
+ cfl          = cfl_pld90b_sphv_10hv
+ cflexp       = cflexp_pld90b_sphv_10hv
+ cfw          = cfw_pld90b_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld90b_sphv_10hv
+ uo           = uo_pld90b_sphv_10hv*delr_uch_pld90b_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld90b_sphv_10hv
+ fbet1w       = fbet1w_pld90b_sphv_10hv*(1-fem)
+ lp1          = lp1_pld90b_sphv_10hv
+ lp1w         = lp1w_pld90b_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld90b_sphv_10hv
+ lp2          = lp2_pld90b_sphv_10hv
+ betw1        = betw1_pld90b_sphv_10hv*(1-fem)
+ betw2        = betw2_pld90b_sphv_10hv*(1-fem)
+ wbet         = wbet_pld90b_sphv_10hv
+ stbeto       = stbeto_pld90b_sphv_10hv
+ stbetl       = stbetl_pld90b_sphv_10hv
+ stbetw       = stbetw_pld90b_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld90b_sphv_10hv*(1-fem)
+ mueo         = mueo_pld90b_sphv_10hv
+ muew         = muew_pld90b_sphv_10hv*(1-fem)
+ stmueo       = stmueo_pld90b_sphv_10hv
+ themuo       = themuo_pld90b_sphv_10hv
+ stthemuo     = stthemuo_pld90b_sphv_10hv
+ cso          = cso_pld90b_sphv_10hv
+ csl          = csl_pld90b_sphv_10hv
+ cslexp       = cslexp_pld90b_sphv_10hv
+ csw          = csw_pld90b_sphv_10hv*(1-fem)
+ cslw         = cslw_pld90b_sphv_10hv*(1-fem)
+ stcso        = stcso_pld90b_sphv_10hv
+ xcoro        = xcoro_pld90b_sphv_10hv
+ xcorl        = xcorl_pld90b_sphv_10hv
+ xcorw        = xcorw_pld90b_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld90b_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld90b_sphv_10hv
+ fetao        = fetao_pld90b_sphv_10hv
+ rsw1         = rsw1_pld90b_sphv_10hv
+ rsw2         = rsw2_pld90b_sphv_10hv*(1-fem)
+ strso        = strso_pld90b_sphv_10hv
+ rsbo         = rsbo_pld90b_sphv_10hv
+ rsgo         = rsgo_pld90b_sphv_10hv
+ thesato      = thesato_pld90b_sphv_10hv*(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*(0.3))
+ thesatl      = thesatl_pld90b_sphv_10hv
+ thesatlexp   = thesatlexp_pld90b_sphv_10hv
+ thesatw      = thesatw_pld90b_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld90b_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld90b_sphv_10hv
+ stthesatl    = stthesatl_pld90b_sphv_10hv
+ stthesatw    = stthesatw_pld90b_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld90b_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld90b_sphv_10hv
+ thesatgo     = thesatgo_pld90b_sphv_10hv
+ thesatgl     = thesatgl_pld90b_sphv_10hv
+ thesatgw     = thesatgw_pld90b_sphv_10hv*(1-fem)
+ vdscale      = vdscale_pld90b_sphv_10hv
+ vdscaleb     = vdscaleb_pld90b_sphv_10hv
+ stvdscale    = stvdscale_pld90b_sphv_10hv
+ axo          = axo_pld90b_sphv_10hv
+ axl          = axl_pld90b_sphv_10hv
+ alpl         = alpl_pld90b_sphv_10hv
+ alplexp      = alplexp_pld90b_sphv_10hv
+ alpw         = alpw_pld90b_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld90b_sphv_10hv
+ alp1lexp     = alp1lexp_pld90b_sphv_10hv
+ alp1l2       = alp1l2_pld90b_sphv_10hv
+ alp1w        = alp1w_pld90b_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld90b_sphv_10hv
+ alp2lexp     = alp2lexp_pld90b_sphv_10hv
+ alp2l2       = alp2l2_pld90b_sphv_10hv
+ alp2w        = alp2w_pld90b_sphv_10hv*(1-fem)
+ vpo          = vpo_pld90b_sphv_10hv
+ a1o          = a1o_pld90b_sphv_10hv
+ a1l          = a1l_pld90b_sphv_10hv
+ a1w          = a1w_pld90b_sphv_10hv*(1-fem)
+ a2o          = a2o_pld90b_sphv_10hv
+ sta2o        = sta2o_pld90b_sphv_10hv
+ a3o          = a3o_pld90b_sphv_10hv
+ a3l          = a3l_pld90b_sphv_10hv
+ a3w          = a3w_pld90b_sphv_10hv*(1-fem)
+ a4o          = a4o_pld90b_sphv_10hv
+ a4l          = a4l_pld90b_sphv_10hv
+ a4w          = a4w_pld90b_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld90b_sphv_10hv
+ iginvlw      = iginvlw_pld90b_sphv_10hv
+ igovw        = igovw_pld90b_sphv_10hv
+ igovdw       = igovdw_pld90b_sphv_10hv
+ stigo        = stigo_pld90b_sphv_10hv
+ gc2o         = gc2o_pld90b_sphv_10hv
+ gc3o         = gc3o_pld90b_sphv_10hv
+ chibo        = chibo_pld90b_sphv_10hv
+ agidlw       = agidlw_pld90b_sphv_10hv
+ agidldw      = agidldw_pld90b_sphv_10hv
+ bgidlo       = bgidlo_pld90b_sphv_10hv
+ bgidldo      = bgidldo_pld90b_sphv_10hv
+ stbgidlo     = stbgidlo_pld90b_sphv_10hv
+ stbgidldo    = stbgidldo_pld90b_sphv_10hv
+ cgidlo       = cgidlo_pld90b_sphv_10hv
+ cgidldo      = cgidldo_pld90b_sphv_10hv
+ cgbovl       = cgbovl_pld90b_sphv_10hv
+ cfrw         = cfrw_pld90b_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld90b_sphv_10hv*(1-fem)
+ fnto         = fnto_pld90b_sphv_10hv
+ nfalw        = nfalw_pld90b_sphv_10hv
+ nfblw        = nfblw_pld90b_sphv_10hv
+ nfclw        = nfclw_pld90b_sphv_10hv
+ efo          = efo_pld90b_sphv_10hv
+ lintnoi      = lintnoi_pld90b_sphv_10hv
+ alpnoi       = alpnoi_pld90b_sphv_10hv
+ kvthoweo     = kvthoweo_pld90b_sphv_10hv
+ kvthowel     = kvthowel_pld90b_sphv_10hv
+ kvthowew     = kvthowew_pld90b_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld90b_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld90b_sphv_10hv
+ kuowel       = kuowel_pld90b_sphv_10hv
+ kuowew       = kuowew_pld90b_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld90b_sphv_10hv*(1-fem)
+ rgo          = rgo_pld90b_sphv_10hv
+ rsh          = rsh_pld90b_sphv_10hv
+ rbulko       = rbulko_pld90b_sphv_10hv
+ rwello       = rwello_pld90b_sphv_10hv
+ rjunso       = rjunso_pld90b_sphv_10hv/(w+dwrjunso_pld90b_sphv_10hv*(1-fem))
+ rjundo       = rjundo_pld90b_sphv_10hv/(w+dwrjundo_pld90b_sphv_10hv*(1-fem))
+ rint         = rint_pld90b_sphv_10hv
+ rvpoly       = rvpoly_pld90b_sphv_10hv
+ rshg         = rshg_pld90b_sphv_10hv
+ dlsil        = dlsil_pld90b_sphv_10hv
+ saref        = saref_pld90b_sphv_10hv
+ sbref        = sbref_pld90b_sphv_10hv
+ wlod         = wlod_pld90b_sphv_10hv
+ kuo          = kuo_pld90b_sphv_10hv
+ kvsat        = kvsat_pld90b_sphv_10hv
+ tkuo         = tkuo_pld90b_sphv_10hv
+ lkuo         = lkuo_pld90b_sphv_10hv
+ wkuo         = wkuo_pld90b_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld90b_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld90b_sphv_10hv
+ wlodkuo      = wlodkuo_pld90b_sphv_10hv
+ kvtho        = kvtho_pld90b_sphv_10hv
+ lkvtho       = lkvtho_pld90b_sphv_10hv
+ wkvtho       = wkvtho_pld90b_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld90b_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld90b_sphv_10hv
+ wlodvth      = wlodvth_pld90b_sphv_10hv
+ stetao       = stetao_pld90b_sphv_10hv
+ lodetao      = lodetao_pld90b_sphv_10hv
+ scref        = scref_pld90b_sphv_10hv
+ web          = web_pld90b_sphv_10hv
+ wec          = wec_pld90b_sphv_10hv
+ adr1o        = adr1o_pld90b_sphv_10hv
+ adr1l        = adr1l_pld90b_sphv_10hv
+ adr1w        = adr1w_pld90b_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld90b_sphv_10hv
+ stadr2o      = stadr2o_pld90b_sphv_10hv
+ adr3o        = adr3o_pld90b_sphv_10hv
+ adr3l        = adr3l_pld90b_sphv_10hv
+ adr3w        = adr3w_pld90b_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld90b_sphv_10hv
+ adr4l        = adr4l_pld90b_sphv_10hv
+ adr4w        = adr4w_pld90b_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld90b_sphv_10hv
+ adr5l        = adr5l_pld90b_sphv_10hv
+ adr5w        = adr5w_pld90b_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld90b_sphv_10hv
+ bidr1l       = bidr1l_pld90b_sphv_10hv
+ bidr1w       = bidr1w_pld90b_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld90b_sphv_10hv
+ bidr2w       = bidr2w_pld90b_sphv_10hv*(1-fem)
+ rtho       = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld90b_sphv_10hv
+ strthao      = strthao_pld90b_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld90b_sphv_10hv*delr_res_pld90b_sphv_10hv*(1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*(0.18))*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld90b_ronratio)*fac_rshldd)
+ xw           = xw_pld90b_sphv_10hv*(1-fem)
+ nwxw         = (nwxw_pld90b_sphv_10hv+1.0e-12*dela_dwox_pld90b_sphv_10hv)*(1-fem)
+ xl           = xl_pld90b_sphv_10hv
+ xlw          = xlw_pld90b_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld90b_sphv_10hv
+ nst          = nst_pld90b_sphv_10hv
+ ats          = ats_pld90b_sphv_10hv
+ dfinf        = dfinf_pld90b_sphv_10hv
+ dfw          = dfw_pld90b_sphv_10hv*(1-fem)
+ dfl          = dfl_pld90b_sphv_10hv
+ dflw         = dflw_pld90b_sphv_10hv*(1-fem)
+ dp           = dp_pld90b_sphv_10hv
+ ecrit        = ecrit_pld90b_sphv_10hv*tfact_ecrit
+ ecorn        = ecorn_pld90b_sphv_10hv*tfact_ecrit
+ du           = du_pld90b_sphv_10hv
+ tc1          = tc1_pld90b_sphv_10hv
+ tc2          = tc2_pld90b_sphv_10hv
+ tc1l         = tc1l_pld90b_sphv_10hv
+ tc2l         = tc2l_pld90b_sphv_10hv
+ tc1w         = tc1w_pld90b_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld90b_sphv_10hv*(1-fem)
+ theacc       = theacc_pld90b_sphv_10hv
+ theacc2      = theacc2_pld90b_sphv_10hv
+ rva          = rva_pld90b_sphv_10hv
+ dta          = dta_pld90b_sphv_10hv
+ trj          = trj_pld90b_sphv_10hv
+ cjarea       = cjarea_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlsti       = cjlsti_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlgat       = cjarea_pld90b_sphv_10hv*djunc*delr_cj_pld90b_sphv_10hv
+ vbiarea      = vbiarea_pld90b_sphv_10hv
+ vbisti       = vbisti_pld90b_sphv_10hv
+ vbigat       = vbigat_pld90b_sphv_10hv
+ parea        = parea_pld90b_sphv_10hv
+ psti         = psti_pld90b_sphv_10hv
+ pgat         = pgat_pld90b_sphv_10hv
+ is1area      = is1area_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttarea       = ttarea_pld90b_sphv_10hv
+ is2area      = is2area_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irarea       = irarea_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1area    = stis1area_pld90b_sphv_10hv
+ stis2area    = stis2area_pld90b_sphv_10hv
+ stirarea     = stirarea_pld90b_sphv_10hv
+ n1area       = n1area_pld90b_sphv_10hv
+ n2area       = n2area_pld90b_sphv_10hv
+ nrarea       = nrarea_pld90b_sphv_10hv
+ is1lsti      = is1lsti_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlsti       = ttlsti_pld90b_sphv_10hv
+ is2lsti      = is2lsti_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlsti       = irlsti_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1sti     = stis1sti_pld90b_sphv_10hv
+ stis2sti     = stis2sti_pld90b_sphv_10hv
+ stirsti      = stirsti_pld90b_sphv_10hv
+ n1sti        = n1sti_pld90b_sphv_10hv
+ n2sti        = n2sti_pld90b_sphv_10hv
+ nrsti        = nrsti_pld90b_sphv_10hv
+ is1lgat      = is1area_pld90b_sphv_10hv*djunc*delr_is_pld90b_sphv_10hv
+ ttlgat       = ttlgat_pld90b_sphv_10hv
+ is2lgat      = is2area_pld90b_sphv_10hv*djunc*delr_is2_pld90b_sphv_10hv
+ irlgat       = irarea_pld90b_sphv_10hv*djunc*delr_ir_pld90b_sphv_10hv
+ stis1gat     = stis1gat_pld90b_sphv_10hv
+ stis2gat     = stis2gat_pld90b_sphv_10hv
+ stirgat      = stirgat_pld90b_sphv_10hv
+ n1gat        = n1gat_pld90b_sphv_10hv
+ n2gat        = n2gat_pld90b_sphv_10hv
+ nrgat        = nrgat_pld90b_sphv_10hv
+ cjaread      = cjaread_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlstid      = cjlstid_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlgatd      = cjlgatd_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ vbiaread     = vbiaread_pld90b_sphv_10hv
+ vbistid      = vbistid_pld90b_sphv_10hv
+ vbigatd      = vbigatd_pld90b_sphv_10hv
+ paread       = paread_pld90b_sphv_10hv
+ pstid        = pstid_pld90b_sphv_10hv
+ pgatd        = pgatd_pld90b_sphv_10hv
+ is1aread     = is1aread_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttaread      = ttaread_pld90b_sphv_10hv
+ is2aread     = is2aread_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ iraread      = iraread_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1aread   = stis1aread_pld90b_sphv_10hv
+ stis2aread   = stis2aread_pld90b_sphv_10hv
+ stiraread    = stiraread_pld90b_sphv_10hv
+ n1aread      = n1aread_pld90b_sphv_10hv
+ n2aread      = n2aread_pld90b_sphv_10hv
+ nraread      = nraread_pld90b_sphv_10hv
+ is1lstid     = is1lstid_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlstid      = ttlstid_pld90b_sphv_10hv
+ is2lstid     = is2lstid_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlstid      = irlstid_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1stid    = stis1stid_pld90b_sphv_10hv
+ stis2stid    = stis2stid_pld90b_sphv_10hv
+ stirstid     = stirstid_pld90b_sphv_10hv
+ n1stid       = n1stid_pld90b_sphv_10hv
+ n2stid       = n2stid_pld90b_sphv_10hv
+ nrstid       = nrstid_pld90b_sphv_10hv
+ is1lgatd     = is1aread_pld90b_sphv_10hv*djunc*delr_is_pld90b_sphv_10hv
+ ttlgatd      = ttlgatd_pld90b_sphv_10hv
+ is2lgatd     = is2aread_pld90b_sphv_10hv*djunc*delr_is2_pld90b_sphv_10hv
+ irlgatd      = irlgatd_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1gatd    = stis1gatd_pld90b_sphv_10hv
+ stis2gatd    = stis2gatd_pld90b_sphv_10hv
+ stirgatd     = stirgatd_pld90b_sphv_10hv
+ n1gatd       = n1gatd_pld90b_sphv_10hv
+ n2gatd       = n2gatd_pld90b_sphv_10hv
+ nrgatd       = nrgatd_pld90b_sphv_10hv
+ cjaread2     = cjaread2_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlstid2     = cjlstid2_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ vbiaread2    = vbiaread2_pld90b_sphv_10hv
+ vbistid2     = vbistid2_pld90b_sphv_10hv
+ paread2      = paread2_pld90b_sphv_10hv
+ pstid2       = pstid2_pld90b_sphv_10hv
+ is1aread2    = is1aread2_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttaread2     = ttaread2_pld90b_sphv_10hv
+ is2aread2    = is2aread2_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ iraread2     = iraread2_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1aread2  = stis1aread2_pld90b_sphv_10hv
+ stis2aread2  = stis2aread2_pld90b_sphv_10hv
+ stiraread2   = stiraread2_pld90b_sphv_10hv
+ n1aread2     = n1aread2_pld90b_sphv_10hv
+ n2aread2     = n2aread2_pld90b_sphv_10hv
+ nraread2     = nraread2_pld90b_sphv_10hv
+ is1lstid2    = is1lstid2_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlstid2     = ttlstid2_pld90b_sphv_10hv
+ is2lstid2    = is2lstid2_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlstid2     = irlstid2_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1stid2   = stis1stid2_pld90b_sphv_10hv
+ stis2stid2   = stis2stid2_pld90b_sphv_10hv
+ stirstid2    = stirstid2_pld90b_sphv_10hv
+ n1stid2      = n1stid2_pld90b_sphv_10hv
+ n2stid2      = n2stid2_pld90b_sphv_10hv
+ nrstid2      = nrstid2_pld90b_sphv_10hv
+ aacc         = aacc_pld90b_sphv_10hv
+ eais1area    = eais1area_pld90b_sphv_10hv
+ eais2area    = eais2area_pld90b_sphv_10hv
+ eairarea     = eairarea_pld90b_sphv_10hv
+ eais1sti     = eais1sti_pld90b_sphv_10hv
+ eais2sti     = eais2sti_pld90b_sphv_10hv
+ eairsti      = eairsti_pld90b_sphv_10hv
+ eais1gat     = eais1gat_pld90b_sphv_10hv
+ eais2gat     = eais2gat_pld90b_sphv_10hv
+ eairgat      = eairgat_pld90b_sphv_10hv
+ eais1aread   = eais1aread_pld90b_sphv_10hv
+ eais2aread   = eais2aread_pld90b_sphv_10hv
+ eairaread    = eairaread_pld90b_sphv_10hv
+ eais1stid    = eais1stid_pld90b_sphv_10hv
+ eais2stid    = eais2stid_pld90b_sphv_10hv
+ eairstid     = eairstid_pld90b_sphv_10hv
+ eais1gatd    = eais1gatd_pld90b_sphv_10hv
+ eais2gatd    = eais2gatd_pld90b_sphv_10hv
+ eairgatd     = eairgatd_pld90b_sphv_10hv
+ eais1aread2  = eais1aread2_pld90b_sphv_10hv
+ eais2aread2  = eais2aread2_pld90b_sphv_10hv
+ eairaread2   = eairaread2_pld90b_sphv_10hv
+ eais1stid2   = eais1stid2_pld90b_sphv_10hv
+ eais2stid2   = eais2stid2_pld90b_sphv_10hv
+ eairstid2    = eairstid2_pld90b_sphv_10hv


// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr = 27
+    toxo = 320e-9
+    vfbo = 0
+    nsubo = 2.35e22
+    npck = 1e22
+    lpck = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo   = 0


cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cgs_ply_fld)
rgate (g gi) resistor r=(rply*((w+2*10.675*(1-fem))/(length*3*ng)))
xdsub (s sub) cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)) perim=(plnbl*(1-lpe)) soa=1

if (ng_dmy>=2) {

amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}

include "./smos10hv_ade_dfrt.scs" section=pld90b_10hv_dfrt
ends


//***********************************************************
endsection powermos_simple
//***********************************************************

//***********************************************************
section substrate_cap
//***********************************************************

subckt clgo_box_sub_10hv (p n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    area_diode                     = 1e-02
+    perim_diode                    = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_d_val                     = (area_diode+(area_diode==0)*1e-2)
+    perim_d_val                    = (perim_diode+(perim_diode==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    area_d_um                      = (sDOTmult*sDOTmult*area_d_val)
+    perim_d_um                     = (sDOTmult*perim_d_val)
+    apar_a                         = (((6.37161e-17*0.92*1.24)/(delr_tox_box))*((1.1494)+(0.0018)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.8138)+(-0.0038)*(temp-27)),0.001)
+    apar_b                         = (((4.2336e-17*0.9*0.8)/(delr_tox_box))*t_apar_b)
+    apar_slope                     = ((-0.30)*((1.3242)+(0.0055)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)))
+    apar_dv                        = (1.05)
+    ppar_a                         = ((3.37858e-16*1.25/(delr_tox_box))*((0.9529)+(-0.0004)*(temp-27)+0*(-3e-6)*(temp-27)*(temp-27)))
+    ppar_b                         = (((7.00e-17*1.15)/(delr_tox_box))*((0.9591)+(-0.0039)*(temp-27)+(9e-6)*(temp-27)*(temp-27)))
+    ppar_slope                     = ((0.1064)*((0.7702)+(0.0007)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_dv                        = ((0.065)+((0.0688)+(0.0011)*(temp-27)+(0)*(temp-27)*(temp-27)))

bcbox_perim (n sub) bsource q=(-perim_um*(ppar_a*v(sub,n)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,n)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (n sub) bsource q=(-area_um*(apar_a*v(sub,n)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,n)+(apar_dv)))) tc1=0 tc2=0
xdpw_nw (p n) dnw_pepi_10hv area=(area_d_um) perim=(perim_d_um) soa=1

include "./smos10hv_ade_dfrt.scs" section=clgo_box_sub_10hv_dfrt
ends

subckt cpwtub_box_sub_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    apar_slope                     = (-4.00e-01)
+    apar_dv                        = (0.1)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_slope                     = (-4.00e-01)
+    ppar_dv                        = (-1.1)

bcbox_perim (p sub) bsource q=(-perim_um*(ppar_a*v(sub,p)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,p)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (p sub) bsource q=(-area_um*(apar_a*v(sub,p)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,p)+(apar_dv)))) tc1=0 tc2=0

include "./smos10hv_ade_dfrt.scs" section=cpwtub_box_sub_10hv_dfrt
ends

subckt cpwtub_box_sub_float_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    apar_slope                     = (-4.00e-01)
+    apar_dv                        = (0.1)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_slope                     = (-4.00e-01)
+    ppar_dv                        = (-1.1)

bcbox_perim (p sub) bsource q=(-perim_um*(ppar_a*v(sub,p)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,p)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (p sub) bsource q=(-area_um*(apar_a*v(sub,p)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,p)+(apar_dv)))) tc1=0 tc2=0
res (p sub) resistor r=1e8

include "./smos10hv_ade_dfrt.scs" section=cpwtub_box_sub_float_10hv_dfrt
ends

subckt cnwtub_box_sub_10hv (n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((4.09623e-17*1.04/(delr_tox_box))*((1.0913)+(0.0023)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    apar_b                         = (((2.10539e-17*0.97)/(delr_tox_box))*((0.7587)+(-0.005)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    apar_slope                     = (0.2)
+    apar_dv                        = (0)
+    ppar_a                         = ((3.55255e-16*0.95/(delr_tox_box))*((0.986)+(0.0013)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)))
+    ppar_b                         = (((1.3821e-16*0.65)/(delr_tox_box))*((0.9869)+(-0.004)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    ppar_slope                     = (0.935)
+    ppar_dv                        = (0)

bcbox_perim (n sub) bsource q=(-perim_um*(ppar_a*v(sub,n)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,n)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (n sub) bsource q=(-area_um*(apar_a*v(sub,n)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,n)+(apar_dv)))) tc1=0 tc2=0

include "./smos10hv_ade_dfrt.scs" section=cnwtub_box_sub_10hv_dfrt
ends

subckt cdgoptub_box_sub_10hv (n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = (((6.37161e-17*0.92*1.24)/(delr_tox_box))*((1.1494)+(0.0018)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.8138)+(-0.0038)*(temp-27)),0.001)
+    apar_b                         = (((4.2336e-17*0.9*0.8)/(delr_tox_box))*t_apar_b)
+    apar_slope                     = ((-0.30)*((1.3242)+(0.0055)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)))
+    apar_dv                        = (1.05)
+    ppar_a                         = ((3.37858e-16*1.25/(delr_tox_box))*((0.9529)+(-0.0004)*(temp-27)+0*(-3e-6)*(temp-27)*(temp-27)))
+    ppar_b                         = (((7.00e-17*1.15)/(delr_tox_box))*((0.9591)+(-0.0039)*(temp-27)+(9e-6)*(temp-27)*(temp-27)))
+    ppar_slope                     = ((0.1064)*((0.7702)+(0.0007)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_dv                        = ((0.065)+((0.0688)+(0.0011)*(temp-27)+(0)*(temp-27)*(temp-27)))

bcbox_perim (n sub) bsource q=(-perim_um*(ppar_a*v(sub,n)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,n)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (n sub) bsource q=(-area_um*(apar_a*v(sub,n)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,n)+(apar_dv)))) tc1=0 tc2=0

include "./smos10hv_ade_dfrt.scs" section=cdgoptub_box_sub_10hv_dfrt
ends

subckt cdgontub_box_sub_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    apar_slope                     = (-4.00e-01)
+    apar_dv                        = (0.1)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_slope                     = (-4.00e-01)
+    ppar_dv                        = (-1.1)

bcbox_perim (p sub) bsource q=(-perim_um*(ppar_a*v(sub,p)+(ppar_b/ppar_slope)*ln_cosh(ppar_slope*v(sub,p)+(ppar_dv)))) tc1=0 tc2=0
bcbox_area (p sub) bsource q=(-area_um*(apar_a*v(sub,p)+(apar_b/apar_slope)*ln_cosh(apar_slope*v(sub,p)+(apar_dv)))) tc1=0 tc2=0

include "./smos10hv_ade_dfrt.scs" section=cdgontub_box_sub_10hv_dfrt
ends

//***********************************************************
endsection substrate_cap
//***********************************************************

//***********************************************************
section substrate_cap_simple
//***********************************************************

subckt clgo_box_sub_10hv (p n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    area_diode                     = 1e-02
+    perim_diode                    = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_d_val                     = (area_diode+(area_diode==0)*1e-2)
+    perim_d_val                    = (perim_diode+(perim_diode==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    area_d_um                      = (sDOTmult*sDOTmult*area_d_val)
+    perim_d_um                     = (sDOTmult*perim_d_val)
+    apar_a                         = (((6.37161e-17*0.92*1.24)/(delr_tox_box))*((1.1494)+(0.0018)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.8138)+(-0.0038)*(temp-27)),0.001)
+    apar_b                         = (((4.2336e-17*0.9*0.8)/(delr_tox_box))*t_apar_b)
+    ppar_a                         = ((3.37858e-16*1.25/(delr_tox_box))*((0.9529)+(-0.0004)*(temp-27)+0*(-3e-6)*(temp-27)*(temp-27)))
+    ppar_b                         = (((7.00e-17*1.15)/(delr_tox_box))*((0.9591)+(-0.0039)*(temp-27)+(9e-6)*(temp-27)*(temp-27)))
+    ca                             = (area_um*(apar_a+apar_b))
+    cp                             = (perim_um*(ppar_a*0.989))
+    totalcap                       = (ca+cp)

cbox (n sub) capacitor c=totalcap
xdpw_nw (p n) dnw_pepi_10hv area=(area_d_um) perim=(perim_d_um) soa=1

include "./smos10hv_ade_dfrt.scs" section=clgo_box_sub_10hv_dfrt
ends

subckt cpwtub_box_sub_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    totalcap                       = ((perim_um*(ppar_a+ppar_b))+(area_um*(apar_a+apar_b)))

cbox (p sub) capacitor c=totalcap

include "./smos10hv_ade_dfrt.scs" section=cpwtub_box_sub_10hv_dfrt
ends

subckt cpwtub_box_sub_float_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    totalcap                       = ((perim_um*(ppar_a+ppar_b))+(area_um*(apar_a+apar_b)))

cbox (p sub) capacitor c=totalcap
res (p sub) resistor r=1e8

include "./smos10hv_ade_dfrt.scs" section=cpwtub_box_sub_float_10hv_dfrt
ends

subckt cnwtub_box_sub_10hv (n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((4.09623e-17*1.04/(delr_tox_box))*((1.0913)+(0.0023)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    apar_b                         = (((2.10539e-17*0.97)/(delr_tox_box))*((0.7587)+(-0.005)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    ppar_a                         = ((3.55255e-16*0.95/(delr_tox_box))*((0.986)+(0.0013)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)))
+    ppar_b                         = (((1.3821e-16*0.65)/(delr_tox_box))*((0.9869)+(-0.004)*(temp-27)+(2e-5)*(temp-27)*(temp-27)))
+    totalcap                       = ((perim_um*(ppar_a+ppar_b))+(area_um*(apar_a+apar_b)))

cbox (n sub) capacitor c=totalcap

include "./smos10hv_ade_dfrt.scs" section=cnwtub_box_sub_10hv_dfrt
ends

subckt cdgoptub_box_sub_10hv (n sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = (((6.37161e-17*0.92*1.24)/(delr_tox_box))*((1.1494)+(0.0018)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.8138)+(-0.0038)*(temp-27)),0.001)
+    apar_b                         = (((4.2336e-17*0.9*0.8)/(delr_tox_box))*t_apar_b)
+    ppar_a                         = ((3.37858e-16*1.25/(delr_tox_box))*((0.9529)+(-0.0004)*(temp-27)+0*(-3e-6)*(temp-27)*(temp-27)))
+    ppar_b                         = (((7.00e-17*1.15)/(delr_tox_box))*((0.9591)+(-0.0039)*(temp-27)+(9e-6)*(temp-27)*(temp-27)))
+    ca                             = (area_um*(apar_a+apar_b))
+    cp                             = (perim_um*(ppar_a*0.989))
+    totalcap                       = (ca+cp)

cbox (n sub) capacitor c=totalcap

include "./smos10hv_ade_dfrt.scs" section=cdgoptub_box_sub_10hv_dfrt
ends

subckt cdgontub_box_sub_10hv (p sub)

parameters
+    area                           = 1e-02
+    perim                          = 1e-02
+    soa                            = 1
+    delr_tox_box                   = (nom_delr_tox_box*(1.0+nsig_delr_tox_box*sig_delr_tox_box))
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    area_um                        = (sDOTmult*sDOTmult*area_val)
+    perim_um                       = (sDOTmult*perim_val)
+    apar_a                         = ((6.96885e-17*1.03/(delr_tox_box))*((1.0114)+(0.0017)*(temp-27)+(5e-6)*(temp-27)*(temp-27)))
+    t_apar_b                       = maxa(0,((0.9926)+(-0.0028)*(temp-27)+(-1e-5)*(temp-27)*(temp-27)),0.001)
+    apar_b                         = ((4.60545e-17*0.95/(delr_tox_box))*t_apar_b)
+    ppar_a                         = ((2.31312e-16*1.05*1.3/(delr_tox_box))*((0.9509)+(0.0006)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    ppar_b                         = ((6.64565e-17*0.52*1.5/(delr_tox_box))*((1.217)+(-0.0021)*(temp-27)+(0)*(temp-27)*(temp-27)))
+    totalcap                       = ((perim_um*(ppar_a+ppar_b))+(area_um*(apar_a+apar_b)))

cbox (p sub) capacitor c=totalcap

include "./smos10hv_ade_dfrt.scs" section=cdgontub_box_sub_10hv_dfrt
ends

//***********************************************************
endsection substrate_cap_simple
//***********************************************************

//***********************************************************
section drsf_zener
//***********************************************************

subckt dz5_10hv (p n sub)

parameters
+    w                              = 3.4
+    nc                             = 1
+    lpe                            = 0
+    soa                            = 1
+    fault_dz5_leakage_outlier      = fault_dz5_leakage_outlier_global
+    nsmm_dela_bv_dz5_10hv          = tmp_nsmm_dela_bv_dz5_10hv
+    nsmm_delr_isr_dz5_10hv         = tmp_nsmm_delr_isr_dz5_10hv
+    tc_bv_mm                       = (1+(temp-27)*(8.5e-4))
+    dela_bv_dz5_10hv               = (nom_dela_bv_dz5_10hv+nsig_dela_bv_dz5_10hv*sig_dela_bv_dz5_10hv+tc_bv_mm*nsmm_dela_bv_dz5_10hv*smm_dela_bv_dz5_10hv(w)/sqrt(nc))
+    delr_isr_dz5_10hv              = (nom_delr_isr_dz5_10hv*(exp(sig_delr_isr_dz5_10hv*nsig_delr_isr_dz5_10hv))*(1+nsmm_delr_isr_dz5_10hv*smm_delr_isr_dz5_10hv(w)/sqrt(nc)))
+    meffval                        = (nc)
+    ldpn                           = (3.4+0.35)
+    wdpn                           = (w+(-0.5))
+    adpn                           = (wdpn*ldpn*sDOTmult2)
+    pdpn                           = (2*(wdpn+ldpn)*sDOTmult)
+    adpn0                          = (3.4*3.4*sDOTmult2)
+    liso                           = (2.98*2+nc*3.4+(nc-1)*3.41)
+    wiso                           = (2.98*2+w)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (815/pdpn)*pow((temp+273.15)/(27+273.15),0.7)
+    cj_dz5_10hv                    = ((2.019e-15*adpn+4.88591e-15*pdpn))
+    pta_dz5_10hv                   = (0.00138660409680497)
+    aphi_tnom                      = (0.887525)
+    aphi_calc                      = (aphi_tnom-pta_dz5_10hv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.377414)

model dz5_10hv_forward1 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((1.0e-50))*1.0e12)
+ bv            = (5.055+(dela_bv_dz5_10hv)+(temp-27)*((0.00102019)+(temp-27)*(5.29086e-07)))
+ ibv           = (((100e-6/adpn0*adpn))*1.0e12)
+ nz            = (0.1)
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.935)
+ kf            = (2.5e-7)
+ eg            = (1.188)
+ tlev          = (2)
+ gap1          = (460e-6)
+ gap2          = (601.5)

model dz5_10hv_forward2 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((1.86844e-19*pdpn))*1.0e12)
+ n             = (1.003)
+ cj            = ((((cj_dz5_10hv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.377414)
+ tt            = (3.0e-9)
+ xti           = (0.2)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.78)
+ kf            = (2.7e-10)
+ eg            = (1.188)
+ tlev          = (2)
+ gap1          = (460e-6)
+ gap2          = (601.5)

model dz5_10hv_reverse1 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((1.35e-15*adpn)*(delr_isr_dz5_10hv)))*1.0e12)
+ n             = (11.5+(temp-27)*((-0.0295751)+(temp-27)*(5.6182e-05)))
+ xti           = (10)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.75)
+ kf            = (1.0e-10)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (460e-06)
+ gap2          = (601.5)

model dz5_10hv_reverse2 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((2.0e-41*adpn)*(exp(-(dela_bv_dz5_10hv-nom_dela_bv_dz5_10hv)/(2.5*0.026)))))*1.0e12)
+ n             = (2.5)
+ xti           = (0)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.75)
+ kf            = (1.0e-10)
+ eg            = (4.92)
+ tlev          = (2)
+ gap1          = (0)
+ gap2          = (601.5)

bileak (n pi) bsource i=((fault_dz5_leakage_outlier==1)*((5.37e-7)*(sqrt(v(n,pi)**2+1e-10**2)+(v(n,pi)-1e-10))/2)) tc1=2.5e-3 tc2=0
ddz5_10hvf1 (pi n) dz5_10hv_forward1 m=(meffval)
ddz5_10hvf2 (pi n) dz5_10hv_forward2 m=(meffval)
ddz5_10hvz1 (n pi) dz5_10hv_reverse1 m=(meffval)
ddz5_10hvz2 (n pi) dz5_10hv_reverse2 m=(meffval)
aprint_function print_function
+ device="dz5_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_dz5_leakage_outlier
rrdz5_10hv (p pi) resistor r=(rseries) m=(meffval)
xsubcap_dz5_10hv (n sub) cnwtub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=dz5_10hv_dfrt
ends

subckt dz5b_10hv (p n sub)

parameters
+    w                              = 3.4
+    nc                             = 1
+    lpe                            = 0
+    soa                            = 1
+    fault_dz5b_leakage_outlier     = fault_dz5b_leakage_outlier_global
+    nsmm_dela_bv_dz5b_10hv         = tmp_nsmm_dela_bv_dz5b_10hv
+    nsmm_delr_isr_dz5b_10hv        = tmp_nsmm_delr_isr_dz5b_10hv
+    dela_bv_dz5b_10hv              = (nom_dela_bv_dz5b_10hv+nsig_dela_bv_dz5b_10hv*sig_dela_bv_dz5b_10hv+nsmm_dela_bv_dz5b_10hv*smm_dela_bv_dz5b_10hv(w)/sqrt(nc))
+    dela_bv_tc2_dz5b_10hv          = (nom_dela_bv_tc2_dz5b_10hv+nsig_dela_bv_tc2_dz5b_10hv*sig_dela_bv_tc2_dz5b_10hv)
+    delr_isr_dz5b_10hv             = (nom_delr_isr_dz5b_10hv*(exp(sig_delr_isr_dz5b_10hv*nsig_delr_isr_dz5b_10hv))*(1+nsmm_delr_isr_dz5b_10hv*smm_delr_isr_dz5b_10hv(w)/sqrt(nc)))
+    meffval                        = (nc)
+    ldpn                           = (3.4)
+    wdpn                           = (w)
+    adpn                           = (wdpn*ldpn*sDOTmult2)
+    pdpn                           = (2*(wdpn+ldpn)*sDOTmult)
+    adpn0                          = (3.4*3.4*sDOTmult2)
+    liso                           = (2.98*2+nc*3.4+(nc-1)*3.41)
+    wiso                           = (2.98*2+w)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (1230/pdpn)*pow((temp+273.15)/(tnom+273.15),0.9)
+    cj_dz5b_10hv                   = ((2.776e-15*adpn+3.283e-15*pdpn))
+    dtemp                          = (temp-tnom)
+    pta_dz5b_10hv                  = (0.00138660409680497)
+    aphi_tnom                      = (0.887525)
+    aphi_calc                      = (aphi_tnom-pta_dz5b_10hv*dtemp)
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.377414)
+    bv_tnom                        = (5.110+dela_bv_dz5b_10hv)
+    tc1                            = (1.2345e-3*bv_tnom+(-5.2067e-3))
+    tc2                            = (5.5417e-7+dela_bv_tc2_dz5b_10hv)
+    tc3                            = ((-3.4879e-3)*tc2+3.8556e-10)

model dz5b_10hv_forward1 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((1.0e-50))*1.0e12)
+ bv            = (bv_tnom+tc1*dtemp+tc2*dtemp*dtemp+tc3*dtemp*dtemp*dtemp)
+ ibv           = (((100e-6/adpn0*adpn))*1.0e12)
+ nz            = (0.08)
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.8)
+ kf            = (7.5e-8)
+ eg            = (1.188)
+ tlev          = (2)
+ gap1          = (460e-6)
+ gap2          = (601.5)

model dz5b_10hv_forward2 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((1.86844e-19*pdpn))*1.0e12)
+ n             = (1.003)
+ cj            = ((((cj_dz5b_10hv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.377414)
+ tt            = (3.0e-9)
+ xti           = (2.4)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.75)
+ kf            = (2.7e-10)
+ eg            = (1.11)
+ tlev          = (2)
+ gap1          = (460e-6)
+ gap2          = (601.5)

model dz5b_10hv_reverse1 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((6.85e-16*adpn)*(delr_isr_dz5b_10hv)))*1.0e12)
+ n             = (11.5+dtemp*((-0.0290751)+dtemp*(6.0182e-05)))
+ xti           = (14)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.75)
+ kf            = (1.0e-10)
+ eg            = (1.18)
+ tlev          = (2)
+ gap1          = (460e-06)
+ gap2          = (601.5)

model dz5b_10hv_reverse2 diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((6.0e-42*adpn)*(exp(-(dela_bv_dz5b_10hv-nom_dela_bv_dz5b_10hv)/(2.5*0.026)))))*1.0e12)
+ n             = (2.5)
+ xti           = (0)
+ tnom  = (27)
+ fc            = (0.9)
+ af            = (1.75)
+ kf            = (1.0e-10)
+ eg            = (4.92)
+ tlev          = (2)
+ gap1          = (0)
+ gap2          = (601.5)

bileak (n pi) bsource i=((fault_dz5b_leakage_outlier==1)*((1.43e-7)*(sqrt(v(n,pi)**2+1e-10**2)+(v(n,pi)-1e-10))/2)) tc1=2.5e-3 tc2=0
ddz5b_10hvf1 (pi n) dz5b_10hv_forward1 m=(meffval)
ddz5b_10hvf2 (pi n) dz5b_10hv_forward2 m=(meffval)
ddz5b_10hvz1 (n pi) dz5b_10hv_reverse1 m=(meffval)
ddz5b_10hvz2 (n pi) dz5b_10hv_reverse2 m=(meffval)
aprint_function print_function
+ device="dz5b_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_dz5b_leakage_outlier
rrdz5b_10hv (p pi) resistor r=(rseries) m=(meffval)
xsubcap_dz5b_10hv (n sub) cnwtub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=dz5b_10hv_dfrt
ends

subckt drsf45_10hv (p n sub)

parameters
+    w                              = 1.8
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    delr_isr_drsf45_10hv           = (nom_delr_isr_drsf45_10hv*exp(sig_delr_isr_drsf45_10hv*nsig_delr_isr_drsf45_10hv))
+    delr_isf_drsf45_10hv           = (nom_delr_isf_drsf45_10hv*exp(sig_delr_isf_drsf45_10hv*nsig_delr_isf_drsf45_10hv))
+    rhvnw                          = (1.6+(1.35))
+    ahvnw                          = ((2*rhvnw*(w-1.0)+pi4models*(rhvnw*rhvnw))*sDOTmult2)
+    phvnw                          = ((2*(w-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    phvnw0                         = ((2*(1.6-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    rncom                          = (2.75+(1.5))
+    pncom                          = ((2*(w-1.0)+pi4models*2*rncom)*sDOTmult)
+    wiso                           = (9.5+w)
+    lint                           = (3.85)
+    lext                           = (3.035)
+    lcell                          = (2*(1.6))
+    liso                           = (np*lcell+(np-1)*lint+2*lext)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (21.7291/(w**0.781166-0.498068))
+    cj_drsf45_10hv                 = ((2.46411e-16*ahvnw+8.2032e-17*phvnw))
+    pta_drsf45_10hv                = (0.00261891359174924)
+    aphi_tnom                      = (0.5)
+    aphi_calc                      = (aphi_tnom-pta_drsf45_10hv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.206789)
+    tkel                           = (temp+273.15)
+    tkelnom                        = (27+273.15)
+    trel                           = (tkel/tkelnom)
+    kay                            = (8.86e-5)

model drsf45_10hv_forward diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((4.4005e-19)*delr_isf_drsf45_10hv))*1.0e12)
+ n             = (1.053)
+ bv            = (60.5)
+ ibv           = (((100e-9/(phvnw0)))*1.0e12)
+ cj            = ((((cj_drsf45_10hv/phvnw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.206789)
+ tt            = (1.27e-9)
+ xti           = (1.375)
+ tnom  = (27)
+ fc            = (0.9)
+ ik            = (((8.25e-6/phvnw*ahvnw))*1.0e12)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

model drsf45_10hv_reverse diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((delr_isr_drsf45_10hv)*(3.34152e-14)*(trel*trel*exp(-(0.465/kay)*((1/tkel)-(1/tkelnom))))))*1.0e12)
+ n             = (23000+(temp-27)*((-84)+(0)*(temp-27)))
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

dforward (p n_i) drsf45_10hv_forward area=(phvnw) m=(np)
dleak (n p) drsf45_10hv_reverse area=(pncom) m=(np)
rdrsf45_10hv_series (n n_i) resistor r=(rseries) m=(np)
xsubcap_drsf45_10hv (p sub) cdgontub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=drsf45_10hv_dfrt
ends

subckt drsf45b_10hv (p n sub)

parameters
+    w                              = 1.8
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    delr_isr_drsf45b_10hv          = (nom_delr_isr_drsf45b_10hv*exp(sig_delr_isr_drsf45b_10hv*nsig_delr_isr_drsf45b_10hv))
+    delr_isf_drsf45b_10hv          = (nom_delr_isf_drsf45b_10hv*exp(sig_delr_isf_drsf45b_10hv*nsig_delr_isf_drsf45b_10hv))
+    dela_dw_isf_drsf45b_10hv       = (nom_dela_dw_isf_drsf45b_10hv+nsig_dela_dw_isf_drsf45b_10hv*sig_dela_dw_isf_drsf45b_10hv)
+    rhvnw                          = (1.6+(1.35))
+    ahvnw                          = ((2*rhvnw*(w-1.0)+pi4models*(rhvnw*rhvnw))*sDOTmult2)
+    phvnw                          = ((2*(w-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    phvnw0                         = ((2*(1.8-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    rncom                          = (2.75+(0.0))
+    pncom                          = ((2*(w-1.0)+pi4models*2*rncom)*sDOTmult)
+    wiso                           = (9.5+w)
+    lint                           = (3.85)
+    lext                           = (3.035)
+    lcell                          = (2*(1.6))
+    liso                           = (np*lcell+(np-1)*lint+2*lext)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (62.72/(w+0.5))*pow((temp+273.15)/(27+273.15),-0.25*(w+1)/w)
+    cj_drsf45b_10hv                = ((1.782e-16*ahvnw+2.638e-16*phvnw))
+    pta_drsf45b_10hv               = (0.00261891359174924)
+    aphi_tnom                      = (0.5)
+    aphi_calc                      = (aphi_tnom-pta_drsf45b_10hv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.206789)
+    tkel                           = (temp+273.15)
+    tkelnom                        = (27+273.15)
+    trel                           = (tkel/tkelnom)
+    kay                            = (8.86e-5)

model drsf45b_10hv_forward diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((0.9493*2.45e-19)*delr_isf_drsf45b_10hv)*((w+0.1832+dela_dw_isf_drsf45b_10hv)/w))*1.0e12)
+ n             = (1.03)
+ bv            = (60.5)
+ ibv           = (((100e-9/(phvnw0)))*1.0e12)
+ cj            = ((((cj_drsf45b_10hv/phvnw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.206789)
+ tt            = (1.27e-9)
+ xti           = (1.3)
+ tnom  = (27)
+ fc            = (0.9)
+ ik            = (((1.276*6.15e-5)*(w/(w+21)))*1.0e12)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

model drsf45b_10hv_reverse diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((delr_isr_drsf45b_10hv)*(3.5e-14)*(trel*trel*exp(-(0.382/kay)*((1/tkel)-(1/tkelnom))))))*1.0e12)
+ n             = (23000+(temp-27)*((-100)+(0)*(temp-27)))
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

dforward (p n_i) drsf45b_10hv_forward area=(phvnw) m=(np)
dleak (n p) drsf45b_10hv_reverse area=(pncom) m=(np)
rdrsf45b_10hv_series (n n_i) resistor r=(rseries) m=(np)
xsubcap_drsf45b_10hv (p sub) cdgontub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=drsf45b_10hv_dfrt
ends

subckt drsf90_10hv (p n sub)

parameters
+    w                              = 2.0
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    delr_isr_drsf90_10hv           = (nom_delr_isr_drsf90_10hv*exp(sig_delr_isr_drsf90_10hv*nsig_delr_isr_drsf90_10hv))
+    delr_isf_drsf90_10hv           = (nom_delr_isf_drsf90_10hv*exp(sig_delr_isf_drsf90_10hv*nsig_delr_isf_drsf90_10hv))
+    rhvnw                          = (4.85+(0.015))
+    ahvnw                          = ((2*rhvnw*(w-1.0)+pi4models*(rhvnw*rhvnw))*sDOTmult2)
+    phvnw                          = ((2*(w-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    phvnw0                         = ((2*(2.0-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    rncom                          = (6.0+(0.015))
+    pncom                          = ((2*(w-1.0)+pi4models*2*rncom)*sDOTmult)
+    wiso                           = (15.96+w)
+    lint                           = (4.05)
+    lext                           = (3.135)
+    lcell                          = (2*(4.85))
+    liso                           = (np*lcell+(np-1)*lint+2*lext)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (97.6459/(w+0.427476))
+    cj_drsf90_10hv                 = ((1.69148e-16*ahvnw+5.65882e-16*phvnw))
+    pta_drsf90_10hv                = (0.00261891359174924)
+    aphi_tnom                      = (0.5)
+    aphi_calc                      = (aphi_tnom-pta_drsf90_10hv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.225103)
+    tkel                           = (temp+273.15)
+    tkelnom                        = (27+273.15)
+    trel                           = (tkel/tkelnom)
+    kay                            = (8.86e-5)

model drsf90_10hv_forward diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((6.77e-19)*delr_isf_drsf90_10hv))*1.0e12)
+ n             = (1.073)
+ bv            = (111)
+ ibv           = (((100e-9/(phvnw0)))*1.0e12)
+ cj            = ((((cj_drsf90_10hv/phvnw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.225103)
+ tt            = (1.27e-9)
+ xti           = (1.475)
+ tnom  = (27)
+ fc            = (0.9)
+ ik            = (((2.2e-5))*1.0e12)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

model drsf90_10hv_reverse diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((delr_isr_drsf90_10hv)*(1.67076e-14)*(trel*trel*exp(-(0.500/kay)*((1/tkel)-(1/tkelnom))))))*1.0e12)
+ n             = (23500+(temp-27)*((-85)+(0)*(temp-27)))
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

dforward (p n_i) drsf90_10hv_forward area=(phvnw) m=(np)
dleak (n p) drsf90_10hv_reverse area=(pncom) m=(np)
rdrsf90_10hv_series (n n_i) resistor r=(rseries) m=(np)
xsubcap_drsf90_10hv (p sub) cdgontub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=drsf90_10hv_dfrt
ends

subckt drsf90b_10hv (p n sub)

parameters
+    w                              = 2.0
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    delr_isr_drsf90b_10hv          = (nom_delr_isr_drsf90b_10hv*exp(sig_delr_isr_drsf90b_10hv*nsig_delr_isr_drsf90b_10hv))
+    delr_isf_drsf90b_10hv          = (nom_delr_isf_drsf90b_10hv*exp(sig_delr_isf_drsf90b_10hv*nsig_delr_isf_drsf90b_10hv))
+    dela_dw_isf_drsf90b_10hv       = (nom_dela_dw_isf_drsf90b_10hv+nsig_dela_dw_isf_drsf90b_10hv*sig_dela_dw_isf_drsf90b_10hv)
+    rhvnw                          = (4.85+(0.015))
+    ahvnw                          = ((2*rhvnw*(w-1.0)+pi4models*(rhvnw*rhvnw))*sDOTmult2)
+    phvnw                          = ((2*(w-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    phvnw0                         = ((2*(2.0-1.0)+pi4models*2*rhvnw)*sDOTmult)
+    rncom                          = (6.0+(-3.0))
+    pncom                          = ((2*(w-1.0)+pi4models*2*rncom)*sDOTmult)
+    wiso                           = (15.96+w)
+    lint                           = (4.05)
+    lext                           = (3.135)
+    lcell                          = (2*(4.85))
+    liso                           = (np*lcell+(np-1)*lint+2*lext)
+    aiso                           = (wiso*liso)
+    piso                           = (2*(wiso+liso))
+    rseries                        = (97.6459/(w+1))*pow((temp+273.15)/(27+273.15),-0.1*(w+4)/w)
+    cj_drsf90b_10hv                = ((1.179e-16*ahvnw+7.498e-16*phvnw))
+    pta_drsf90b_10hv               = (0.00261891359174924)
+    aphi_tnom                      = (0.5)
+    aphi_calc                      = (aphi_tnom-pta_drsf90b_10hv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.225103)
+    tkel                           = (temp+273.15)
+    tkelnom                        = (27+273.15)
+    trel                           = (tkel/tkelnom)
+    kay                            = (8.86e-5)

model drsf90b_10hv_forward diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((6.25e-19*0.963/3.049*1.35)*delr_isf_drsf90b_10hv)*((w+0.3548+dela_dw_isf_drsf90b_10hv)/w))*1.0e12)
+ n             = (1.03)
+ bv            = (111)
+ ibv           = (((100e-9/(phvnw0)))*1.0e12)
+ cj            = ((((cj_drsf90b_10hv/phvnw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (0.225103)
+ tt            = (1.27e-9)
+ xti           = (1.475)
+ tnom  = (27)
+ fc            = (0.9)
+ ik            = (((0.907*3.01e-5)*(w/(w+23.63)))*1.0e12)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

model drsf90b_10hv_reverse diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((delr_isr_drsf90b_10hv)*(1.60076e-14)*(trel*trel*exp(-(0.485/kay)*((1/tkel)-(1/tkelnom))))))*1.0e12)
+ n             = (23500+(temp-27)*((-97)+(0)*(temp-27)))
+ xti           = (3)
+ tnom  = (27)
+ fc            = (0.9)
+ eg            = (1.17)
+ tlev          = (2)
+ gap1          = (473e-6)
+ gap2          = (636)

dforward (p n_i) drsf90b_10hv_forward area=(phvnw) m=(np)
dleak (n p) drsf90b_10hv_reverse area=(pncom) m=(np)
rdrsf90b_10hv_series (n n_i) resistor r=(rseries) m=(np)
xsubcap_drsf90b_10hv (p sub) cdgontub_box_sub_10hv area=((1-lpe)*aiso+lpe*0.001) perim=((1-lpe)*piso+lpe*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=drsf90b_10hv_dfrt
ends

//***********************************************************
endsection drsf_zener
//***********************************************************

//***********************************************************
section diode
//***********************************************************

subckt dnplus_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    nsmm_delr_is_dnplus_10hv       = tmp_nsmm_delr_is_dnplus_10hv
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nsd_pw)
+    aphi_calc                      = (aphi_tnom-pta_junc_nsd_pw*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nsd_pw)
+    pphi_tnom                      = (pphi_junc_nsd_pw)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nsd_pw*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nsd_pw)
+    ww                             = ((1e-20+perim+sqrt(abs(perim*perim-16*area)))/4)
+    ll                             = ((area+1e-20)/ww)
+    delr_is_dnplus_10hv            = (1.0+nsmm_delr_is_dnplus_10hv*smm_delr_is_dnplus_10hv(ll,ww))

model dnsd_pw_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((ajs_junc_nsd_pw*1.49)*delr_is_dnplus_10hv))*1.0e12)
+ n             = ((ajnd_junc_nsd_pw)*0.996)
+ cj            = ((((acj0_junc_nsd_pw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nsd_pw)
+ xti           = (0.65)
+ fc            = (0.9)
+ bv            = (7)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.4*abs(sqrt(area_val))+4e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (aeg_junc_nsd_pw)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nsd_pw)
+ gap2          = (abetaeg_junc_nsd_pw)

model dnsd_pw_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = ((((pjs_junc_nsd_pw/sDOTmult)*0.72*delr_is_dnplus_10hv))*1.0e12)
+ n             = ((pjnd_junc_nsd_pw)*0.954)
+ cj            = ((((pcj0_junc_nsd_pw/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nsd_pw)
+ xti           = (0.8)
+ fc            = (0.9)
+ bv            = (7)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.4*abs(sqrt(area_val))+4e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (peg_junc_nsd_pw)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nsd_pw)
+ gap2          = (pbetaeg_junc_nsd_pw)

ddnsd_pw_10hv_area (p n) dnsd_pw_10hv_area area=area_val m=(1)
ddnsd_pw_10hv_perim (p n) dnsd_pw_10hv_perim area=perim_val m=(1)

include "./smos10hv_ade_dfrt.scs" section=dnplus_10hv_dfrt
ends

subckt dpplus_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    nsmm_delr_is_dpplus_10hv       = tmp_nsmm_delr_is_dpplus_10hv
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_psd_nw)
+    aphi_calc                      = (aphi_tnom-pta_junc_psd_nw*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_psd_nw)
+    pphi_tnom                      = (pphi_junc_psd_nw)
+    pphi_calc                      = (pphi_tnom-ptp_junc_psd_nw*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_psd_nw)
+    ww                             = ((1e-20+perim+sqrt(abs(perim*perim-16*area)))/4)
+    ll                             = ((area+1e-20)/ww)
+    delr_is_dpplus_10hv            = (1.0+nsmm_delr_is_dpplus_10hv*smm_delr_is_dpplus_10hv(ll,ww))

model dpsd_nw_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_psd_nw*1.5)*delr_is_dpplus_10hv)*1.0e12)
+ n             = (ajnd_junc_psd_nw)
+ cj            = ((((acj0_junc_psd_nw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_psd_nw)
+ xti           = (axti_junc_psd_nw)
+ fc            = (0.9)
+ bv            = (7)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((5e-10*(1+0.5*abs(sqrt(area_val))+6e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (aeg_junc_psd_nw)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_psd_nw)
+ gap2          = (abetaeg_junc_psd_nw)

model dpsd_nw_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_psd_nw/sDOTmult*1.6)*delr_is_dpplus_10hv)*1.0e12)
+ n             = (pjnd_junc_psd_nw)
+ cj            = ((((pcj0_junc_psd_nw/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_psd_nw)
+ xti           = (pxti_junc_psd_nw+0.8)
+ fc            = (0.9)
+ bv            = (7)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((5e-10*(1+0.5*abs(sqrt(area_val))+6e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (peg_junc_psd_nw)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_psd_nw)
+ gap2          = (pbetaeg_junc_psd_nw)

ddpsd_nw_10hv_area (p n) dpsd_nw_10hv_area area=area_val m=(1)
ddpsd_nw_10hv_perim (p n) dpsd_nw_10hv_perim area=perim_val m=(1)

include "./smos10hv_ade_dfrt.scs" section=dpplus_10hv_dfrt
ends

subckt dnfet_10hv (p n sub)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    ring                           = 1
+    lpe                            = 0
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nsd_phv)
+    aphi_calc                      = (aphi_tnom-pta_junc_nsd_phv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nsd_phv)
+    pphi_tnom                      = (pphi_junc_nsd_phv)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nsd_phv*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nsd_phv)
+    wg                             = ((perim_val+sqrt(abs(perim_val*perim_val-16*area_val)))/4)
+    lg                             = (area_val/wg)
+    wiso                           = (wg+2*1.11)
+    liso                           = (2*lg+2*1.11+0.36)
+    aiso                           = (wiso*liso)
+    piso                           = (2*wiso+2*liso)

model dnsd_phv_10hv_area_f diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nsd_phv*0.95))*1.0e12)
+ n             = (ajnd_junc_nsd_phv)
+ cj            = ((((acj0_junc_nsd_phv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nsd_phv)
+ xti           = (axti_junc_nsd_phv-0.17)
+ fc            = (0.9)
+ bv            = (10)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.14*abs(sqrt(area_val))+4e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (aeg_junc_nsd_phv)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nsd_phv)
+ gap2          = (abetaeg_junc_nsd_phv)

model dnsd_phv_10hv_perim_f diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nsd_phv/sDOTmult*0.85))*1.0e12)
+ n             = (pjnd_junc_nsd_phv)
+ cj            = ((((pcj0_junc_nsd_phv/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nsd_phv)
+ xti           = (pxti_junc_nsd_phv-0.17)
+ fc            = (0.9)
+ bv            = (10)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.14*abs(sqrt(perim_val))+4e-5*perim_val**2))*1e12)*1.0e-12)
+ eg            = (peg_junc_nsd_phv)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nsd_phv)
+ gap2          = (pbetaeg_junc_nsd_phv)

model dnsd_phv_10hv_perim_r diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nsd_phv/sDOTmult*0.85*0.4))*1.0e12)
+ n             = (25.5+(temp-27)*((-0.07)+(0)*(temp-27)))
+ xti           = (pxti_junc_nsd_phv-0.017)
+ fc            = (0.9)
+ eg            = (peg_junc_nsd_phv)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nsd_phv)
+ gap2          = (pbetaeg_junc_nsd_phv)

ddnsd_phv_10hv_areaf (p n) dnsd_phv_10hv_area_f area=area_val m=(1)
ddnsd_phv_10hv_perimf (p n) dnsd_phv_10hv_perim_f area=perim_val m=(1)
ddnsd_phv_10hv_perimr (n p) dnsd_phv_10hv_perim_r area=perim_val m=(1)
xsubcap_dnfet_10hv (p sub) cdgontub_box_sub_10hv area=(ring*(1-lpe)*aiso+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=dnfet_10hv_dfrt
ends

subckt dpfet_10hv (p n sub)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    ring                           = 1
+    lpe                            = 0
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_psd_nhv)
+    aphi_calc                      = (aphi_tnom-pta_junc_psd_nhv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_psd_nhv)
+    pphi_tnom                      = (pphi_junc_psd_nhv)
+    pphi_calc                      = (pphi_tnom-ptp_junc_psd_nhv*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_psd_nhv)
+    wg                             = ((perim_val+sqrt(abs(perim_val*perim_val-16*area_val)))/4)
+    lg                             = (area_val/wg)
+    wiso                           = (wg+2*1.11)
+    liso                           = (2*lg+2*1.11+0.36)
+    aiso                           = (wiso*liso)
+    piso                           = (2*wiso+2*liso)

model dpsd_nhv_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_psd_nhv))*1.0e12)
+ n             = (ajnd_junc_psd_nhv)
+ cj            = ((((acj0_junc_psd_nhv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_psd_nhv)
+ xti           = (axti_junc_psd_nhv)
+ fc            = (0.9)
+ bv            = (9)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.14*abs(sqrt(area_val))+4e-5*area_val**2))*1e12)*1.0e-12)
+ eg            = (aeg_junc_psd_nhv)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_psd_nhv)
+ gap2          = (abetaeg_junc_psd_nhv)

model dpsd_nhv_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_psd_nhv/sDOTmult*0.85))*1.0e12)
+ n             = (pjnd_junc_psd_nhv)
+ cj            = ((((pcj0_junc_psd_nhv/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_psd_nhv)
+ xti           = (pxti_junc_psd_nhv-0.27)
+ fc            = (0.9)
+ bv            = (9)
+ ibv           = (((1e-7))*1.0e12)
+ rs            = (((1e-9*(1+0.04*abs(sqrt(perim_val))+4e-5*perim_val**2))*1e12)*1.0e-12)
+ eg            = (peg_junc_psd_nhv)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_psd_nhv)
+ gap2          = (pbetaeg_junc_psd_nhv)

ddpsd_nhv_10hv_area (p n) dpsd_nhv_10hv_area area=area_val m=(1)
ddpsd_nhv_10hv_perim (p n) dpsd_nhv_10hv_perim area=perim_val m=(1)
xsubcap_dpfet_10hv (n sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=dpfet_10hv_dfrt
ends


// dpldd_10hv


subckt dpldd_10hv (p n)

parameters
+ area				 = (6.76)
+ soa				 = (1)



//internal calculation
+ area_val = (area+(area==0)*1e-2)
+ tc_cbbt  = (1+tanh((temp-27)*0.03))
+ tc_mm_dta = (1+(temp-27)*(2.55e-3))
+ rseries  = (24.0/area_val)

// parameters for process variations
+ nsmm_dela_dta_dpldd_junc_10hv    = tmp_nsmm_dela_dta_dpldd_junc_10hv
+ delr_is_dpldd_junc_10hv         = (nom_delr_is_dpldd_junc_10hv*exp(sig_delr_is_dpldd_junc_10hv*nsig_delr_is_dpldd_junc_10hv))
+ delr_ir_dpldd_junc_10hv         = (nom_delr_ir_dpldd_junc_10hv*exp(sig_delr_ir_dpldd_junc_10hv*nsig_delr_ir_dpldd_junc_10hv))
+ dela_bv_dpldd_junc_10hv	  = (nom_dela_bv_dpldd_junc_10hv+nsig_dela_bv_dpldd_junc_10hv*sig_dela_bv_dpldd_junc_10hv)
+ delr_cj_dpldd_junc_10hv	  = (nom_delr_cj_dpldd_junc_10hv*(1.0+nsig_delr_cj_dpldd_junc_10hv*sig_delr_cj_dpldd_junc_10hv))
+ dela_dta_dpldd_junc_10hv        = (nsmm_dela_dta_dpldd_junc_10hv*smm_dela_dta_dpldd_junc_10hv(area_val)*tc_mm_dta)


model judi1 judi type=n
//special parameters
+ trj        = 27
+ imax       = 100
+ rthresh    = 1e-3
//series conductance
+ gsbot      = gsbot_dpldd_junc_10hv
+ gssti      = gssti_dpldd_junc_10hv
+ gsgat      = gsgat_dpldd_junc_10hv
//current component model parameters
+ idsatrbot  = (idsatrbot_dpldd_junc_10hv*delr_is_dpldd_junc_10hv)
+ idsatrsti  = (idsatrsti_dpldd_junc_10hv*delr_is_dpldd_junc_10hv)
+ nbot       = nbot_dpldd_junc_10hv
+ ikrbot     = ikrbot_dpldd_junc_10hv
+ nkbot      = nkbot_dpldd_junc_10hv
+ nsti       = nbot_dpldd_junc_10hv
+ ikrsti     = ikrbot_dpldd_junc_10hv
+ nksti      = nkbot_dpldd_junc_10hv
+ csrhbot    = csrhbot_dpldd_junc_10hv
+ csrhsti    = csrhsti_dpldd_junc_10hv
+ ctatbot    = (ctatbot_dpldd_junc_10hv*delr_ir_dpldd_junc_10hv)
+ ctatsti    = ctatsti_dpldd_junc_10hv
+ mefftatbot =  mefftatbot_dpldd_junc_10hv
+ mefftatsti =  mefftatsti_dpldd_junc_10hv
+ cbbtbot    = (cbbtbot_dpldd_junc_10hv*tc_cbbt*delr_ir_dpldd_junc_10hv)
+ cbbtsti    = cbbtsti_dpldd_junc_10hv
+ fbbtrbot   = fbbtrbot_dpldd_junc_10hv
+ fbbtrsti   = fbbtrsti_dpldd_junc_10hv
+ xjunsti    = xjunsti_dpldd_junc_10hv
+ xjungat    = xjungat_dpldd_junc_10hv
//breakdown voltage parameters
+ vbrbot     = (vbrbot_dpldd_junc_10hv+dela_bv_dpldd_junc_10hv)
+ vbrsti     = (vbrsti_dpldd_junc_10hv+dela_bv_dpldd_junc_10hv)
+ vbrgat     = (vbrgat_dpldd_junc_10hv+dela_bv_dpldd_junc_10hv)
+ pbrbot     = pbrbot_dpldd_junc_10hv
+ pbrsti     = pbrsti_dpldd_junc_10hv
+ pbrgat     = pbrgat_dpldd_junc_10hv
+ frev       = frev_dpldd_junc_10hv
//charge model parameters
+ cjorbot    = (cjorbot_dpldd_junc_10hv*delr_cj_dpldd_junc_10hv)
+ cjorsti    = (cjorsti_dpldd_junc_10hv*delr_cj_dpldd_junc_10hv)
+ vbirbot    = vbirbot_dpldd_junc_10hv
+ vbirsti    = vbirsti_dpldd_junc_10hv
+ pbot       = pbot_dpldd_junc_10hv
+ psti       = psti_dpldd_junc_10hv
+ phigbot    = phigbot_dpldd_junc_10hv
+ phigsti    = phigsti_dpldd_junc_10hv
+ neffbot    = neffbot_dpldd_junc_10hv
+ neffsti    = neffsti_dpldd_junc_10hv
//temperature dependenty
+ stfbbtbot  = stfbbtbot_dpldd_junc_10hv
+ stfbbtsti  = stfbbtsti_dpldd_junc_10hv
+ stvbrbot   = stvbrbot_dpldd_junc_10hv
+ stvbrsti   = stvbrsti_dpldd_junc_10hv
+ xisbot     = xisbot_dpldd_junc_10hv
+ tc1rs      = tc1rs_dpldd_junc_10hv
+ xikbot     = xikbot_dpldd_junc_10hv


d1 (pi n) judi1 ab=(area_val) ls=0.0 lg=0.0  swrrmod=0 swjunexp=0 dta=(0.0+dela_dta_dpldd_junc_10hv)
rp1 (p pi) resistor r=rseries  tc1=-2.5e-3 tc2=0


//xdsub (s sub) cdgoptub_box_sub_10hv area=(10) perim=(10) soa=1


include "./smos10hv_ade_dfrt.scs" section=dpldd_10hv_dfrt
ends


//***********************************************************
endsection diode
//***********************************************************

//***********************************************************
section capacitor
ahdl_include "./veriloga/caplh_vlaver6p1_forspectre.va"

//***********************************************************
ahdl_include "./veriloga/MOSCAP_ver3p1.va"


subckt cdp_10hv (t b nw sub)

parameters
+    area                           = 2.480625
+    perim                          = 6.3
+    w                              = 1.575
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdp_10hv             = tmp_nsmm_delr_cdp_10hv
+    ww                             = ((perim+sqrt(abs(perim*perim-16*area)))/4)
+    ll                             = (area/ww)
+    delr_cpp_cdp_10hv              = (nom_delr_cpp_cdp_10hv*(1.0+nsig_delr_cpp_cdp_10hv*sig_delr_cpp_cdp_10hv+nsmm_delr_cdp_10hv*smm_delr_cdp_10hv(ll,ww)/sqrt(np)))
+    delr_cfr_cdp_10hv              = (nom_delr_cfr_cdp_10hv*(1.0+nsig_delr_cfr_cdp_10hv*sig_delr_cfr_cdp_10hv+nsmm_delr_cdp_10hv*smm_delr_cdp_10hv(ll,ww)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    cpp_cdp_10hv                   = (1.60711e-15*delr_cpp_cdp_10hv)
+    cfr_cdp_10hv                   = (4.22043e-17*delr_cfr_cdp_10hv)
+    woverlap_cdp_10hv              = (0.51+0.51)
+    loverlap_cdp_10hv              = (1.065+0.51)
+    areat                          = (area)
+    perimt                         = (perim)
+    areab                          = ((ll+loverlap_cdp_10hv)*(ww+woverlap_cdp_10hv))
+    perimb                         = ((2*(ll+loverlap_cdp_10hv+ww+woverlap_cdp_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((ll+loverlap_cdp_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (ww+woverlap_cdp_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdp_10hv+sDOTmult*perimt*cfr_cdp_10hv)
+    c_p2p1_eff                     = (c_p2p1/(areat*sDOTmult*sDOTmult))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)
+    deltat                         = (temp-27)
+    delr_rs_poly0_r3               = (nom_delr_rs_poly0_r3*(1.0+nsig_delr_rs_poly0_r3_cdp_10hv*sig_delr_rs_poly0_r3))
+    l                              = area/w
+    r_poly0_par                    = (235.967880218066*delr_rs_poly0_r3*(l/3.0+0.51)/(w+0.51*2)/np)

acdp_10hvt (t bi) caplh_vla
+ area=(areat*sDOTmult*sDOTmult)
+ c0=(c_p2p1_eff)
+ a2=(-4.967951e-19*(1+(deltat)*(0.00408361)))
+ a3=(-12.27955e-20*(1+(deltat)*(-0.00110933)))
+ delv=(0.407316*(1+(deltat)*(0.0155345)+(deltat)*(deltat)*(3.55229e-05)))
+ tc1=(3.09435e-05)
+ tc2=(1.42121e-09)
+ num=(np)
ccdp_10hvb (bi nw) capacitor c=c_p1nw m=(np)
xsubcap_cdp_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)
rbottom (b bi) resistor r=r_poly0_par

include "./smos10hv_ade_dfrt.scs" section=cdp_10hv_dfrt
ends

subckt cdpf_10hv (t b nw sub)

parameters
+    w                              = 2.32
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdpf_10hv            = tmp_nsmm_delr_cdpf_10hv
+    delr_cpp_cdpf_10hv             = (nom_delr_cpp_cdpf_10hv*(1.0+nsig_delr_cpp_cdpf_10hv*sig_delr_cpp_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cfr_cdpf_10hv             = (nom_delr_cfr_cdpf_10hv*(1.0+nsig_delr_cfr_cdpf_10hv*sig_delr_cfr_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cfrlv_cdpf_10hv           = (nom_delr_cfrlv_cdpf_10hv*(1.0+nsig_delr_cfrlv_cdpf_10hv*sig_delr_cfrlv_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    area                           = (w*l)
+    perim                          = (2*(w+l))
+    cpp_cdpf_10hv                  = (1.60711e-15*delr_cpp_cdpf_10hv)
+    cfr_cdpf_10hv                  = (4.22043e-17*delr_cfr_cdpf_10hv)
+    woverlap_cdpf_10hv             = (0.51+0.51)
+    loverlap_cdpf_10hv             = (1.065+0.51)
+    areat                          = (w*l)
+    perimt                         = (2*(w+l))
+    areab                          = ((l+loverlap_cdpf_10hv)*(w+woverlap_cdpf_10hv))
+    perimb                         = ((2*(l+loverlap_cdpf_10hv+w+woverlap_cdpf_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((l+loverlap_cdpf_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (w+woverlap_cdpf_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdpf_10hv+sDOTmult*perimt*cfr_cdpf_10hv)
+    c_p2p1_eff                     = (c_p2p1/(areat*sDOTmult*sDOTmult))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)
+    deltat                         = (temp-27)
+    delr_rs_poly0_r3               = (nom_delr_rs_poly0_r3*(1.0+nsig_delr_rs_poly0_r3_cdpf_10hv*sig_delr_rs_poly0_r3))
+    r_poly0_par                    = (235.967880218066*delr_rs_poly0_r3*(l/3.0+0.51)/(w+0.51*2)/np)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w-1.32+(-0.324067))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.34025*(cm1m1+cm2m2+cm3m3+cm4m4)+2.30743*(cm1m2+cm2m3+cm3m4))
+    ctotal                         = (cfr*(1.0+deltat*(1.88434e-06+deltat*(0)))*delr_cfrlv_cdpf_10hv)
+    nom_cfr_m1_ply_cdpf            = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cdpf            = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cdpf            = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cdpf            = (0.030043167348678e-15)
+    cpp_m1_ply_cdpf                = (0.10244680628272e-15)
+    cpp_m2_ply_cdpf                = (0.031129787985865e-15)
+    cfr_m1_ply_cdpf                = (0.0496645438078e-15)
+    cfr_m2_ply_cdpf                = (0.0340576640831725e-15)
+    cfr_m3_ply_cdpf                = (0.0324247720343545e-15)
+    cfr_m4_ply_cdpf                = (0.030043167348678e-15)
+    lf                             = (w-1.32)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cdpf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cdpf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cdpf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cdpf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cdpf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cdpf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cdpf+area_b_m2_ply*cpp_m2_ply_cdpf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cdpf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cdpf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cdpf*ratio_cfr_m3_ply_outer+perim_outer_b_m4_ply*cfr_m4_ply_cdpf*ratio_cfr_m4_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

acdpf_10hvt (t bi) caplh_vla
+ area=(areat*sDOTmult*sDOTmult)
+ c0=(c_p2p1_eff)
+ a2=(-4.96951e-19*(1+(deltat)*(0.00643833)))
+ a3=(-12.27955e-20*(1+(deltat)*(-0.00100482)))
+ delv=(0.407316*(1+(deltat)*(0.00802459)+(deltat)*(deltat)*(-3.21275e-05)))
+ tc1=(3.20261e-05)
+ tc2=(-1.62404e-11)
+ num=(np)
ccdpf_10hv_cfrlv (t b) capacitor c=ctotal m=(np)
ccdpf_10hv_cfrlv_bply (t b) capacitor c=(cp_b) m=(np)
ccdpf_10hvb (bi nw) capacitor c=c_p1nw m=(np)
xsubcap_cdpf_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)
rbottom (b bi) resistor r=r_poly0_par

include "./smos10hv_ade_dfrt.scs" section=cdpf_10hv_dfrt
ends

subckt cdpf_m1m2m3_10hv (t b nw sub)

parameters
+    w                              = 2.32
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdpf_m1m2m3_10hv     = tmp_nsmm_delr_cdpf_m1m2m3_10hv
+    delr_cpp_cdpf_m1m2m3_10hv      = (nom_delr_cpp_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cpp_cdpf_m1m2m3_10hv*sig_delr_cpp_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cfr_cdpf_m1m2m3_10hv      = (nom_delr_cfr_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cfr_cdpf_m1m2m3_10hv*sig_delr_cfr_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cfrlv_cdpf_m1m2m3_10hv    = (nom_delr_cfrlv_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cfrlv_cdpf_m1m2m3_10hv*sig_delr_cfrlv_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    area                           = (w*l)
+    perim                          = (2*(w+l))
+    cpp_cdpf_10hv                  = (1.60711e-15*delr_cpp_cdpf_m1m2m3_10hv)
+    cfr_cdpf_10hv                  = (4.22043e-17*delr_cfr_cdpf_m1m2m3_10hv)
+    woverlap_cdpf_10hv             = (0.51+0.51)
+    loverlap_cdpf_10hv             = (1.065+0.51)
+    areat                          = (w*l)
+    perimt                         = (2*(w+l))
+    areab                          = ((l+loverlap_cdpf_10hv)*(w+woverlap_cdpf_10hv))
+    perimb                         = ((2*(l+loverlap_cdpf_10hv+w+woverlap_cdpf_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((l+loverlap_cdpf_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (w+woverlap_cdpf_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdpf_10hv+sDOTmult*perimt*cfr_cdpf_10hv)
+    c_p2p1_eff                     = (c_p2p1/(areat*sDOTmult*sDOTmult))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)
+    deltat                         = (temp-27)
+    delr_rs_poly0_r3               = (nom_delr_rs_poly0_r3*(1.0+nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv*sig_delr_rs_poly0_r3))
+    r_poly0_par                    = (235.967880218066*delr_rs_poly0_r3*(l/3.0+0.51)/(w+0.51*2)/np)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w-1.32+(-0.374159067188369))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.511232710195269*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.511232710195269*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.6258705349406*(cm1m1+cm2m2+cm3m3)+4.03181371037931*(cm1m2+cm2m3))
+    ctotal                         = (cfr*(1.0+deltat*(-768.273775799702e-06+deltat*(0)))*delr_cfrlv_cdpf_m1m2m3_10hv)
+    nom_cfr_m1_ply_cdpf            = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cdpf            = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cdpf            = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cdpf            = (0.030043167348678e-15)
+    cpp_m1_ply_cdpf                = (0.10244680628272e-15)
+    cpp_m2_ply_cdpf                = (0.031129787985865e-15)
+    cfr_m1_ply_cdpf                = (0.0496645438078e-15)
+    cfr_m2_ply_cdpf                = (0.0340576640831725e-15)
+    cfr_m3_ply_cdpf                = (0.0324247720343545e-15)
+    cfr_m4_ply_cdpf                = (0.030043167348678e-15)
+    lf                             = (w-1.32)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cdpf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cdpf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cdpf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cdpf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cdpf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cdpf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cdpf+area_b_m2_ply*cpp_m2_ply_cdpf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cdpf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cdpf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cdpf*ratio_cfr_m3_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

acdpf_10hvt (t bi) caplh_vla
+ area=(areat*sDOTmult*sDOTmult)
+ c0=(c_p2p1_eff)
+ a2=(-4.96951e-19*(1+(deltat)*(-0.00464228168959155)))
+ a3=(-12.27955e-20*(1+(deltat)*(-0.00189834059324412)))
+ delv=(0.11123565640816*(1+(deltat)*(-0.0583522833226433)+(deltat)*(deltat)*(-3.21275e-05)))
+ tc1=(348.852016756149e-6)
+ tc2=(-16.2404e-12)
+ num=(np)
ccdpf_m1m2m3_10hv_cfrlv (t b) capacitor c=ctotal m=(np)
ccdpf_m1m2m3_10hv_cfrlv_bply (t b) capacitor c=(cp_b) m=(np)
ccdpf_m1m2m3_10hvb (bi nw) capacitor c=c_p1nw m=(np)
xsubcap_cdpf_m1m2m3_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)
rbottom (b bi) resistor r=r_poly0_par

include "./smos10hv_ade_dfrt.scs" section=cdpf_m1m2m3_10hv_dfrt
ends

subckt cglv_10hv (t nw sub)

parameters
+    l                              = 1.29
+    w                              = 1.29
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cglv_10hv_tox        = tmp_nsmm_delr_cglv_10hv_tox
+    delr_cpp_ply_fld               = (nom_delr_cpp_ply_fld*(1.0+nsig_delr_cpp_ply_fld*sig_delr_cpp_ply_fld))
+    delr_cfr_ply_fld               = (nom_delr_cfr_ply_fld*(1.0+nsig_delr_cfr_ply_fld*sig_delr_cfr_ply_fld))
+    delr_cglv_10hv_tox             = (nom_delr_cglv_10hv_tox*(1.0+nsig_delr_cglv_10hv_tox*sig_delr_cglv_10hv_tox+nsmm_delr_cglv_10hv_tox*smm_delr_cglv_10hv_tox(l,w)/sqrt(np)))
+    dela_cglv_10hv_vfb             = (nom_dela_cglv_10hv_vfb+nsig_dela_cglv_10hv_vfb*sig_dela_cglv_10hv_vfb)
+    delr_cglv_10hv_ileak           = (nom_delr_cglv_10hv_ileak*exp(nsig_delr_cglv_10hv_ileak*sig_delr_cglv_10hv_ileak))
+    ca_fld                         = (nom_cpp_ply_fld*delr_cpp_ply_fld)
+    cp_fld                         = (nom_cfr_ply_fld*delr_cfr_ply_fld)
+    ply2dt                         = (3.06)
+    w_aa2dt                        = (2.22)
+    ply2ply                        = (0.51)
+    wply_ovl_aa                    = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(l*wply_ovl_aa)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*(l+wply_ovl_aa))*sDOTmult)
+    val_tag_fld                    = (ca_fld*a_tag_fld_um2+cp_fld*p_tag_fld_um+1e-17)
+    lsub                           = (l*np+(np-1)*ply2ply+ply2dt)
+    wsub                           = (w+w_aa2dt)
+    areab_um2                      = (lsub*wsub)
+    perimb_um                      = ((lsub+wsub)*2)
+    dw                             = (0)
+    dl                             = (-0.0324298*1e-6)
+    weff                           = (moscap==1)*(w)+(moscap==0)*(w*1e-6+dw)
+    leff                           = (moscap==1)*(l-0.0324298)+(moscap==0)*(l*1e-6+dl)
+    weffleak                       = (w+0)
+    leffleak                       = (l-0.0324298)
+    area_eff                       = (weffleak*leffleak*np)
+    apar                           = ((1.0e-18)*(1+3.25e-3*(temp-27)))
+    bpar                           = (14)
+    ppar                           = ((0.275)*(1-0.35e-3*(temp-27)))
+    a2par                          = ((8e-18)*(1+3.0e-3*(temp-27)+15e-6*(temp-27)*(temp-27)))
+    b2par                          = ((8.5)*(1+0.13e-3*(temp-27)))
+    p2par                          = (0.1)

bileak_fwd (t nw) bsource i=((apar*v(t,nw)*exp(bpar*(maxa(v(t,nw),0,1e-12)**(ppar))))*area_eff*delr_cglv_10hv_ileak) tc1=0 tc2=0
bileak_rev (nw t) bsource i=((a2par*v(nw,t)*exp(b2par*(maxa(v(nw,t),0,1e-12)**(p2par))))*area_eff*delr_cglv_10hv_ileak) tc1=0 tc2=0

if (moscap==0) {

model cglvx mosvar
+ level    = (1000)
+ noscale  = (1)
+ gc3hvo   = (0.063)
+ gc2hvo   = (0.375)
+ gcohvo   = (0)
+ igovhvw  = (0)
+ igchvlw  = (0)
+ gc3o     = (0.063)
+ gc2o     = (0.375)
+ gcoo     = (0)
+ igovw    = (0)
+ iginvlw  = (0)
+ novo     = (5e+25)
+ lov      = (0)
+ stig     = (2)
+ chibpo   = (4.5)
+ chibo    = (3.1)
+ swigate  = (0)
+ feta     = (1)
+ stuac    = (0)
+ strshs   = (0)
+ strend   = (0)
+ strpv    = (0)
+ strshg   = (0)
+ typep    = (-1)
+ type     = (-1)
+ uacred   = (0)
+ uac      = (0.05)
+ rend     = (0.0001)
+ rpv      = (0)
+ rshg     = (1)
+ wmax     = (9.9e+09)
+ wmin     = (1e-08)
+ lmax     = (9.9e+09)
+ lmin     = (1e-08)
+ tr       = (27)
+ vmax     = (1e+04)
+ tmax     = (500)
+ tmin     = (-100)
+ revision = (0)
+ subversion = (0)
+ version  = (1.1)
+ dwr      = (0)
+ qmc      = (0)
+ npo      = (1.0e+27)
+ swres    = (1)
+ stvfb    = (-0.000434067)
+ rshs     = (218.35)
+ cfrw     = (0)
+ cfrl     = (3.10356e-16*1e6)
+ nsubo    = (3.15982e+17*1e6)
+ vfbo     = (-0.0858716+(dela_cglv_10hv_vfb))
+ toxo     = (34.7925*1e-10*(delr_cglv_10hv_tox))
+ tau      = (0.001)
ccglv_10hv (t nw nw) cglvx l=(leff) w=(weff) m=(np)
ccglv_10hvt (t nw) capacitor c=(val_tag_fld) m=(np)
xsubcap_cglv_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_um2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_um+lpe*0.001+(1-ring)*0.001) soa=(1)
} else if (moscap==1) {
aglv_10hv (t nw) MOSCAP
+ type=(-1)
+ scale=(1.0e-6)
+ shrink=(0)
+ l=(leff)
+ w=(weff)
+ m=(np)
+ tnom=(27)
+ nb=(3.15982e+17)
+ tox=(34.7925*(delr_cglv_10hv_tox))
+ vfb=(-0.0858716+(dela_cglv_10hv_vfb))
+ rshsub=(218.35)
+ tau=(0.001)
+ tcvfb=(-0.000434067)
+ cfrw=(0)
+ cfrl=(3.10356e-16)
ccglv_10hvt (t nw) capacitor c=(val_tag_fld) m=(np)
xsubcap_cglv_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_um2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_um+lpe*0.001+(1-ring)*0.001) soa=(1)
}

include "./smos10hv_ade_dfrt.scs" section=cglv_10hv_dfrt
ends

subckt cghv_10hv (t nw sub)

parameters
+    l                              = 1.5
+    w                              = 1.5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghv_10hv_tox        = tmp_nsmm_delr_cghv_10hv_tox
+    delr_tox_cghv_10hv             = (nom_delr_tox_cghv_10hv*(1.0+nsig_delr_tox_cghv_10hv*sig_delr_tox_cghv_10hv+nsmm_delr_cghv_10hv_tox*smm_delr_cghv_10hv_tox(w,l)/sqrt(np)))
+    dela_vfb_cghv_10hv             = (nom_dela_vfb_cghv_10hv+nsig_dela_vfb_cghv_10hv*sig_dela_vfb_cghv_10hv)
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = ((cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um)*np+1.0e-17)
+    w_nw                           = (w+(2.22))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    weff                           = ((w-2*((-1.1e-2)+(-8.99e-2)/w+(0.0647798/(w*l))))*1e-6)
+    leff                           = ((l-2*((-0.023)+(8.79e-3)/l))*1e-6)
+    tox                            = (134.75*delr_tox_cghv_10hv)

model cghvx mosvar
+ level    = (1000)
+ noscale  = (1)
+ gc3hvo   = (0.063)
+ gc2hvo   = (0.375)
+ gcohvo   = (0)
+ igovhvw  = (0)
+ igchvlw  = (0)
+ gc3o     = (0.063)
+ gc2o     = (0.375)
+ gcoo     = (0)
+ igovw    = (0)
+ iginvlw  = (0)
+ novo     = (5e+25)
+ lov      = (0)
+ stig     = (2)
+ chibpo   = (4.5)
+ chibo    = (3.1)
+ swigate  = (0)
+ feta     = (1)
+ stuac    = (0)
+ strshs   = (0)
+ strend   = (0)
+ strpv    = (0)
+ strshg   = (0)
+ typep    = (-1)
+ type     = (-1)
+ uacred   = (0)
+ uac      = (0.05)
+ rend     = (0.0001)
+ rpv      = (0)
+ rshg     = (1)
+ wmax     = (9.9e+09)
+ wmin     = (1e-08)
+ lmax     = (9.9e+09)
+ lmin     = (1e-08)
+ tr       = (27)
+ vmax     = (1e+04)
+ tmax     = (500)
+ tmin     = (-100)
+ revision = (0)
+ subversion = (0)
+ version  = (1.1)
+ dwr      = (0)
+ qmc      = (0)
+ npo      = (1.0e+27)
+ swres    = (1)
+ stvfb    = (-0.000453852)
+ rshs     = (492)
+ cfrw     = (0*1e6)
+ cfrl     = (0*1e6)
+ nsubo    = (10.85e+16*1e6)
+ vfbo     = (-0.147+dela_vfb_cghv_10hv)
+ toxo     = (tox*1e-10)
+ tau      = (1.1e-12)

ccghv_10hv (t nw nw) cghvx l=(leff) w=(weff) m=(np)
ccghv_10hv_tag (t nw) capacitor c=(val_tag_fld)
xsubcap_cghv_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghv_10hv_dfrt
ends

subckt cghvf_10hv (t nw sub)

parameters
+    w                              = 1.5
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghvf_10hv           = tmp_nsmm_delr_cghvf_10hv
+    delr_mm_cghvf_10hv             = (1.0+nsmm_delr_cghvf_10hv*smm_delr_cghvf_10hv(w,nf)/sqrt(np))
+    delr_cfrlv_cghvf_10hv          = (nom_delr_cfrlv_cghvf_10hv*(1+nsig_delr_cfrlv_cghvf_10hv*sig_delr_cfrlv_cghvf_10hv))*delr_mm_cghvf_10hv
+    delr_tox_cghvf_10hv            = (nom_delr_tox_cghvf_10hv*(1.0+nsig_delr_tox_cghvf_10hv*sig_delr_tox_cghvf_10hv))/delr_mm_cghvf_10hv
+    dela_vfb_cghvf_10hv            = (nom_dela_vfb_cghvf_10hv+nsig_dela_vfb_cghvf_10hv*sig_dela_vfb_cghvf_10hv)
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = ((cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um)*np+1.0e-17)*delr_mm_cghvf_10hv
+    w_nw                           = (w+(2.22))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    weff                           = ((w-2*((-0.0676341)+(0.168808)/w+(-0.242109/(w*l))))*1e-6)
+    leff                           = ((l-2*((-0.0728568)+(0.0815649)/l))*1e-6)
+    tox                            = (135.95*delr_tox_cghvf_10hv)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w+(0.06))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.04252*(cm1m1+cm2m2+cm3m3+cm4m4)+3.05239091*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(1.88434e-06+deltat*(0)))*delr_cfrlv_cghvf_10hv)
+    nom_cfr_m1_ply_cghvf           = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cghvf           = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cghvf           = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cghvf           = (0.030043167348678e-15)
+    cpp_m1_ply_cghvf               = (0.10244680628272e-15)
+    cpp_m2_ply_cghvf               = (0.031129787985865e-15)
+    cfr_m1_ply_cghvf               = (0.0496645438078e-15)
+    cfr_m2_ply_cghvf               = (0.0340576640831725e-15)
+    cfr_m3_ply_cghvf               = (0.0324247720343545e-15)
+    cfr_m4_ply_cghvf               = (0.030043167348678e-15)
+    lf                             = (w)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cghvf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cghvf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cghvf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cghvf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cghvf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cghvf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cghvf+area_b_m2_ply*cpp_m2_ply_cghvf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cghvf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cghvf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cghvf*ratio_cfr_m3_ply_outer+perim_outer_b_m4_ply*cfr_m4_ply_cghvf*ratio_cfr_m4_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)*delr_mm_cghvf_10hv

model cghvx mosvar
+ level    = (1000)
+ noscale  = (1)
+ gc3hvo   = (0.063)
+ gc2hvo   = (0.375)
+ gcohvo   = (0)
+ igovhvw  = (0)
+ igchvlw  = (0)
+ gc3o     = (0.063)
+ gc2o     = (0.375)
+ gcoo     = (0)
+ igovw    = (0)
+ iginvlw  = (0)
+ novo     = (5e+25)
+ lov      = (0)
+ stig     = (2)
+ chibpo   = (4.5)
+ chibo    = (3.1)
+ swigate  = (0)
+ feta     = (1)
+ stuac    = (0)
+ strshs   = (0)
+ strend   = (0)
+ strpv    = (0)
+ strshg   = (0)
+ typep    = (-1)
+ type     = (-1)
+ uacred   = (0)
+ uac      = (0.05)
+ rend     = (0.0001)
+ rpv      = (0)
+ rshg     = (1)
+ wmax     = (9.9e+09)
+ wmin     = (1e-08)
+ lmax     = (9.9e+09)
+ lmin     = (1e-08)
+ tr       = (27)
+ vmax     = (1e+04)
+ tmax     = (500)
+ tmin     = (-100)
+ revision = (0)
+ subversion = (0)
+ version  = (1.1)
+ dwr      = (0)
+ qmc      = (0)
+ npo      = (1.0e+27)
+ swres    = (1)
+ stvfb    = (-0.000453852)
+ rshs     = (492)
+ cfrw     = (0*1e6)
+ cfrl     = (0*1e6)
+ nsubo    = (10.65e+16*1e6)
+ vfbo     = (-0.14+dela_vfb_cghvf_10hv)
+ toxo     = (tox*1e-10)
+ tau      = (1.1e-12)

ccghvf_10hv_cghv_acc (t nw nw) cghvx l=(leff) w=(weff) m=(np)
ccghvf_10hv_cghv_tag (t nw) capacitor c=(val_tag_fld)
ccghvf_10hv_cfrlv (t nw) capacitor c=ctotal m=(np)
ccghvf_10hv_cfrlv_bply (t nw) capacitor c=(cp_b) m=(np)
xsubcap_cghvf_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghvf_10hv_dfrt
ends

subckt cghvf_m1m2m3_10hv (t nw sub)

parameters
+    w                              = 1.5
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghvf_m1m2m3_10hv    = tmp_nsmm_delr_cghvf_m1m2m3_10hv
+    delr_mm_cghvf_m1m2m3_10hv      = (1.0+nsmm_delr_cghvf_m1m2m3_10hv*smm_delr_cghvf_m1m2m3_10hv(w,nf)/sqrt(np))
+    delr_cfrlv_cghvf_m1m2m3_10hv   = (nom_delr_cfrlv_cghvf_m1m2m3_10hv*(1+nsig_delr_cfrlv_cghvf_m1m2m3_10hv*sig_delr_cfrlv_cghvf_m1m2m3_10hv))*delr_mm_cghvf_m1m2m3_10hv
+    delr_tox_cghvf_m1m2m3_10hv     = (nom_delr_tox_cghvf_m1m2m3_10hv*(1.0+nsig_delr_tox_cghvf_m1m2m3_10hv*sig_delr_tox_cghvf_m1m2m3_10hv))/delr_mm_cghvf_m1m2m3_10hv
+    dela_vfb_cghvf_m1m2m3_10hv     = (nom_dela_vfb_cghvf_m1m2m3_10hv+nsig_dela_vfb_cghvf_m1m2m3_10hv*sig_dela_vfb_cghvf_m1m2m3_10hv)
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = ((cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um)*np+1.0e-17)*delr_mm_cghvf_m1m2m3_10hv
+    w_nw                           = (w+(2.22))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    weff                           = ((w-2*((-0.0676341)+(0.168808)/w+(-0.242109/(w*l))))*1e-6)
+    leff                           = ((l-2*((-0.0728568)+(0.0815649)/l))*1e-6)
+    tox                            = (135.95*delr_tox_cghvf_m1m2m3_10hv)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w+(0.451685858874743))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.781167189135986*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.781167189135986*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.905192736088498*(cm1m1+cm2m2+cm3m3)+8.12938520971509*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(-13.5886641100536e-6+deltat*(0)))*delr_cfrlv_cghvf_m1m2m3_10hv)
+    nom_cfr_m1_ply_cghvf           = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cghvf           = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cghvf           = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cghvf           = (0.030043167348678e-15)
+    cpp_m1_ply_cghvf               = (0.10244680628272e-15)
+    cpp_m2_ply_cghvf               = (0.031129787985865e-15)
+    cfr_m1_ply_cghvf               = (0.0496645438078e-15)
+    cfr_m2_ply_cghvf               = (0.0340576640831725e-15)
+    cfr_m3_ply_cghvf               = (0.0324247720343545e-15)
+    cfr_m4_ply_cghvf               = (0.030043167348678e-15)
+    lf                             = (w)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cghvf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cghvf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cghvf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cghvf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cghvf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cghvf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cghvf+area_b_m2_ply*cpp_m2_ply_cghvf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cghvf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cghvf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cghvf*ratio_cfr_m3_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)*delr_mm_cghvf_m1m2m3_10hv

model cghvx mosvar
+ level    = (1000)
+ noscale  = (1)
+ gc3hvo   = (0.063)
+ gc2hvo   = (0.375)
+ gcohvo   = (0)
+ igovhvw  = (0)
+ igchvlw  = (0)
+ gc3o     = (0.063)
+ gc2o     = (0.375)
+ gcoo     = (0)
+ igovw    = (0)
+ iginvlw  = (0)
+ novo     = (5e+25)
+ lov      = (0)
+ stig     = (2)
+ chibpo   = (4.5)
+ chibo    = (3.1)
+ swigate  = (0)
+ feta     = (1)
+ stuac    = (0)
+ strshs   = (0)
+ strend   = (0)
+ strpv    = (0)
+ strshg   = (0)
+ typep    = (-1)
+ type     = (-1)
+ uacred   = (0)
+ uac      = (0.05)
+ rend     = (0.0001)
+ rpv      = (0)
+ rshg     = (1)
+ wmax     = (9.9e+09)
+ wmin     = (1e-08)
+ lmax     = (9.9e+09)
+ lmin     = (1e-08)
+ tr       = (27)
+ vmax     = (1e+04)
+ tmax     = (500)
+ tmin     = (-100)
+ revision = (0)
+ subversion = (0)
+ version  = (1.1)
+ dwr      = (0)
+ qmc      = (0)
+ npo      = (1.0e+27)
+ swres    = (1)
+ stvfb    = (-0.000453852)
+ rshs     = (492)
+ cfrw     = (0*1e6)
+ cfrl     = (0*1e6)
+ nsubo    = (10.65e+16*1e6)
+ vfbo     = (-0.14+dela_vfb_cghvf_m1m2m3_10hv)
+ toxo     = (tox*1e-10)
+ tau      = (1.1e-12)

ccghvf_m1m2m3_10hv_cghv_acc (t nw nw) cghvx l=(leff) w=(weff) m=(np)
ccghvf_m1m2m3_10hv_cghv_tag (t nw) capacitor c=(val_tag_fld)
ccghvf_m1m2m3_10hv_cfrlv (t nw) capacitor c=ctotal m=(np)
ccghvf_m1m2m3_10hv_cfrlv_bply (t nw) capacitor c=(cp_b) m=(np)
xsubcap_cghvf_m1m2m3_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghvf_m1m2m3_10hv_dfrt
ends

subckt cfrlv_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfrlv_10hv           = tmp_nsmm_delr_cfrlv_10hv
+    delr_cfrlv_10hv                = (nom_delr_cfrlv_10hv*(1+nsig_delr_cfrlv_10hv*sig_delr_cfrlv_10hv+nsmm_delr_cfrlv_10hv*smm_delr_cfrlv_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.00558787))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.25)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.899449*(cm1m1+cm2m2+cm3m3+cm4m4)+3.43239*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*((-1.80771e-06)+deltat*(0)))*delr_cfrlv_10hv)
+    lf                             = (l+(-1.835))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.672e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.771245)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.771245)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfrlv_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfrlv_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfrlv_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfrlv_10hv_dfrt
ends

subckt cfrlv_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfrlv_m1m2m3_10hv    = tmp_nsmm_delr_cfrlv_m1m2m3_10hv
+    delr_cfrlv_m1m2m3_10hv         = (nom_delr_cfrlv_m1m2m3_10hv*(1+nsig_delr_cfrlv_m1m2m3_10hv*sig_delr_cfrlv_m1m2m3_10hv+nsmm_delr_cfrlv_m1m2m3_10hv*smm_delr_cfrlv_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.0240035566969705))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.25)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.51128187803718*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.51128187803718*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.11453281406575*(cm1m1+cm2m2+cm3m3)+9.18862337488317*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(9.61579973601801e-06+deltat*(0)))*delr_cfrlv_m1m2m3_10hv)
+    lf                             = (l+(-1.835))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.672e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.771245)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.771245)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfrlv_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfrlv_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfrlv_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfrlv_m1m2m3_10hv_dfrt
ends

subckt cfr45_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr45_10hv           = tmp_nsmm_delr_cfr45_10hv
+    delr_cfr45_10hv                = (nom_delr_cfr45_10hv*(1+nsig_delr_cfr45_10hv*sig_delr_cfr45_10hv+nsmm_delr_cfr45_10hv*smm_delr_cfr45_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(-0.0153274))
+    wf                             = (0.21)
+    fd                             = (0.27)
+    lfext                          = (0.33)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.991811*(cm1m1+cm2m2+cm3m3+cm4m4)+2.93878*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    rtemp                          = ((temp+273.15)/(27+273.15))
+    ctotal                         = (cfr*(rtemp**(-0.0017632))*delr_cfr45_10hv)
+    lf                             = (l+(-1.80771))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.944e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.760446)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.760446)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr45_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr45_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr45_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr45_10hv_dfrt
ends

subckt cfr45_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr45_m1m2m3_10hv    = tmp_nsmm_delr_cfr45_m1m2m3_10hv
+    delr_cfr45_m1m2m3_10hv         = (nom_delr_cfr45_m1m2m3_10hv*(1+nsig_delr_cfr45_m1m2m3_10hv*sig_delr_cfr45_m1m2m3_10hv+nsmm_delr_cfr45_m1m2m3_10hv*smm_delr_cfr45_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(9.4142001687e-3))
+    wf                             = (0.21)
+    fd                             = (0.27)
+    lfext                          = (0.33)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.521029268026436*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.521029268026436*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.1590056022086*(cm1m1+cm2m2+cm3m3)+8.18731140121642*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(7.23948746567116e-6+deltat*(0)))*delr_cfr45_m1m2m3_10hv)
+    lf                             = (l+(-1.80771))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.944e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.760446)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.760446)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr45_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr45_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr45_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr45_m1m2m3_10hv_dfrt
ends

subckt cfr90_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr90_10hv           = tmp_nsmm_delr_cfr90_10hv
+    delr_cfr90_10hv                = (nom_delr_cfr90_10hv*(1+nsig_delr_cfr90_10hv*sig_delr_cfr90_10hv+nsmm_delr_cfr90_10hv*smm_delr_cfr90_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(-0.00144186))
+    wf                             = (0.21)
+    fd                             = (0.45)
+    lfext                          = (0.55)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.01976*(cm1m1+cm2m2+cm3m3+cm4m4)+2.51342*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(-2.88434e-05+deltat*(4.29049e-08)))*delr_cfr90_10hv)
+    lf                             = (l+(-2.13892))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(2.712e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.850281)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.850281)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr90_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr90_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr90_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr90_10hv_dfrt
ends

subckt cfr90_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr90_m1m2m3_10hv    = tmp_nsmm_delr_cfr90_m1m2m3_10hv
+    delr_cfr90_m1m2m3_10hv         = (nom_delr_cfr90_m1m2m3_10hv*(1+nsig_delr_cfr90_m1m2m3_10hv*sig_delr_cfr90_m1m2m3_10hv+nsmm_delr_cfr90_m1m2m3_10hv*smm_delr_cfr90_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.115081044654))
+    wf                             = (0.21)
+    fd                             = (0.45)
+    lfext                          = (0.55)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.598311365148279*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.598311365148279*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.02729591969074*(cm1m1+cm2m2+cm3m3)+6.40002059467394*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(-1.88470114859037e-5+deltat*(4.21448297209379e-8)))*delr_cfr90_m1m2m3_10hv)
+    lf                             = (l+(-2.13892))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(2.712e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.850281)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.850281)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr90_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr90_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr90_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr90_m1m2m3_10hv_dfrt
ends

subckt cfr120_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    finger_spacing                 = 0.7
+    nsmm_delr_cfr120_10hv          = tmp_nsmm_delr_cfr120_10hv
+    fac_nom_delr_cfr120_10hv       = ((1.017619669)*(finger_spacing==0.7)+(1.0037875)*(finger_spacing==1.0)+(0.940463701)*(finger_spacing==1.3)+(0.911066818)*(finger_spacing==1.6))
+    fac_sig_delr_cfr120_10hv       = ((1)*(finger_spacing==0.7)+(0.730388)*(finger_spacing==1.0)+(0.800096)*(finger_spacing==1.3)+(0.938526)*(finger_spacing==1.6))
+    delr_cfr120_10hv               = (fac_nom_delr_cfr120_10hv*nom_delr_cfr120_10hv*(1+nsig_delr_cfr120_10hv*fac_sig_delr_cfr120_10hv*sig_delr_cfr120_10hv+nsmm_delr_cfr120_10hv*smm_delr_cfr120_10hv(l,nf,finger_spacing)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (3000*1e-4)
+    thick_m2                       = (2700*1e-4)
+    thick_m3                       = (3800*1e-4)
+    thick_m4                       = (3800*1e-4)
+    fd                             = (finger_spacing)
+    dnf                            = ((0.1748)*(fd==0.7)+(0.2248)*(fd==1.0)+(0.29)*(fd==1.3)+(0.4337)*(fd==1.6))
+    dlf                            = ((1.059)*(fd==0.7)+(1.654)*(fd==1.0)+(2.369)*(fd==1.3)+(3.740)*(fd==1.6))
+    wf                             = (0.21)
+    lf_m                           = (l+dlf)
+    lfext                          = (finger_spacing+0.2)
+    perim_snake                    = (nf-1)*(lf_m)+dnf*((lf_m)-dlf*nf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cfr_m2_m1_tcad                 = (6.460e-18*(fd==0.7)+5.557e-18*(fd==1.0)+4.489e-18*(fd==1.3)+3.525e-18*(fd==1.6))
+    cfr_m3_m2_tcad                 = (6.517e-18*(fd==0.7)+5.699e-18*(fd==1.0)+4.749e-18*(fd==1.3)+3.902e-18*(fd==1.6))
+    cfr_m4_m3_tcad                 = (7.588e-18*(fd==0.7)+7.236e-18*(fd==1.0)+6.687e-18*(fd==1.3)+6.113e-18*(fd==1.6))
+    cm1m2_t                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_t                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm3m4_t                        = (cfr_m4_m3_tcad*(sDOTmult*perim_snake))
+    cm1m2_b                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_b                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm3m4_b                        = (cfr_m4_m3_tcad*(sDOTmult*perim_snake))
+    cm1m2                          = (cm1m2_t+cm1m2_b)
+    cm2m3                          = (cm2m3_t+cm2m3_b)
+    cm3m4                          = (cm3m4_t+cm3m4_b)
+    cc1                            = (1.013791842*(1.234902143*(fd==0.7)+1.155000592*(fd==1.0)+1.125716531*(fd==1.3)+1.115667867*(fd==1.6)))
+    cc2                            = (1.013791842*(1.521842268*(fd==0.7)+1.423374905*(fd==1.0)+1.387286442*(fd==1.3)+1.374902884*(fd==1.6)))
+    tc1                            = ((-9.5884e-06)*(fd==0.7)+(-1.2019e-05)*(fd==1.0)+(-1.4466e-05)*(fd==1.3)+(-1.6249e-05)*(fd==1.6))
+    tc2                            = ((7.3828e-09)*(fd==0.7)+(0)*(fd==1.0)+(0)*(fd==1.3)+(0)*(fd==1.6))
+    cfr                            = (cc1*(cm1m1+cm2m2+cm3m3+cm4m4)+cc2*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(tc1+deltat*(tc2)))*delr_cfr120_10hv)
+    dlfb                           = (-1.240777636)
+    fac_ctw_pin                    = (1.029377173*(fd==0.7)+1.087783894*(fd==1.0)+1.139137904*(fd==1.3)+1.206401912*(fd==1.6))
+    fac_ctw_pout                   = (0.707618814*(fd==0.7)+0.961358325*(fd==1.0)+0.8962057*(fd==1.3)+0.711779027*(fd==1.6))
+    fac_cbw_pin                    = (0.991608703*(fd==0.7)+1.067918388*(fd==1.0)+1.103755153*(fd==1.3)+1.195179402*(fd==1.6))
+    fac_cbw_pout                   = (0.739684191*(fd==0.7)+0.85258914*(fd==1.0)+0.855185467*(fd==1.3)+0.719906198*(fd==1.6))
+    lf                             = (l+dlfb)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = (lroot*2+wroot)
+    perim_outer_b_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = (lroot*2+wroot)
+    perim_outer_b_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in_tcad                = (2.080e-17*(fd==0.7)+2.389e-17*(fd==1.0)+2.570e-17*(fd==1.3)+2.675e-17*(fd==1.6))
+    ratio_cfr_inner                = (cfr_fld_in_tcad/nom_cfr_m1_fld)
+    cfr120_inner                   = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld))
+    cfr_m1_fld_outer_tcad          = (2.842e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer_tcad/nom_cfr_m1_fld)
+    cfr_m2_fld_outer_tcad          = (1.107e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer_tcad/nom_cfr_m2_fld)
+    cfr_m3_fld_outer_tcad          = (9.863e-18)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer_tcad/nom_cfr_m3_fld)
+    cfr_m4_fld_outer_tcad          = (1.518e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer_tcad/nom_cfr_m4_fld)
+    cbot_perim_in_t                = (cfr120_inner*fac_ctw_pin)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*fac_ctw_pout)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = (cfr120_inner*fac_cbw_pin)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*fac_cbw_pout)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr120_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr120_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr120_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr120_10hv_dfrt
ends

subckt cfr120_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    finger_spacing                 = 0.7
+    nsmm_delr_cfr120_m1m2m3_10hv   = tmp_nsmm_delr_cfr120_m1m2m3_10hv
+    fac_nom_delr_cfr120_m1m2m3_10hv = ((1.007139019)*(finger_spacing==0.7)+(1.005809773)*(finger_spacing==1.0)+(0.974195475)*(finger_spacing==1.3)+(0.943091443)*(finger_spacing==1.6))
+    fac_sig_delr_cfr120_m1m2m3_10hv = ((1)*(finger_spacing==0.7)+(1.055939)*(finger_spacing==1.0)+(0.876056)*(finger_spacing==1.3)+(1.189821)*(finger_spacing==1.6))
+    delr_cfr120_m1m2m3_10hv        = (fac_nom_delr_cfr120_m1m2m3_10hv*nom_delr_cfr120_m1m2m3_10hv*(1+nsig_delr_cfr120_m1m2m3_10hv*fac_sig_delr_cfr120_m1m2m3_10hv*sig_delr_cfr120_m1m2m3_10hv+nsmm_delr_cfr120_m1m2m3_10hv*smm_delr_cfr120_m1m2m3_10hv(l,nf,finger_spacing)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (3000*1e-4)
+    thick_m2                       = (2700*1e-4)
+    thick_m3                       = (3800*1e-4)
+    fd                             = (finger_spacing)
+    dnf                            = ((0.1924)*(fd==0.7)+(0.2813)*(fd==1.0)+(0.3222)*(fd==1.3)+(0.369)*(fd==1.6))
+    dlf                            = ((1.147)*(fd==0.7)+(1.877)*(fd==1.0)+(2.614)*(fd==1.3)+(3.466)*(fd==1.6))
+    wf                             = (0.21)
+    lf_m                           = (l+dlf)
+    lfext                          = (finger_spacing+0.2)
+    perim_snake                    = (nf-1)*(l+dlf)+dnf*((l+dlf)-dlf*nf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cfr_m2_m1_tcad                 = (6.460e-18*(fd==0.7)+5.561e-18*(fd==1.0)+4.506e-18*(fd==1.3)+3.562e-18*(fd==1.6))
+    cfr_m3_m2_tcad                 = (6.804e-18*(fd==0.7)+6.398e-18*(fd==1.0)+5.837e-18*(fd==1.3)+5.272e-18*(fd==1.6))
+    cm1m2_t                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_t                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm1m2_b                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_b                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm1m2                          = (cm1m2_t+cm1m2_b)
+    cm2m3                          = (cm2m3_t+cm2m3_b)
+    cc1                            = (0.981140899*(0.812897617*(fd==0.7)+0.716044443*(fd==1.0)+0.678287324*(fd==1.3)+0.667253559*(fd==1.6)))
+    cc2                            = (0.981140899*(2.532163025*(fd==0.7)+2.230466942*(fd==1.0)+2.112854125*(fd==1.3)+2.078484125*(fd==1.6)))
+    tc1                            = ((-1.0791e-06)*(fd==0.7)+(-5.0854e-06)*(fd==1.0)+(-8.5839e-06)*(fd==1.3)+(-1.1953e-05)*(fd==1.6))
+    tc2                            = ((7.0437e-09)*(fd==0.7)+(0)*(fd==1.0)+(0)*(fd==1.3)+(0)*(fd==1.6))
+    cfr                            = (cc1*(cm1m1+cm2m2+cm3m3)+cc2*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(tc1+deltat*(tc2)))*delr_cfr120_m1m2m3_10hv)
+    dlfb                           = (-1.237998007)
+    fac_ctw_pin                    = (1.030935115*(fd==0.7)+1.088972595*(fd==1.0)+1.144223777*(fd==1.3)+1.211719164*(fd==1.6))
+    fac_ctw_pout                   = (0.775100125*(fd==0.7)+1.040963952*(fd==1.0)+0.971500726*(fd==1.3)+0.766728777*(fd==1.6))
+    fac_cbw_pin                    = (0.992118953*(fd==0.7)+1.064721597*(fd==1.0)+1.106222307*(fd==1.3)+1.197159448*(fd==1.6))
+    fac_cbw_pout                   = (0.799803446*(fd==0.7)+0.914976005*(fd==1.0)+0.921839972*(fd==1.3)+0.778977738*(fd==1.6))
+    lf                             = (l+dlfb)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = (lroot*2+wroot)
+    perim_outer_b_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = (lroot*2+wroot)
+    perim_outer_b_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in_tcad                = (2.080e-17*(fd==0.7)+2.389e-17*(fd==1.0)+2.570e-17*(fd==1.3)+2.675e-17*(fd==1.6))
+    ratio_cfr_inner                = (cfr_fld_in_tcad/nom_cfr_m1_fld)
+    cfr120_inner                   = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld))
+    cfr_m1_fld_outer_tcad          = (2.90e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer_tcad/nom_cfr_m1_fld)
+    cfr_m2_fld_outer_tcad          = (1.238e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer_tcad/nom_cfr_m2_fld)
+    cfr_m3_fld_outer_tcad          = (1.809e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer_tcad/nom_cfr_m3_fld)
+    cbot_perim_in_t                = (cfr120_inner*fac_ctw_pin)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*fac_ctw_pout)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = (cfr120_inner*fac_cbw_pin)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*fac_cbw_pout)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr120_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr120_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr120_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr120_m1m2m3_10hv_dfrt
ends

//***********************************************************
endsection capacitor
//***********************************************************

//***********************************************************
section capacitor_simple
//***********************************************************

subckt cdp_10hv (t b nw sub)

parameters
+    area                           = 2.480625
+    perim                          = 6.3
+    w                              = 1.575
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdp_10hv             = tmp_nsmm_delr_cdp_10hv
+    ww                             = ((perim+sqrt(abs(perim*perim-16*area)))/4)
+    ll                             = (area/ww)
+    delr_cpp_cdp_10hv              = (nom_delr_cpp_cdp_10hv*(1.0+nsig_delr_cpp_cdp_10hv*sig_delr_cpp_cdp_10hv+nsmm_delr_cdp_10hv*smm_delr_cdp_10hv(ll,ww)/sqrt(np)))
+    delr_cfr_cdp_10hv              = (nom_delr_cfr_cdp_10hv*(1.0+nsig_delr_cfr_cdp_10hv*sig_delr_cfr_cdp_10hv+nsmm_delr_cdp_10hv*smm_delr_cdp_10hv(ll,ww)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    cpp_cdp_10hv                   = (1.60711e-15*delr_cpp_cdp_10hv)
+    cfr_cdp_10hv                   = (4.22043e-17*delr_cfr_cdp_10hv)
+    woverlap_cdp_10hv              = (0.51+0.51)
+    loverlap_cdp_10hv              = (1.065+0.51)
+    areat                          = (area)
+    perimt                         = (perim)
+    areab                          = ((ll+loverlap_cdp_10hv)*(ww+woverlap_cdp_10hv))
+    perimb                         = ((2*(ll+loverlap_cdp_10hv+ww+woverlap_cdp_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((ll+loverlap_cdp_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (ww+woverlap_cdp_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    deltat                         = (temp-27)
+    tc1                            = (3.09435e-05)
+    tc2                            = (1.42121e-09)
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdp_10hv+sDOTmult*perimt*cfr_cdp_10hv)
+    c_p2p1_t                       = (c_p2p1*(1+deltat*(tc1+deltat*tc2)))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)

ccdp_10hvt (t b) capacitor c=c_p2p1_t m=(np)
ccdp_10hvb (b nw) capacitor c=c_p1nw m=(np)
xsubcap_cdp_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cdp_10hv_dfrt
ends

subckt cdpf_10hv (t b nw sub)

parameters
+    w                              = 2.32
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdpf_10hv            = tmp_nsmm_delr_cdpf_10hv
+    delr_cpp_cdpf_10hv             = (nom_delr_cpp_cdpf_10hv*(1.0+nsig_delr_cpp_cdpf_10hv*sig_delr_cpp_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cfr_cdpf_10hv             = (nom_delr_cfr_cdpf_10hv*(1.0+nsig_delr_cfr_cdpf_10hv*sig_delr_cfr_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cfrlv_cdpf_10hv           = (nom_delr_cfrlv_cdpf_10hv*(1.0+nsig_delr_cfrlv_cdpf_10hv*sig_delr_cfrlv_cdpf_10hv+nsmm_delr_cdpf_10hv*smm_delr_cdpf_10hv(w,nf)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    area                           = (w*l)
+    perim                          = (2*(w+l))
+    cpp_cdpf_10hv                  = (1.60711e-15*delr_cpp_cdpf_10hv)
+    cfr_cdpf_10hv                  = (4.22043e-17*delr_cfr_cdpf_10hv)
+    woverlap_cdpf_10hv             = (0.51+0.51)
+    loverlap_cdpf_10hv             = (1.065+0.51)
+    areat                          = (w*l)
+    perimt                         = (2*(w+l))
+    areab                          = ((l+loverlap_cdpf_10hv)*(w+woverlap_cdpf_10hv))
+    perimb                         = ((2*(l+loverlap_cdpf_10hv+w+woverlap_cdpf_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((l+loverlap_cdpf_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (w+woverlap_cdpf_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    deltat                         = (temp-27)
+    tc1                            = (3.20261e-05)
+    tc2                            = (-1.62404e-11)
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdpf_10hv+sDOTmult*perimt*cfr_cdpf_10hv)
+    c_p2p1_t                       = (c_p2p1*(1+deltat*(tc1+deltat*tc2)))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w-1.32+(-0.324067))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.34025*(cm1m1+cm2m2+cm3m3+cm4m4)+2.30743*(cm1m2+cm2m3+cm3m4))
+    ctotal                         = (cfr*(1.0+deltat*(1.88434e-06+deltat*(0)))*delr_cfrlv_cdpf_10hv)
+    nom_cfr_m1_ply_cdpf            = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cdpf            = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cdpf            = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cdpf            = (0.030043167348678e-15)
+    cpp_m1_ply_cdpf                = (0.10244680628272e-15)
+    cpp_m2_ply_cdpf                = (0.031129787985865e-15)
+    cfr_m1_ply_cdpf                = (0.0496645438078e-15)
+    cfr_m2_ply_cdpf                = (0.0340576640831725e-15)
+    cfr_m3_ply_cdpf                = (0.0324247720343545e-15)
+    cfr_m4_ply_cdpf                = (0.030043167348678e-15)
+    lf                             = (w-1.32)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cdpf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cdpf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cdpf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cdpf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cdpf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cdpf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cdpf+area_b_m2_ply*cpp_m2_ply_cdpf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cdpf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cdpf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cdpf*ratio_cfr_m3_ply_outer+perim_outer_b_m4_ply*cfr_m4_ply_cdpf*ratio_cfr_m4_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccdpf_10hvt (t b) capacitor c=c_p2p1_t m=(np)
ccdpf_10hv_cfrlv (t b) capacitor c=ctotal m=(np)
ccdpf_10hv_cfrlv_bply (t b) capacitor c=(cp_b) m=(np)
ccdpf_10hvb (b nw) capacitor c=c_p1nw m=(np)
xsubcap_cdpf_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cdpf_10hv_dfrt
ends

subckt cdpf_m1m2m3_10hv (t b nw sub)

parameters
+    w                              = 2.32
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_cdpf_m1m2m3_10hv     = tmp_nsmm_delr_cdpf_m1m2m3_10hv
+    delr_cpp_cdpf_m1m2m3_10hv      = (nom_delr_cpp_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cpp_cdpf_m1m2m3_10hv*sig_delr_cpp_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cfr_cdpf_m1m2m3_10hv      = (nom_delr_cfr_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cfr_cdpf_m1m2m3_10hv*sig_delr_cfr_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cfrlv_cdpf_m1m2m3_10hv    = (nom_delr_cfrlv_cdpf_m1m2m3_10hv*(1.0+nsig_delr_cfrlv_cdpf_m1m2m3_10hv*sig_delr_cfrlv_cdpf_m1m2m3_10hv+nsmm_delr_cdpf_m1m2m3_10hv*smm_delr_cdpf_m1m2m3_10hv(w,nf)/sqrt(np)))
+    delr_cpp_ply0_fld_cdp          = (nom_delr_cpp_ply0_fld_cdp*(1.0+nsig_delr_cpp_ply0_fld_cdp*sig_delr_cpp_ply0_fld_cdp))
+    delr_cfr_ply0_fld_cdp          = (nom_delr_cfr_ply0_fld_cdp*(1.0+nsig_delr_cfr_ply0_fld_cdp*sig_delr_cfr_ply0_fld_cdp))
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    area                           = (w*l)
+    perim                          = (2*(w+l))
+    cpp_cdpf_10hv                  = (1.60711e-15*delr_cpp_cdpf_m1m2m3_10hv)
+    cfr_cdpf_10hv                  = (4.22043e-17*delr_cfr_cdpf_m1m2m3_10hv)
+    woverlap_cdpf_10hv             = (0.51+0.51)
+    loverlap_cdpf_10hv             = (1.065+0.51)
+    areat                          = (w*l)
+    perimt                         = (2*(w+l))
+    areab                          = ((l+loverlap_cdpf_10hv)*(w+woverlap_cdpf_10hv))
+    perimb                         = ((2*(l+loverlap_cdpf_10hv+w+woverlap_cdpf_10hv)))
+    lpoly02dt                      = (2.235+0.51)
+    wpoly02dt                      = (2*0.51)
+    liso                           = ((l+loverlap_cdpf_10hv)*np+(0.75)*(np-1)+lpoly02dt)
+    wiso                           = (w+woverlap_cdpf_10hv+wpoly02dt)
+    aiso                           = (liso*wiso)
+    piso                           = (2*(liso+wiso))
+    deltat                         = (temp-27)
+    tc1                            = (348.852016756149e-6)
+    tc2                            = (-16.2404e-12)
+    c_p2p1                         = (sDOTmult*sDOTmult*areat*cpp_cdpf_10hv+sDOTmult*perimt*cfr_cdpf_10hv)
+    c_p2p1_t                       = (c_p2p1*(1+deltat*(tc1+deltat*tc2)))
+    c_p1nw                         = (sDOTmult*sDOTmult*areab*nom_cpp_ply0_fld_cdp*delr_cpp_ply0_fld_cdp+sDOTmult*perimb*nom_cfr_ply0_fld_cdp*delr_cfr_ply0_fld_cdp)
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w-1.32+(-0.374159067188369))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.511232710195269*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.511232710195269*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.6258705349406*(cm1m1+cm2m2+cm3m3)+4.03181371037931*(cm1m2+cm2m3))
+    ctotal                         = (cfr*(1.0+deltat*(-768.273775799702e-06+deltat*(0)))*delr_cfrlv_cdpf_m1m2m3_10hv)
+    nom_cfr_m1_ply_cdpf            = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cdpf            = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cdpf            = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cdpf            = (0.030043167348678e-15)
+    cpp_m1_ply_cdpf                = (0.10244680628272e-15)
+    cpp_m2_ply_cdpf                = (0.031129787985865e-15)
+    cfr_m1_ply_cdpf                = (0.0496645438078e-15)
+    cfr_m2_ply_cdpf                = (0.0340576640831725e-15)
+    cfr_m3_ply_cdpf                = (0.0324247720343545e-15)
+    cfr_m4_ply_cdpf                = (0.030043167348678e-15)
+    lf                             = (w-1.32)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cdpf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cdpf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cdpf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cdpf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cdpf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cdpf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cdpf+area_b_m2_ply*cpp_m2_ply_cdpf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cdpf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cdpf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cdpf*ratio_cfr_m3_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccdpf_m1m2m3_10hvt (t b) capacitor c=c_p2p1_t m=(np)
ccdpf_m1m2m3_10hv_cfrlv (t b) capacitor c=ctotal m=(np)
ccdpf_m1m2m3_10hv_cfrlv_bply (t b) capacitor c=(cp_b) m=(np)
ccdpf_m1m2m3_10hvb (b nw) capacitor c=c_p1nw m=(np)
xsubcap_cdpf_m1m2m3_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*aiso+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*piso+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cdpf_m1m2m3_10hv_dfrt
ends

subckt cglv_10hv (t nw sub)

parameters
+    l                              = 1.29
+    w                              = 1.29
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cglv_10hv_tox        = tmp_nsmm_delr_cglv_10hv_tox
+    delr_cpp_ply_fld               = (nom_delr_cpp_ply_fld*(1.0+nsig_delr_cpp_ply_fld*sig_delr_cpp_ply_fld))
+    delr_cfr_ply_fld               = (nom_delr_cfr_ply_fld*(1.0+nsig_delr_cfr_ply_fld*sig_delr_cfr_ply_fld))
+    delr_cglv_10hv_tox             = (nom_delr_cglv_10hv_tox*(1.0+nsig_delr_cglv_10hv_tox*sig_delr_cglv_10hv_tox+nsmm_delr_cglv_10hv_tox*smm_delr_cglv_10hv_tox(l,w)/sqrt(np)))
+    delr_cglv_10hv_ileak           = (nom_delr_cglv_10hv_ileak*exp(nsig_delr_cglv_10hv_ileak*sig_delr_cglv_10hv_ileak))
+    ca_fld                         = (nom_cpp_ply_fld*delr_cpp_ply_fld)
+    cp_fld                         = (nom_cfr_ply_fld*delr_cfr_ply_fld)
+    ply2dt                         = (3.06)
+    w_aa2dt                        = (2.22)
+    ply2ply                        = (0.51)
+    wply_ovl_aa                    = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(l*wply_ovl_aa)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*(l+wply_ovl_aa))*sDOTmult)
+    val_tag_fld                    = (ca_fld*a_tag_fld_um2+cp_fld*p_tag_fld_um+1e-17)
+    lsub                           = (l*np+(np-1)*ply2ply+ply2dt)
+    wsub                           = (w+w_aa2dt)
+    areab_um2                      = (lsub*wsub)
+    perimb_um                      = ((lsub+wsub)*2)
+    weff                           = (w+(0))
+    leff                           = (l+(-0.0324298))
+    area_eff                       = (weff*leff*np)
+    apar                           = ((1.0e-18)*(1+3.25e-3*(temp-27)))
+    bpar                           = (14)
+    ppar                           = ((0.275)*(1-0.35e-3*(temp-27)))
+    a2par                          = ((8e-18)*(1+3.0e-3*(temp-27)+15e-6*(temp-27)*(temp-27)))
+    b2par                          = ((8.5)*(1+0.13e-3*(temp-27)))
+    p2par                          = (0.1)
+    tox                            = (34.7925*(delr_cglv_10hv_tox))
+    totalcap                       = ((0.9697963)*3.9*8.85e-12*weff*leff*1e-12/(tox*1e-10))

bileak_fwd (t nw) bsource i=((apar*v(t,nw)*exp(bpar*(maxa(v(t,nw),0,1e-12)**(ppar))))*area_eff*delr_cglv_10hv_ileak) tc1=0 tc2=0
bileak_rev (nw t) bsource i=((a2par*v(nw,t)*exp(b2par*(maxa(v(nw,t),0,1e-12)**(p2par))))*area_eff*delr_cglv_10hv_ileak) tc1=0 tc2=0
ccglv_10hv (t nw) capacitor c=totalcap m=(np)
ccglv_10hvt (t nw) capacitor c=(val_tag_fld) m=(np)
xsubcap_cglv_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_um2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_um+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cglv_10hv_dfrt
ends

subckt cghv_10hv (t nw sub)

parameters
+    l                              = 1.5
+    w                              = 1.5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghv_10hv_tox        = tmp_nsmm_delr_cghv_10hv_tox
+    delr_tox_cghv_10hv             = (nom_delr_tox_cghv_10hv*(1.0+nsig_delr_tox_cghv_10hv*sig_delr_tox_cghv_10hv+nsmm_delr_cghv_10hv_tox*smm_delr_cghv_10hv_tox(w,l)/sqrt(np)))
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = (cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um+1.0e-17)
+    w_nw                           = (w+(2.22))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    tox                            = (140.25*(delr_tox_cghv_10hv))
+    totalcap                       = ((1.033117)*3.9*8.85e-12*w*l*1e-12/(tox*1e-10))

ccghv_10hv (t nw) capacitor c=totalcap m=(np)
ccghv_10hv_tag (t nw) capacitor c=(val_tag_fld) m=(np)
xsubcap_cghv_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghv_10hv_dfrt
ends

subckt cghvf_10hv (t nw sub)

parameters
+    w                              = 1.5
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghvf_10hv           = tmp_nsmm_delr_cghvf_10hv
+    delr_mm_cghvf_10hv             = (1.0+nsmm_delr_cghvf_10hv*smm_delr_cghvf_10hv(w,nf)/sqrt(np))
+    delr_cfrlv_cghvf_10hv          = (nom_delr_cfrlv_cghvf_10hv*(1+nsig_delr_cfrlv_cghvf_10hv*sig_delr_cfrlv_cghvf_10hv))*delr_mm_cghvf_10hv
+    delr_tox_cghvf_10hv            = (nom_delr_tox_cghvf_10hv*(1.0+nsig_delr_tox_cghvf_10hv*sig_delr_tox_cghvf_10hv))/delr_mm_cghvf_10hv
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = (cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um+1.0e-17)*delr_mm_cghvf_10hv
+    w_nw                           = (w+(2.42))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    tox                            = (141.25*(delr_tox_cghvf_10hv))
+    totalcap                       = ((1.0339)*3.9*8.85e-12*w*l*1e-12/(tox*1e-10))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w+(0.06))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.04252*(cm1m1+cm2m2+cm3m3+cm4m4)+3.05239091*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = ((1.0339)*cfr*(1.0+deltat*(1.88434e-06+deltat*(0)))*delr_cfrlv_cghvf_10hv)
+    nom_cfr_m1_ply_cghvf           = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cghvf           = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cghvf           = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cghvf           = (0.030043167348678e-15)
+    cpp_m1_ply_cghvf               = (0.10244680628272e-15)
+    cpp_m2_ply_cghvf               = (0.031129787985865e-15)
+    cfr_m1_ply_cghvf               = (0.0496645438078e-15)
+    cfr_m2_ply_cghvf               = (0.0340576640831725e-15)
+    cfr_m3_ply_cghvf               = (0.0324247720343545e-15)
+    cfr_m4_ply_cghvf               = (0.030043167348678e-15)
+    lf                             = (w)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cghvf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cghvf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cghvf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cghvf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cghvf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cghvf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cghvf+area_b_m2_ply*cpp_m2_ply_cghvf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cghvf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cghvf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cghvf*ratio_cfr_m3_ply_outer+perim_outer_b_m4_ply*cfr_m4_ply_cghvf*ratio_cfr_m4_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)*delr_mm_cghvf_10hv

ccghvf_10hv (t nw) capacitor c=totalcap m=(np)
ccghvf_10hv_cghv_tag (t nw) capacitor c=(val_tag_fld) m=(np)
ccghvf_10hv_cfrlv (t nw) capacitor c=ctotal m=(np)
ccghvf_10hv_cfrlv_bply (t nw) capacitor c=(cp_b) m=(np)
xsubcap_cghvf_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghvf_10hv_dfrt
ends

subckt cghvf_m1m2m3_10hv (t nw sub)

parameters
+    w                              = 1.5
+    nf                             = 5
+    np                             = 1
+    lpe                            = 0
+    soa                            = 1
+    ring                           = 1
+    nsmm_delr_cghvf_m1m2m3_10hv    = tmp_nsmm_delr_cghvf_m1m2m3_10hv
+    delr_mm_cghvf_m1m2m3_10hv      = (1.0+nsmm_delr_cghvf_m1m2m3_10hv*smm_delr_cghvf_m1m2m3_10hv(w,nf)/sqrt(np))
+    delr_cfrlv_cghvf_m1m2m3_10hv   = (nom_delr_cfrlv_cghvf_m1m2m3_10hv*(1+nsig_delr_cfrlv_cghvf_m1m2m3_10hv*sig_delr_cfrlv_cghvf_m1m2m3_10hv))*delr_mm_cghvf_m1m2m3_10hv
+    delr_tox_cghvf_m1m2m3_10hv     = (nom_delr_tox_cghvf_m1m2m3_10hv*(1.0+nsig_delr_tox_cghvf_m1m2m3_10hv*sig_delr_tox_cghvf_m1m2m3_10hv))/delr_mm_cghvf_m1m2m3_10hv
+    l                              = (2*0.15+((nf-1)*(0.21)+nf*(0.21)))
+    w_ply_tag                      = (0.63)
+    a_tag_fld_um2                  = ((1-lpe)*(w_ply_tag*l)*sDOTmult*sDOTmult)
+    p_tag_fld_um                   = ((1-lpe)*(2*l+2*w_ply_tag)*sDOTmult)
+    val_tag_fld                    = (cpp_ply_fld*a_tag_fld_um2+cfr_ply_fld*p_tag_fld_um+1.0e-17)*delr_mm_cghvf_m1m2m3_10hv
+    w_nw                           = (w+(2.42))
+    l_nw                           = ((l*np+(3.06))+(0.51)*(np-1))
+    areab_xdr2                     = ((w_nw)*(l_nw))
+    perimb_xdr                     = (2*(w_nw+l_nw))
+    tox                            = (141.25*(delr_tox_cghvf_m1m2m3_10hv))
+    totalcap                       = ((1.0339)*3.9*8.85e-12*w*l*1e-12/(tox*1e-10))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (w+(0.451685858874743))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.21)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.781167189135986*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.781167189135986*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.905192736088498*(cm1m1+cm2m2+cm3m3)+8.12938520971509*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = ((1.0339)*cfr*(1.0+deltat*(-13.5886641100536e-6+deltat*(0)))*delr_cfrlv_cghvf_m1m2m3_10hv)
+    nom_cfr_m1_ply_cghvf           = (0.0496645438078e-15)
+    nom_cfr_m2_ply_cghvf           = (0.0340576640831725e-15)
+    nom_cfr_m3_ply_cghvf           = (0.0324247720343545e-15)
+    nom_cfr_m4_ply_cghvf           = (0.030043167348678e-15)
+    cpp_m1_ply_cghvf               = (0.10244680628272e-15)
+    cpp_m2_ply_cghvf               = (0.031129787985865e-15)
+    cfr_m1_ply_cghvf               = (0.0496645438078e-15)
+    cfr_m2_ply_cghvf               = (0.0340576640831725e-15)
+    cfr_m3_ply_cghvf               = (0.0324247720343545e-15)
+    cfr_m4_ply_cghvf               = (0.030043167348678e-15)
+    lf                             = (w)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_b_m1_ply                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_b_m1_ply           = (lroot*2+wroot)
+    area_b_m2_ply                  = (lfext*wf*(nf+1)/2)
+    perim_outer_b_m2_ply           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_ply           = (lroot*2+wroot)
+    perim_outer_b_m4_ply           = ((lf+lfext+lroot)*2+wroot)
+    cfr_ply_in                     = (0.5*(9.735e-18))
+    ratio_cfr_inner                = (cfr_ply_in/nom_cfr_m1_ply_cghvf)
+    cfr_m1_ply_outer               = (1.479e-17)
+    ratio_cfr_m1_ply_outer         = (cfr_m1_ply_outer/nom_cfr_m1_ply_cghvf)
+    cfr_m2_ply_outer               = (1.995e-18)
+    ratio_cfr_m2_ply_outer         = (cfr_m2_ply_outer/nom_cfr_m2_ply_cghvf)
+    cfr_m3_ply_outer               = (7.045e-19)
+    ratio_cfr_m3_ply_outer         = (cfr_m3_ply_outer/nom_cfr_m3_ply_cghvf)
+    cfr_m4_ply_outer               = (4.650e-19)
+    ratio_cfr_m4_ply_outer         = (cfr_m4_ply_outer/nom_cfr_m4_ply_cghvf)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_ply_cghvf))
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_ply*cpp_m1_ply_cghvf+area_b_m2_ply*cpp_m2_ply_cghvf))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_ply*cfr_m1_ply_cghvf*ratio_cfr_m1_ply_outer+perim_outer_b_m2_ply*cfr_m2_ply_cghvf*ratio_cfr_m2_ply_outer+perim_outer_b_m3_ply*cfr_m3_ply_cghvf*ratio_cfr_m3_ply_outer))
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)*delr_mm_cghvf_m1m2m3_10hv

ccghvf_m1m2m3_10hv (t nw) capacitor c=totalcap m=(np)
ccghvf_m1m2m3_10hv_cghv_tag (t nw) capacitor c=(val_tag_fld) m=(np)
ccghvf_m1m2m3_10hv_cfrlv (t nw) capacitor c=ctotal m=(np)
ccghvf_m1m2m3_10hv_cfrlv_bply (t nw) capacitor c=(cp_b) m=(np)
xsubcap_cghvf_m1m2m3_10hv (nw sub) cnwtub_box_sub_10hv area=(ring*(1-lpe)*areab_xdr2+lpe*0.001+(1-ring)*0.001) perim=(ring*(1-lpe)*perimb_xdr+lpe*0.001+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=cghvf_m1m2m3_10hv_dfrt
ends

subckt cfrlv_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfrlv_10hv           = tmp_nsmm_delr_cfrlv_10hv
+    delr_cfrlv_10hv                = (nom_delr_cfrlv_10hv*(1+nsig_delr_cfrlv_10hv*sig_delr_cfrlv_10hv+nsmm_delr_cfrlv_10hv*smm_delr_cfrlv_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.00558787))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.25)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.899449*(cm1m1+cm2m2+cm3m3+cm4m4)+3.43239*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*((-1.80771e-06)+deltat*(0)))*delr_cfrlv_10hv)
+    lf                             = (l+(-1.835))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.672e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.771245)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.771245)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfrlv_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfrlv_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfrlv_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfrlv_10hv_dfrt
ends

subckt cfrlv_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfrlv_m1m2m3_10hv    = tmp_nsmm_delr_cfrlv_m1m2m3_10hv
+    delr_cfrlv_m1m2m3_10hv         = (nom_delr_cfrlv_m1m2m3_10hv*(1+nsig_delr_cfrlv_m1m2m3_10hv*sig_delr_cfrlv_m1m2m3_10hv+nsmm_delr_cfrlv_m1m2m3_10hv*smm_delr_cfrlv_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.0240035566969705))
+    wf                             = (0.21)
+    fd                             = (0.21)
+    lfext                          = (0.25)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.51128187803718*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.51128187803718*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.11453281406575*(cm1m1+cm2m2+cm3m3)+9.18862337488317*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(9.61579973601801e-06+deltat*(0)))*delr_cfrlv_m1m2m3_10hv)
+    lf                             = (l+(-1.835))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.672e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.771245)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.960619)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.771245)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfrlv_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfrlv_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfrlv_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfrlv_m1m2m3_10hv_dfrt
ends

subckt cfr45_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr45_10hv           = tmp_nsmm_delr_cfr45_10hv
+    delr_cfr45_10hv                = (nom_delr_cfr45_10hv*(1+nsig_delr_cfr45_10hv*sig_delr_cfr45_10hv+nsmm_delr_cfr45_10hv*smm_delr_cfr45_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(-0.0153274))
+    wf                             = (0.21)
+    fd                             = (0.27)
+    lfext                          = (0.33)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (0.991811*(cm1m1+cm2m2+cm3m3+cm4m4)+2.93878*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    rtemp                          = ((temp+273.15)/(27+273.15))
+    ctotal                         = (cfr*(rtemp**(-0.0017632))*delr_cfr45_10hv)
+    lf                             = (l+(-1.80771))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.944e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.760446)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.760446)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr45_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr45_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr45_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr45_10hv_dfrt
ends

subckt cfr45_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr45_m1m2m3_10hv    = tmp_nsmm_delr_cfr45_m1m2m3_10hv
+    delr_cfr45_m1m2m3_10hv         = (nom_delr_cfr45_m1m2m3_10hv*(1+nsig_delr_cfr45_m1m2m3_10hv*sig_delr_cfr45_m1m2m3_10hv+nsmm_delr_cfr45_m1m2m3_10hv*smm_delr_cfr45_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(9.4142001687e-3))
+    wf                             = (0.21)
+    fd                             = (0.27)
+    lfext                          = (0.33)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.521029268026436*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.521029268026436*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.1590056022086*(cm1m1+cm2m2+cm3m3)+8.18731140121642*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(7.23948746567116e-6+deltat*(0)))*delr_cfr45_m1m2m3_10hv)
+    lf                             = (l+(-1.80771))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(1.944e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.760446)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.974202)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.760446)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr45_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr45_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr45_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr45_m1m2m3_10hv_dfrt
ends

subckt cfr90_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr90_10hv           = tmp_nsmm_delr_cfr90_10hv
+    delr_cfr90_10hv                = (nom_delr_cfr90_10hv*(1+nsig_delr_cfr90_10hv*sig_delr_cfr90_10hv+nsmm_delr_cfr90_10hv*smm_delr_cfr90_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(-0.00144186))
+    wf                             = (0.21)
+    fd                             = (0.45)
+    lfext                          = (0.55)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((1.38*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((1.38*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cm3m4                          = (((1.38*eox)/thick_m4_m3)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.01976*(cm1m1+cm2m2+cm3m3+cm4m4)+2.51342*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(-2.88434e-05+deltat*(4.29049e-08)))*delr_cfr90_10hv)
+    lf                             = (l+(-2.13892))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(2.712e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.850281)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*0.850281)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr90_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr90_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr90_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr90_10hv_dfrt
ends

subckt cfr90_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    nsmm_delr_cfr90_m1m2m3_10hv    = tmp_nsmm_delr_cfr90_m1m2m3_10hv
+    delr_cfr90_m1m2m3_10hv         = (nom_delr_cfr90_m1m2m3_10hv*(1+nsig_delr_cfr90_m1m2m3_10hv*sig_delr_cfr90_m1m2m3_10hv+nsmm_delr_cfr90_m1m2m3_10hv*smm_delr_cfr90_m1m2m3_10hv(l,nf)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (2500*1e-4)
+    thick_m2                       = (2500*1e-4)
+    thick_m3                       = (3500*1e-4)
+    thick_m4                       = (3500*1e-4)
+    thick_m2_m1                    = (5000*1e-4)
+    thick_m3_m2                    = (5000*1e-4)
+    thick_m4_m3                    = (5000*1e-4)
+    lf_m                           = (l+(0.115081044654))
+    wf                             = (0.21)
+    fd                             = (0.45)
+    lfext                          = (0.55)
+    area_fingers                   = (nf*lf_m*wf)
+    perim_snake                    = ((nf-1)*(lf_m+lfext+fd)+nf*wf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm1m2                          = (((0.598311365148279*eox)/thick_m2_m1)*(sDOTmult*sDOTmult*area_fingers))
+    cm2m3                          = (((0.598311365148279*eox)/thick_m3_m2)*(sDOTmult*sDOTmult*area_fingers))
+    cfr                            = (1.02729591969074*(cm1m1+cm2m2+cm3m3)+6.40002059467394*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(-1.88470114859037e-5+deltat*(4.21448297209379e-8)))*delr_cfr90_m1m2m3_10hv)
+    lf                             = (l+(-2.13892))
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m1_fld           = (lroot*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_b_m3_fld           = (lroot*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in                     = (0.5*(2.712e-17))
+    ratio_cfr_inner                = (cfr_fld_in/nom_cfr_m1_fld)
+    cfr_m1_fld_outer               = (2.57696418289585e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer/nom_cfr_m1_fld)
+    cfr_m2_fld_outer               = (1.176e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer/nom_cfr_m2_fld)
+    cfr_m3_fld_outer               = (1.026e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer/nom_cfr_m3_fld)
+    cfr_m4_fld_outer               = (1.753e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer/nom_cfr_m4_fld)
+    cbot_perim_in_t                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+area_t_m2_fld*cpp_m2_fld))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.850281)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld)*0.965364)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+area_b_m2_fld*cpp_m2_fld))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*0.850281)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr90_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr90_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr90_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr90_m1m2m3_10hv_dfrt
ends

subckt cfr120_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    finger_spacing                 = 0.7
+    nsmm_delr_cfr120_10hv          = tmp_nsmm_delr_cfr120_10hv
+    fac_nom_delr_cfr120_10hv       = ((1.017619669)*(finger_spacing==0.7)+(1.0037875)*(finger_spacing==1.0)+(0.940463701)*(finger_spacing==1.3)+(0.911066818)*(finger_spacing==1.6))
+    fac_sig_delr_cfr120_10hv       = ((1)*(finger_spacing==0.7)+(0.730388)*(finger_spacing==1.0)+(0.800096)*(finger_spacing==1.3)+(0.938526)*(finger_spacing==1.6))
+    delr_cfr120_10hv               = (fac_nom_delr_cfr120_10hv*nom_delr_cfr120_10hv*(1+nsig_delr_cfr120_10hv*fac_sig_delr_cfr120_10hv*sig_delr_cfr120_10hv+nsmm_delr_cfr120_10hv*smm_delr_cfr120_10hv(l,nf,finger_spacing)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (3000*1e-4)
+    thick_m2                       = (2700*1e-4)
+    thick_m3                       = (3800*1e-4)
+    thick_m4                       = (3800*1e-4)
+    fd                             = (finger_spacing)
+    dnf                            = ((0.1748)*(fd==0.7)+(0.2248)*(fd==1.0)+(0.29)*(fd==1.3)+(0.4337)*(fd==1.6))
+    dlf                            = ((1.059)*(fd==0.7)+(1.654)*(fd==1.0)+(2.369)*(fd==1.3)+(3.740)*(fd==1.6))
+    wf                             = (0.21)
+    lf_m                           = (l+dlf)
+    lfext                          = (finger_spacing+0.2)
+    perim_snake                    = (nf-1)*(lf_m)+dnf*((lf_m)-dlf*nf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cm4m4                          = (((eox*thick_m4)/fd)*(sDOTmult*perim_snake))
+    cfr_m2_m1_tcad                 = (6.460e-18*(fd==0.7)+5.557e-18*(fd==1.0)+4.489e-18*(fd==1.3)+3.525e-18*(fd==1.6))
+    cfr_m3_m2_tcad                 = (6.517e-18*(fd==0.7)+5.699e-18*(fd==1.0)+4.749e-18*(fd==1.3)+3.902e-18*(fd==1.6))
+    cfr_m4_m3_tcad                 = (7.588e-18*(fd==0.7)+7.236e-18*(fd==1.0)+6.687e-18*(fd==1.3)+6.113e-18*(fd==1.6))
+    cm1m2_t                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_t                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm3m4_t                        = (cfr_m4_m3_tcad*(sDOTmult*perim_snake))
+    cm1m2_b                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_b                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm3m4_b                        = (cfr_m4_m3_tcad*(sDOTmult*perim_snake))
+    cm1m2                          = (cm1m2_t+cm1m2_b)
+    cm2m3                          = (cm2m3_t+cm2m3_b)
+    cm3m4                          = (cm3m4_t+cm3m4_b)
+    cc1                            = (1.013791842*(1.234902143*(fd==0.7)+1.155000592*(fd==1.0)+1.125716531*(fd==1.3)+1.115667867*(fd==1.6)))
+    cc2                            = (1.013791842*(1.521842268*(fd==0.7)+1.423374905*(fd==1.0)+1.387286442*(fd==1.3)+1.374902884*(fd==1.6)))
+    tc1                            = ((-9.5884e-06)*(fd==0.7)+(-1.2019e-05)*(fd==1.0)+(-1.4466e-05)*(fd==1.3)+(-1.6249e-05)*(fd==1.6))
+    tc2                            = ((7.3828e-09)*(fd==0.7)+(0)*(fd==1.0)+(0)*(fd==1.3)+(0)*(fd==1.6))
+    cfr                            = (cc1*(cm1m1+cm2m2+cm3m3+cm4m4)+cc2*(cm1m2+cm2m3+cm3m4))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(tc1+deltat*(tc2)))*delr_cfr120_10hv)
+    dlfb                           = (-1.240777636)
+    fac_ctw_pin                    = (1.029377173*(fd==0.7)+1.087783894*(fd==1.0)+1.139137904*(fd==1.3)+1.206401912*(fd==1.6))
+    fac_ctw_pout                   = (0.707618814*(fd==0.7)+0.961358325*(fd==1.0)+0.8962057*(fd==1.3)+0.711779027*(fd==1.6))
+    fac_cbw_pin                    = (0.991608703*(fd==0.7)+1.067918388*(fd==1.0)+1.103755153*(fd==1.3)+1.195179402*(fd==1.6))
+    fac_cbw_pout                   = (0.739684191*(fd==0.7)+0.85258914*(fd==1.0)+0.855185467*(fd==1.3)+0.719906198*(fd==1.6))
+    lf                             = (l+dlfb)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = (lroot*2+wroot)
+    perim_outer_b_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = (lroot*2+wroot)
+    perim_outer_b_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m4_fld           = (lroot*2+wroot)
+    perim_outer_b_m4_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in_tcad                = (2.080e-17*(fd==0.7)+2.389e-17*(fd==1.0)+2.570e-17*(fd==1.3)+2.675e-17*(fd==1.6))
+    ratio_cfr_inner                = (cfr_fld_in_tcad/nom_cfr_m1_fld)
+    cfr120_inner                   = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld))
+    cfr_m1_fld_outer_tcad          = (2.842e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer_tcad/nom_cfr_m1_fld)
+    cfr_m2_fld_outer_tcad          = (1.107e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer_tcad/nom_cfr_m2_fld)
+    cfr_m3_fld_outer_tcad          = (9.863e-18)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer_tcad/nom_cfr_m3_fld)
+    cfr_m4_fld_outer_tcad          = (1.518e-17)
+    ratio_cfr_m4_fld_outer         = (cfr_m4_fld_outer_tcad/nom_cfr_m4_fld)
+    cbot_perim_in_t                = (cfr120_inner*fac_ctw_pin)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_t_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*fac_ctw_pout)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = (cfr120_inner*fac_cbw_pin)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer+perim_outer_b_m4_fld*cfr_m4_fld*ratio_cfr_m4_fld_outer)*fac_cbw_pout)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr120_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr120_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr120_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr120_10hv_dfrt
ends

subckt cfr120_m1m2m3_10hv (t b well)

parameters
+    l                              = 3
+    nf                             = 7
+    np                             = 1
+    soa                            = 1
+    finger_spacing                 = 0.7
+    nsmm_delr_cfr120_m1m2m3_10hv   = tmp_nsmm_delr_cfr120_m1m2m3_10hv
+    fac_nom_delr_cfr120_m1m2m3_10hv = ((1.007139019)*(finger_spacing==0.7)+(1.005809773)*(finger_spacing==1.0)+(0.974195475)*(finger_spacing==1.3)+(0.943091443)*(finger_spacing==1.6))
+    fac_sig_delr_cfr120_m1m2m3_10hv = ((1)*(finger_spacing==0.7)+(1.055939)*(finger_spacing==1.0)+(0.876056)*(finger_spacing==1.3)+(1.189821)*(finger_spacing==1.6))
+    delr_cfr120_m1m2m3_10hv        = (fac_nom_delr_cfr120_m1m2m3_10hv*nom_delr_cfr120_m1m2m3_10hv*(1+nsig_delr_cfr120_m1m2m3_10hv*fac_sig_delr_cfr120_m1m2m3_10hv*sig_delr_cfr120_m1m2m3_10hv+nsmm_delr_cfr120_m1m2m3_10hv*smm_delr_cfr120_m1m2m3_10hv(l,nf,finger_spacing)/sqrt(np)))
+    eox                            = (3.9*8.85e-12*1e-6)
+    thick_m1                       = (3000*1e-4)
+    thick_m2                       = (2700*1e-4)
+    thick_m3                       = (3800*1e-4)
+    fd                             = (finger_spacing)
+    dnf                            = ((0.1924)*(fd==0.7)+(0.2813)*(fd==1.0)+(0.3222)*(fd==1.3)+(0.369)*(fd==1.6))
+    dlf                            = ((1.147)*(fd==0.7)+(1.877)*(fd==1.0)+(2.614)*(fd==1.3)+(3.466)*(fd==1.6))
+    wf                             = (0.21)
+    lf_m                           = (l+dlf)
+    lfext                          = (finger_spacing+0.2)
+    perim_snake                    = (nf-1)*(l+dlf)+dnf*((l+dlf)-dlf*nf)
+    cm1m1                          = (((eox*thick_m1)/fd)*(sDOTmult*perim_snake))
+    cm2m2                          = (((eox*thick_m2)/fd)*(sDOTmult*perim_snake))
+    cm3m3                          = (((eox*thick_m3)/fd)*(sDOTmult*perim_snake))
+    cfr_m2_m1_tcad                 = (6.460e-18*(fd==0.7)+5.561e-18*(fd==1.0)+4.506e-18*(fd==1.3)+3.562e-18*(fd==1.6))
+    cfr_m3_m2_tcad                 = (6.804e-18*(fd==0.7)+6.398e-18*(fd==1.0)+5.837e-18*(fd==1.3)+5.272e-18*(fd==1.6))
+    cm1m2_t                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_t                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm1m2_b                        = (cfr_m2_m1_tcad*(sDOTmult*perim_snake))
+    cm2m3_b                        = (cfr_m3_m2_tcad*(sDOTmult*perim_snake))
+    cm1m2                          = (cm1m2_t+cm1m2_b)
+    cm2m3                          = (cm2m3_t+cm2m3_b)
+    cc1                            = (0.981140899*(0.812897617*(fd==0.7)+0.716044443*(fd==1.0)+0.678287324*(fd==1.3)+0.667253559*(fd==1.6)))
+    cc2                            = (0.981140899*(2.532163025*(fd==0.7)+2.230466942*(fd==1.0)+2.112854125*(fd==1.3)+2.078484125*(fd==1.6)))
+    tc1                            = ((-1.0791e-06)*(fd==0.7)+(-5.0854e-06)*(fd==1.0)+(-8.5839e-06)*(fd==1.3)+(-1.1953e-05)*(fd==1.6))
+    tc2                            = ((7.0437e-09)*(fd==0.7)+(0)*(fd==1.0)+(0)*(fd==1.3)+(0)*(fd==1.6))
+    cfr                            = (cc1*(cm1m1+cm2m2+cm3m3)+cc2*(cm1m2+cm2m3))
+    deltat                         = (temp-27)
+    ctotal                         = (cfr*(1.0+deltat*(tc1+deltat*(tc2)))*delr_cfr120_m1m2m3_10hv)
+    dlfb                           = (-1.237998007)
+    fac_ctw_pin                    = (1.030935115*(fd==0.7)+1.088972595*(fd==1.0)+1.144223777*(fd==1.3)+1.211719164*(fd==1.6))
+    fac_ctw_pout                   = (0.775100125*(fd==0.7)+1.040963952*(fd==1.0)+0.971500726*(fd==1.3)+0.766728777*(fd==1.6))
+    fac_cbw_pin                    = (0.992118953*(fd==0.7)+1.064721597*(fd==1.0)+1.106222307*(fd==1.3)+1.197159448*(fd==1.6))
+    fac_cbw_pout                   = (0.799803446*(fd==0.7)+0.914976005*(fd==1.0)+0.921839972*(fd==1.3)+0.778977738*(fd==1.6))
+    lf                             = (l+dlfb)
+    lroot                          = (0.3)
+    wroot                          = ((nf-1)*fd+nf*wf)
+    perim_inner                    = ((nf-1)*(lf+lfext+fd)+nf*wf)
+    area_t_m1_fld                  = (((lf+lfext)*wf*(nf-1)/2)+(lroot*wroot))
+    area_b_m1_fld                  = (((lf+lfext)*wf*(nf+1)/2)+(lroot*wroot))
+    perim_outer_t_m1_fld           = (lroot*2+wroot)
+    perim_outer_b_m1_fld           = ((lf+lfext+lroot)*2+wroot)
+    area_t_m2_fld                  = (lfext*wf*(nf-1)/2)
+    area_b_m2_fld                  = (lfext*wf*(nf+1)/2)
+    perim_outer_t_m2_fld           = (lroot*2+wroot)
+    perim_outer_b_m2_fld           = ((lf+lfext+lroot)*2+wroot)
+    perim_outer_t_m3_fld           = (lroot*2+wroot)
+    perim_outer_b_m3_fld           = ((lf+lfext+lroot)*2+wroot)
+    cfr_fld_in_tcad                = (2.080e-17*(fd==0.7)+2.389e-17*(fd==1.0)+2.570e-17*(fd==1.3)+2.675e-17*(fd==1.6))
+    ratio_cfr_inner                = (cfr_fld_in_tcad/nom_cfr_m1_fld)
+    cfr120_inner                   = ((sDOTmult*perim_inner*ratio_cfr_inner*cfr_m1_fld))
+    cfr_m1_fld_outer_tcad          = (2.90e-17)
+    ratio_cfr_m1_fld_outer         = (cfr_m1_fld_outer_tcad/nom_cfr_m1_fld)
+    cfr_m2_fld_outer_tcad          = (1.238e-17)
+    ratio_cfr_m2_fld_outer         = (cfr_m2_fld_outer_tcad/nom_cfr_m2_fld)
+    cfr_m3_fld_outer_tcad          = (1.809e-17)
+    ratio_cfr_m3_fld_outer         = (cfr_m3_fld_outer_tcad/nom_cfr_m3_fld)
+    cbot_perim_in_t                = (cfr120_inner*fac_ctw_pin)
+    cbot_area_t                    = (sDOTmult*sDOTmult*(area_t_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_t               = (sDOTmult*(perim_outer_t_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_t_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_t_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*fac_ctw_pout)
+    cp_t                           = (cbot_area_t+cbot_perim_out_t+cbot_perim_in_t)
+    cbot_perim_in_b                = (cfr120_inner*fac_cbw_pin)
+    cbot_area_b                    = (sDOTmult*sDOTmult*(area_b_m1_fld*cpp_m1_fld+0.0))
+    cbot_perim_out_b               = (sDOTmult*(perim_outer_b_m1_fld*cfr_m1_fld*ratio_cfr_m1_fld_outer+perim_outer_b_m2_fld*cfr_m2_fld*ratio_cfr_m2_fld_outer+perim_outer_b_m3_fld*cfr_m3_fld*ratio_cfr_m3_fld_outer)*fac_cbw_pout)
+    cp_b                           = (cbot_area_b+cbot_perim_out_b+cbot_perim_in_b)

ccfr120_m1m2m3_10hv_tb (t b) capacitor c=ctotal m=(np)
ccfr120_m1m2m3_10hv_tfld (t well) capacitor c=(cp_t) m=(np)
ccfr120_m1m2m3_10hv_bfld (b well) capacitor c=(cp_b) m=(np)

include "./smos10hv_ade_dfrt.scs" section=cfr120_m1m2m3_10hv_dfrt
ends

//***********************************************************
endsection capacitor_simple
//***********************************************************

//***********************************************************
section bjt
//***********************************************************

subckt npn_10hv (c b e sub)

parameters
+    le                             = 3.0
+    we                             = 3.0
+    nerows                         = 1
+    necolumns                      = 1
+    np                             = 1
+    soa                            = 1
+    drift                          = 0
+    nsmm_dela_dle_npn_10hv_vbic    = tmp_nsmm_dela_dle_npn_10hv_vbic
+    nsmm_delr_psbe_npn_10hv_vbic   = tmp_nsmm_delr_psbe_npn_10hv_vbic
+    nsmm_delr_psb_npn_10hv_vbic    = tmp_nsmm_delr_psb_npn_10hv_vbic
+    nsmm_delr_jbei_npn_10hv_vbic   = tmp_nsmm_delr_jbei_npn_10hv_vbic
+    nsmm_delr_jben_npn_10hv_vbic   = tmp_nsmm_delr_jben_npn_10hv_vbic
+    delr_psbe_npn_10hv_vbic        = (nom_delr_psbe_npn_10hv_vbic*(1.0+nsig_delr_psbe_npn_10hv_vbic*sig_delr_psbe_npn_10hv_vbic+nsmm_delr_psbe_npn_10hv_vbic*smm_delr_psbe_npn_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_psb_npn_10hv_vbic         = (nom_delr_psb_npn_10hv_vbic*(1.0+nsig_delr_psb_npn_10hv_vbic*sig_delr_psb_npn_10hv_vbic+nsmm_delr_psb_npn_10hv_vbic*smm_delr_psb_npn_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    dela_dle_npn_10hv_vbic         = (nom_dela_dle_npn_10hv_vbic+nsig_dela_dle_npn_10hv_vbic*sig_dela_dle_npn_10hv_vbic+nsmm_dela_dle_npn_10hv_vbic*smm_dela_dle_npn_10hv_vbic(le,we)/sqrt(nerows*necolumns*np))
+    delr_jbei_npn_10hv_vbic        = (nom_delr_jbei_npn_10hv_vbic*(1.0+nsig_delr_jbei_npn_10hv_vbic*sig_delr_jbei_npn_10hv_vbic+nsmm_delr_jbei_npn_10hv_vbic*smm_delr_jbei_npn_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jben_npn_10hv_vbic        = (nom_delr_jben_npn_10hv_vbic*exp(nsig_delr_jben_npn_10hv_vbic*sig_delr_jben_npn_10hv_vbic+nsmm_delr_jben_npn_10hv_vbic*smm_delr_jben_npn_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    wc                             = (0.33)
+    nc                             = (3)
+    leb                            = (1.0*sDOTmult)
+    lp                             = (3.6*sDOTmult)
+    dbeh                           = (0.33*sDOTmult)
+    dc                             = (0.2*sDOTmult)
+    tca                            = (1.11*sDOTmult)
+    lee                            = (2.33*sDOTmult)
+    le_f                           = (le*sDOTmult)
+    we_f                           = (we*sDOTmult)
+    wc_f                           = (wc*sDOTmult)
+    aeb1                           = ((le_f+dela_dle_npn_10hv_vbic)*(we_f+dela_dle_npn_10hv_vbic))
+    peb1                           = (2*(le_f+we_f+2*dela_dle_npn_10hv_vbic))
+    aebd                           = (le_f*we_f)
+    pebd                           = (2*(le_f+we_f))
+    deo                            = (leb+dbeh+lp)
+    lb                             = (necolumns*le_f+2*deo+(necolumns-1)*lee)
+    wb                             = (nerows*we_f+2*deo+(nerows-1)*lee)
+    abc                            = (lb*wb)
+    pbc                            = (2*(lb+wb))
+    lcol                           = (lb+2*(wc+dc+tca))
+    wcol                           = (wb+2*(wc+dc+tca))
+    acs                            = (lcol*wcol)
+    pcs                            = (2*(lcol+wcol))
+    arb                            = (10)
+    nb                             = (1)
+    nbrrb                          = (1)
+    rlrb                           = (1.0)
+    grb                            = (1/rlrb+we_f/le_f-rlrb+(le_f/we_f-we_f/le_f+rlrb-1/rlrb)*1/(1+exp(-1*arb*we_f/le_f+arb*rlrb)))
+    g1rb                           = (1+0.5*(grb-1-((grb-1)*(grb-1)+0.1/arb)**0.5))

model npn vbic type=npn
+ vers     = (1.20)
+ imelt    = (1e6)
+ tnom     = (27)
+ is       = ((necolumns*nerows*(1.224563e-18*aeb1+5.853293e-19*peb1))*delr_psbe_npn_10hv_vbic)
+ nf       = (1.002356)
+ nr       = (1.001631)
+ vef      = (1.05*(((1.224563e-18*aeb1+5.853293e-19*peb1)/((1.224563e-18*aeb1/55.92251)+(5.853293e-19*peb1/94.48287)))/(delr_psbe_npn_10hv_vbic*(1)))*(1-(0.05/120)*(temp-27)))
+ ver      = (((1.224563e-18*aeb1+5.853293e-19*peb1)/((1.224563e-18*aeb1/11.57671)+(5.853293e-19*peb1/4.084985)))/sqrt(delr_psbe_npn_10hv_vbic))
+ ikf      = (necolumns*nerows*(9.313976e-06*aeb1+1.779971e-05*peb1)/delr_psbe_npn_10hv_vbic)
+ ikr      = ((1.820567e-06*abc+1.075928e-11*pbc)/delr_psbe_npn_10hv_vbic)
+ wbe      = (1.0)
+ ibei     = (necolumns*nerows*(3.320281e-20*aeb1+1.361636e-35*peb1)*delr_jbei_npn_10hv_vbic)
+ nei      = (1.014013)
+ iben     = (necolumns*nerows*(4.686466e-35*aeb1+1.485403e-17*peb1)*delr_jben_npn_10hv_vbic)
+ nen      = (1.46541)
+ ibci     = (9.976141e-24*abc+1.440401e-22*pbc)
+ nci      = (0.8516461)
+ ibcn     = (6.765203e-19*abc+1.724547e-18*pbc)
+ ncn      = (1.254374)
+ avc1     = ((0.03441786/aeb1)+0.01145267)
+ avc2     = (nerows*necolumns*4.748843/(abc-nerows*necolumns*aeb1)+32.1317)
+ re       = (1/(necolumns*nerows)*(33.14786/(aeb1)**0.4042376)*delr_psbe_npn_10hv_vbic)
+ rbi      = ((1/(necolumns*nerows))*((6*nbrrb-3+(20-(6*nbrrb-3))*g1rb)**(-1))*6554.705*delr_psbe_npn_10hv_vbic*grb)
+ rbx      = (1/(nerows*necolumns*nb*(0.005629667*we_f+5e-09/le_f))*delr_psb_npn_10hv_vbic)
+ rcx      = (0.05*((2651.051/(necolumns*nerows*aeb1))+1.437197e-09*lcol/(wcol)+1117.215/(wcol*nc*wc_f)))
+ rci      = (0.01)
+ vo       = (0)
+ gamm     = (0)
+ hrcf     = (0)
+ aje      = (-0.5)
+ cbeo     = (0.0)
+ cje      = (necolumns*nerows*(6.086719e-16*aebd+9.774762e-17*pebd)/sqrt(delr_psbe_npn_10hv_vbic))
+ pe       = ((0.6700358*6.086719e-16*aebd+0.6962529*9.774762e-17*pebd)/(6.086719e-16*aebd+9.774762e-17*pebd))
+ me       = ((0.3268948*6.086719e-16*aebd+0.1*9.774762e-17*pebd)/(6.086719e-16*aebd+9.774762e-17*pebd))
+ fc       = (0.95)
+ tf       = (1.4e-10/delr_psbe_npn_10hv_vbic*(((temp+273.15)/(27+273.15))**0.4))
+ qtf      = (0)
+ xtf      = (1.178056)
+ vtf      = (2.298096)
+ itf      = (1e-7*nerows*necolumns*aeb1)
+ td       = (0)
+ tr       = ((1.17*11.295e-9)*(165.4/abc))
+ ajc      = (-0.5)
+ cbco     = (0)
+ cjc      = ((1.185396e-16*abc+2.733775e-17*pbc)*(1))
+ pc       = (1.5*((0.4208787*1.185396e-16*abc+0.1*2.733775e-17*pbc)/(1.185396e-16*abc+2.733775e-17*pbc)))
+ mc       = ((0.3147849*1.185396e-16*abc+0.95*2.733775e-17*pbc)/(1.185396e-16*abc+2.733775e-17*pbc))
+ cjep     = (0)
+ qco      = (0)
+ ajs      = (-0.5)
+ cjcp     = (0)
+ ps       = (0.3)
+ ms       = (0.7)
+ wsp      = (0)
+ isp      = (0)
+ nfp      = (1)
+ ikp      = (0)
+ ibeip    = (0)
+ ibenp    = (0)
+ ibcip    = (0)
+ ncip     = (1)
+ ibcnp    = (0)
+ ncnp     = (2)
+ rbp      = (1e-02)
+ rs       = (1)
+ ea       = (1.151)
+ eap      = (1.184)
+ eaie     = (1.128)
+ eaic     = (1.12)
+ eais     = (1.281)
+ eane     = (1.170)
+ eanc     = (1.193)
+ eans     = (1.12)
+ xis      = (3.982)
+ xii      = (3.399)
+ xin      = (0.1)
+ tnf      = (-3.315e-5)
+ tavc     = (0.0)
+ xre      = (0.0)
+ xrs      = (0.000)
+ xvo      = (0.000)
+ isrr     = (1)
+ dear     = (-0.02)
+ afn      = (1.35)
+ bfn      = (0.884846)
+ kfn      = ((5e-14)/((necolumns*nerows)**0.5))*(2*aeb1+8.5*peb1)/(peb1*aeb1)
+ xrb      = (1.0)
+ xrbx     = (1.0)
+ xrc      = (0.000)
+ xrcx     = (0.000)
+ xrbp     = (0.000)

qnpn (c b e sub) npn m=(np)
xcbox_sub_10hv (c sub) cdgoptub_box_sub_10hv area=(acs) perim=(pcs) m=(np) soa=1

include "./smos10hv_ade_dfrt.scs" section=npn_10hv_dfrt
ends

subckt npn_b_10hv (c b e sub)

parameters
+    le                             = 3.0
+    we                             = 3.0
+    nerows                         = 1
+    necolumns                      = 1
+    np                             = 1
+    soa                            = 1
+    drift                          = 0
+    fault_npn_b_beta_outlier       = (fault_npn_b_beta_outlier_global)
+    delr_jbe_outlier               = ((fault_npn_b_beta_outlier==0)*1.0+(fault_npn_b_beta_outlier==1)*1.25)
+    nsmm_dela_dle_npn_b_10hv_vbic  = tmp_nsmm_dela_dle_npn_b_10hv_vbic
+    nsmm_delr_psbe_npn_b_10hv_vbic = tmp_nsmm_delr_psbe_npn_b_10hv_vbic
+    nsmm_delr_psb_npn_b_10hv_vbic  = tmp_nsmm_delr_psb_npn_b_10hv_vbic
+    nsmm_delr_jbei_npn_b_10hv_vbic = tmp_nsmm_delr_jbei_npn_b_10hv_vbic
+    nsmm_delr_jben_npn_b_10hv_vbic = tmp_nsmm_delr_jben_npn_b_10hv_vbic
+    delr_psbe_npn_b_10hv_vbic      = (nom_delr_psbe_npn_b_10hv_vbic*(1.0+nsig_delr_psbe_npn_b_10hv_vbic*sig_delr_psbe_npn_b_10hv_vbic+nsmm_delr_psbe_npn_b_10hv_vbic*smm_delr_psbe_npn_b_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_psb_npn_b_10hv_vbic       = (nom_delr_psb_npn_b_10hv_vbic*(1.0+nsig_delr_psb_npn_b_10hv_vbic*sig_delr_psb_npn_b_10hv_vbic+nsmm_delr_psb_npn_b_10hv_vbic*smm_delr_psb_npn_b_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    dela_dle_npn_b_10hv_vbic       = (nom_dela_dle_npn_b_10hv_vbic+nsig_dela_dle_npn_b_10hv_vbic*sig_dela_dle_npn_b_10hv_vbic+nsmm_dela_dle_npn_b_10hv_vbic*smm_dela_dle_npn_b_10hv_vbic(le,we)/sqrt(nerows*necolumns*np))
+    delr_jbei_npn_b_10hv_vbic      = (nom_delr_jbei_npn_b_10hv_vbic*(1.0+nsig_delr_jbei_npn_b_10hv_vbic*sig_delr_jbei_npn_b_10hv_vbic+nsmm_delr_jbei_npn_b_10hv_vbic*smm_delr_jbei_npn_b_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jben_npn_b_10hv_vbic      = (nom_delr_jben_npn_b_10hv_vbic*exp(nsig_delr_jben_npn_b_10hv_vbic*sig_delr_jben_npn_b_10hv_vbic+nsmm_delr_jben_npn_b_10hv_vbic*smm_delr_jben_npn_b_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    wc                             = (0.33)
+    nc                             = (3)
+    leb                            = (1.0*sDOTmult)
+    lp                             = (2.7*sDOTmult)
+    dbeh                           = (0.33*sDOTmult)
+    dc                             = (1.1*sDOTmult)
+    tca                            = (1.11*sDOTmult)
+    lee                            = (2.33*sDOTmult)
+    le_f                           = (le*sDOTmult)
+    we_f                           = (we*sDOTmult)
+    wc_f                           = (wc*sDOTmult)
+    aeb1                           = ((le_f+dela_dle_npn_b_10hv_vbic)*(we_f+dela_dle_npn_b_10hv_vbic))
+    peb1                           = (2*(le_f+we_f+2*dela_dle_npn_b_10hv_vbic))
+    aebd                           = (le_f*we_f)
+    pebd                           = (2*(le_f+we_f))
+    deo                            = (leb+dbeh+lp)
+    lb                             = (necolumns*le_f+2*deo+(necolumns-1)*lee)
+    wb                             = (nerows*we_f+2*deo+(nerows-1)*lee)
+    abc                            = (lb*wb)
+    pbc                            = (2*(lb+wb))
+    lcol                           = (lb+2*(wc+dc+tca))
+    wcol                           = (wb+2*(wc+dc+tca))
+    acs                            = (lcol*wcol)
+    pcs                            = (2*(lcol+wcol))
+    arb                            = (10)
+    nb                             = (1)
+    nbrrb                          = (1)
+    rlrb                           = (1.0)
+    grb                            = (1/rlrb+we_f/le_f-rlrb+(le_f/we_f-we_f/le_f+rlrb-1/rlrb)*1/(1+exp(-1*arb*we_f/le_f+arb*rlrb)))
+    g1rb                           = (1+0.5*(grb-1-((grb-1)*(grb-1)+0.1/arb)**0.5))
+    min_lwcol                      = (min((lcol)/(wcol),(wcol)/(lcol)))

model npn_b vbic type=npn
+ vers     = (1.20)
+ imelt    = (1e6)
+ tnom     = (27)
+ is       = ((necolumns*nerows*(1.224563e-18*aeb1+5.853293e-19*peb1))*delr_psbe_npn_b_10hv_vbic)
+ nf       = (1.002356)
+ nr       = (1.001631)
+ vef      = (1.15*1.05*(((1.224563e-18*aeb1+5.853293e-19*peb1)/((1.224563e-18*aeb1/55.92251)+(5.853293e-19*peb1/94.48287)))/(delr_psbe_npn_b_10hv_vbic*(1)))*(1-(0.05/120)*(temp-27)))
+ ver      = (1.045*((1.224563e-18*aeb1+5.853293e-19*peb1)/((1.224563e-18*aeb1/11.57671)+(5.853293e-19*peb1/4.084985)))/sqrt(delr_psbe_npn_b_10hv_vbic))
+ ikf      = (necolumns*nerows*(9.313976e-06*aeb1+1.779971e-05*peb1)/delr_psbe_npn_b_10hv_vbic)
+ ikr      = ((1.820567e-06*abc+1.075928e-11*pbc)/delr_psbe_npn_b_10hv_vbic)
+ wbe      = (1.0)
+ ibei     = (0.85*necolumns*nerows*(3.320281e-20*aeb1+1.361636e-35*peb1)*delr_jbe_outlier*delr_jbei_npn_b_10hv_vbic)
+ nei      = (1.014013)
+ iben     = (0.7*necolumns*nerows*(4.686466e-35*aeb1+1.485403e-17*peb1)*delr_jbe_outlier*delr_jben_npn_b_10hv_vbic)
+ nen      = (1.46541)
+ ibci     = ((0.1*9.976141e-24*abc+2*1.440401e-22*pbc)*31)
+ nci      = (0.8516461*1.11)
+ ibcn     = ((6.765203e-19*abc+2*1.724547e-18*pbc)*0.6)
+ ncn      = (1.254374)
+ avc1     = ((0.03441786/aeb1)+0.01145267)
+ avc2     = ((nerows*necolumns*4.748843/(abc-nerows*necolumns*aeb1)+32.1317)*1.2)
+ re       = (250/(necolumns*nerows*(aeb1))*delr_psbe_npn_b_10hv_vbic)
+ rbi      = ((1/(necolumns*nerows))*((6*nbrrb-3+(20-(6*nbrrb-3))*g1rb)**(-1))*6554.705*delr_psbe_npn_b_10hv_vbic*grb)
+ rbx      = (1/(nerows*necolumns*nb*(0.005629667*we_f+5e-09/le_f))*delr_psb_npn_b_10hv_vbic)*(0)
+ rcx      = (150*min_lwcol*(1/12-(1/12-1/28.45)*min_lwcol))
+ rci      = (0.01)
+ vo       = (0)
+ gamm     = (0)
+ hrcf     = (0)
+ aje      = (-0.5)
+ cbeo     = (0.0)
+ cje      = (0.99*necolumns*nerows*(6.086719e-16*aebd+9.774762e-17*pebd)/sqrt(delr_psbe_npn_b_10hv_vbic))
+ pe       = (0.95*(0.6700358*6.086719e-16*aebd+0.6962529*9.774762e-17*pebd)/(6.086719e-16*aebd+9.774762e-17*pebd))
+ me       = (0.98*(0.3268948*6.086719e-16*aebd+0.1*9.774762e-17*pebd)/(6.086719e-16*aebd+9.774762e-17*pebd))
+ fc       = (0.95)
+ tf       = (1.4e-10/delr_psbe_npn_b_10hv_vbic*(((temp+273.15)/(27+273.15))**0.4))
+ qtf      = (0)
+ xtf      = (1.178056)
+ vtf      = (2.298096)
+ itf      = (1e-7*nerows*necolumns*aeb1)
+ td       = (0)
+ tr       = (1.17*11.295e-9)*(80/(wcol*lcol))
+ ajc      = (-0.5)
+ cbco     = (0)
+ cjc      = ((1e-16*abc+5.733775e-17*pbc)*(1.36))
+ pc       = (1.4*((0.4*1.185396e-16*abc+0.1*2.733775e-17*pbc)/(1.185396e-16*abc+2.733775e-17*pbc)))
+ mc       = ((0.305*1.185396e-16*abc+0.25*2.733775e-17*pbc)/(1.185396e-16*abc+2.733775e-17*pbc))*(1.1)
+ cjep     = (0)
+ qco      = (0)
+ ajs      = (-0.5)
+ cjcp     = (0)
+ ps       = (0.3)
+ ms       = (0.7)
+ wsp      = (0)
+ isp      = (0)
+ nfp      = (1)
+ ikp      = (0)
+ ibeip    = (0)
+ ibenp    = (0)
+ ibcip    = (0)
+ ncip     = (1)
+ ibcnp    = (0)
+ ncnp     = (2)
+ rbp      = (1e-02)
+ rs       = (1)
+ ea       = (1.151)
+ eap      = (1.184)
+ eaie     = (1.128)
+ eaic     = (1.12)
+ eais     = (1.281)
+ eane     = (1.170)
+ eanc     = (1.193)
+ eans     = (1.12)
+ xis      = (3.982*0.96)
+ xii      = (3.399*0.96)
+ xin      = (0.1)
+ tnf      = (-3.315e-5)
+ tavc     = (0.0)
+ xre      = (0.0)
+ xrs      = (0.000)
+ xvo      = (0.000)
+ isrr     = (1)
+ dear     = (-0.02)
+ afn      = (1.35)
+ bfn      = (0.884846)
+ kfn      = ((5e-14)/((necolumns*nerows)**0.5))*(2*aeb1+8.5*peb1)/(peb1*aeb1)
+ xrb      = (1.0)
+ xrbx     = (1.0)
+ xrc      = (0.000)
+ xrcx     = (0.000)
+ xrbp     = (0.000)

qnpn_b (c b e sub) npn_b m=(np)
xcbox_sub_10hv (c sub) cdgoptub_box_sub_10hv area=(acs) perim=(pcs) m=(np) soa=1
aprint_function print_function
+ device="npn_b_10hv"
+ modelfunction="fault_model_beta_outlier"
+ enableflag=fault_npn_b_beta_outlier

include "./smos10hv_ade_dfrt.scs" section=npn_b_10hv_dfrt
ends

subckt pnp_10hv (c b e sub)

parameters
+    le                             = 3.0
+    we                             = 3.0
+    necolumns                      = 1
+    nerows                         = 1
+    np                             = 1
+    soa                            = 1
+    drift                          = 0
+    nsmm_dela_dle_pnp_10hv_vbic    = tmp_nsmm_dela_dle_pnp_10hv_vbic
+    nsmm_delr_psbe_pnp_10hv_vbic   = tmp_nsmm_delr_psbe_pnp_10hv_vbic
+    nsmm_delr_psb_pnp_10hv_vbic    = tmp_nsmm_delr_psb_pnp_10hv_vbic
+    nsmm_delr_jbei_pnp_10hv_vbic   = tmp_nsmm_delr_jbei_pnp_10hv_vbic
+    nsmm_delr_jben_pnp_10hv_vbic   = tmp_nsmm_delr_jben_pnp_10hv_vbic
+    dela_dle_pnp_10hv_vbic         = (nom_dela_dle_pnp_10hv_vbic+nsig_dela_dle_pnp_10hv_vbic*sig_dela_dle_pnp_10hv_vbic+nsmm_dela_dle_pnp_10hv_vbic*smm_dela_dle_pnp_10hv_vbic(le,we)/sqrt(nerows*necolumns*np))
+    delr_psbe_pnp_10hv_vbic        = (nom_delr_psbe_pnp_10hv_vbic*(1.0+nsig_delr_psbe_pnp_10hv_vbic*sig_delr_psbe_pnp_10hv_vbic+nsmm_delr_psbe_pnp_10hv_vbic*smm_delr_psbe_pnp_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_psb_pnp_10hv_vbic         = (nom_delr_psb_pnp_10hv_vbic*(1.0+nsig_delr_psb_pnp_10hv_vbic*sig_delr_psb_pnp_10hv_vbic+nsmm_delr_psb_pnp_10hv_vbic*smm_delr_psb_pnp_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jbei_pnp_10hv_vbic        = (nom_delr_jbei_pnp_10hv_vbic*(1.0+nsig_delr_jbei_pnp_10hv_vbic*sig_delr_jbei_pnp_10hv_vbic+nsmm_delr_jbei_pnp_10hv_vbic*smm_delr_jbei_pnp_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jben_pnp_10hv_vbic        = (nom_delr_jben_pnp_10hv_vbic*exp(nsig_delr_jben_pnp_10hv_vbic*sig_delr_jben_pnp_10hv_vbic+nsmm_delr_jben_pnp_10hv_vbic*smm_delr_jben_pnp_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_n_col_pnp_10hv_vbic       = (nom_delr_n_col_pnp_10hv_vbic*(1.0+nsig_delr_n_col_pnp_10hv_vbic*sig_delr_n_col_pnp_10hv_vbic))
+    delr_x_col_pnp_10hv_vbic       = (nom_delr_x_col_pnp_10hv_vbic*(1.0+nsig_delr_x_col_pnp_10hv_vbic*sig_delr_x_col_pnp_10hv_vbic))
+    dela_vth_relimo                = (0)
+    delr_u0_relimo                 = (1)
+    dela_vth_relimo_mod            = (0)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    rvbeibfdegr                    = (0)
+    rvbedamage                     = (0)
+    leb                            = (1.5*sDOTmult)
+    dbeh                           = (0.33*sDOTmult)
+    lp                             = (1.0*sDOTmult)
+    dbca                           = (2.1*sDOTmult)
+    wc                             = (0.5*sDOTmult)
+    dca                            = (2.4*sDOTmult)
+    dcia                           = (0.3*sDOTmult)
+    wi                             = (0.33*sDOTmult)
+    tia                            = (1.11*sDOTmult)
+    lee                            = (3.33*sDOTmult)
+    le_f                           = (le*sDOTmult)
+    we_f                           = (we*sDOTmult)
+    aeb1                           = ((le_f+dela_dle_pnp_10hv_vbic)*(we_f+dela_dle_pnp_10hv_vbic))
+    peb1                           = (2*(le_f+we_f+2*dela_dle_pnp_10hv_vbic))
+    aebd                           = (le_f*we_f)
+    pebd                           = (2*(le_f+we_f))
+    deo                            = (leb+dbeh+lp)
+    lb                             = (necolumns*le_f+2*deo+(necolumns-1)*lee)
+    wb                             = (nerows*we_f+2*deo+(nerows-1)*lee)
+    abc                            = (lb*wb)
+    pbc                            = (2*(lb+wb))
+    lcol                           = (lb+2*(dbca+wc+dca))
+    wcol                           = (wb+2*(dbca+wc+dca))
+    acs                            = (lcol*wcol)
+    pcs                            = (2*(lcol+wcol))
+    lnbl                           = (lcol+2*(dcia+wi+tia))
+    wnbl                           = (wcol+2*(dcia+wi+tia))
+    anbl                           = (lnbl*wnbl)
+    pnbl                           = (2*(lnbl+wnbl))
+    nbrrb                          = (1)
+    arb                            = (10)
+    rlrb                           = (1.0)
+    grb                            = (1/rlrb+we_f/le_f-rlrb+(le_f/we_f-we_f/le_f+rlrb-1/rlrb)*(1/(1+exp(-1*arb*we_f/le_f+arb*rlrb))))
+    g1rb                           = (1+0.5*(grb-1-((grb-1)*(grb-1)+0.1/arb)**0.5))
+    rclatinv                       = ((2*necolumns*nerows*(wcol/(necolumns*nerows+1)))/(0.5*le_f+deo+dbca)+(2*(necolumns*nerows-1)*(wcol/(necolumns*nerows+1)))/(0.5*lee+0.5*le_f+deo+dbca)+0.5*lcol/(0.5*we_f+deo+dbca))
+    rclat                          = (rclatinv**(-1))
+    pta_pepi_nbl                   = (0.00239189955977876)
+    aphi_tnom                      = (0.56868367614107262)
+    aphi_calc                      = (aphi_tnom-pta_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (0.1+0.5*((aphi_calc-0.1)+sqrt((aphi_calc-0.1)**2)))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.94999999999999996)
+    ptp_pepi_nhv                   = (0.00284697165469726)
+    pphi_tnom                      = (0.43077617572594573)
+    pphi_calc                      = (pphi_tnom-ptp_pepi_nhv*(temp-tnom))
+    pphi_temp                      = (0.1+0.5*((pphi_calc-0.1)+sqrt((pphi_calc-0.1)**2)))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (0.10000000000000001)

model pnp vbic type=pnp
+ vers     = (1.20)
+ imelt    = (1e6)
+ tnom     = (27)
+ is       = ((necolumns*nerows*(2.561195e-18*aeb1+2.656899e-19*peb1+8.422601e-19))*delr_psbe_pnp_10hv_vbic)
+ nf       = (1.003122)
+ nr       = ((1.004824))
+ vef      = ((((2.561195e-18*aeb1+2.656899e-19*peb1+8.422601e-19)/((2.561195e-18*aeb1/173.0666)+(2.656899e-19*peb1/300536.6)+8.422601e-19/708388.3))/(delr_psbe_pnp_10hv_vbic*sqrt(delr_n_col_pnp_10hv_vbic)))*(1-(0.10/120)*(temp-27)))
+ ver      = ((enable_punch_through*0.59)+(((2.561195e-18*aeb1+2.656899e-19*peb1+8.422601e-19)/((2.561195e-18*aeb1/3.08517)+(2.656899e-19*peb1/5.180988)+8.422601e-19/3.17663))/sqrt(delr_psbe_pnp_10hv_vbic)))
+ ikf      = (0.25*((necolumns*nerows*(0*1.507e-6*aeb1+1.6*9.387e-6*peb1+1116.803e-9))/delr_psbe_pnp_10hv_vbic))
+ ikr      = ((1e-12*abc+3.134091e-07*pbc)/delr_psbe_pnp_10hv_vbic)
+ wbe      = (1.0)
+ ibei     = (necolumns*nerows*(4.975524e-20*aeb1+2.071841e-46*peb1)*delr_jbei_pnp_10hv_vbic)
+ nei      = (1.011528)
+ iben     = ((necolumns*nerows*(2.148482e-30*aeb1+2.242981e-17*peb1)*delr_jben_pnp_10hv_vbic)+dela_vth_relimo+rvbeibfdegr)
+ nen      = (1.662544)
+ ibci     = (2.806043e-23*abc+3.655269e-17*pbc)
+ nci      = (1.434201)
+ ibcn     = (8.338778e-23*abc+2.421991e-18*pbc)
+ ncn      = (1.416945)
+ avc1     = ((0.3615772/aeb1)+120.7332)
+ avc2     = (nerows*necolumns*1160.77/(abc-nerows*necolumns*aeb1)+52.622)
+ re       = (4.134*(1/(necolumns*nerows)*(0.0002399765/aeb1+107.7741/peb1)*delr_psbe_pnp_10hv_vbic))
+ rbi      = ((1/(necolumns*nerows))*((6-3+(20-(6-3))*g1rb)**(-1))*11680*delr_psbe_pnp_10hv_vbic*grb)
+ rbx      = (1/(necolumns*nerows*(1.273e-3*we_f+12.06/le_f))*delr_psb_pnp_10hv_vbic)
+ rcx      = (((0.35*delr_x_col_pnp_10hv_vbic)/(pcs*wc)+(0.35*rclat)*(1/delr_n_col_pnp_10hv_vbic)+680.7175*delr_x_col_pnp_10hv_vbic)/(np*aeb1*delr_n_col_pnp_10hv_vbic))
+ rci      = (0.20*(1/(necolumns*nerows)*(10000+0*37000/aeb1+0.5*375100/peb1)))
+ vo       = (100)
+ gamm     = (0.1*((2.744e-9+1.475e-11*aeb1)*(1+0*0.0002381*(temp-tnom))))
+ hrcf     = (1)
+ aje      = (-0.5)
+ cbeo     = (0.0)
+ cje      = (necolumns*nerows*(4.735011e-16*aebd+1.595285e-16*pebd)/sqrt(delr_psbe_pnp_10hv_vbic))
+ pe       = ((0.7978629*4.735011e-16*aebd+0.7552916*1.595285e-16*pebd)/(4.735011e-16*aebd+1.595285e-16*pebd))
+ me       = ((0.5002571*4.735011e-16*aebd+0.1*1.595285e-16*pebd)/(4.735011e-16*aebd+1.595285e-16*pebd))
+ fc       = (0.95)
+ tf       = (1.6e-12*((aeb1+9)/peb1)/delr_psbe_pnp_10hv_vbic*(((temp+273.15)/(27+273.15))**1.5))
+ qtf      = (111.9374)
+ xtf      = (24.81169)
+ vtf      = (7.325271)
+ itf      = (1.8*(necolumns*nerows*(1e-7*aeb1+10e-6*peb1+0.0004111356))*((temp+273.15)/(27+273.15))**-2)
+ td       = (0)
+ tr       = (10*(((3.625282e-12*2.561195e-18*aeb1+3.203965e-22*2.656899e-19*peb1+1.567056e-19*8.422601e-19)/(2.561195e-18*aeb1+2.656899e-19*peb1+8.422601e-19))/delr_psbe_pnp_10hv_vbic))
+ ajc      = (-0.5)
+ cbco     = (0)
+ cjc      = ((4.367103e-17*abc+3.195942e-16*pbc+9.903211e-17)*sqrt(delr_n_col_pnp_10hv_vbic))
+ pc       = ((0.2324931*4.367103e-17*abc+0.525084*3.195942e-16*pbc)/(4.367103e-17*abc+3.195942e-16*pbc))
+ mc       = ((0.95*4.367103e-17*abc+0.5002016*3.195942e-16*pbc)/(4.367103e-17*abc+3.195942e-16*pbc))
+ cjep     = (0)
+ qco      = (0)
+ ajs      = (-0.5)
+ cjcp     = (0)
+ ps       = (0.3)
+ ms       = (0.7)
+ wsp      = (0)
+ isp      = (0)
+ nfp      = (1)
+ ikp      = (0)
+ ibeip    = (0)
+ ibenp    = (0)
+ ibcip    = (0)
+ ncip     = (1)
+ ibcnp    = (0)
+ ncnp     = (2)
+ rbp      = (0)
+ rs       = (1e-2)
+ ea       = (1.17)
+ eap      = (1.194)
+ eaie     = (1.157)
+ eaic     = (1.067)
+ eais     = (1.02)
+ eane     = (1.162)
+ eanc     = (1.05)
+ eans     = (1.12)
+ xis      = (2.982)
+ xii      = (1.919)
+ xin      = (1.78e-05)
+ xikf     = (1.776e-15)
+ tnf      = (3.379e-06)
+ tavc     = (0.0)
+ xre      = (-0.06693)
+ xrs      = (0.000)
+ xvo      = (5.414)
+ afn      = (1.35)
+ bfn      = (0.884)
+ kfn      = 4.0*((5e-14)/((necolumns*nerows)**0.5))*(8.5)/(aeb1)
+ xrb      = (1.2)
+ xrbx     = (1.2)
+ xrc      = (1.743)
+ xrcx     = (1.743)
+ xrbp     = (1.743)

model dpepi_nbl_10hv_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((2.593e-23*acs))*1.0e12)
+ n             = (0.974)
+ ik            = (((6.285e-11*acs))*1.0e12)
+ cj            = ((((9.903211e-17*acs)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (0.1+0.5*((aphi_calc-0.1)+sqrt((aphi_calc-0.1)**2)))
+ mj            = (0.94999999999999996)
+ xti           = (1.112e-05)
+ fc            = (0.9)
+ tt            = (45e-9)
+ eg            = (0.8)
+ tlev          = (2)
+ gap1          = (459.6e-06)
+ gap2          = (601.5)

model dpepi_nhv_10hv_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((6.619e-20*pcs))*1.0e12)
+ n             = (0.985)
+ ik            = (((3.84e-6*pcs))*1.0e12)
+ cj            = ((((2.208024e-16*pcs)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (0.1+0.5*((pphi_calc-0.1)+sqrt((pphi_calc-0.1)**2)))
+ mj            = (0.10000000000000001)
+ xti           = (1e-12)
+ fc            = (0.9)
+ tt            = (45e-9)
+ eg            = (1.169)
+ tlev          = (2)
+ gap1          = (459.6e-06)
+ gap2          = (601.5)

parameters
+    apar=1.0e-16*(2.0*(we+le)*necolumns*nerows*np)
+    vbpar=(6.0-(2.0*(we+le))*6e-3)*(1-1.15e-3*(temp-27))
+    mpar=(3.0)
+    kboq=(8.617087e-5)
+    vtm = (kboq*(temp+273.15))
+    rseries=1.1e6/(2.0*(we+le)*necolumns*nerows*np)
if(enable_punch_through==1) {
bice_punchthru_rev (ci e) bsource i=apar*( exp(((sqrt(v(ci,e)**2+0.1)+v(ci,e))*0.5- (vbpar))/(mpar*vtm))- exp(((sqrt(0.1))*0.5 -(vbpar))/(mpar*vtm)) ) tc1=0 tc2=0
rb_punchthru_rev   (c ci) resistor r=rseries
}

qpnp (c b e sub) pnp m=(np)
ddpepi_nbl_10hv_area (c b) dpepi_nbl_10hv_area m=(np)
ddpepi_nhv_10hv_perim (c b) dpepi_nhv_10hv_perim m=(np)
xcbox_sub_10hv (b sub) cdgoptub_box_sub_10hv area=(anbl) perim=(pnbl) m=(np) soa=1

include "./smos10hv_ade_dfrt.scs" section=pnp_10hv_dfrt
ends

subckt pnp_iso_10hv (c b e iso sub)

parameters
+    le                             = 3.0
+    we                             = 3.0
+    necolumns                      = 1
+    nerows                         = 1
+    np                             = 1
+    soa                            = 1
+    drift                          = 0
+    nsmm_dela_dle_pnp_iso_10hv_vbic = tmp_nsmm_dela_dle_pnp_iso_10hv_vbic
+    nsmm_delr_psbe_pnp_iso_10hv_vbic = tmp_nsmm_delr_psbe_pnp_iso_10hv_vbic
+    nsmm_delr_psb_pnp_iso_10hv_vbic = tmp_nsmm_delr_psb_pnp_iso_10hv_vbic
+    nsmm_delr_jbei_pnp_iso_10hv_vbic = tmp_nsmm_delr_jbei_pnp_iso_10hv_vbic
+    nsmm_delr_jben_pnp_iso_10hv_vbic = tmp_nsmm_delr_jben_pnp_iso_10hv_vbic
+    dela_dle_pnp_iso_10hv_vbic     = (nom_dela_dle_pnp_iso_10hv_vbic+nsig_dela_dle_pnp_iso_10hv_vbic*sig_dela_dle_pnp_iso_10hv_vbic+nsmm_dela_dle_pnp_iso_10hv_vbic*smm_dela_dle_pnp_iso_10hv_vbic(le,we)/sqrt(nerows*necolumns*np))
+    delr_psbe_pnp_iso_10hv_vbic    = (nom_delr_psbe_pnp_iso_10hv_vbic*(1.0+nsig_delr_psbe_pnp_iso_10hv_vbic*sig_delr_psbe_pnp_iso_10hv_vbic+nsmm_delr_psbe_pnp_iso_10hv_vbic*smm_delr_psbe_pnp_iso_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_psb_pnp_iso_10hv_vbic     = (nom_delr_psb_pnp_iso_10hv_vbic*(1.0+nsig_delr_psb_pnp_iso_10hv_vbic*sig_delr_psb_pnp_iso_10hv_vbic+nsmm_delr_psb_pnp_iso_10hv_vbic*smm_delr_psb_pnp_iso_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jbei_pnp_iso_10hv_vbic    = (nom_delr_jbei_pnp_iso_10hv_vbic*(1.0+nsig_delr_jbei_pnp_iso_10hv_vbic*sig_delr_jbei_pnp_iso_10hv_vbic+nsmm_delr_jbei_pnp_iso_10hv_vbic*smm_delr_jbei_pnp_iso_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_jben_pnp_iso_10hv_vbic    = (nom_delr_jben_pnp_iso_10hv_vbic*exp(nsig_delr_jben_pnp_iso_10hv_vbic*sig_delr_jben_pnp_iso_10hv_vbic+nsmm_delr_jben_pnp_iso_10hv_vbic*smm_delr_jben_pnp_iso_10hv_vbic(le,we)/sqrt(nerows*necolumns*np)))
+    delr_n_col_pnp_iso_10hv_vbic   = (nom_delr_n_col_pnp_iso_10hv_vbic*(1.0+nsig_delr_n_col_pnp_iso_10hv_vbic*sig_delr_n_col_pnp_iso_10hv_vbic))
+    delr_x_col_pnp_iso_10hv_vbic   = (nom_delr_x_col_pnp_iso_10hv_vbic*(1.0+nsig_delr_x_col_pnp_iso_10hv_vbic*sig_delr_x_col_pnp_iso_10hv_vbic))
+    dela_vth_relimo                = (0)
+    delr_u0_relimo                 = (1)
+    dela_vth_relimo_mod            = (0)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    rvbeibfdegr                    = (0)
+    rvbedamage                     = (0)
+    leb                            = (1.5*sDOTmult)
+    dbeh                           = (0.33*sDOTmult)
+    lp                             = (1.0*sDOTmult)
+    dbca                           = (2.1*sDOTmult)
+    wc                             = (0.5*sDOTmult)
+    dca                            = (2.4*sDOTmult)
+    dcia                           = (0.3*sDOTmult)
+    wi                             = (0.33*sDOTmult)
+    tia                            = (1.11*sDOTmult)
+    lee                            = (3.33*sDOTmult)
+    le_f                           = (le*sDOTmult)
+    we_f                           = (we*sDOTmult)
+    aeb1                           = ((le_f+dela_dle_pnp_iso_10hv_vbic)*(we_f+dela_dle_pnp_iso_10hv_vbic))
+    peb1                           = (2*(le_f+we_f+2*dela_dle_pnp_iso_10hv_vbic))
+    aebd                           = (le_f*we_f)
+    pebd                           = (2*(le_f+we_f))
+    deo                            = (leb+dbeh+lp)
+    lb                             = (necolumns*le_f+2*deo+(necolumns-1)*lee)
+    wb                             = (nerows*we_f+2*deo+(nerows-1)*lee)
+    abc                            = (lb*wb)
+    pbc                            = (2*(lb+wb))
+    lcol                           = (lb+2*(dbca+wc+dca))
+    wcol                           = (wb+2*(dbca+wc+dca))
+    acs                            = (lcol*wcol)
+    pcs                            = (2*(lcol+wcol))
+    lnbl                           = (lcol+2*(dcia+wi+tia))
+    wnbl                           = (wcol+2*(dcia+wi+tia))
+    anbl                           = (lnbl*wnbl)
+    pnbl                           = (2*(lnbl+wnbl))
+    nbrrb                          = (1)
+    arb                            = (10)
+    rlrb                           = (1.0)
+    grb                            = (1/rlrb+we_f/le_f-rlrb+(le_f/we_f-we_f/le_f+rlrb-1/rlrb)*(1/(1+exp(-1*arb*we_f/le_f+arb*rlrb))))
+    g1rb                           = (1+0.5*(grb-1-((grb-1)*(grb-1)+0.1/arb)**0.5))
+    rclatinv                       = ((2*necolumns*nerows*(wcol/(necolumns*nerows+1)))/(0.5*le_f+deo+dbca)+(2*(necolumns*nerows-1)*(wcol/(necolumns*nerows+1)))/(0.5*lee+0.5*le_f+deo+dbca)+0.5*lcol/(0.5*we_f+deo+dbca))
+    rclat                          = (rclatinv**(-1))
+    pta_pepi_nbl                   = (0.00239189955977876)
+    aphi_tnom                      = (0.56868367614107262)
+    aphi_calc                      = (aphi_tnom-pta_pepi_nbl*(temp-tnom))
+    aphi_temp                      = (0.1+0.5*((aphi_calc-0.1)+sqrt((aphi_calc-0.1)**2)))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (0.94999999999999996)
+    ptp_pepi_nhv                   = (0.00284697165469726)
+    pphi_tnom                      = (0.43077617572594573)
+    pphi_calc                      = (pphi_tnom-ptp_pepi_nhv*(temp-tnom))
+    pphi_temp                      = (0.1+0.5*((pphi_calc-0.1)+sqrt((pphi_calc-0.1)**2)))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (0.10000000000000001)

model pnp_iso vbic type=pnp
+ vers     = (1.20)
+ imelt    = (1e6)
+ tnom     = (27)
+ is       = ((necolumns*nerows*(2.347e-18*aeb1+2.322e-19*peb1+2.946e-19))*delr_psbe_pnp_iso_10hv_vbic)
+ nf       = (1.001)
+ nr       = ((1.0))
+ vef      = ((((2.347e-18*aeb1+2.322e-19*peb1+2.946e-19)/((2.347e-18*aeb1/301.6)+(2.322e-19*peb1/30.05e3)+2.946e-19/3.98e6))/(delr_psbe_pnp_iso_10hv_vbic*sqrt(delr_n_col_pnp_iso_10hv_vbic)))*(1-(0.10/120)*(temp-27)))
+ ver      = ((enable_punch_through*0.78)+(((2.347e-18*aeb1+2.322e-19*peb1+2.946e-19)/((2.347e-18*aeb1/3)+(2.322e-19*peb1/5)+2.946e-19/3))/sqrt(delr_psbe_pnp_iso_10hv_vbic)))
+ ikf      = ((necolumns*nerows*(1.507e-6*aeb1+9.387e-6*peb1+6.803e-9))/delr_psbe_pnp_iso_10hv_vbic)
+ ikr      = ((1e-12*abc+3.134e-07*pbc)/delr_psbe_pnp_iso_10hv_vbic)
+ wbe      = (1.0)
+ ibei     = (necolumns*nerows*(3.942e-20*aeb1+2.072e-46*peb1)*delr_jbei_pnp_iso_10hv_vbic)
+ nei      = (1.009)
+ iben     = ((necolumns*nerows*(5.174e-21*aeb1+11.11e-18*peb1)*delr_jben_pnp_iso_10hv_vbic)+dela_vth_relimo+rvbeibfdegr)
+ nen      = (1.599)
+ ibci     = (2.764e-19*abc+4.392e-19*pbc)
+ nci      = (1.174)
+ ibcn     = (8.339e-22*abc+4.392e-19*pbc)
+ ncn      = (1.11)
+ avc1     = ((0.3615772/aeb1)+120.7332)
+ avc2     = (nerows*necolumns*1160.77/(abc-nerows*necolumns*aeb1)+52.622)
+ re       = (4.28*(1/(necolumns*nerows)*(2.4e-3/aeb1+111.6/peb1)*delr_psbe_pnp_iso_10hv_vbic))
+ rbi      = ((1/(necolumns*nerows))*((6-3+(20-(6-3))*g1rb)**(-1))*11680*delr_psbe_pnp_iso_10hv_vbic*grb)
+ rbx      = (1/(necolumns*nerows*(1.273e-3*we_f+12.06/le_f))*delr_psb_pnp_iso_10hv_vbic)
+ rcx      = 1000*(((0.35*delr_x_col_pnp_iso_10hv_vbic)/(pcs*wc))/(np*delr_n_col_pnp_iso_10hv_vbic))
+ rci      = 1.3*((min(wcol/lcol,lcol/wcol)*(1/12-(1/12-1/28.45)*min(wcol/lcol,lcol/wcol))*70.71e3+0.05*238.9e3/(lcol+wcol)))
+ vo       = (9.858e3)
+ gamm     = 0.2*(3.345e-9)
+ hrcf     = (0.1)
+ aje      = (-0.5)
+ cbeo     = (0.0)
+ cje      = (necolumns*nerows*(4.735011e-16*aebd+1.595285e-16*pebd)/sqrt(delr_psbe_pnp_iso_10hv_vbic))
+ pe       = ((0.7978629*4.735011e-16*aebd+0.7552916*1.595285e-16*pebd)/(4.735011e-16*aebd+1.595285e-16*pebd))
+ me       = ((0.5002571*4.735011e-16*aebd+0.1*1.595285e-16*pebd)/(4.735011e-16*aebd+1.595285e-16*pebd))
+ fc       = (0.95)
+ tf       = 0.72*(1.6e-12*((aeb1+12)/peb1)/delr_psbe_pnp_iso_10hv_vbic*(((temp+273.15)/(27+273.15))**1.3))
+ qtf      = (111.9374)
+ xtf      = (24.81169)
+ vtf      = (7.325271)
+ itf      = 0.6*(1.8*(necolumns*nerows*(20*1e-7*aeb1+10e-6*peb1+0.0004111356))*((temp+273.15)/(27+273.15))**-2.5)
+ td       = (0)
+ tr       = (5e-12)
+ ajc      = (-0.5)
+ cbco     = (0)
+ cjc      = ((4.367103e-17*abc+3.195942e-16*pbc+9.903211e-17)*sqrt(delr_n_col_pnp_iso_10hv_vbic))
+ pc       = ((0.2324931*4.367103e-17*abc+0.525084*3.195942e-16*pbc)/(4.367103e-17*abc+3.195942e-16*pbc))
+ mc       = ((0.95*4.367103e-17*abc+0.5002016*3.195942e-16*pbc)/(4.367103e-17*abc+3.195942e-16*pbc))
+ cjep     = (0)
+ qco      = (0)
+ ajs      = (-0.5)
+ cjcp     = (((9.903211e-17*acs)+(2.208024e-16*pcs)))
+ ps       = (0.505)
+ ms       = (0.7)
+ wsp      = (0.9991)
+ isp      = ((89.5e-18*acs+1.504e-22*pcs+1e-24))
+ nfp      = (1.059)
+ ikp      = ((62.85e-12*acs)+(3.84e-6*pcs))
+ ibeip    = (1e-20*acs+1e-20*pcs)
+ ibenp    = (1e-20*acs+1e-20*pcs)
+ ibcip    = (2.513e-19*acs)
+ ncip     = (1.18)
+ ibcnp    = (0)
+ ncnp     = (1)
+ rbp      = (0)
+ rs       = (1e-2)
+ ea       = (1.132)
+ eap      = (1.08)
+ eaie     = (1.21)
+ eaic     = (1.162)
+ eais     = (1.02)
+ eane     = (1.05)
+ eanc     = (1.05)
+ eans     = (1.12)
+ xis      = (4.308)
+ xii      = (0.01)
+ xin      = (2.832)
+ xikf     = (0)
+ tnf      = (3.899e-06)
+ tavc     = (0.0)
+ xre      = (0)
+ xrs      = (0.000)
+ xvo      = (0)
+ afn      = (1.35)
+ bfn      = (0.884)
+ kfn      = 4.0*((5e-14)/((necolumns*nerows)**0.5))*(8.5)/(aeb1)
+ xrb      = (1.2)
+ xrbx     = (1.2)
+ xrc      = (1)
+ xrcx     = (1)
+ xrbp     = (1)

parameters
+    apar=1.0e-16*(2.0*(we+le)*necolumns*nerows*np)
+    vbpar=(6.0-(2.0*(we+le))*6e-3)*(1-1.15e-3*(temp-27))
+    mpar=(3.0)
+    kboq=(8.617087e-5)
+    vtm = (kboq*(temp+273.15))
+    rseries=1.1e6/(2.0*(we+le)*necolumns*nerows*np)
if(enable_punch_through==1) {
bice_punchthru_rev (ci e) bsource i=apar*( exp(((sqrt(v(ci,e)**2+0.1)+v(ci,e))*0.5- (vbpar))/(mpar*vtm))- exp(((sqrt(0.1))*0.5 -(vbpar))/(mpar*vtm)) ) tc1=0 tc2=0
rb_punchthru_rev   (c ci) resistor r=rseries
}

qpnp_iso (c b e iso) pnp_iso m=(np)
xcbox_sub_10hv (iso sub) cdgoptub_box_sub_10hv area=(anbl) perim=(pnbl) m=(np) soa=1

include "./smos10hv_ade_dfrt.scs" section=pnp_iso_10hv_dfrt
ends

//***********************************************************
endsection bjt
//***********************************************************

//***********************************************************
section diode_parasitic
//***********************************************************

subckt dnsd_lvpw_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nsd_pw)
+    aphi_t                         = (aphi_tnom-pta_junc_nsd_pw*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nsd_pw)
+    pphi_tnom                      = (pphi_junc_nsd_pw)
+    pphi_t                         = (pphi_tnom-ptp_junc_nsd_pw*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nsd_pw)

model dnsd_lvpw_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nsd_pw))*1.0e12)
+ n             = (ajnd_junc_nsd_pw)
+ cj            = ((((acj0_junc_nsd_pw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nsd_pw)
+ xti           = (axti_junc_nsd_pw)
+ fc            = (0.9)
+ eg            = (aeg_junc_nsd_pw)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nsd_pw)
+ gap2          = (abetaeg_junc_nsd_pw)

model dnsd_lvpw_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nsd_pw/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nsd_pw)
+ cj            = ((((pcj0_junc_nsd_pw/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nsd_pw)
+ xti           = (pxti_junc_nsd_pw)
+ fc            = (0.9)
+ eg            = (peg_junc_nsd_pw)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nsd_pw)
+ gap2          = (pbetaeg_junc_nsd_pw)

ddnsd_lvpw_10hv_area (p n) dnsd_lvpw_10hv_area area=area_val
ddnsd_lvpw_10hv_perim (p n) dnsd_lvpw_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnsd_lvpw_10hv_dfrt
ends

subckt dpsd_lvnw_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_psd_nw)
+    aphi_t                         = (aphi_tnom-pta_junc_psd_nw*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_psd_nw)
+    pphi_tnom                      = (pphi_junc_psd_nw)
+    pphi_t                         = (pphi_tnom-ptp_junc_psd_nw*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_psd_nw)

model dpsd_lvnw_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_psd_nw))*1.0e12)
+ n             = (ajnd_junc_psd_nw)
+ cj            = ((((acj0_junc_psd_nw)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_psd_nw)
+ xti           = (axti_junc_psd_nw)
+ fc            = (0.9)
+ eg            = (aeg_junc_psd_nw)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_psd_nw)
+ gap2          = (abetaeg_junc_psd_nw)

model dpsd_lvnw_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_psd_nw/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_psd_nw)
+ cj            = ((((pcj0_junc_psd_nw/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_psd_nw)
+ xti           = (pxti_junc_psd_nw)
+ fc            = (0.9)
+ eg            = (peg_junc_psd_nw)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_psd_nw)
+ gap2          = (pbetaeg_junc_psd_nw)

ddpsd_lvnw_10hv_area (p n) dpsd_lvnw_10hv_area area=area_val
ddpsd_lvnw_10hv_perim (p n) dpsd_lvnw_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dpsd_lvnw_10hv_dfrt
ends

subckt dnsd_phv_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nsd_phv)
+    aphi_t                         = (aphi_tnom-pta_junc_nsd_phv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nsd_phv)
+    pphi_tnom                      = (pphi_junc_nsd_phv)
+    pphi_t                         = (pphi_tnom-ptp_junc_nsd_phv*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nsd_phv)

model dnsd_phv_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nsd_phv))*1.0e12)
+ n             = (ajnd_junc_nsd_phv)
+ cj            = ((((acj0_junc_nsd_phv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nsd_phv)
+ xti           = (axti_junc_nsd_phv)
+ fc            = (0.9)
+ eg            = (aeg_junc_nsd_phv)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nsd_phv)
+ gap2          = (abetaeg_junc_nsd_phv)

model dnsd_phv_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nsd_phv/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nsd_phv)
+ cj            = ((((pcj0_junc_nsd_phv/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nsd_phv)
+ xti           = (pxti_junc_nsd_phv)
+ fc            = (0.9)
+ eg            = (peg_junc_nsd_phv)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nsd_phv)
+ gap2          = (pbetaeg_junc_nsd_phv)

ddnsd_phv_10hv_area (p n) dnsd_phv_10hv_area area=area_val
ddnsd_phv_10hv_perim (p n) dnsd_phv_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnsd_phv_10hv_dfrt
ends

subckt dpsd_nhv_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_psd_nhv)
+    aphi_t                         = (aphi_tnom-pta_junc_psd_nhv*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_psd_nhv)
+    pphi_tnom                      = (pphi_junc_psd_nhv)
+    pphi_t                         = (pphi_tnom-ptp_junc_psd_nhv*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_psd_nhv)

model dpsd_nhv_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_psd_nhv))*1.0e12)
+ n             = (ajnd_junc_psd_nhv)
+ cj            = ((((acj0_junc_psd_nhv)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_psd_nhv)
+ xti           = (axti_junc_psd_nhv)
+ fc            = (0.9)
+ eg            = (aeg_junc_psd_nhv)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_psd_nhv)
+ gap2          = (abetaeg_junc_psd_nhv)

model dpsd_nhv_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_psd_nhv/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_psd_nhv)
+ cj            = ((((pcj0_junc_psd_nhv/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_psd_nhv)
+ xti           = (pxti_junc_psd_nhv)
+ fc            = (0.9)
+ eg            = (peg_junc_psd_nhv)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_psd_nhv)
+ gap2          = (pbetaeg_junc_psd_nhv)

ddpsd_nhv_10hv_area (p n) dpsd_nhv_10hv_area area=area_val
ddpsd_nhv_10hv_perim (p n) dpsd_nhv_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dpsd_nhv_10hv_dfrt
ends

subckt dnw_pepi_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nw_pepi)
+    aphi_t                         = (aphi_tnom-pta_junc_nw_pepi*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nw_pepi)
+    pphi_tnom                      = (pphi_junc_nw_pepi)
+    pphi_t                         = (pphi_tnom-ptp_junc_nw_pepi*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nw_pepi)

model dnw_pepi_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nw_pepi))*1.0e12)
+ n             = (ajnd_junc_nw_pepi)
+ cj            = ((((acj0_junc_nw_pepi)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nw_pepi)
+ xti           = (axti_junc_nw_pepi)
+ fc            = (0.9)
+ eg            = (aeg_junc_nw_pepi)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nw_pepi)
+ gap2          = (abetaeg_junc_nw_pepi)

model dnw_pepi_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nw_pepi/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nw_pepi)
+ cj            = ((((pcj0_junc_nw_pepi/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nw_pepi)
+ xti           = (pxti_junc_nw_pepi)
+ fc            = (0.9)
+ eg            = (peg_junc_nw_pepi)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nw_pepi)
+ gap2          = (pbetaeg_junc_nw_pepi)

ddnw_pepi_10hv_area (p n) dnw_pepi_10hv_area area=area_val
ddnw_pepi_10hv_perim (p n) dnw_pepi_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnw_pepi_10hv_dfrt
ends

subckt dnw_pepi_tr_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nw_pepi_tr)
+    aphi_t                         = (aphi_tnom-pta_junc_nw_pepi_tr*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nw_pepi_tr)
+    pphi_tnom                      = (pphi_junc_nw_pepi_tr)
+    pphi_t                         = (pphi_tnom-ptp_junc_nw_pepi_tr*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nw_pepi_tr)

model dnw_pepi_tr_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nw_pepi_tr))*1.0e12)
+ n             = (ajnd_junc_nw_pepi_tr)
+ cj            = ((((acj0_junc_nw_pepi_tr)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nw_pepi_tr)
+ xti           = (axti_junc_nw_pepi_tr)
+ fc            = (0.9)
+ eg            = (aeg_junc_nw_pepi_tr)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nw_pepi_tr)
+ gap2          = (abetaeg_junc_nw_pepi_tr)

model dnw_pepi_tr_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nw_pepi_tr/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nw_pepi_tr)
+ cj            = ((((pcj0_junc_nw_pepi_tr/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nw_pepi_tr)
+ xti           = (pxti_junc_nw_pepi_tr)
+ fc            = (0.9)
+ eg            = (peg_junc_nw_pepi_tr)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nw_pepi_tr)
+ gap2          = (pbetaeg_junc_nw_pepi_tr)

ddnw_pepi_tr_10hv_area (p n) dnw_pepi_tr_10hv_area area=area_val
ddnw_pepi_tr_10hv_perim (p n) dnw_pepi_tr_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnw_pepi_tr_10hv_dfrt
ends

subckt dnhv_pepi_tr_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nhv_pepi_tr)
+    aphi_t                         = (aphi_tnom-pta_junc_nhv_pepi_tr*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nhv_pepi_tr)
+    pphi_tnom                      = (pphi_junc_nhv_pepi_tr)
+    pphi_t                         = (pphi_tnom-ptp_junc_nhv_pepi_tr*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nhv_pepi_tr)

model dnhv_pepi_tr_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nhv_pepi_tr))*1.0e12)
+ n             = (ajnd_junc_nhv_pepi_tr)
+ cj            = ((((acj0_junc_nhv_pepi_tr)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nhv_pepi_tr)
+ xti           = (axti_junc_nhv_pepi_tr)
+ fc            = (0.9)
+ eg            = (aeg_junc_nhv_pepi_tr)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nhv_pepi_tr)
+ gap2          = (abetaeg_junc_nhv_pepi_tr)

model dnhv_pepi_tr_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nhv_pepi_tr/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nhv_pepi_tr)
+ cj            = ((((pcj0_junc_nhv_pepi_tr/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nhv_pepi_tr)
+ xti           = (pxti_junc_nhv_pepi_tr)
+ fc            = (0.9)
+ eg            = (peg_junc_nhv_pepi_tr)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nhv_pepi_tr)
+ gap2          = (pbetaeg_junc_nhv_pepi_tr)

ddnhv_pepi_tr_10hv_area (p n) dnhv_pepi_tr_10hv_area area=area_val
ddnhv_pepi_tr_10hv_perim (p n) dnhv_pepi_tr_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnhv_pepi_tr_10hv_dfrt
ends

subckt dnbl_pepi_tr_10hv (p n)

parameters
+    area                           = 0
+    perim                          = 0
+    soa                            = 1
+    area_val                       = (area+(area==0)*1e-2)
+    perim_val                      = (perim+(perim==0)*1e-2)
+    aphi_tnom                      = (aphi_junc_nbl_pepi_tr)
+    aphi_t                         = (aphi_tnom-pta_junc_nbl_pepi_tr*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_t))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nbl_pepi_tr)
+    pphi_tnom                      = (pphi_junc_nbl_pepi_tr)
+    pphi_t                         = (pphi_tnom-ptp_junc_nbl_pepi_tr*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_t))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nbl_pepi_tr)

model dnbl_pepi_tr_10hv_area diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((ajs_junc_nbl_pepi_tr))*1.0e12)
+ n             = (ajnd_junc_nbl_pepi_tr)
+ cj            = ((((acj0_junc_nbl_pepi_tr)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_t))
+ mj            = (aexm_junc_nbl_pepi_tr)
+ xti           = (axti_junc_nbl_pepi_tr)
+ fc            = (0.9)
+ eg            = (aeg_junc_nbl_pepi_tr)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nbl_pepi_tr)
+ gap2          = (abetaeg_junc_nbl_pepi_tr)

model dnbl_pepi_tr_10hv_perim diode
+ dskip         = (no)
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ is            = (((pjs_junc_nbl_pepi_tr/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nbl_pepi_tr)
+ cj            = ((((pcj0_junc_nbl_pepi_tr/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_t))
+ mj            = (pexm_junc_nbl_pepi_tr)
+ xti           = (pxti_junc_nbl_pepi_tr)
+ fc            = (0.9)
+ eg            = (peg_junc_nbl_pepi_tr)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nbl_pepi_tr)
+ gap2          = (pbetaeg_junc_nbl_pepi_tr)

ddnbl_pepi_tr_10hv_area (p n) dnbl_pepi_tr_10hv_area area=area_val
ddnbl_pepi_tr_10hv_perim (p n) dnbl_pepi_tr_10hv_perim area=perim_val

include "./smos10hv_ade_dfrt.scs" section=dnbl_pepi_tr_10hv_dfrt
ends

//***********************************************************
endsection diode_parasitic
//***********************************************************

//***********************************************************
section mosfet
//***********************************************************

subckt nmos_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.21
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrd                            = 0
+    nrs                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    fault_injection_nmos_leakage_outlier = fault_injection_nmos_leakage_outlier_global
+    nsmm_delr_gox_nmos_10hv_bsim4  = tmp_nsmm_delr_gox_nmos_10hv_bsim4
+    nsmm_dela_vfb_nmos_10hv_bsim4  = tmp_nsmm_dela_vfb_nmos_10hv_bsim4
+    nsmm_delr_nsub_nmos_10hv_bsim4 = tmp_nsmm_delr_nsub_nmos_10hv_bsim4
+    nsmm_dela_vtl_nmos_10hv_bsim4  = tmp_nsmm_dela_vtl_nmos_10hv_bsim4
+    nsmm_dela_dl_nmos_10hv_bsim4   = tmp_nsmm_dela_dl_nmos_10hv_bsim4
+    nsmm_dela_dwox_nmos_10hv_bsim4 = tmp_nsmm_dela_dwox_nmos_10hv_bsim4
+    nsmm_delr_ubref_nmos_10hv_bsim4 = tmp_nsmm_delr_ubref_nmos_10hv_bsim4
+    nsmm_delr_rsh_nmos_10hv_bsim4  = tmp_nsmm_delr_rsh_nmos_10hv_bsim4
+    nsmm_dela_vtw_nmos_10hv_bsim4  = tmp_nsmm_dela_vtw_nmos_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos_vthratio           = (1.0)
+    presto_nmos_betaratio          = (1.8)
+    relimo_ratio1_a_hci_nmos_10hv  = (0.045410628)
+    relimo_ratio1_b_hci_nmos_10hv  = (-0.173723092)
+    we                             = (0.5*(wemin_nmos_10hv+w+sqrt((w-wemin_nmos_10hv)*(w-wemin_nmos_10hv))))
+    as_i                           = (as+(as==0)*(1-lpe)*(lg2aa_nmos_10hv*we))
+    ps_i                           = (ps+(ps==0)*(1-lpe)*(2*(lg2aa_nmos_10hv+we)))
+    ad_i                           = (ad+(ad==0)*(1-lpe)*(lg2aa_nmos_10hv*we))
+    pd_i                           = (pd+(pd==0)*(1-lpe)*(2*(lg2aa_nmos_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_nmos_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_nmos_10hv/w))
+    liso                           = (laa2iso_left_nmos_10hv+lg2aa_nmos_10hv+l+lg2aa_nmos_10hv+laa2iso_right_nmos_10hv)
+    wiso                           = (wg2iso_nmos_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    rleak_nmos                     = (29045)
+    lchmin_nmos                    = (0.15)
+    nmos_astivfb                   = (0.00635)*1.15
+    nmos_bstivfb                   = (-2.828e-4)*2.5
+    nmos_astinsub                  = (1.4e-5)
+    nmos_astiubref                 = (-0.0222)*1.15
+    nmos_bstiubref                 = (-0.01)
+    nmos_cstiubref                 = (-0.115)*(-1.0)
+    nmos_sapar0                    = (0.023+0.035*l)
+    nmos_sapar1                    = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+nmos_sapar0*(np-1)+nmos_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+nmos_sapar0*(np-1)+nmos_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((nmos_astivfb+nmos_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+nmos_astinsub*stress)/(1+nmos_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(nmos_astiubref+l*nmos_bstiubref)*stress+(nmos_cstiubref/sqrt(w)))/(1+(nmos_astiubref+l*nmos_bstiubref)*stress0+(nmos_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-06
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = 0
+    ldmu0_dte                      = 1.6e-07
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = 0
+    wdmu0_dte                      = 1.0e-07
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    dela_cd_nmos_10hv_bsim4        = (nom_dela_cd_nmos_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_nmos_10hv_bsim4)
+    delr_tox_nmos_10hv_bsim4       = (nom_delr_tox_nmos_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_nmos_10hv_bsim4+nsmm_delr_gox_nmos_10hv_bsim4*smm_delr_gox_nmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_nmos_10hv_bsim4      = (nom_dela_dwox_nmos_10hv_bsim4+nsig_dela_dwox_nmos_10hv_bsim4*sig_dela_dwox_nmos_10hv_bsim4+nsmm_dela_dwox_nmos_10hv_bsim4*smm_dela_dwox_nmos_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vfb_nmos_10hv_bsim4       = (nom_dela_vfb_nmos_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_nmos_10hv_bsim4*sig_dela_vfb_nmos_10hv_bsim4+nsmm_dela_vfb_nmos_10hv_bsim4*smm_dela_vfb_nmos_10hv_bsim4(l,w)/sqrt(1*np)+nsmm_dela_vtl_nmos_10hv_bsim4*smm_dela_vtl_nmos_10hv_bsim4(l,w)/sqrt(1*np)/l+nsmm_dela_vtw_nmos_10hv_bsim4*smm_dela_vtw_nmos_10hv_bsim4(l,w)/sqrt(1*np)/w)
+    delr_ubref_nmos_10hv_bsim4     = (nom_delr_ubref_nmos_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_nmos_10hv_bsim4*sig_delr_ubref_nmos_10hv_bsim4+nsmm_delr_ubref_nmos_10hv_bsim4*smm_delr_ubref_nmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_od_nmos_10hv_bsim4        = (nom_dela_od_nmos_10hv_bsim4+nsig_dela_od_nmos_10hv_bsim4*sig_dela_od_nmos_10hv_bsim4+nsmm_dela_dl_nmos_10hv_bsim4*smm_dela_dl_nmos_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_nmos_10hv_bsim4        = (dela_cd_nmos_10hv_bsim4+dela_od_nmos_10hv_bsim4)
+    dela_vtl_nmos_10hv_bsim4       = (nom_dela_vtl_nmos_10hv_bsim4+nsig_dela_vtl_nmos_10hv_bsim4*sig_dela_vtl_nmos_10hv_bsim4)
+    dela_vtw_nmos_10hv_bsim4       = (nom_dela_vtw_nmos_10hv_bsim4+nsig_dela_vtw_nmos_10hv_bsim4*sig_dela_vtw_nmos_10hv_bsim4)
+    dela_vtm_nmos_10hv_bsim4       = (nom_dela_vtm_nmos_10hv_bsim4+nsig_dela_vtm_nmos_10hv_bsim4*sig_dela_vtm_nmos_10hv_bsim4)
+    delr_a0_nmos_10hv_bsim4        = (nom_delr_a0_nmos_10hv_bsim4*(1.0+nsig_delr_a0_nmos_10hv_bsim4*sig_delr_a0_nmos_10hv_bsim4))
+    delr_pvsat_nmos_10hv_bsim4     = (nom_delr_pvsat_nmos_10hv_bsim4*(1.0+nsig_delr_pvsat_nmos_10hv_bsim4*sig_delr_pvsat_nmos_10hv_bsim4))
+    delr_rsh_nmos_10hv_bsim4       = (1+nsmm_delr_rsh_nmos_10hv_bsim4*smm_delr_rsh_nmos_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_nmos_10hv_bsim4      = (fac_nsub_sti_final*(1+nsmm_delr_nsub_nmos_10hv_bsim4*smm_delr_nsub_nmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_lvoff_nmos_10hv_bsim4     = (nom_dela_lvoff_nmos_10hv_bsim4+nsig_dela_lvoff_nmos_10hv_bsim4*sig_dela_lvoff_nmos_10hv_bsim4)
+    dela_pvoff_nmos_10hv_bsim4     = (nom_dela_pvoff_nmos_10hv_bsim4+nsig_dela_pvoff_nmos_10hv_bsim4*sig_dela_pvoff_nmos_10hv_bsim4)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.072e-09*delr_tox_nmos_10hv_bsim4)
+    cox                            = (epsox/tox)
+    kboq                           = (8.617087e-5)
+    vtm                            = (kboq*(temp+273.15))
+    eg                             = (1.16-7.02e-4*(temp+273.15)*(temp+273.15)/(temp+1108.0))
+    nit                            = (1.45e10*((temp+273.15)/300.15)*sqrt((temp+273.15)/300.15)*exp(21.5565981-eg/(2.0*vtm)))
+    phis                           = (0.4+vtm*log(1.7e+17/nit)+0.1223)

model nmos_10hv bsim4 type=n version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.072e-09*delr_tox_nmos_10hv_bsim4)
+ toxm     = (3.072e-09)
+ toxp     = (((3.072e-09*delr_tox_nmos_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.7e+17*delr_nsub_nmos_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (1.676e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ rsh      = (9.8)
+ rshg     = (0.1)
+ lint     = (1.100e-08-0.5e-06*dela_dl_nmos_10hv_bsim4)
+ wint     = (3.096e-08-0.5e-06*dela_dwox_nmos_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (-5e-22)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (-5.453e-15)
+ wwn      = (1.0)
+ ll       = (1e-15)
+ lln      = (1.0)
+ lw       = (-2e-15)
+ lwn      = (1.0)
+ dwg      = (-8e-09)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (1e-10)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (0.223+dela_vfb_nmos_10hv_bsim4+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos_10hv-relimo_ratio1_b_hci_nmos_10hv)+(sqrt(delr_nsub_nmos_10hv_bsim4)-1)*0.2413*(18/5)*sqrt(phis))
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (0.0021+dela_vtm_nmos_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.1223)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.2413*sqrt(delr_nsub_nmos_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.01*sqrt(delr_nsub_nmos_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (14.0+80*dela_vtw_nmos_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (-6.5)
+ pk3      = (0.0)
+ k3b      = (-0.5)
+ lk3b     = (0.0)
+ wk3b     = (0.2)
+ pk3b     = (0.0)
+ w0       = (1.1e-06)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (2.10e-07+1e-06*dela_vtl_nmos_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (-6.4e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (0.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.03368)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.3006)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (1e-05)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (-0.1)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (950000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.152)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((2.8-2.0*((temp+273.15)/(tnom+273.15)-1))*delr_a0_nmos_10hv_bsim4*delr_a0_relimo)
+ la0      = (0.0)
+ wa0      = (0.0)
+ pa0      = (0.0)
+ ags      = (0.8505)
+ lags     = (0.0)
+ wags     = (0.0)
+ pags     = (0.0)
+ b0       = (7.58e-07)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (6.78e-07)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.0609)
+ lketa    = (0.008)
+ wketa    = (0.0)
+ pketa    = (0.001)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((362.5*delr_ubref_nmos_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (5.0)
+ ua       = (-9.5e-10)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (2.436e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.1061)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e+14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (130000.0)
+ lvsat    = (-3500.0)
+ wvsat    = (0.0)
+ pvsat    = (1650.0*delr_pvsat_nmos_10hv_bsim4)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.105)
+ lvoff    = (-0.008+dela_lvoff_nmos_10hv_bsim4)
+ wvoff    = (-0.002775)
+ pvoff    = (-0.0012+dela_pvoff_nmos_10hv_bsim4)
+ tvoff    = (0.00115)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (0.0)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (1.0)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.011)
+ etab     = (-0.4)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (-0.031)
+ dsub     = (0.86)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0)
+ lcit     = (0.0003)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (17.72)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.4492)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.009205)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.0)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.9272)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (42.07)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.0219)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.04)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((78.25*delr_rsh_nmos_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (8e-07)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (8.0)
+ lalpha1  = (0.0)
+ walpha1  = (4.2)
+ palpha1  = (0.0)
+ beta0    = (16.0)
+ lbeta0   = (0.0)
+ wbeta0   = (0.5)
+ pbeta0   = (0.0)
+ agidl    = (8e-08)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (3200000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (30.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (-0.1)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.3029e-02*pow((temp+273.15)/(tnom+273.15),-0.25))
+ laigbacc = (1.975e-04)*pow((temp+273.15)/(tnom+273.15),-0.25)
+ waigbacc = (-1.75e-05)*pow((temp+273.15)/(tnom+273.15),-0.25)
+ paigbacc = (2.75e-05)*pow((temp+273.15)/(tnom+273.15),-0.25)
+ bigbacc  = (2.761e-03*pow((temp+273.15)/(tnom+273.15),-1.0))
+ lbigbacc = (-2.51e-05)*pow((temp+273.15)/(tnom+273.15),-1.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.05)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (2.0*pow((temp+273.15)/(tnom+273.15),1.0))
+ lnigbacc = (2.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (1.2669e-02*pow((temp+273.15)/(tnom+273.15),0.02))
+ laigbinv = (-2.266e-04*pow((temp+273.15)/(tnom+273.15),0.02))
+ waigbinv = (2.0e-05*pow((temp+273.15)/(tnom+273.15),0.02))
+ paigbinv = (-5.8e-06*pow((temp+273.15)/(tnom+273.15),0.02))
+ bigbinv  = (2.299e-03)
+ lbigbinv = (-1.1e-04)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.1)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (2.0)
+ lnigbinv = (0.2)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (1.2012e-02*pow((temp+273.15)/(tnom+273.15),0.01))
+ laigc    = (-4.05e-05*pow((temp+273.15)/(tnom+273.15),0.01))
+ waigc    = (5.0e-06*pow((temp+273.15)/(tnom+273.15),0.01))
+ paigc    = (2.75e-06*pow((temp+273.15)/(tnom+273.15),0.01))
+ bigc     = (1.25e-03)
+ lbigc    = (-2.5e-05)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.0)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (1.224e-02*pow((temp+273.15)/(tnom+273.15),-0.15))
+ laigsd   = (7.04e-05*pow((temp+273.15)/(tnom+273.15),1.2))
+ waigsd   = (0.0)
+ paigsd   = (9.0e-06*pow((temp+273.15)/(tnom+273.15),1.0))
+ bigsd    = (3.3e-04)
+ lbigsd   = (0.66375e-04)
+ wbigsd   = (0.0)
+ pbigsd   = (6.75e-06)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2e-08)
+ nigc     = (2.0)
+ lnigc    = (0.1)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (1.29e-08*cox+(1-lpe)*0.5*cfr_nmos_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos_s_ply_met*1e6-(1-lpe)*0.5*cfr_nmos_s_ply_met*1e6)
+ cgdo     = (1.29e-08*cox+(1-lpe)*0.5*cfr_nmos_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos_d_ply_met*1e6-(1-lpe)*0.5*cfr_nmos_d_ply_met*1e6)
+ cgbo     = (1.25e-10)
+ cgsl     = (6.022e-11)
+ cgdl     = (6.022e-11)
+ ckappas  = (2.052)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.3e-08)
+ dwc      = (-2.0e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.8)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.09)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.3157)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (7.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_nmos_sd_body)
+ jsws     = (1.0e6*pjs_junc_nmos_sd_body)
+ jswgs    = (1.0e6*chjs_junc_nmos_sd_body)
+ jtss     = (1e-15)
+ jtssws   = (1e-15)
+ jtsswgs  = (1e-15)
+ njts     = (30.0)
+ njtssw   = (25.0)
+ njtsswg  = (2.0)
+ xtss     = (0.2)
+ xtssws   = (0.2)
+ xtsswgs  = (0.2)
+ vtss     = (10.0)
+ vtssws   = (3.0)
+ vtsswgs  = (1.0)
+ tnjts    = (0.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (0.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_nmos_sd_body)
+ mjs      = (aexm_junc_nmos_sd_body)
+ pbs      = (aphi_junc_nmos_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_nmos_sd_body)
+ mjsws    = (pexm_junc_nmos_sd_body)
+ pbsws    = (pphi_junc_nmos_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_nmos_sd_body)
+ mjswgs   = (chexm_junc_nmos_sd_body)
+ pbswgs   = (chphi_junc_nmos_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.643)
+ lute     = (0.05)
+ wute     = (0.06025)
+ pute     = (0.0)
+ kt1      = (-0.2722)
+ lkt1     = (0.0)
+ wkt1     = (0.005)
+ pkt1     = (0.0)
+ kt1l     = (-1.068e-08)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.04861)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (-0.006319)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.003703)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (0.000173)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.00108)
+ lat      = (0.0)
+ wat      = (5e-05)
+ pat      = (0.0)
+ prt      = (0.005121)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_nmos_sd_body)
+ xtis     = (3.0)
+ tpb      = (0.001171)
+ tpbsw    = (0.000651)
+ tpbswg   = (0.0004)
+ tcj      = (0.00083)
+ tcjsw    = (0.000215)
+ tcjswg   = (0.001)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (1.0)
+ wlodku0  = (1.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (1.0)
+ wlodvth  = (1.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (0.0)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (1.0e-03)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ noia     = (noia_nmos_10hv_bsim4)
+ noib     = (noib_nmos_10hv_bsim4)
+ noic     = (noic_nmos_10hv_bsim4)
+ ef       = (ef_nmos_10hv_bsim4)
+ em       = (em_nmos_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

bileak (d s) bsource i=((fault_injection_nmos_leakage_outlier==1)*v(d,s)/(rleak_nmos*l/lchmin_nmos)) tc1=-2e-05 tc2=0
mnmos_10hv_i (d g s b) nmos_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
aprint_function print_function
+ device="nmos_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_injection_nmos_leakage_outlier

include "./smos10hv_ade_dfrt.scs" section=nmos_10hv_dfrt
ends

subckt nmos_ll_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.21
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrd                            = 0
+    nrs                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_nmos_ll_10hv_bsim4 = tmp_nsmm_delr_gox_nmos_ll_10hv_bsim4
+    nsmm_dela_vfb_nmos_ll_10hv_bsim4 = tmp_nsmm_dela_vfb_nmos_ll_10hv_bsim4
+    nsmm_delr_nsub_nmos_ll_10hv_bsim4 = tmp_nsmm_delr_nsub_nmos_ll_10hv_bsim4
+    nsmm_dela_vtl_nmos_ll_10hv_bsim4 = tmp_nsmm_dela_vtl_nmos_ll_10hv_bsim4
+    nsmm_dela_dl_nmos_ll_10hv_bsim4 = tmp_nsmm_dela_dl_nmos_ll_10hv_bsim4
+    nsmm_dela_dwox_nmos_ll_10hv_bsim4 = tmp_nsmm_dela_dwox_nmos_ll_10hv_bsim4
+    nsmm_delr_ubref_nmos_ll_10hv_bsim4 = tmp_nsmm_delr_ubref_nmos_ll_10hv_bsim4
+    nsmm_delr_rsh_nmos_ll_10hv_bsim4 = tmp_nsmm_delr_rsh_nmos_ll_10hv_bsim4
+    nsmm_dela_vtw_nmos_ll_10hv_bsim4 = tmp_nsmm_dela_vtw_nmos_ll_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos_ll_vthratio        = (1.0)
+    presto_nmos_ll_betaratio       = (1.47)
+    relimo_ratio1_a_hci_nmos_ll_10hv = (0.063213703)
+    relimo_ratio1_b_hci_nmos_ll_10hv = (-0.129371941)
+    we                             = (0.5*(wemin_nmos_ll_10hv+w+sqrt((w-wemin_nmos_ll_10hv)*(w-wemin_nmos_ll_10hv))))
+    as_i                           = ((as)+(as==0)*(1-lpe)*(lg2aa_nmos_ll_10hv*we))
+    ps_i                           = ((ps)+(ps==0)*(1-lpe)*(2*(lg2aa_nmos_ll_10hv+we)))
+    ad_i                           = ((ad)+(ad==0)*(1-lpe)*(lg2aa_nmos_ll_10hv*we))
+    pd_i                           = ((pd)+(pd==0)*(1-lpe)*(2*(lg2aa_nmos_ll_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_nmos_ll_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_nmos_ll_10hv/w))
+    liso                           = (laa2iso_left_nmos_ll_10hv+lg2aa_nmos_ll_10hv+l+lg2aa_nmos_ll_10hv+laa2iso_right_nmos_ll_10hv)
+    wiso                           = (wg2iso_nmos_ll_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    nmos_ll_astivfb                = (0.00635*1.2)
+    nmos_ll_bstivfb                = (-2.828e-4)
+    nmos_ll_astinsub               = (1.4e-5)
+    nmos_ll_astiubref              = (-0.0222*1.1)
+    nmos_ll_bstiubref              = (-0.01)
+    nmos_ll_cstiubref              = (-0.115)
+    nmos_ll_sapar0                 = (0.023+0.035*l)
+    nmos_ll_sapar1                 = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+nmos_ll_sapar0*(np-1)+nmos_ll_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+nmos_ll_sapar0*(np-1)+nmos_ll_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((nmos_ll_astivfb+nmos_ll_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+nmos_ll_astinsub*stress)/(1+nmos_ll_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(nmos_ll_astiubref+l*nmos_ll_bstiubref)*stress+(nmos_ll_cstiubref/sqrt(w)))/(1+(nmos_ll_astiubref+l*nmos_ll_bstiubref)*stress0+(nmos_ll_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-06
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = 0
+    ldmu0_dte                      = 1.6e-07
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = 0
+    wdmu0_dte                      = 1.0e-07
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+(temp-27)*(-1.2e-3))
+    dela_cd_nmos_ll_10hv_bsim4     = (nom_dela_cd_nmos_ll_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_nmos_ll_10hv_bsim4)
+    delr_tox_nmos_ll_10hv_bsim4    = (nom_delr_tox_nmos_ll_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_nmos_ll_10hv_bsim4+nsmm_delr_gox_nmos_ll_10hv_bsim4*smm_delr_gox_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_nmos_ll_10hv_bsim4   = (nom_dela_dwox_nmos_ll_10hv_bsim4+nsig_dela_dwox_nmos_ll_10hv_bsim4*sig_dela_dwox_nmos_ll_10hv_bsim4+nsmm_dela_dwox_nmos_ll_10hv_bsim4*smm_dela_dwox_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vfb_nmos_ll_10hv_bsim4    = (nom_dela_vfb_nmos_ll_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_nmos_ll_10hv_bsim4*sig_dela_vfb_nmos_ll_10hv_bsim4+tc_vth_mm*nsmm_dela_vfb_nmos_ll_10hv_bsim4*smm_dela_vfb_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_ubref_nmos_ll_10hv_bsim4  = (nom_delr_ubref_nmos_ll_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_nmos_ll_10hv_bsim4*sig_delr_ubref_nmos_ll_10hv_bsim4+nsmm_delr_ubref_nmos_ll_10hv_bsim4*smm_delr_ubref_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_a0_nmos_ll_10hv_bsim4     = (nom_dela_a0_nmos_ll_10hv_bsim4+nsig_dela_a0_nmos_ll_10hv_bsim4*sig_dela_a0_nmos_ll_10hv_bsim4)
+    dela_vtl_nmos_ll_10hv_bsim4    = (nom_dela_vtl_nmos_ll_10hv_bsim4+nsig_dela_vtl_nmos_ll_10hv_bsim4*sig_dela_vtl_nmos_ll_10hv_bsim4+nsmm_dela_vtl_nmos_ll_10hv_bsim4*smm_dela_vtl_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_od_nmos_ll_10hv_bsim4     = (nom_dela_od_nmos_ll_10hv_bsim4+nsig_dela_od_nmos_ll_10hv_bsim4*sig_dela_od_nmos_ll_10hv_bsim4+nsmm_dela_dl_nmos_ll_10hv_bsim4*smm_dela_dl_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_nmos_ll_10hv_bsim4     = (dela_cd_nmos_ll_10hv_bsim4+dela_od_nmos_ll_10hv_bsim4)
+    delr_vsat_nmos_ll_10hv_bsim4   = (nom_delr_vsat_nmos_ll_10hv_bsim4*(1.0+nsig_delr_vsat_nmos_ll_10hv_bsim4*sig_delr_vsat_nmos_ll_10hv_bsim4))
+    dela_vtw_nmos_ll_10hv_bsim4    = (nom_dela_vtw_nmos_ll_10hv_bsim4+nsig_dela_vtw_nmos_ll_10hv_bsim4*sig_dela_vtw_nmos_ll_10hv_bsim4+nsmm_dela_vtw_nmos_ll_10hv_bsim4*smm_dela_vtw_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtm_nmos_ll_10hv_bsim4    = (nom_dela_vtm_nmos_ll_10hv_bsim4+nsig_dela_vtm_nmos_ll_10hv_bsim4*sig_dela_vtm_nmos_ll_10hv_bsim4)
+    dela_wwl_nmos_ll_10hv_bsim4    = (nom_dela_wwl_nmos_ll_10hv_bsim4+nsig_dela_wwl_nmos_ll_10hv_bsim4*sig_dela_wwl_nmos_ll_10hv_bsim4)
+    delr_rsh_nmos_ll_10hv_bsim4    = (1+nsmm_delr_rsh_nmos_ll_10hv_bsim4*smm_delr_rsh_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_nmos_ll_10hv_bsim4   = (fac_nsub_sti_final*(1+nsmm_delr_nsub_nmos_ll_10hv_bsim4*smm_delr_nsub_nmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_jtss_nmos_ll_10hv_bsim4   = (exp(nom_dela_jtss_nmos_ll_10hv_bsim4+nsig_dela_jtss_nmos_ll_10hv_bsim4*sig_dela_jtss_nmos_ll_10hv_bsim4))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.082e-09*delr_tox_nmos_ll_10hv_bsim4)
+    cox                            = (epsox/tox)

model nmos_ll_10hv bsim4 type=n version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.082e-09*delr_tox_nmos_ll_10hv_bsim4)
+ toxm     = (3.082e-09)
+ toxp     = (((3.082e-09*delr_tox_nmos_ll_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.7e+17)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (2e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (1.1e-08-0.5e-06*dela_dl_nmos_ll_10hv_bsim4)
+ wint     = (3.803e-08-0.5e-06*dela_dwox_nmos_ll_10hv_bsim4)
+ wl       = (1.615e-24)
+ lwl      = (0.0)
+ wwl      = (-4e-22+1e-18*dela_wwl_nmos_ll_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (-5.702e-15)
+ wwn      = (1.0)
+ ll       = (1.653e-15)
+ lln      = (1.0)
+ lw       = (1.615e-24)
+ lwn      = (1.0)
+ dwg      = (-3e-09)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (-5e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (0.438+dela_vfb_nmos_ll_10hv_bsim4+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos_ll_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos_ll_10hv-relimo_ratio1_b_hci_nmos_ll_10hv))
+ lvth0    = (-0.052)
+ wvth0    = (0.0+dela_vtw_nmos_ll_10hv_bsim4)
+ pvth0    = (0.0+dela_vtm_nmos_ll_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.13)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.53*sqrt(delr_nsub_nmos_ll_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (-0.03056*sqrt(delr_nsub_nmos_ll_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (370.7)
+ lk3      = (0.0)
+ wk3      = (-99.1)
+ pk3      = (0.0)
+ k3b      = (1.0)
+ lk3b     = (0.0)
+ wk3b     = (20.0)
+ pk3b     = (0.0)
+ w0       = (1.384e-05)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (5.126e-07+1e-06*dela_vtl_nmos_ll_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (-3.053e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (1.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (1.5)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.032)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (1e-08)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (1.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (3000000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.232)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.836+dela_a0_nmos_ll_10hv_bsim4)*delr_a0_relimo)
+ la0      = (-0.5562)
+ wa0      = (4.232e-10)
+ pa0      = (-0.05954)
+ ags      = (0.6656-0.75*((temp+273.15)/(tnom+273.15)-1))
+ lags     = (0.2037)
+ wags     = (0.0)
+ pags     = (-0.05074)
+ b0       = (1.0e-06)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (4.697e-05)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.05)
+ lketa    = (-0.005)
+ wketa    = (0.001)
+ pketa    = (0.00076)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((300.0*delr_ubref_nmos_ll_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (0.0)
+ ua       = (-9e-10)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (1.66e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.1607)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e+14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (106800.0*delr_vsat_nmos_ll_10hv_bsim4)
+ lvsat    = (-3636.0)
+ wvsat    = (0.0)
+ pvsat    = (100.6)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.15)
+ lvoff    = (-0.004645)
+ wvoff    = (-0.005)
+ pvoff    = (5.12e-04)
+ tvoff    = (0.0)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (0.0)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.5)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.108)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-0.1)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.56)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.001)
+ lcit     = (0.0001)
+ wcit     = (0.0001)
+ pcit     = (-5e-06)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.3694)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.088)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.006096)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.05)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.56)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-10)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.0)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.007868)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((142.4*delr_rsh_nmos_ll_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.32)
+ lprwg    = (-0.025)
+ wprwg    = (0.0)
+ pprwg    = (0.01)
+ prwb     = (-0.1)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (1.6e-09)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (0.018)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (8.0*pow((temp+273.15)/(tnom+273.15),-0.6))
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (1.8e-08*pow((temp+273.15)/(tnom+273.15),3.0)*delr_jtss_nmos_ll_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (1000000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1200.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.6)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.2771e-02*pow((temp+273.15)/(tnom+273.15),-0.3))
+ laigbacc = (1.7347e-04*pow((temp+273.15)/(tnom+273.15),-0.3))
+ waigbacc = (-2.09e-05*pow((temp+273.15)/(tnom+273.15),-0.3))
+ paigbacc = (-2.09e-06*pow((temp+273.15)/(tnom+273.15),-0.3))
+ bigbacc  = (2.8865e-03*pow((temp+273.15)/(tnom+273.15),-1.2))
+ lbigbacc = (-2.51e-05*pow((temp+273.15)/(tnom+273.15),-1.2))
+ wbigbacc = (0.0)
+ pbigbacc = (-3.51e-06*pow((temp+273.15)/(tnom+273.15),-1.2))
+ cigbacc  = (0.05)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (1.2177e-02*pow((temp+273.15)/(tnom+273.15),0.04))
+ laigbinv = (-2.09e-04*pow((temp+273.15)/(tnom+273.15),0.04))
+ waigbinv = (3.2e-05*pow((temp+273.15)/(tnom+273.15),0.04))
+ paigbinv = (-3.2e-06*pow((temp+273.15)/(tnom+273.15),0.04))
+ bigbinv  = (2.0691e-03)
+ lbigbinv = (-1.15e-04)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.006)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.21)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (1.17e-02*pow((temp+273.15)/(tnom+273.15),0.02))
+ laigc    = (-4.05e-05*pow((temp+273.15)/(tnom+273.15),0.02))
+ waigc    = (6e-06*pow((temp+273.15)/(tnom+273.15),0.02))
+ paigc    = (-3e-07*pow((temp+273.15)/(tnom+273.15),0.02))
+ bigc     = (1.125e-03)
+ lbigc    = (-2.5e-05)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.0)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (1.224e-02*pow((temp+273.15)/(tnom+273.15),-0.1))
+ laigsd   = (5.28e-05*pow((temp+273.15)/(tnom+273.15),0.75))
+ waigsd   = (0.0)
+ paigsd   = (8.8e-07*pow((temp+273.15)/(tnom+273.15),0.75))
+ bigsd    = (3.3e-04)
+ lbigsd   = (5.625e-05)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2.4e-08)
+ nigc     = (2.0*pow((temp+273.15)/(tnom+273.15),-0.5))
+ lnigc    = (0.1*pow((temp+273.15)/(tnom+273.15),-0.5))
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (1.05341796875e-08*cox+(1-lpe)*0.5*cfr_nmos_ll_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos_ll_s_ply_met*1e6-(1-lpe)*0.5*cfr_nmos_ll_s_ply_met*1e6)
+ cgdo     = (1.05341796875e-08*cox+(1-lpe)*0.5*cfr_nmos_ll_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos_ll_d_ply_met*1e6-(1-lpe)*0.5*cfr_nmos_ll_d_ply_met*1e6)
+ cgbo     = (0.0)
+ cgsl     = (8.0e-11)
+ cgdl     = (8.0e-11)
+ ckappas  = (3.0)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = ((3.9e-08)*1.102)
+ dwc      = ((-2.0e-08)*1.165)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.8)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.075)
+ lvoffcv  = (-0.012)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.4)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_nmos_ll_sd_body)
+ jsws     = (1.0e6*pjs_junc_nmos_ll_sd_body)
+ jswgs    = (1.0e6*chjs_junc_nmos_ll_sd_body)
+ jtss     = (1e-12*delr_jtss_nmos_ll_10hv_bsim4)
+ jtssws   = (1e-12*delr_jtss_nmos_ll_10hv_bsim4)
+ jtsswgs  = (1e-12*delr_jtss_nmos_ll_10hv_bsim4)
+ njts     = (7.0)
+ njtssw   = (7.0)
+ njtsswg  = (7.0)
+ xtss     = (0.1)
+ xtssws   = (0.1)
+ xtsswgs  = (0.1)
+ vtss     = (15.0)
+ vtssws   = (15.0)
+ vtsswgs  = (15.0)
+ tnjts    = (0.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (0.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_nmos_ll_sd_body)
+ mjs      = (aexm_junc_nmos_ll_sd_body)
+ pbs      = (aphi_junc_nmos_ll_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_nmos_ll_sd_body)
+ mjsws    = (pexm_junc_nmos_ll_sd_body)
+ pbsws    = (pphi_junc_nmos_ll_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_nmos_ll_sd_body)
+ mjswgs   = (chexm_junc_nmos_ll_sd_body)
+ pbswgs   = (chphi_junc_nmos_ll_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.85)
+ lute     = (0.0)
+ wute     = (0.04)
+ pute     = (0.0)
+ kt1      = (-0.3)
+ lkt1     = (0.0)
+ wkt1     = (0.0)
+ pkt1     = (0.0)
+ kt1l     = (0.0)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.052)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (-0.002318)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.002471)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-5.6e-11)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0015)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.001)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_nmos_ll_sd_body)
+ xtis     = (1.0)
+ tpb      = (0.0018)
+ tpbsw    = (0.0018)
+ tpbswg   = (0.0018)
+ tcj      = (0.0008)
+ tcjsw    = (0.0009)
+ tcjswg   = (0.0009)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (0.0)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (0.0)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ noia     = (noia_nmos_ll_10hv_bsim4*500)
+ noib     = (noib_nmos_ll_10hv_bsim4)
+ noic     = (noic_nmos_ll_10hv_bsim4)
+ ef       = (ef_nmos_ll_10hv_bsim4)
+ em       = (em_nmos_ll_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

mnmos_ll_10hv_i (d g s b) nmos_ll_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=nmos_ll_10hv_dfrt
ends

subckt nmos_ull_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.21
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrd                            = 0
+    nrs                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_nmos_ull_10hv_bsim4 = tmp_nsmm_delr_gox_nmos_ull_10hv_bsim4
+    nsmm_dela_vfb_nmos_ull_10hv_bsim4 = tmp_nsmm_dela_vfb_nmos_ull_10hv_bsim4
+    nsmm_delr_nsub_nmos_ull_10hv_bsim4 = tmp_nsmm_delr_nsub_nmos_ull_10hv_bsim4
+    nsmm_dela_vtl_nmos_ull_10hv_bsim4 = tmp_nsmm_dela_vtl_nmos_ull_10hv_bsim4
+    nsmm_dela_dl_nmos_ull_10hv_bsim4 = tmp_nsmm_dela_dl_nmos_ull_10hv_bsim4
+    nsmm_dela_dwox_nmos_ull_10hv_bsim4 = tmp_nsmm_dela_dwox_nmos_ull_10hv_bsim4
+    nsmm_delr_ubref_nmos_ull_10hv_bsim4 = tmp_nsmm_delr_ubref_nmos_ull_10hv_bsim4
+    nsmm_delr_rsh_nmos_ull_10hv_bsim4 = tmp_nsmm_delr_rsh_nmos_ull_10hv_bsim4
+    nsmm_dela_vtw_nmos_ull_10hv_bsim4 = tmp_nsmm_dela_vtw_nmos_ull_10hv_bsim4
+    nsmm_delr_voff_nmos_ull_10hv_bsim4 = tmp_nsmm_delr_voff_nmos_ull_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos_ull_vthratio       = 1.0
+    presto_nmos_ull_betaratio      = 1.47
+    relimo_ratio1_a_hci_nmos_ull_10hv = (0.063213703)
+    relimo_ratio1_b_hci_nmos_ull_10hv = (-0.129371941)
+    we                             = (0.5*(wemin_nmos_ull_10hv+w+sqrt((w-wemin_nmos_ull_10hv)*(w-wemin_nmos_ull_10hv))))
+    as_i                           = ((as)+(as==0)*(1-lpe)*(lg2aa_nmos_ull_10hv*we))
+    ps_i                           = ((ps)+(ps==0)*(1-lpe)*(2*(lg2aa_nmos_ull_10hv+we)))
+    ad_i                           = ((ad)+(ad==0)*(1-lpe)*(lg2aa_nmos_ull_10hv*we))
+    pd_i                           = ((pd)+(pd==0)*(1-lpe)*(2*(lg2aa_nmos_ull_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_nmos_ull_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_nmos_ull_10hv/w))
+    liso                           = (laa2iso_left_nmos_ull_10hv+lg2aa_nmos_ull_10hv+l+lg2aa_nmos_ull_10hv+laa2iso_right_nmos_ull_10hv)
+    wiso                           = (wg2iso_nmos_ull_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    nmos_ull_astivfb               = (0.00635*1.4)
+    nmos_ull_bstivfb               = (-2.828e-4)
+    nmos_ull_astinsub              = (1.4e-5)
+    nmos_ull_astiubref             = (-0.0222*1.1)
+    nmos_ull_bstiubref             = (-0.01*1.2)
+    nmos_ull_cstiubref             = (-0.115*(-7))
+    nmos_ull_sapar0                = (0.023+0.035*l)
+    nmos_ull_sapar1                = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+nmos_ull_sapar0*(np-1)+nmos_ull_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+nmos_ull_sapar0*(np-1)+nmos_ull_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((nmos_ull_astivfb+nmos_ull_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+nmos_ull_astinsub*stress)/(1+nmos_ull_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(nmos_ull_astiubref+l*nmos_ull_bstiubref)*stress+(nmos_ull_cstiubref/sqrt(w)))/(1+(nmos_ull_astiubref+l*nmos_ull_bstiubref)*stress0+(nmos_ull_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
