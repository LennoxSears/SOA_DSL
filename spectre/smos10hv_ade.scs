+ aply_fld_cgb_dmy=(wg2aa_di*l+lp2p_d*(wg2aa_di-wnhv2aa_di)/2)*ng_dmy
+ pply_fld_cgb_dmy=(wg2aa_di+2*l+lp2p_d)*ng_dmy
+ cgb_ply_fld_dmy =(cpp_ply_fld*aply_fld_cgb_dmy+pply_fld_cgb_dmy*cfr_ply_fld)


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_pmos45b_sphv_10hv+tc2_ecrit_pmos45b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ tfact_rs=((temp+273.15)/(tnom+273.15))**0.5
+ tfact_tt=((temp+273.15)/(tnom+273.15))**1*(w+1.0)/w

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*-0.185/w)
+ fac_a_ng_vfbl= ((ngeff/(ngeff+2)-2/(2+2))*0.0085*0)
+ fac_r_ng_uo=(1+((ngeff/(ngeff+2)-2/(2+2))*0.168)/(l*w))

//**parameters for noise
+ fac_r_nfalw=(1+15/l**2)

//**thermal res/cap calculation
+    w_heat=w
+    l_heat=(lacts*nse+l*ng+lp2p_d*ndi+lb2b_s*nsi+number_of_body_internal*(lb2b_s_b-lb2b_s))
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pmos45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pmos45b_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff


// parameters for process variations

+ tc_vth_mm = (1+(temp-27)*(-0.663e-3))

+ nsmm_delr_tox_pmos45b_sphv_10hv  = tmp_nsmm_delr_tox_pmos45b_sphv_10hv
+ nsmm_delr_uch_pmos45b_sphv_10hv  = tmp_nsmm_delr_uch_pmos45b_sphv_10hv
+ nsmm_delr_res_pmos45b_sphv_10hv  = tmp_nsmm_delr_res_pmos45b_sphv_10hv
+ nsmm_dela_vfb_pmos45b_sphv_10hv  = tmp_nsmm_dela_vfb_pmos45b_sphv_10hv
+ nsmm_dela_vtw_pmos45b_sphv_10hv  = tmp_nsmm_dela_vtw_pmos45b_sphv_10hv
+ nsmm_delr_nsub_pmos45b_sphv_10hv = tmp_nsmm_delr_nsub_pmos45b_sphv_10hv
+ nsmm_dela_dw_pmos45b_sphv_10hv = tmp_nsmm_dela_dw_pmos45b_sphv_10hv


+ delr_tox_pmos45b_sphv_10hv = (nom_delr_tox_pmos45b_sphv_10hv*(1+sig_delr_tox_pmos45b_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_pmos45b_sphv_10hv*smm_delr_tox_pmos45b_sphv_10hv(l,w,ng)))
//+ delr_tox_pmos45b_sphv_10hv = (nom_delr_tox_pmos45b_sphv_10hv*(1+sig_delr_tox_pmos45b_sphv_10hv*nsig_delr_tox_pmos45b_sphv_10hv+nsmm_delr_tox_pmos45b_sphv_10hv*smm_delr_tox_pmos45b_sphv_10hv(l,w,ng)))
+ delr_uch_pmos45b_sphv_10hv = (nom_delr_uch_pmos45b_sphv_10hv*(1+sig_delr_uch_pmos45b_sphv_10hv*nsig_delr_uch_pmos45b_sphv_10hv+nsmm_delr_uch_pmos45b_sphv_10hv*smm_delr_uch_pmos45b_sphv_10hv(l,w,ng)))
+ delr_res_pmos45b_sphv_10hv = (nom_delr_res_pmos45b_sphv_10hv*(1+sig_delr_res_pmos45b_sphv_10hv*nsig_delr_res_pmos45b_sphv_10hv+nsmm_delr_res_pmos45b_sphv_10hv*smm_delr_res_pmos45b_sphv_10hv(l,w,ng)))
+ dela_vfb_pmos45b_sphv_10hv = (nom_dela_vfb_pmos45b_sphv_10hv+(sig_dela_vfb_pmos45b_sphv_10hv*nsig_dela_vfb_pmos45b_sphv_10hv)+tc_vth_mm*nsmm_dela_vfb_pmos45b_sphv_10hv*smm_dela_vfb_pmos45b_sphv_10hv(l,w,ng))
+ dela_vtw_pmos45b_sphv_10hv = (nom_dela_vtw_pmos45b_sphv_10hv+(sig_dela_vtw_pmos45b_sphv_10hv*nsig_dela_vtw_pmos45b_sphv_10hv)+nsmm_dela_vtw_pmos45b_sphv_10hv*smm_dela_vtw_pmos45b_sphv_10hv(l,w,ng))
+ dela_vtl_pmos45b_sphv_10hv = (nom_dela_vtl_pmos45b_sphv_10hv+(sig_dela_vtl_pmos45b_sphv_10hv*nsig_dela_vtl_pmos45b_sphv_10hv))
+ dela_vtm_pmos45b_sphv_10hv = (nom_dela_vtm_pmos45b_sphv_10hv+(sig_dela_vtm_pmos45b_sphv_10hv*nsig_dela_vtm_pmos45b_sphv_10hv))
+ dela_dl_pmos45b_sphv_10hv = (nom_dela_dl_pmos45b_sphv_10hv+(sig_dela_dl_pmos45b_sphv_10hv*nsig_dela_dl_pmos45b_sphv_10hv))
+ dela_dw_pmos45b_sphv_10hv = (nom_dela_dw_pmos45b_sphv_10hv+(sig_dela_dw_pmos45b_sphv_10hv*nsig_dela_dw_pmos45b_sphv_10hv))
+ dela_dlw_pmos45b_sphv_10hv = (nom_dela_dlw_pmos45b_sphv_10hv+(sig_dela_dlw_pmos45b_sphv_10hv*nsig_dela_dlw_pmos45b_sphv_10hv))
+ delr_nsub_pmos45b_sphv_10hv = (1+nsmm_delr_nsub_pmos45b_sphv_10hv*smm_delr_nsub_pmos45b_sphv_10hv(l,w,ng))


+    delr_cjs_pmos45b_sphv_10hv	=(nom_delr_cjs_pmos45b_sphv_10hv*(1.0+nsig_delr_cjs_pmos45b_sphv_10hv*sig_delr_cjs_pmos45b_sphv_10hv))
+    delr_cjd_pmos45b_sphv_10hv	=(nom_delr_cjd_pmos45b_sphv_10hv*(1.0+nsig_delr_cjd_pmos45b_sphv_10hv*sig_delr_cjd_pmos45b_sphv_10hv))
+    delr_jsideal_pmos45b_sphv_10hv	=(nom_delr_jsideal_pmos45b_sphv_10hv*exp(nsig_delr_jsideal_pmos45b_sphv_10hv*sig_delr_jsideal_pmos45b_sphv_10hv))
+    delr_jdideal_pmos45b_sphv_10hv	=(nom_delr_jdideal_pmos45b_sphv_10hv*exp(nsig_delr_jdideal_pmos45b_sphv_10hv*sig_delr_jdideal_pmos45b_sphv_10hv))
+    delr_jsnonideal_pmos45b_sphv_10hv	=(nom_delr_jsnonideal_pmos45b_sphv_10hv*exp(nsig_delr_jsnonideal_pmos45b_sphv_10hv*sig_delr_jsnonideal_pmos45b_sphv_10hv))
+    delr_jdnonideal_pmos45b_sphv_10hv	=(nom_delr_jdnonideal_pmos45b_sphv_10hv*exp(nsig_delr_jdnonideal_pmos45b_sphv_10hv*sig_delr_jdnonideal_pmos45b_sphv_10hv))
+    delr_jsdideal_pmos45b_sphv_10hv	=(nom_delr_jsdideal_pmos45b_sphv_10hv*exp(nsig_delr_jsdideal_pmos45b_sphv_10hv*sig_delr_jsdideal_pmos45b_sphv_10hv))

+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_pmos45b_sphv_10hv)
+    cox                            = (epsox/tox)
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)

if (ng_dmy >= 2){

cgd_fld_d_dmy (s d) capacitor c=(cgd_ply_fld_dmy)*0.6

cgb_fld_b_dmy (s b) capacitor c=(cgb_ply_fld_dmy)

mamost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

}

cgs_ply_m1_s (g s) capacitor c=(cfr_ply_m1_s)  //constant part for NS cgg
cgs_m1_m2_s (g s) capacitor c=(3.5e-17*l*ng*(1-lpe)+lpe*1e-20)
//cbs_m1_m2_s (b s) capacitor c=(cbs_m2m1_par)

cgd_fld_d (g d) capacitor c=(cgd_ply_fld)*0.6
cgb_fld_b (g b) capacitor c=(cgb_ply_fld)


xcdgoptub_box_sub_10hv (b sub) cdgoptub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

mamost (d g s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

model sphvt_simkit sphvt
+ type           = p
+ tr           = 27
+ vdscale      = (vdscale_pmos45b_sphv_10hv+vdscalel_pmos45b_sphv_10hv/l+vdscalew_pmos45b_sphv_10hv/w+vdscalelw_pmos45b_sphv_10hv/w/l)
+ vdscaleb      = (vdscaleb_pmos45b_sphv_10hv+vdscalebl_pmos45b_sphv_10hv/l)
+ stvdscale      = stvdscale_pmos45b_sphv_10hv
+ ctgo      = ctgo_pmos45b_sphv_10hv
+ ctbo      = ctbo_pmos45b_sphv_10hv
+ stcto      = stcto_pmos45b_sphv_10hv
+ mumb      = mumb_pmos45b_sphv_10hv
+ mumbexp   = mumbexp_pmos45b_sphv_10hv
+ mumbvclmp      = mumbvclmp_pmos45b_sphv_10hv
+ swdrlin           = 0
+ swgeo        	= 1
+ swigate      	  = 0
+ swimpact     	   = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	    = 1
+ swshe        	= selfheat*enable_selfheat
+ swtcec      	  = 1
+ swimpdr      	  = 1
+ swexp        	= 0
+ swdelvtac    	    = 1
+ swnud        	= 0
+ swptest      	  = 0
+ swgedi      	  = 1
+ qmc           = qmc_pmos45b_sphv_10hv
+ lvaro        	= lvaro_pmos45b_sphv_10hv+1e-6*dela_dl_pmos45b_sphv_10hv+1e-6*dela_dlw_pmos45b_sphv_10hv/w
+ lvarl        	= lvarl_pmos45b_sphv_10hv
+ lvarw        	= lvarw_pmos45b_sphv_10hv
+ lap           = lap_pmos45b_sphv_10hv
+ wvaro        	= (wvaro_pmos45b_sphv_10hv+1e-6*dela_dw_pmos45b_sphv_10hv)
+ wvarl        	= (wvarl_pmos45b_sphv_10hv)
+ wvarw        	= (wvarw_pmos45b_sphv_10hv)
+ wot           = wot_pmos45b_sphv_10hv
+ dlq           = dlq_pmos45b_sphv_10hv
+ dwq           = dwq_pmos45b_sphv_10hv
+ vfbo           = (vfbo_pmos45b_sphv_10hv+dela_vfb_pmos45b_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pmos45b_vthratio)
+ vfbl           = (vfbl_pmos45b_sphv_10hv+fac_a_ng_vfbl+dela_vtl_pmos45b_sphv_10hv)
+ vfbw           = (vfbw_pmos45b_sphv_10hv+dela_vtw_pmos45b_sphv_10hv)
+ vfblw        	= (vfblw_pmos45b_sphv_10hv+dela_vtm_pmos45b_sphv_10hv)
+ stvfbo       	 = stvfbo_pmos45b_sphv_10hv
+ stvfbl       	 = stvfbl_pmos45b_sphv_10hv
+ stvfbw       	 = stvfbw_pmos45b_sphv_10hv
+ stvfblw      	  = stvfblw_pmos45b_sphv_10hv
+ toxo           = toxo_pmos45b_sphv_10hv*delr_tox_pmos45b_sphv_10hv
+ epsroxo      	  = epsroxo_pmos45b_sphv_10hv
+ nsubo        	= nsubo_pmos45b_sphv_10hv*delr_nsub_pmos45b_sphv_10hv*(1-log(l/30)*0.025)
+ nsubw        	= nsubw_pmos45b_sphv_10hv
+ wseg           = wseg_pmos45b_sphv_10hv
+ npck           = npck_pmos45b_sphv_10hv
+ npckw        	= npckw_pmos45b_sphv_10hv
+ wsegp        	= wsegp_pmos45b_sphv_10hv
+ lpck           = lpck_pmos45b_sphv_10hv
+ lpckw        	= lpckw_pmos45b_sphv_10hv
+ fol1           = fol1_pmos45b_sphv_10hv
+ fol2           = fol2_pmos45b_sphv_10hv
+ facneffaco   	     = facneffaco_pmos45b_sphv_10hv
+ facneffacl   	     = facneffacl_pmos45b_sphv_10hv
+ facneffacw   	     = facneffacw_pmos45b_sphv_10hv
+ facneffaclw  	      = facneffaclw_pmos45b_sphv_10hv
+ gfacnudo     	   = gfacnudo_pmos45b_sphv_10hv
+ gfacnudl     	   = gfacnudl_pmos45b_sphv_10hv
+ gfacnudlexp  	      = gfacnudlexp_pmos45b_sphv_10hv
+ gfacnudw     	   = gfacnudw_pmos45b_sphv_10hv
+ gfacnudlw    	    = gfacnudlw_pmos45b_sphv_10hv
+ vsbnudo      	  = vsbnudo_pmos45b_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_pmos45b_sphv_10hv
+ vnsubo       	 = vnsubo_pmos45b_sphv_10hv
+ nslpo        	= nslpo_pmos45b_sphv_10hv
+ dnsubo       	 = dnsubo_pmos45b_sphv_10hv
+ dphibo       	 = dphibo_pmos45b_sphv_10hv
+ dphibl       	 = dphibl_pmos45b_sphv_10hv
+ dphiblexp    	    = dphiblexp_pmos45b_sphv_10hv
+ dphibw       	 = (dphibw_pmos45b_sphv_10hv)
+ dphiblw      	  = (dphiblw_pmos45b_sphv_10hv)
+ delvtaco     	   = delvtaco_pmos45b_sphv_10hv
+ delvtacl     	   = delvtacl_pmos45b_sphv_10hv
+ delvtaclexp  	      = delvtaclexp_pmos45b_sphv_10hv
+ delvtacw     	   = delvtacw_pmos45b_sphv_10hv
+ delvtaclw    	    = delvtaclw_pmos45b_sphv_10hv
+ npo           = npo_pmos45b_sphv_10hv
+ npl           = npl_pmos45b_sphv_10hv
+ cto           = cto_pmos45b_sphv_10hv
+ ctl           = ctl_pmos45b_sphv_10hv
+ ctlexp       	 = ctlexp_pmos45b_sphv_10hv
+ ctw           = ctw_pmos45b_sphv_10hv
+ ctlw           = ctlw_pmos45b_sphv_10hv
+ toxovo       	 = toxovo_pmos45b_sphv_10hv*delr_tox_pmos45b_sphv_10hv
+ toxovdo      	  = toxovdo_pmos45b_sphv_10hv*delr_tox_pmos45b_sphv_10hv
+ lov           = lov_pmos45b_sphv_10hv
+ dlovd        	= dlovd_pmos45b_sphv_10hv
+ novo           = novo_pmos45b_sphv_10hv
+ novdo        	= novdo_pmos45b_sphv_10hv
+ cfl           = cfl_pmos45b_sphv_10hv
+ cflexp       	 = cflexp_pmos45b_sphv_10hv
+ cfw           = cfw_pmos45b_sphv_10hv
+ cfbo           = cfbo_pmos45b_sphv_10hv
+ uo           = (uo_pmos45b_sphv_10hv*delr_uch_pmos45b_sphv_10hv*delr_u0_relimo*fac_r_ng_uo)
+ fbet1        	= fbet1_pmos45b_sphv_10hv
+ fbet1w       	 = fbet1w_pmos45b_sphv_10hv
+ lp1           = lp1_pmos45b_sphv_10hv
+ lp1w           = lp1w_pmos45b_sphv_10hv
+ fbet2        	= fbet2_pmos45b_sphv_10hv
+ lp2           = lp2_pmos45b_sphv_10hv
+ betw1        	= betw1_pmos45b_sphv_10hv
+ betw2        	= betw2_pmos45b_sphv_10hv
+ wbet           = wbet_pmos45b_sphv_10hv
+ stbeto       	 = stbeto_pmos45b_sphv_10hv
+ stbetl       	 = stbetl_pmos45b_sphv_10hv
+ stbetw       	 = stbetw_pmos45b_sphv_10hv
+ stbetlw      	  = stbetlw_pmos45b_sphv_10hv
+ mueo           = (mueo_pmos45b_sphv_10hv)
+ muew           = muew_pmos45b_sphv_10hv
+ stmueo       	 = stmueo_pmos45b_sphv_10hv
+ themuo       	 = themuo_pmos45b_sphv_10hv
+ stthemuo     	   = stthemuo_pmos45b_sphv_10hv
+ cso           = cso_pmos45b_sphv_10hv
+ csl           = csl_pmos45b_sphv_10hv
+ cslexp       	 = cslexp_pmos45b_sphv_10hv
+ csw           = csw_pmos45b_sphv_10hv
+ cslw           = cslw_pmos45b_sphv_10hv
+ stcso        	= stcso_pmos45b_sphv_10hv
+ xcoro        	= xcoro_pmos45b_sphv_10hv
+ xcorl        	= xcorl_pmos45b_sphv_10hv
+ xcorw        	= xcorw_pmos45b_sphv_10hv
+ xcorlw       	 = xcorlw_pmos45b_sphv_10hv
+ stxcoro      	  = stxcoro_pmos45b_sphv_10hv
+ fetao        	= fetao_pmos45b_sphv_10hv
+ rsw1           = rsw1_pmos45b_sphv_10hv
+ rsw2           = rsw2_pmos45b_sphv_10hv
+ strso        	= strso_pmos45b_sphv_10hv
+ rsbo           = rsbo_pmos45b_sphv_10hv
+ rsgo           = rsgo_pmos45b_sphv_10hv
+ thesato      	  = (thesato_pmos45b_sphv_10hv)
+ thesatl      	  = thesatl_pmos45b_sphv_10hv
+ thesatlexp   	     = thesatlexp_pmos45b_sphv_10hv
+ thesatw      	  = (thesatw_pmos45b_sphv_10hv)
+ thesatlw     	   = thesatlw_pmos45b_sphv_10hv
+ stthesato    	    = stthesato_pmos45b_sphv_10hv
+ stthesatl    	    = stthesatl_pmos45b_sphv_10hv
+ stthesatw    	    = stthesatw_pmos45b_sphv_10hv
+ stthesatlw   	     = stthesatlw_pmos45b_sphv_10hv
+ thesatbo     	   = thesatbo_pmos45b_sphv_10hv
+ thesatgo     	   = thesatgo_pmos45b_sphv_10hv
+ thesatgl     	   = thesatgl_pmos45b_sphv_10hv
+ thesatgw     	   = thesatgw_pmos45b_sphv_10hv
+ axo           = axo_pmos45b_sphv_10hv
+ axl           = axl_pmos45b_sphv_10hv
+ alpl           = alpl_pmos45b_sphv_10hv
+ alplexp      	  = alplexp_pmos45b_sphv_10hv
+ alpw           = alpw_pmos45b_sphv_10hv
+ alp1l1       	 = alp1l1_pmos45b_sphv_10hv
+ alp1lexp     	   = alp1lexp_pmos45b_sphv_10hv
+ alp1l2       	 = alp1l2_pmos45b_sphv_10hv
+ alp1w        	= alp1w_pmos45b_sphv_10hv
+ alp2l1       	 = alp2l1_pmos45b_sphv_10hv
+ alp2lexp     	   = alp2lexp_pmos45b_sphv_10hv
+ alp2l2       	 = alp2l2_pmos45b_sphv_10hv
+ alp2w        	= alp2w_pmos45b_sphv_10hv
+ vpo           = vpo_pmos45b_sphv_10hv
+ a1o           = a1o_pmos45b_sphv_10hv
+ a1l           = a1l_pmos45b_sphv_10hv
+ a1w           = a1w_pmos45b_sphv_10hv
+ a2o           = a2o_pmos45b_sphv_10hv
+ sta2o        	= sta2o_pmos45b_sphv_10hv
+ a3o           = a3o_pmos45b_sphv_10hv
+ a3l           = a3l_pmos45b_sphv_10hv
+ a3w           = a3w_pmos45b_sphv_10hv
+ a4o           = a4o_pmos45b_sphv_10hv
+ a4l           = a4l_pmos45b_sphv_10hv
+ a4w           = a4w_pmos45b_sphv_10hv
+ gcoo           = gcoo_pmos45b_sphv_10hv
+ iginvlw      	  = iginvlw_pmos45b_sphv_10hv
+ igovw        	= igovw_pmos45b_sphv_10hv
+ igovdw       	 = igovdw_pmos45b_sphv_10hv
+ stigo        	= stigo_pmos45b_sphv_10hv
+ gc2o           = gc2o_pmos45b_sphv_10hv
+ gc3o           = gc3o_pmos45b_sphv_10hv
+ chibo        	= chibo_pmos45b_sphv_10hv
+ agidlw       	 = agidlw_pmos45b_sphv_10hv
+ agidldw      	  = agidldw_pmos45b_sphv_10hv
+ bgidlo       	 = bgidlo_pmos45b_sphv_10hv
+ bgidldo      	  = bgidldo_pmos45b_sphv_10hv
+ stbgidlo     	   = stbgidlo_pmos45b_sphv_10hv
+ stbgidldo    	    = stbgidldo_pmos45b_sphv_10hv
+ cgidlo       	 = cgidlo_pmos45b_sphv_10hv
+ cgidldo      	  = cgidldo_pmos45b_sphv_10hv
+ cgbovl       	 = cgbovl_pmos45b_sphv_10hv
+ cfrw           = cfrw_pmos45b_sphv_10hv
+ cfrdw        	= cfrdw_pmos45b_sphv_10hv
+ fnto           = fnto_pmos45b_sphv_10hv
+ nfalw        	= nfalw_pmos45b_sphv_10hv*fac_r_nfalw
+ nfblw        	= nfblw_pmos45b_sphv_10hv
+ nfclw        	= nfclw_pmos45b_sphv_10hv
+ efo           = efo_pmos45b_sphv_10hv
+ lintnoi      	  = lintnoi_pmos45b_sphv_10hv
+ alpnoi       	 = alpnoi_pmos45b_sphv_10hv
+ kvthoweo     	   = kvthoweo_pmos45b_sphv_10hv
+ kvthowel     	   = kvthowel_pmos45b_sphv_10hv
+ kvthowew     	   = kvthowew_pmos45b_sphv_10hv
+ kvthowelw    	    = kvthowelw_pmos45b_sphv_10hv
+ kuoweo       	 = kuoweo_pmos45b_sphv_10hv
+ kuowel       	 = kuowel_pmos45b_sphv_10hv
+ kuowew       	 = kuowew_pmos45b_sphv_10hv
+ kuowelw      	  = kuowelw_pmos45b_sphv_10hv
+ rgo           = rgo_pmos45b_sphv_10hv
+ rsh           = rsh_pmos45b_sphv_10hv
+ rbulko       	 = rbulko_pmos45b_sphv_10hv
+ rwello       	 = rwello_pmos45b_sphv_10hv
+ rjunso       	 = rjunso_pmos45b_sphv_10hv/(w+dwrjunso_pmos45b_sphv_10hv)*tfact_rs
+ rjundo       	 = rjundo_pmos45b_sphv_10hv/(w+dwrjundo_pmos45b_sphv_10hv)*sqrt(l)/(sqrt(l)+1.5)*tfact_rs
+ rint           = rint_pmos45b_sphv_10hv
+ rvpoly       	 = rvpoly_pmos45b_sphv_10hv
+ rshg           = rshg_pmos45b_sphv_10hv
+ dlsil        	= dlsil_pmos45b_sphv_10hv
+ saref        	= saref_pmos45b_sphv_10hv
+ sbref        	= sbref_pmos45b_sphv_10hv
+ wlod           = wlod_pmos45b_sphv_10hv
+ kuo           = kuo_pmos45b_sphv_10hv
+ kvsat        	= kvsat_pmos45b_sphv_10hv
+ tkuo           = tkuo_pmos45b_sphv_10hv
+ lkuo           = lkuo_pmos45b_sphv_10hv
+ wkuo           = wkuo_pmos45b_sphv_10hv
+ pkuo           = pkuo_pmos45b_sphv_10hv
+ llodkuo      	  = llodkuo_pmos45b_sphv_10hv
+ wlodkuo      	  = wlodkuo_pmos45b_sphv_10hv
+ kvtho        	= kvtho_pmos45b_sphv_10hv
+ lkvtho       	 = lkvtho_pmos45b_sphv_10hv
+ wkvtho       	 = wkvtho_pmos45b_sphv_10hv
+ pkvtho       	 = pkvtho_pmos45b_sphv_10hv
+ llodvth      	  = llodvth_pmos45b_sphv_10hv
+ wlodvth      	  = wlodvth_pmos45b_sphv_10hv
+ stetao       	 = stetao_pmos45b_sphv_10hv
+ lodetao      	  = lodetao_pmos45b_sphv_10hv
+ scref        	= scref_pmos45b_sphv_10hv
+ web           = web_pmos45b_sphv_10hv
+ wec           = wec_pmos45b_sphv_10hv
+ adr1o        	= adr1o_pmos45b_sphv_10hv
+ adr1l        	= adr1l_pmos45b_sphv_10hv
+ adr1w        	= adr1w_pmos45b_sphv_10hv
+ adr2o        	= adr2o_pmos45b_sphv_10hv
+ stadr2o      	  = stadr2o_pmos45b_sphv_10hv
+ adr3o        	= adr3o_pmos45b_sphv_10hv
+ adr3l        	= adr3l_pmos45b_sphv_10hv
+ adr3w        	= adr3w_pmos45b_sphv_10hv
+ adr4o        	= adr4o_pmos45b_sphv_10hv
+ adr4l        	= adr4l_pmos45b_sphv_10hv
+ adr4w        	= adr4w_pmos45b_sphv_10hv
+ adr5o        	= adr5o_pmos45b_sphv_10hv
+ adr5l        	= adr5l_pmos45b_sphv_10hv
+ adr5w        	= adr5w_pmos45b_sphv_10hv
+ bidr1o       	 = bidr1o_pmos45b_sphv_10hv
+ bidr1l       	 = bidr1l_pmos45b_sphv_10hv
+ bidr1w       	 = bidr1w_pmos45b_sphv_10hv
+ bidr2o       	 = bidr2o_pmos45b_sphv_10hv
+ bidr2w       	 = bidr2w_pmos45b_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	= 0
+ strtho       	 = strtho_pmos45b_sphv_10hv
+ strthao       	 = strthao_pmos45b_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	= 0
+ rshldd       	 = (rshldd_pmos45b_sphv_10hv*fac_r_ng_rshldd*delr_res_pmos45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pmos45b_ronratio))
+ xw           = (xw_pmos45b_sphv_10hv)
+ nwxw           = (nwxw_pmos45b_sphv_10hv)
+ xl           = xl_pmos45b_sphv_10hv
+ xlw           = xlw_pmos45b_sphv_10hv
+ dxlsat       	 = dxlsat_pmos45b_sphv_10hv
+ nst           = nst_pmos45b_sphv_10hv
+ ats           = ats_pmos45b_sphv_10hv
+ dfinf        	= dfinf_pmos45b_sphv_10hv
+ dfw           = dfw_pmos45b_sphv_10hv
+ dfl           = dfl_pmos45b_sphv_10hv
+ dflw           = dflw_pmos45b_sphv_10hv
+ dp           = dp_pmos45b_sphv_10hv
+ ecrit        	= ecrit_pmos45b_sphv_10hv*tfact_ecrit*(1+1.0/w)
+ ecorn        	= ecorn_pmos45b_sphv_10hv*tfact_ecrit*(1+1.0/w)
+ xvsat           = xvsat_pmos45b_sphv_10hv
+ du           = du_pmos45b_sphv_10hv
+ tc1           = tc1_pmos45b_sphv_10hv
+ tc2           = tc2_pmos45b_sphv_10hv
+ tc1l           = tc1l_pmos45b_sphv_10hv
+ tc2l           = tc2l_pmos45b_sphv_10hv
+ tc1w           = tc1w_pmos45b_sphv_10hv
+ tc2w           = tc2w_pmos45b_sphv_10hv
+ theacc       	 = theacc_pmos45b_sphv_10hv
+ theacc2      	  = theacc2_pmos45b_sphv_10hv
+ rva           = rva_pmos45b_sphv_10hv
+ dta           = dta_pmos45b_sphv_10hv
+ //*** junc cap parameters for s/b ***
+ //in ams2p0 synced cjarea, cjlsti and cjlgat three paramters
+ cjarea      	 =	cjarea_pmos45b_sphv_10hv*delr_cjs_pmos45b_sphv_10hv
+ cjlsti      	 =	0
+ cjlgat      	 =	cjarea_pmos45b_sphv_10hv*djunc*delr_cjs_pmos45b_sphv_10hv*0
+ vbiarea     	  =	vbiarea_pmos45b_sphv_10hv
+ vbisti      	 =	vbiarea_pmos45b_sphv_10hv
+ vbigat      	 =	vbiarea_pmos45b_sphv_10hv
+ parea       	=	parea_pmos45b_sphv_10hv
+ psti           =	parea_pmos45b_sphv_10hv
+ pgat           =	parea_pmos45b_sphv_10hv
+ //*** ideal current parameters for s/b ***
+ is1area 	 	  = is1area_pmos45b_sphv_10hv*delr_jsideal_pmos45b_sphv_10hv
+ stis1area 	 	  = stis1area_pmos45b_sphv_10hv
+ n1area 		 	  = n1area_pmos45b_sphv_10hv
+ is1lsti 	 	  = is1area_pmos45b_sphv_10hv*djunc*delr_jsideal_pmos45b_sphv_10hv*0
+ stis1sti	 	  = stis1area_pmos45b_sphv_10hv
+ n1sti 		 	  = n1area_pmos45b_sphv_10hv
+ is1lgat 	 	  = is1area_pmos45b_sphv_10hv*djunc*delr_jsideal_pmos45b_sphv_10hv*0
+ stis1gat 	 	  = stis1area_pmos45b_sphv_10hv
+ n1gat 		 	  = n1area_pmos45b_sphv_10hv
+ //*** non-ideal current parameters for s/b ***
+ is2area   		 = is2area_pmos45b_sphv_10hv*delr_jsnonideal_pmos45b_sphv_10hv
+ stis2area 		 = stis2area_pmos45b_sphv_10hv
+ n2area 	  		 = n2area_pmos45b_sphv_10hv
+ is2lsti   		 = is2area_pmos45b_sphv_10hv*djunc*delr_jsnonideal_pmos45b_sphv_10hv*0
+ stis2sti  		 = stis2area_pmos45b_sphv_10hv
+ n2sti 	  		 = n2area_pmos45b_sphv_10hv
+ is2lgat   		 = is2area_pmos45b_sphv_10hv*djunc*delr_jsnonideal_pmos45b_sphv_10hv*0
+ stis2gat  		 = stis2area_pmos45b_sphv_10hv
+ n2gat 	  		 = n2area_pmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for s/b ***
+ irarea 	 		  = irarea_pmos45b_sphv_10hv*delr_jsnonideal_pmos45b_sphv_10hv
+ stirarea 		  = stirarea_pmos45b_sphv_10hv
+ nrarea 	 		  = nrarea_pmos45b_sphv_10hv
+ irlsti 	 		  = irarea_pmos45b_sphv_10hv*djunc*delr_jsnonideal_pmos45b_sphv_10hv
+ stirsti  		  = stirarea_pmos45b_sphv_10hv
+ nrsti 	 		  = nrarea_pmos45b_sphv_10hv
+ irlgat 	 		  = irarea_pmos45b_sphv_10hv*djunc*delr_jsnonideal_pmos45b_sphv_10hv*0
+ stirgat  		  = stirarea_pmos45b_sphv_10hv
+ nrgat 	 		  = nrarea_pmos45b_sphv_10hv
+ // *** rr for s/b ***
+ ttarea   	 = ttarea_pmos45b_sphv_10hv
+ ttlsti   	 = ttlsti_pmos45b_sphv_10hv
+ ttlgat   	 = ttlgat_pmos45b_sphv_10hv
+ //*** junc cap parameters for d/b ***
+ cjaread    	  =	  cjaread_pmos45b_sphv_10hv*delr_cjd_pmos45b_sphv_10hv
+ cjlstid    	  =	  cjlstid_pmos45b_sphv_10hv*delr_cjd_pmos45b_sphv_10hv
+ cjlgatd    	  =	  cjaread_pmos45b_sphv_10hv*djunc*delr_cjd_pmos45b_sphv_10hv
+ vbiaread   	   =	  vbiaread_pmos45b_sphv_10hv
+ vbistid    	  =	  vbistid_pmos45b_sphv_10hv
+ vbigatd    	  =	  vbigatd_pmos45b_sphv_10hv
+ paread     	 =	  paread_pmos45b_sphv_10hv
+ pstid      	=	  paread_pmos45b_sphv_10hv
+ pgatd      	=	  paread_pmos45b_sphv_10hv
+ //*** ideal current parameters for d/b ***
+ is1aread   		 = is1aread_pmos45b_sphv_10hv*delr_jdideal_pmos45b_sphv_10hv
+ stis1aread 		 = stis1aread_pmos45b_sphv_10hv
+ n1aread    		 = n1aread_pmos45b_sphv_10hv
+ is1lstid   		 = is1aread_pmos45b_sphv_10hv*djunc*delr_jdideal_pmos45b_sphv_10hv*0
+ stis1stid  		 = stis1aread_pmos45b_sphv_10hv
+ n1stid 	   		 = n1aread_pmos45b_sphv_10hv
+ is1lgatd   		 = is1aread_pmos45b_sphv_10hv*djunc*delr_jdideal_pmos45b_sphv_10hv
+ stis1gatd  		 = stis1aread_pmos45b_sphv_10hv
+ n1gatd 	   		 = n1aread_pmos45b_sphv_10hv
+ //*** non-ideal current parameters for d/b ***
+ is2aread   		  = is2aread_pmos45b_sphv_10hv*delr_jdnonideal_pmos45b_sphv_10hv
+ stis2aread 		  = stis2aread_pmos45b_sphv_10hv
+ n2aread    		  = n2aread_pmos45b_sphv_10hv
+ is2lstid   		  = is2aread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv*0
+ stis2stid  		  = stis2aread_pmos45b_sphv_10hv
+ n2stid 	   		  = n2aread_pmos45b_sphv_10hv
+ is2lgatd   		  = is2aread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv
+ stis2gatd  		  = stis2aread_pmos45b_sphv_10hv
+ n2gatd 	   		  = n2aread_pmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d/b ***
+ iraread   		  = iraread_pmos45b_sphv_10hv*delr_jdnonideal_pmos45b_sphv_10hv
+ stiraread 		  = stiraread_pmos45b_sphv_10hv
+ nraread   		  = nraread_pmos45b_sphv_10hv
+ irlstid   		  = iraread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv*0
+ stirstid  		  = stiraread_pmos45b_sphv_10hv
+ nrstid 	  		  = nraread_pmos45b_sphv_10hv
+ irlgatd   		  = iraread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv
+ stirgatd  		  = stiraread_pmos45b_sphv_10hv
+ nrgatd 	  		  = nraread_pmos45b_sphv_10hv
+ // *** rr  for d/b ***
+ ttaread  	  = ttaread_pmos45b_sphv_10hv*tfact_tt
+ ttlstid  	  = ttlstid_pmos45b_sphv_10hv*tfact_tt
+ ttlgatd  	  = ttlgatd_pmos45b_sphv_10hv*tfact_tt
+ //*** junc cap parameters for d2/b ***
+ cjaread2   	   =	      cjaread_pmos45b_sphv_10hv*delr_cjd_pmos45b_sphv_10hv
+ cjlstid2   	   =	      cjlstid_pmos45b_sphv_10hv*delr_cjd_pmos45b_sphv_10hv
+ vbiaread2  	    =	      vbiaread_pmos45b_sphv_10hv
+ vbistid2   	   =	      vbiaread_pmos45b_sphv_10hv
+ paread2    	  =	      paread_pmos45b_sphv_10hv
+ pstid2     	 =	      paread_pmos45b_sphv_10hv
+ //*** ideal current parameters for d2/b ***
+ is1aread2   		  = is1aread_pmos45b_sphv_10hv*delr_jdideal_pmos45b_sphv_10hv
+ stis1aread2 		  = stis1aread_pmos45b_sphv_10hv
+ n1aread2    		  = n1aread_pmos45b_sphv_10hv
+ is1lstid2   		  = is1aread_pmos45b_sphv_10hv*djunc*delr_jdideal_pmos45b_sphv_10hv*0
+ stis1stid2  		  = stis1aread_pmos45b_sphv_10hv
+ n1stid2     		  = n1aread_pmos45b_sphv_10hv
+ //*** non-ideal current parameters for d2/b ***
+ is2aread2   		  = is2aread_pmos45b_sphv_10hv*delr_jdnonideal_pmos45b_sphv_10hv
+ stis2aread2 		  = stis2aread_pmos45b_sphv_10hv
+ n2aread2    		  = n2aread_pmos45b_sphv_10hv
+ is2lstid2   		  = is2aread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv*0
+ stis2stid2  		  = stis2aread_pmos45b_sphv_10hv
+ n2stid2     		  = n2aread_pmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d2/b ***
+ iraread2   		  = iraread_pmos45b_sphv_10hv*delr_jdnonideal_pmos45b_sphv_10hv
+ stiraread2 		  = stiraread_pmos45b_sphv_10hv
+ nraread2   		  = nraread_pmos45b_sphv_10hv
+ irlstid2   		  = iraread_pmos45b_sphv_10hv*djunc*delr_jdnonideal_pmos45b_sphv_10hv*0
+ stirstid2  		  = stiraread_pmos45b_sphv_10hv
+ nrstid2    		  = nraread_pmos45b_sphv_10hv
+ // *** transit time  for d2/b ***
+ ttaread2 	   = ttaread2_pmos45b_sphv_10hv*tfact_tt
+ ttlstid2 	   = ttlstid2_pmos45b_sphv_10hv*tfact_tt
+ // *** other temp dependence ***
+ eais1area     = eais1area_pmos45b_sphv_10hv
+ eais2area     = eais2area_pmos45b_sphv_10hv
+ eairarea      = eairarea_pmos45b_sphv_10hv
+ eais1sti      = eais1sti_pmos45b_sphv_10hv
+ eais2sti      = eais2sti_pmos45b_sphv_10hv
+ eairsti       = eairsti_pmos45b_sphv_10hv
+ eais1gat      = eais1gat_pmos45b_sphv_10hv
+ eais2gat      = eais2gat_pmos45b_sphv_10hv
+ eairgat       = eairgat_pmos45b_sphv_10hv
+ eais1aread    = eais1aread_pmos45b_sphv_10hv
+ eais2aread    = eais2aread_pmos45b_sphv_10hv
+ eairaread     = eairaread_pmos45b_sphv_10hv
+ eais1stid     = eais1stid_pmos45b_sphv_10hv
+ eais2stid     = eais2stid_pmos45b_sphv_10hv
+ eairstid      = eairstid_pmos45b_sphv_10hv
+ eais1gatd     = eais1gatd_pmos45b_sphv_10hv
+ eais2gatd     = eais2gatd_pmos45b_sphv_10hv
+ eairgatd      = eairgatd_pmos45b_sphv_10hv
+ eais1aread2   = eais1aread2_pmos45b_sphv_10hv
+ eais2aread2   = eais2aread2_pmos45b_sphv_10hv
+ eairaread2    = eairaread2_pmos45b_sphv_10hv
+ eais1stid2    = eais1stid2_pmos45b_sphv_10hv
+ eais2stid2    = eais2stid2_pmos45b_sphv_10hv
+ eairstid2     = eairstid2_pmos45b_sphv_10hv
+ ikfarea               = ikfarea_pmos45b_sphv_10hv
+ ikflsti               = ikfarea_pmos45b_sphv_10hv*djunc
+ ikflgat               = ikfarea_pmos45b_sphv_10hv*djunc
+ stikfarea              = stikfarea_pmos45b_sphv_10hv
+ stikfsti              = stikfarea_pmos45b_sphv_10hv
+ stikfgat              = stikfarea_pmos45b_sphv_10hv
+ ikfaread              = ikfaread_pmos45b_sphv_10hv*(w/(w+dwikfaread_pmos45b_sphv_10hv))
+ ikflstid              = ikfaread_pmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos45b_sphv_10hv))
+ ikflgatd              = ikfaread_pmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos45b_sphv_10hv))
+ ikfaread2             = ikfaread_pmos45b_sphv_10hv*(w/(w+dwikfaread_pmos45b_sphv_10hv))
+ ikflstid2             = ikfaread_pmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos45b_sphv_10hv))
+ stikfaread             = stikfaread_pmos45b_sphv_10hv
+ stikfstid             = stikfaread_pmos45b_sphv_10hv
+ stikfgatd             = stikfaread_pmos45b_sphv_10hv
+ stikfaread2            = stikfaread_pmos45b_sphv_10hv
+ stikfstid2            = stikfaread_pmos45b_sphv_10hv





include "./smos10hv_ade_dfrt.scs" section=pmos45b_10hv_dfrt
ends

// pmoshs45b_10hv



//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt pmoshs45b_10hv (d g s b sub)
parameters
+ l=1.0
+ w=1.8
+ ng=2
+ lpe=0
+ soa=1
+ selfheat=1
+ sti_dummy=0

parameters
+ mode_rthcth=1
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pmoshs45b_vthratio  = 1.0*(0.0026*1/l+0.9911)
+    presto_pmoshs45b_ronratio  = 0.01/1.0/(0.3*l+1.0)

+ nde=(fmod(ng,2))
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)         //treat two adjacent sources separated by body as one
+ ndi=(nd-nde)
+ nsi=(ns-nse)          //treat two adjacent sources separated by body as one

//dummy parameters
+ ng_dmy=(2*sti_dummy)
+ ngeff=(ng+ng_dmy)
+ ndi_eff=(ngeff/2)
+ nsi_eff=((ngeff-2)/2)

//calculation of junction instance parameters
+    lacts    = 0.375
+    ldr1     = 0.65
+    lsplit   = 0.35
+    ldrift   = 1.7
+    lactd    = 0.69
+    wdrift   = (w)
+    wnwx   = 1.11   //active to DT inner
+    as_i=(lacts*w)
+    ps_i=2*(lacts+w)
+    ad_i=((ldr1+lsplit)+ldrift/2)*(w+2*wnwx)
+    pd_i=(w+2*wnwx) //no horizonal junction edge due to DT
+    ad2_i=(lactd/2+ldrift/2)*(w+2*wnwx)
+    pd2_i=(0)  //no horizonal junction edge due to DT

//calculation for nbl/psub junction
+    lg2pepi_s    = 2.175  // dt to poly end
+    lp2p_d    =  6.09 	   // drain nhv end to nhv end
+    lb2b_s    = 1.8	   // poly end to ploy at internal source
+    wg2pepi    = 1.11     // width active side to DT interal edge
+    xbody                       = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody                       = (wg2pepi*2+w)
+    abody                       = (xbody*ybody)
+    pbody                       = (2*(xbody+ybody))

//calculation of parasitic cap cbs_m2m1 (m1-m2 overlap vertical part)
+    length_cbs_m2m1                = 0.165
+    width_cbs_m2m1                 = (w-0.05*2)
+    area_cbs_m2m1                  = (ngeff*length_cbs_m2m1*width_cbs_m2m1)
+    perim_cbs_m2m1                 = (ngeff*2*(length_cbs_m2m1+width_cbs_m2m1)-nsi_eff*2*width_cbs_m2m1)
+    cbs_m2m1_par    = ((1-lpe)*(cfr_m2_m1*perim_cbs_m2m1+cpp_m2_m1*area_cbs_m2m1)+lpe*1e-20)

//calculation of parasitic cap cgd_m1m2 (m1-m2 no overlap in pcell)

//calculation of parasitic cap cgs_m1m2 (m1-m2 no overlap)

//**** calculation for m1 to poly gate capacitance, Cgs, unit is micron ********
+ cfr_ply_m1_s         = w*nom_cfr_m1_ply*ng*(1-lpe)+lpe*1e-19


//calculation of poly over field oxide parasitic cap:cgd_ply_fld
+   lnhv2ply_d=1.9   //nhv to poly edge
+   wg2aa_di=0.6*2
+   wae2plye_isti_g=0.365*2
+   lpoly_hole=0.7
+   aply_fld_cgd=(lnhv2ply_d*(wg2aa_di+w)-(wae2plye_isti_g+w)*lpoly_hole-ldr1*w)*ng
+   pply_fld_cgd= (2*lnhv2ply_d+ wg2aa_di+w+2*lpoly_hole+2*wae2plye_isti_g+w)*ng
+   cgd_ply_fld=aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld

//cgd_ply_fld for dummy
+   aply_fld_cgd_dmy=(lnhv2ply_d*(wg2aa_di+w)-(wae2plye_isti_g+w)*lpoly_hole-ldr1*w)*ng_dmy
+   pply_fld_cgd_dmy= (2*lnhv2ply_d+ wg2aa_di+w+2*lpoly_hole+2*wae2plye_isti_g+w)*ng_dmy
+   cgd_ply_fld_dmy=aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld


//calculation of poly over field oxide parasitic cal:cap cgb_ply_fld
+ aply_fld_cgb=(wg2aa_di*l )*ng
+ pply_fld_cgb= (wg2aa_di+2*l)*ng
+ cgb_ply_fld =(cpp_ply_fld*aply_fld_cgb+pply_fld_cgb*cfr_ply_fld)


//cgb_ply_fld for dummy
+ aply_fld_cgb_dmy=(wg2aa_di*l )*ng_dmy
+ pply_fld_cgb_dmy= (wg2aa_di+2*l)*ng_dmy
+ cgb_ply_fld_dmy =(cpp_ply_fld*aply_fld_cgb_dmy+pply_fld_cgb_dmy*cfr_ply_fld)


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_pmoshs45b_sphv_10hv+tc2_ecrit_pmoshs45b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ tfact_rs=((temp+273.15)/(tnom+273.15))**0.5
+ tfact_tt=((temp+273.15)/(tnom+273.15))**1

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*-0.185/w)
+ fac_a_ng_vfbl= ((ngeff/(ngeff+2)-2/(2+2))*0.0085)
+ fac_r_ng_uo=(1+((ngeff/(ngeff+2)-2/(2+2))*0.168)/(l*w))

//**parameters for noise
+ fac_r_nfalw=(1+15/l**2)

//**thermal res/cap calculation
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi+lacts*nse)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pmoshs45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pmoshs45b_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff


// parameters for process variations

+ tc_vth_mm = (1+(temp-27)*(-0.663e-3))

+ nsmm_delr_tox_pmoshs45b_sphv_10hv  = tmp_nsmm_delr_tox_pmoshs45b_sphv_10hv
+ nsmm_delr_uch_pmoshs45b_sphv_10hv  = tmp_nsmm_delr_uch_pmoshs45b_sphv_10hv
+ nsmm_delr_res_pmoshs45b_sphv_10hv  = tmp_nsmm_delr_res_pmoshs45b_sphv_10hv
+ nsmm_dela_vfb_pmoshs45b_sphv_10hv  = tmp_nsmm_dela_vfb_pmoshs45b_sphv_10hv
+ nsmm_dela_vtw_pmoshs45b_sphv_10hv  = tmp_nsmm_dela_vtw_pmoshs45b_sphv_10hv
+ nsmm_delr_nsub_pmoshs45b_sphv_10hv = tmp_nsmm_delr_nsub_pmoshs45b_sphv_10hv
+ nsmm_dela_dw_pmoshs45b_sphv_10hv = tmp_nsmm_dela_dw_pmoshs45b_sphv_10hv


+ delr_tox_pmoshs45b_sphv_10hv = (nom_delr_tox_pmoshs45b_sphv_10hv*(1+sig_delr_tox_pmoshs45b_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_pmoshs45b_sphv_10hv*smm_delr_tox_pmoshs45b_sphv_10hv(l,w,ng)))
//+ delr_tox_pmoshs45b_sphv_10hv = (nom_delr_tox_pmoshs45b_sphv_10hv*(1+sig_delr_tox_pmoshs45b_sphv_10hv*nsig_delr_tox_pmoshs45b_sphv_10hv+nsmm_delr_tox_pmoshs45b_sphv_10hv*smm_delr_tox_pmoshs45b_sphv_10hv(l,w,ng)))
+ delr_uch_pmoshs45b_sphv_10hv = (nom_delr_uch_pmoshs45b_sphv_10hv*(1+sig_delr_uch_pmoshs45b_sphv_10hv*nsig_delr_uch_pmoshs45b_sphv_10hv+nsmm_delr_uch_pmoshs45b_sphv_10hv*smm_delr_uch_pmoshs45b_sphv_10hv(l,w,ng)))
+ delr_res_pmoshs45b_sphv_10hv = (nom_delr_res_pmoshs45b_sphv_10hv*(1+sig_delr_res_pmoshs45b_sphv_10hv*nsig_delr_res_pmoshs45b_sphv_10hv+nsmm_delr_res_pmoshs45b_sphv_10hv*smm_delr_res_pmoshs45b_sphv_10hv(l,w,ng)))
+ dela_vfb_pmoshs45b_sphv_10hv = (nom_dela_vfb_pmoshs45b_sphv_10hv+(sig_dela_vfb_pmoshs45b_sphv_10hv*nsig_dela_vfb_pmoshs45b_sphv_10hv)+tc_vth_mm*nsmm_dela_vfb_pmoshs45b_sphv_10hv*smm_dela_vfb_pmoshs45b_sphv_10hv(l,w,ng))
+ dela_vtw_pmoshs45b_sphv_10hv = (nom_dela_vtw_pmoshs45b_sphv_10hv+(sig_dela_vtw_pmoshs45b_sphv_10hv*nsig_dela_vtw_pmoshs45b_sphv_10hv)+nsmm_dela_vtw_pmoshs45b_sphv_10hv*smm_dela_vtw_pmoshs45b_sphv_10hv(l,w,ng))
+ dela_vtl_pmoshs45b_sphv_10hv = (nom_dela_vtl_pmoshs45b_sphv_10hv+(sig_dela_vtl_pmoshs45b_sphv_10hv*nsig_dela_vtl_pmoshs45b_sphv_10hv))
+ dela_vtm_pmoshs45b_sphv_10hv = (nom_dela_vtm_pmoshs45b_sphv_10hv+(sig_dela_vtm_pmoshs45b_sphv_10hv*nsig_dela_vtm_pmoshs45b_sphv_10hv))
+ dela_dl_pmoshs45b_sphv_10hv = (nom_dela_dl_pmoshs45b_sphv_10hv+(sig_dela_dl_pmoshs45b_sphv_10hv*nsig_dela_dl_pmoshs45b_sphv_10hv))
+ dela_dw_pmoshs45b_sphv_10hv = (nom_dela_dw_pmoshs45b_sphv_10hv+(sig_dela_dw_pmoshs45b_sphv_10hv*nsig_dela_dw_pmoshs45b_sphv_10hv))
+ dela_dlw_pmoshs45b_sphv_10hv = (nom_dela_dlw_pmoshs45b_sphv_10hv+(sig_dela_dlw_pmoshs45b_sphv_10hv*nsig_dela_dlw_pmoshs45b_sphv_10hv))
+ delr_nsub_pmoshs45b_sphv_10hv = (1+nsmm_delr_nsub_pmoshs45b_sphv_10hv*smm_delr_nsub_pmoshs45b_sphv_10hv(l,w,ng))


+    delr_cjs_pmoshs45b_sphv_10hv	=(nom_delr_cjs_pmoshs45b_sphv_10hv*(1.0+nsig_delr_cjs_pmoshs45b_sphv_10hv*sig_delr_cjs_pmoshs45b_sphv_10hv))
+    delr_cjd_pmoshs45b_sphv_10hv	=(nom_delr_cjd_pmoshs45b_sphv_10hv*(1.0+nsig_delr_cjd_pmoshs45b_sphv_10hv*sig_delr_cjd_pmoshs45b_sphv_10hv))
+    delr_jsideal_pmoshs45b_sphv_10hv	=(nom_delr_jsideal_pmoshs45b_sphv_10hv*exp(nsig_delr_jsideal_pmoshs45b_sphv_10hv*sig_delr_jsideal_pmoshs45b_sphv_10hv))
+    delr_jdideal_pmoshs45b_sphv_10hv	=(nom_delr_jdideal_pmoshs45b_sphv_10hv*exp(nsig_delr_jdideal_pmoshs45b_sphv_10hv*sig_delr_jdideal_pmoshs45b_sphv_10hv))
+    delr_jsnonideal_pmoshs45b_sphv_10hv	=(nom_delr_jsnonideal_pmoshs45b_sphv_10hv*exp(nsig_delr_jsnonideal_pmoshs45b_sphv_10hv*sig_delr_jsnonideal_pmoshs45b_sphv_10hv))
+    delr_jdnonideal_pmoshs45b_sphv_10hv	=(nom_delr_jdnonideal_pmoshs45b_sphv_10hv*exp(nsig_delr_jdnonideal_pmoshs45b_sphv_10hv*sig_delr_jdnonideal_pmoshs45b_sphv_10hv))
+    delr_jsdideal_pmoshs45b_sphv_10hv	=(nom_delr_jsdideal_pmoshs45b_sphv_10hv*exp(nsig_delr_jsdideal_pmoshs45b_sphv_10hv*sig_delr_jsdideal_pmoshs45b_sphv_10hv))

+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_pmoshs45b_sphv_10hv)
+    cox                            = (epsox/tox)
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)

if (ng_dmy >= 2){

cgd_fld_d_dmy (s d) capacitor c=(cgd_ply_fld_dmy)

cgb_fld_b_dmy (s b) capacitor c=(cgb_ply_fld_dmy)

mamost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
}

cgs_ply_m1_s (g s) capacitor c=(cfr_ply_m1_s)  //constant part for NS cgg
cgs_m1_m2_s (g s) capacitor c=(3.5e-17*l*ng*(1-lpe)+lpe*1e-20)
cbs_m1_m2_s (b s) capacitor c=(cbs_m2m1_par)

cgd_fld_d (g d) capacitor c=(cgd_ply_fld)
cgb_fld_b (g b) capacitor c=(cgb_ply_fld)

xcdgoptub_box_sub_10hv (b sub) cdgoptub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

mamost (d g s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

model sphvt_simkit sphvt
+ type           = p
+ tr           = 27
+ vdscale      = (vdscale_pmoshs45b_sphv_10hv+vdscalel_pmoshs45b_sphv_10hv/l+vdscalew_pmoshs45b_sphv_10hv/w+vdscalelw_pmoshs45b_sphv_10hv/w/l)
+ vdscaleb      = (vdscaleb_pmoshs45b_sphv_10hv+vdscalebl_pmoshs45b_sphv_10hv/l)
+ stvdscale      = stvdscale_pmoshs45b_sphv_10hv
+ ctgo      = ctgo_pmoshs45b_sphv_10hv
+ ctbo      = ctbo_pmoshs45b_sphv_10hv
+ stcto      = stcto_pmoshs45b_sphv_10hv
+ mumb      = mumb_pmoshs45b_sphv_10hv
+ mumbexp   = mumbexp_pmoshs45b_sphv_10hv
+ mumbvclmp      = mumbvclmp_pmoshs45b_sphv_10hv
+ swdrlin           = 0
+ swgeo        	= 1
+ swigate      	  = 0
+ swimpact     	   = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	    = 1
+ swshe        	= selfheat*enable_selfheat
+ swtcec      	  = 1
+ swimpdr      	  = 1
+ swexp        	= 0
+ swdelvtac    	    = 1
+ swnud        	= 0
+ swptest      	  = 0
+ swgedi      	  = 1
+ qmc           = qmc_pmoshs45b_sphv_10hv
+ lvaro        	= lvaro_pmoshs45b_sphv_10hv+1e-6*dela_dl_pmoshs45b_sphv_10hv+1e-6*dela_dlw_pmoshs45b_sphv_10hv/w
+ lvarl        	= lvarl_pmoshs45b_sphv_10hv
+ lvarw        	= lvarw_pmoshs45b_sphv_10hv
+ lap           = lap_pmoshs45b_sphv_10hv
+ wvaro        	= (wvaro_pmoshs45b_sphv_10hv+1e-6*dela_dw_pmoshs45b_sphv_10hv)
+ wvarl        	= (wvarl_pmoshs45b_sphv_10hv)
+ wvarw        	= (wvarw_pmoshs45b_sphv_10hv)
+ wot           = wot_pmoshs45b_sphv_10hv
+ dlq           = dlq_pmoshs45b_sphv_10hv
+ dwq           = dwq_pmoshs45b_sphv_10hv
+ vfbo           = (vfbo_pmoshs45b_sphv_10hv+dela_vfb_pmoshs45b_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pmoshs45b_vthratio)
+ vfbl           = (vfbl_pmoshs45b_sphv_10hv+fac_a_ng_vfbl+dela_vtl_pmoshs45b_sphv_10hv)
+ vfbw           = (vfbw_pmoshs45b_sphv_10hv+dela_vtw_pmoshs45b_sphv_10hv)
+ vfblw        	= (vfblw_pmoshs45b_sphv_10hv+dela_vtm_pmoshs45b_sphv_10hv)
+ stvfbo       	 = stvfbo_pmoshs45b_sphv_10hv
+ stvfbl       	 = stvfbl_pmoshs45b_sphv_10hv
+ stvfbw       	 = stvfbw_pmoshs45b_sphv_10hv
+ stvfblw      	  = stvfblw_pmoshs45b_sphv_10hv
+ toxo           = toxo_pmoshs45b_sphv_10hv*delr_tox_pmoshs45b_sphv_10hv
+ epsroxo      	  = epsroxo_pmoshs45b_sphv_10hv
+ nsubo        	= nsubo_pmoshs45b_sphv_10hv*delr_nsub_pmoshs45b_sphv_10hv*(1-log(l/30)*0.025)
+ nsubw        	= nsubw_pmoshs45b_sphv_10hv
+ wseg           = wseg_pmoshs45b_sphv_10hv
+ npck           = npck_pmoshs45b_sphv_10hv
+ npckw        	= npckw_pmoshs45b_sphv_10hv
+ wsegp        	= wsegp_pmoshs45b_sphv_10hv
+ lpck           = lpck_pmoshs45b_sphv_10hv
+ lpckw        	= lpckw_pmoshs45b_sphv_10hv
+ fol1           = fol1_pmoshs45b_sphv_10hv
+ fol2           = fol2_pmoshs45b_sphv_10hv
+ facneffaco   	     = facneffaco_pmoshs45b_sphv_10hv
+ facneffacl   	     = facneffacl_pmoshs45b_sphv_10hv
+ facneffacw   	     = facneffacw_pmoshs45b_sphv_10hv
+ facneffaclw  	      = facneffaclw_pmoshs45b_sphv_10hv
+ gfacnudo     	   = gfacnudo_pmoshs45b_sphv_10hv
+ gfacnudl     	   = gfacnudl_pmoshs45b_sphv_10hv
+ gfacnudlexp  	      = gfacnudlexp_pmoshs45b_sphv_10hv
+ gfacnudw     	   = gfacnudw_pmoshs45b_sphv_10hv
+ gfacnudlw    	    = gfacnudlw_pmoshs45b_sphv_10hv
+ vsbnudo      	  = vsbnudo_pmoshs45b_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_pmoshs45b_sphv_10hv
+ vnsubo       	 = vnsubo_pmoshs45b_sphv_10hv
+ nslpo        	= nslpo_pmoshs45b_sphv_10hv
+ dnsubo       	 = dnsubo_pmoshs45b_sphv_10hv
+ dphibo       	 = dphibo_pmoshs45b_sphv_10hv
+ dphibl       	 = dphibl_pmoshs45b_sphv_10hv
+ dphiblexp    	    = dphiblexp_pmoshs45b_sphv_10hv
+ dphibw       	 = (dphibw_pmoshs45b_sphv_10hv)
+ dphiblw      	  = (dphiblw_pmoshs45b_sphv_10hv)
+ delvtaco     	   = delvtaco_pmoshs45b_sphv_10hv
+ delvtacl     	   = delvtacl_pmoshs45b_sphv_10hv
+ delvtaclexp  	      = delvtaclexp_pmoshs45b_sphv_10hv
+ delvtacw     	   = delvtacw_pmoshs45b_sphv_10hv
+ delvtaclw    	    = delvtaclw_pmoshs45b_sphv_10hv
+ npo           = npo_pmoshs45b_sphv_10hv
+ npl           = npl_pmoshs45b_sphv_10hv
+ cto           = cto_pmoshs45b_sphv_10hv
+ ctl           = ctl_pmoshs45b_sphv_10hv
+ ctlexp       	 = ctlexp_pmoshs45b_sphv_10hv
+ ctw           = ctw_pmoshs45b_sphv_10hv
+ ctlw           = ctlw_pmoshs45b_sphv_10hv
+ toxovo       	 = toxovo_pmoshs45b_sphv_10hv*delr_tox_pmoshs45b_sphv_10hv
+ toxovdo      	  = toxovdo_pmoshs45b_sphv_10hv*delr_tox_pmoshs45b_sphv_10hv
+ lov           = lov_pmoshs45b_sphv_10hv
+ dlovd        	= dlovd_pmoshs45b_sphv_10hv
+ novo           = novo_pmoshs45b_sphv_10hv
+ novdo        	= novdo_pmoshs45b_sphv_10hv
+ cfl           = cfl_pmoshs45b_sphv_10hv
+ cflexp       	 = cflexp_pmoshs45b_sphv_10hv
+ cfw           = cfw_pmoshs45b_sphv_10hv
+ cfbo           = cfbo_pmoshs45b_sphv_10hv
+ uo           = (uo_pmoshs45b_sphv_10hv*delr_uch_pmoshs45b_sphv_10hv*delr_u0_relimo*fac_r_ng_uo)
+ fbet1        	= fbet1_pmoshs45b_sphv_10hv
+ fbet1w       	 = fbet1w_pmoshs45b_sphv_10hv
+ lp1           = lp1_pmoshs45b_sphv_10hv
+ lp1w           = lp1w_pmoshs45b_sphv_10hv
+ fbet2        	= fbet2_pmoshs45b_sphv_10hv
+ lp2           = lp2_pmoshs45b_sphv_10hv
+ betw1        	= betw1_pmoshs45b_sphv_10hv
+ betw2        	= betw2_pmoshs45b_sphv_10hv
+ wbet           = wbet_pmoshs45b_sphv_10hv
+ stbeto       	 = stbeto_pmoshs45b_sphv_10hv
+ stbetl       	 = stbetl_pmoshs45b_sphv_10hv
+ stbetw       	 = stbetw_pmoshs45b_sphv_10hv
+ stbetlw      	  = stbetlw_pmoshs45b_sphv_10hv
+ mueo           = (mueo_pmoshs45b_sphv_10hv)
+ muew           = muew_pmoshs45b_sphv_10hv
+ stmueo       	 = stmueo_pmoshs45b_sphv_10hv
+ themuo       	 = themuo_pmoshs45b_sphv_10hv
+ stthemuo     	   = stthemuo_pmoshs45b_sphv_10hv
+ cso           = cso_pmoshs45b_sphv_10hv
+ csl           = csl_pmoshs45b_sphv_10hv
+ cslexp       	 = cslexp_pmoshs45b_sphv_10hv
+ csw           = csw_pmoshs45b_sphv_10hv
+ cslw           = cslw_pmoshs45b_sphv_10hv
+ stcso        	= stcso_pmoshs45b_sphv_10hv
+ xcoro        	= xcoro_pmoshs45b_sphv_10hv
+ xcorl        	= xcorl_pmoshs45b_sphv_10hv
+ xcorw        	= xcorw_pmoshs45b_sphv_10hv
+ xcorlw       	 = xcorlw_pmoshs45b_sphv_10hv
+ stxcoro      	  = stxcoro_pmoshs45b_sphv_10hv
+ fetao        	= fetao_pmoshs45b_sphv_10hv
+ rsw1           = rsw1_pmoshs45b_sphv_10hv
+ rsw2           = rsw2_pmoshs45b_sphv_10hv
+ strso        	= strso_pmoshs45b_sphv_10hv
+ rsbo           = rsbo_pmoshs45b_sphv_10hv
+ rsgo           = rsgo_pmoshs45b_sphv_10hv
+ thesato      	  = (thesato_pmoshs45b_sphv_10hv)
+ thesatl      	  = thesatl_pmoshs45b_sphv_10hv
+ thesatlexp   	     = thesatlexp_pmoshs45b_sphv_10hv
+ thesatw      	  = (thesatw_pmoshs45b_sphv_10hv)
+ thesatlw     	   = thesatlw_pmoshs45b_sphv_10hv
+ stthesato    	    = stthesato_pmoshs45b_sphv_10hv
+ stthesatl    	    = stthesatl_pmoshs45b_sphv_10hv
+ stthesatw    	    = stthesatw_pmoshs45b_sphv_10hv
+ stthesatlw   	     = stthesatlw_pmoshs45b_sphv_10hv
+ thesatbo     	   = thesatbo_pmoshs45b_sphv_10hv
+ thesatgo     	   = thesatgo_pmoshs45b_sphv_10hv
+ thesatgl     	   = thesatgl_pmoshs45b_sphv_10hv
+ thesatgw     	   = thesatgw_pmoshs45b_sphv_10hv
+ axo           = axo_pmoshs45b_sphv_10hv
+ axl           = axl_pmoshs45b_sphv_10hv
+ alpl           = alpl_pmoshs45b_sphv_10hv
+ alplexp      	  = alplexp_pmoshs45b_sphv_10hv
+ alpw           = alpw_pmoshs45b_sphv_10hv
+ alp1l1       	 = alp1l1_pmoshs45b_sphv_10hv
+ alp1lexp     	   = alp1lexp_pmoshs45b_sphv_10hv
+ alp1l2       	 = alp1l2_pmoshs45b_sphv_10hv
+ alp1w        	= alp1w_pmoshs45b_sphv_10hv
+ alp2l1       	 = alp2l1_pmoshs45b_sphv_10hv
+ alp2lexp     	   = alp2lexp_pmoshs45b_sphv_10hv
+ alp2l2       	 = alp2l2_pmoshs45b_sphv_10hv
+ alp2w        	= alp2w_pmoshs45b_sphv_10hv
+ vpo           = vpo_pmoshs45b_sphv_10hv
+ a1o           = a1o_pmoshs45b_sphv_10hv
+ a1l           = a1l_pmoshs45b_sphv_10hv
+ a1w           = a1w_pmoshs45b_sphv_10hv
+ a2o           = a2o_pmoshs45b_sphv_10hv
+ sta2o        	= sta2o_pmoshs45b_sphv_10hv
+ a3o           = a3o_pmoshs45b_sphv_10hv
+ a3l           = a3l_pmoshs45b_sphv_10hv
+ a3w           = a3w_pmoshs45b_sphv_10hv
+ a4o           = a4o_pmoshs45b_sphv_10hv
+ a4l           = a4l_pmoshs45b_sphv_10hv
+ a4w           = a4w_pmoshs45b_sphv_10hv
+ gcoo           = gcoo_pmoshs45b_sphv_10hv
+ iginvlw      	  = iginvlw_pmoshs45b_sphv_10hv
+ igovw        	= igovw_pmoshs45b_sphv_10hv
+ igovdw       	 = igovdw_pmoshs45b_sphv_10hv
+ stigo        	= stigo_pmoshs45b_sphv_10hv
+ gc2o           = gc2o_pmoshs45b_sphv_10hv
+ gc3o           = gc3o_pmoshs45b_sphv_10hv
+ chibo        	= chibo_pmoshs45b_sphv_10hv
+ agidlw       	 = agidlw_pmoshs45b_sphv_10hv
+ agidldw      	  = agidldw_pmoshs45b_sphv_10hv
+ bgidlo       	 = bgidlo_pmoshs45b_sphv_10hv
+ bgidldo      	  = bgidldo_pmoshs45b_sphv_10hv
+ stbgidlo     	   = stbgidlo_pmoshs45b_sphv_10hv
+ stbgidldo    	    = stbgidldo_pmoshs45b_sphv_10hv
+ cgidlo       	 = cgidlo_pmoshs45b_sphv_10hv
+ cgidldo      	  = cgidldo_pmoshs45b_sphv_10hv
+ cgbovl       	 = cgbovl_pmoshs45b_sphv_10hv
+ cfrw           = cfrw_pmoshs45b_sphv_10hv
+ cfrdw        	= cfrdw_pmoshs45b_sphv_10hv
+ fnto           = fnto_pmoshs45b_sphv_10hv
+ nfalw        	= nfalw_pmoshs45b_sphv_10hv*fac_r_nfalw
+ nfblw        	= nfblw_pmoshs45b_sphv_10hv
+ nfclw        	= nfclw_pmoshs45b_sphv_10hv
+ efo           = efo_pmoshs45b_sphv_10hv
+ lintnoi      	  = lintnoi_pmoshs45b_sphv_10hv
+ alpnoi       	 = alpnoi_pmoshs45b_sphv_10hv
+ kvthoweo     	   = kvthoweo_pmoshs45b_sphv_10hv
+ kvthowel     	   = kvthowel_pmoshs45b_sphv_10hv
+ kvthowew     	   = kvthowew_pmoshs45b_sphv_10hv
+ kvthowelw    	    = kvthowelw_pmoshs45b_sphv_10hv
+ kuoweo       	 = kuoweo_pmoshs45b_sphv_10hv
+ kuowel       	 = kuowel_pmoshs45b_sphv_10hv
+ kuowew       	 = kuowew_pmoshs45b_sphv_10hv
+ kuowelw      	  = kuowelw_pmoshs45b_sphv_10hv
+ rgo           = rgo_pmoshs45b_sphv_10hv
+ rsh           = rsh_pmoshs45b_sphv_10hv
+ rbulko       	 = rbulko_pmoshs45b_sphv_10hv
+ rwello       	 = rwello_pmoshs45b_sphv_10hv
+ rjunso       	 = rjunso_pmoshs45b_sphv_10hv/(w+dwrjunso_pmoshs45b_sphv_10hv)*tfact_rs
+ rjundo       	 = rjundo_pmoshs45b_sphv_10hv/(w+dwrjundo_pmoshs45b_sphv_10hv)*sqrt(l)/(sqrt(l)+1.5)*tfact_rs
+ rint           = rint_pmoshs45b_sphv_10hv
+ rvpoly       	 = rvpoly_pmoshs45b_sphv_10hv
+ rshg           = rshg_pmoshs45b_sphv_10hv
+ dlsil        	= dlsil_pmoshs45b_sphv_10hv
+ saref        	= saref_pmoshs45b_sphv_10hv
+ sbref        	= sbref_pmoshs45b_sphv_10hv
+ wlod           = wlod_pmoshs45b_sphv_10hv
+ kuo           = kuo_pmoshs45b_sphv_10hv
+ kvsat        	= kvsat_pmoshs45b_sphv_10hv
+ tkuo           = tkuo_pmoshs45b_sphv_10hv
+ lkuo           = lkuo_pmoshs45b_sphv_10hv
+ wkuo           = wkuo_pmoshs45b_sphv_10hv
+ pkuo           = pkuo_pmoshs45b_sphv_10hv
+ llodkuo      	  = llodkuo_pmoshs45b_sphv_10hv
+ wlodkuo      	  = wlodkuo_pmoshs45b_sphv_10hv
+ kvtho        	= kvtho_pmoshs45b_sphv_10hv
+ lkvtho       	 = lkvtho_pmoshs45b_sphv_10hv
+ wkvtho       	 = wkvtho_pmoshs45b_sphv_10hv
+ pkvtho       	 = pkvtho_pmoshs45b_sphv_10hv
+ llodvth      	  = llodvth_pmoshs45b_sphv_10hv
+ wlodvth      	  = wlodvth_pmoshs45b_sphv_10hv
+ stetao       	 = stetao_pmoshs45b_sphv_10hv
+ lodetao      	  = lodetao_pmoshs45b_sphv_10hv
+ scref        	= scref_pmoshs45b_sphv_10hv
+ web           = web_pmoshs45b_sphv_10hv
+ wec           = wec_pmoshs45b_sphv_10hv
+ adr1o        	= adr1o_pmoshs45b_sphv_10hv
+ adr1l        	= adr1l_pmoshs45b_sphv_10hv
+ adr1w        	= adr1w_pmoshs45b_sphv_10hv
+ adr2o        	= adr2o_pmoshs45b_sphv_10hv
+ stadr2o      	  = stadr2o_pmoshs45b_sphv_10hv
+ adr3o        	= adr3o_pmoshs45b_sphv_10hv
+ adr3l        	= adr3l_pmoshs45b_sphv_10hv
+ adr3w        	= adr3w_pmoshs45b_sphv_10hv
+ adr4o        	= adr4o_pmoshs45b_sphv_10hv
+ adr4l        	= adr4l_pmoshs45b_sphv_10hv
+ adr4w        	= adr4w_pmoshs45b_sphv_10hv
+ adr5o        	= adr5o_pmoshs45b_sphv_10hv
+ adr5l        	= adr5l_pmoshs45b_sphv_10hv
+ adr5w        	= adr5w_pmoshs45b_sphv_10hv
+ bidr1o       	 = bidr1o_pmoshs45b_sphv_10hv
+ bidr1l       	 = bidr1l_pmoshs45b_sphv_10hv
+ bidr1w       	 = bidr1w_pmoshs45b_sphv_10hv
+ bidr2o       	 = bidr2o_pmoshs45b_sphv_10hv
+ bidr2w       	 = bidr2w_pmoshs45b_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	= 0
+ strtho       	 = strtho_pmoshs45b_sphv_10hv
+ strthao       	 = strthao_pmoshs45b_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	= 0
+ rshldd       	 = (rshldd_pmoshs45b_sphv_10hv*fac_r_ng_rshldd*delr_res_pmoshs45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pmoshs45b_ronratio))
+ xw           = (xw_pmoshs45b_sphv_10hv)
+ nwxw           = (nwxw_pmoshs45b_sphv_10hv)
+ xl           = xl_pmoshs45b_sphv_10hv
+ xlw           = xlw_pmoshs45b_sphv_10hv
+ dxlsat       	 = dxlsat_pmoshs45b_sphv_10hv
+ nst           = nst_pmoshs45b_sphv_10hv
+ ats           = ats_pmoshs45b_sphv_10hv
+ dfinf        	= dfinf_pmoshs45b_sphv_10hv
+ dfw           = dfw_pmoshs45b_sphv_10hv
+ dfl           = dfl_pmoshs45b_sphv_10hv
+ dflw           = dflw_pmoshs45b_sphv_10hv
+ dp           = dp_pmoshs45b_sphv_10hv
+ ecrit        	= ecrit_pmoshs45b_sphv_10hv*tfact_ecrit*(1+1.0/w)
+ ecorn        	= ecorn_pmoshs45b_sphv_10hv*tfact_ecrit*(1+1.0/w)
+ xvsat           = xvsat_pmoshs45b_sphv_10hv
+ du           = du_pmoshs45b_sphv_10hv
+ tc1           = tc1_pmoshs45b_sphv_10hv
+ tc2           = tc2_pmoshs45b_sphv_10hv
+ tc1l           = tc1l_pmoshs45b_sphv_10hv
+ tc2l           = tc2l_pmoshs45b_sphv_10hv
+ tc1w           = tc1w_pmoshs45b_sphv_10hv
+ tc2w           = tc2w_pmoshs45b_sphv_10hv
+ theacc       	 = theacc_pmoshs45b_sphv_10hv
+ theacc2      	  = theacc2_pmoshs45b_sphv_10hv
+ rva           = rva_pmoshs45b_sphv_10hv
+ dta           = dta_pmoshs45b_sphv_10hv
+ //*** junc cap parameters for s/b ***
+ //in ams2p0 synced cjarea, cjlsti and cjlgat three paramters
+ cjarea      	 =	cjarea_pmoshs45b_sphv_10hv*delr_cjs_pmoshs45b_sphv_10hv
+ cjlsti      	 =	0
+ cjlgat      	 =	cjarea_pmoshs45b_sphv_10hv*djunc*delr_cjs_pmoshs45b_sphv_10hv*0
+ vbiarea     	  =	vbiarea_pmoshs45b_sphv_10hv
+ vbisti      	 =	vbiarea_pmoshs45b_sphv_10hv
+ vbigat      	 =	vbiarea_pmoshs45b_sphv_10hv
+ parea       	=	parea_pmoshs45b_sphv_10hv
+ psti           =	parea_pmoshs45b_sphv_10hv
+ pgat           =	parea_pmoshs45b_sphv_10hv
+ //*** ideal current parameters for s/b ***
+ is1area 	 	  = is1area_pmoshs45b_sphv_10hv*delr_jsideal_pmoshs45b_sphv_10hv
+ stis1area 	 	  = stis1area_pmoshs45b_sphv_10hv
+ n1area 		 	  = n1area_pmoshs45b_sphv_10hv
+ is1lsti 	 	  = is1area_pmoshs45b_sphv_10hv*djunc*delr_jsideal_pmoshs45b_sphv_10hv*0
+ stis1sti	 	  = stis1area_pmoshs45b_sphv_10hv
+ n1sti 		 	  = n1area_pmoshs45b_sphv_10hv
+ is1lgat 	 	  = is1area_pmoshs45b_sphv_10hv*djunc*delr_jsideal_pmoshs45b_sphv_10hv*0
+ stis1gat 	 	  = stis1area_pmoshs45b_sphv_10hv
+ n1gat 		 	  = n1area_pmoshs45b_sphv_10hv
+ //*** non-ideal current parameters for s/b ***
+ is2area   		 = is2area_pmoshs45b_sphv_10hv*delr_jsnonideal_pmoshs45b_sphv_10hv
+ stis2area 		 = stis2area_pmoshs45b_sphv_10hv
+ n2area 	  		 = n2area_pmoshs45b_sphv_10hv
+ is2lsti   		 = is2area_pmoshs45b_sphv_10hv*djunc*delr_jsnonideal_pmoshs45b_sphv_10hv*0
+ stis2sti  		 = stis2area_pmoshs45b_sphv_10hv
+ n2sti 	  		 = n2area_pmoshs45b_sphv_10hv
+ is2lgat   		 = is2area_pmoshs45b_sphv_10hv*djunc*delr_jsnonideal_pmoshs45b_sphv_10hv*0
+ stis2gat  		 = stis2area_pmoshs45b_sphv_10hv
+ n2gat 	  		 = n2area_pmoshs45b_sphv_10hv
+ //*** non-ideal reverse current parameters for s/b ***
+ irarea 	 		  = irarea_pmoshs45b_sphv_10hv*delr_jsnonideal_pmoshs45b_sphv_10hv
+ stirarea 		  = stirarea_pmoshs45b_sphv_10hv
+ nrarea 	 		  = nrarea_pmoshs45b_sphv_10hv
+ irlsti 	 		  = irarea_pmoshs45b_sphv_10hv*djunc*delr_jsnonideal_pmoshs45b_sphv_10hv*0
+ stirsti  		  = stirarea_pmoshs45b_sphv_10hv
+ nrsti 	 		  = nrarea_pmoshs45b_sphv_10hv
+ irlgat 	 		  = irarea_pmoshs45b_sphv_10hv*djunc*delr_jsnonideal_pmoshs45b_sphv_10hv*0
+ stirgat  		  = stirarea_pmoshs45b_sphv_10hv
+ nrgat 	 		  = nrarea_pmoshs45b_sphv_10hv
+ // *** rr for s/b ***
+ ttarea   	 = ttarea_pmoshs45b_sphv_10hv
+ ttlsti   	 = ttlsti_pmoshs45b_sphv_10hv
+ ttlgat   	 = ttlgat_pmoshs45b_sphv_10hv
+ //*** junc cap parameters for d/b ***
+ cjaread    	  =	  cjaread_pmoshs45b_sphv_10hv*delr_cjd_pmoshs45b_sphv_10hv
+ cjlstid    	  =	  cjlstid_pmoshs45b_sphv_10hv*delr_cjd_pmoshs45b_sphv_10hv
+ cjlgatd    	  =	  cjaread_pmoshs45b_sphv_10hv*djunc*delr_cjd_pmoshs45b_sphv_10hv
+ vbiaread   	   =	  vbiaread_pmoshs45b_sphv_10hv
+ vbistid    	  =	  vbistid_pmoshs45b_sphv_10hv
+ vbigatd    	  =	  vbigatd_pmoshs45b_sphv_10hv
+ paread     	 =	  paread_pmoshs45b_sphv_10hv
+ pstid      	=	  paread_pmoshs45b_sphv_10hv
+ pgatd      	=	  paread_pmoshs45b_sphv_10hv
+ //*** ideal current parameters for d/b ***
+ is1aread   		 = is1aread_pmoshs45b_sphv_10hv*delr_jdideal_pmoshs45b_sphv_10hv
+ stis1aread 		 = stis1aread_pmoshs45b_sphv_10hv
+ n1aread    		 = n1aread_pmoshs45b_sphv_10hv
+ is1lstid   		 = is1aread_pmoshs45b_sphv_10hv*djunc*delr_jdideal_pmoshs45b_sphv_10hv
+ stis1stid  		 = stis1aread_pmoshs45b_sphv_10hv
+ n1stid 	   		 = n1aread_pmoshs45b_sphv_10hv
+ is1lgatd   		 = is1aread_pmoshs45b_sphv_10hv*djunc*delr_jdideal_pmoshs45b_sphv_10hv
+ stis1gatd  		 = stis1aread_pmoshs45b_sphv_10hv
+ n1gatd 	   		 = n1aread_pmoshs45b_sphv_10hv
+ //*** non-ideal current parameters for d/b ***
+ is2aread   		  = is2aread_pmoshs45b_sphv_10hv*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stis2aread 		  = stis2aread_pmoshs45b_sphv_10hv
+ n2aread    		  = n2aread_pmoshs45b_sphv_10hv
+ is2lstid   		  = is2aread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stis2stid  		  = stis2aread_pmoshs45b_sphv_10hv
+ n2stid 	   		  = n2aread_pmoshs45b_sphv_10hv
+ is2lgatd   		  = is2aread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stis2gatd  		  = stis2aread_pmoshs45b_sphv_10hv
+ n2gatd 	   		  = n2aread_pmoshs45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d/b ***
+ iraread   		  = iraread_pmoshs45b_sphv_10hv*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stiraread 		  = stiraread_pmoshs45b_sphv_10hv
+ nraread   		  = nraread_pmoshs45b_sphv_10hv
+ irlstid   		  = iraread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stirstid  		  = stiraread_pmoshs45b_sphv_10hv
+ nrstid 	  		  = nraread_pmoshs45b_sphv_10hv
+ irlgatd   		  = iraread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stirgatd  		  = stiraread_pmoshs45b_sphv_10hv
+ nrgatd 	  		  = nraread_pmoshs45b_sphv_10hv
+ // *** rr  for d/b ***
+ ttaread  	  = ttaread_pmoshs45b_sphv_10hv*tfact_tt
+ ttlstid  	  = ttlstid_pmoshs45b_sphv_10hv*tfact_tt
+ ttlgatd  	  = ttlgatd_pmoshs45b_sphv_10hv*tfact_tt
+ //*** junc cap parameters for d2/b ***
+ cjaread2   	   =	      cjaread_pmoshs45b_sphv_10hv*delr_cjd_pmoshs45b_sphv_10hv
+ cjlstid2   	   =	      cjlstid_pmoshs45b_sphv_10hv*delr_cjd_pmoshs45b_sphv_10hv
+ vbiaread2  	    =	      vbiaread_pmoshs45b_sphv_10hv
+ vbistid2   	   =	      vbiaread_pmoshs45b_sphv_10hv
+ paread2    	  =	      paread_pmoshs45b_sphv_10hv
+ pstid2     	 =	      paread_pmoshs45b_sphv_10hv
+ //*** ideal current parameters for d2/b ***
+ is1aread2   		  = is1aread_pmoshs45b_sphv_10hv*delr_jdideal_pmoshs45b_sphv_10hv
+ stis1aread2 		  = stis1aread_pmoshs45b_sphv_10hv
+ n1aread2    		  = n1aread_pmoshs45b_sphv_10hv
+ is1lstid2   		  = is1aread_pmoshs45b_sphv_10hv*djunc*delr_jdideal_pmoshs45b_sphv_10hv
+ stis1stid2  		  = stis1aread_pmoshs45b_sphv_10hv
+ n1stid2     		  = n1aread_pmoshs45b_sphv_10hv
+ //*** non-ideal current parameters for d2/b ***
+ is2aread2   		  = is2aread_pmoshs45b_sphv_10hv*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stis2aread2 		  = stis2aread_pmoshs45b_sphv_10hv
+ n2aread2    		  = n2aread_pmoshs45b_sphv_10hv
+ is2lstid2   		  = is2aread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stis2stid2  		  = stis2aread_pmoshs45b_sphv_10hv
+ n2stid2     		  = n2aread_pmoshs45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d2/b ***
+ iraread2   		  = iraread_pmoshs45b_sphv_10hv*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stiraread2 		  = stiraread_pmoshs45b_sphv_10hv
+ nraread2   		  = nraread_pmoshs45b_sphv_10hv
+ irlstid2   		  = iraread_pmoshs45b_sphv_10hv*djunc*delr_jdnonideal_pmoshs45b_sphv_10hv
+ stirstid2  		  = stiraread_pmoshs45b_sphv_10hv
+ nrstid2    		  = nraread_pmoshs45b_sphv_10hv
+ // *** transit time  for d2/b ***
+ ttaread2 	   = ttaread2_pmoshs45b_sphv_10hv*tfact_tt
+ ttlstid2 	   = ttlstid2_pmoshs45b_sphv_10hv*tfact_tt
+ // *** other temp dependence ***
+ eais1area     = eais1area_pmoshs45b_sphv_10hv
+ eais2area     = eais2area_pmoshs45b_sphv_10hv
+ eairarea      = eairarea_pmoshs45b_sphv_10hv
+ eais1sti      = eais1sti_pmoshs45b_sphv_10hv
+ eais2sti      = eais2sti_pmoshs45b_sphv_10hv
+ eairsti       = eairsti_pmoshs45b_sphv_10hv
+ eais1gat      = eais1gat_pmoshs45b_sphv_10hv
+ eais2gat      = eais2gat_pmoshs45b_sphv_10hv
+ eairgat       = eairgat_pmoshs45b_sphv_10hv
+ eais1aread    = eais1aread_pmoshs45b_sphv_10hv
+ eais2aread    = eais2aread_pmoshs45b_sphv_10hv
+ eairaread     = eairaread_pmoshs45b_sphv_10hv
+ eais1stid     = eais1stid_pmoshs45b_sphv_10hv
+ eais2stid     = eais2stid_pmoshs45b_sphv_10hv
+ eairstid      = eairstid_pmoshs45b_sphv_10hv
+ eais1gatd     = eais1gatd_pmoshs45b_sphv_10hv
+ eais2gatd     = eais2gatd_pmoshs45b_sphv_10hv
+ eairgatd      = eairgatd_pmoshs45b_sphv_10hv
+ eais1aread2   = eais1aread2_pmoshs45b_sphv_10hv
+ eais2aread2   = eais2aread2_pmoshs45b_sphv_10hv
+ eairaread2    = eairaread2_pmoshs45b_sphv_10hv
+ eais1stid2    = eais1stid2_pmoshs45b_sphv_10hv
+ eais2stid2    = eais2stid2_pmoshs45b_sphv_10hv
+ eairstid2     = eairstid2_pmoshs45b_sphv_10hv
+ ikfarea               = ikfarea_pmoshs45b_sphv_10hv
+ ikflsti               = ikfarea_pmoshs45b_sphv_10hv*djunc
+ ikflgat               = ikfarea_pmoshs45b_sphv_10hv*djunc
+ stikfarea              = stikfarea_pmoshs45b_sphv_10hv
+ stikfsti              = stikfarea_pmoshs45b_sphv_10hv
+ stikfgat              = stikfarea_pmoshs45b_sphv_10hv
+ ikfaread              = ikfaread_pmoshs45b_sphv_10hv*(w/(w+dwikfaread_pmoshs45b_sphv_10hv))
+ ikflstid              = ikfaread_pmoshs45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmoshs45b_sphv_10hv))
+ ikflgatd              = ikfaread_pmoshs45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmoshs45b_sphv_10hv))
+ ikfaread2             = ikfaread_pmoshs45b_sphv_10hv*(w/(w+dwikfaread_pmoshs45b_sphv_10hv))
+ ikflstid2             = ikfaread_pmoshs45b_sphv_10hv*djunc*(w/(w+dwikfaread_pmoshs45b_sphv_10hv))
+ stikfaread             = stikfaread_pmoshs45b_sphv_10hv
+ stikfstid             = stikfaread_pmoshs45b_sphv_10hv
+ stikfgatd             = stikfaread_pmoshs45b_sphv_10hv
+ stikfaread2            = stikfaread_pmoshs45b_sphv_10hv
+ stikfstid2            = stikfaread_pmoshs45b_sphv_10hv





include "./smos10hv_ade_dfrt.scs" section=pmoshs45b_10hv_dfrt
ends

// pmos90b_10hv



//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt pmos90b_10hv (d g s b sub)
parameters
+ l=1.0
+ w=5.0
+ ng=2
+ sti_dummy=0
+ lpe=0
+ soa=1
+ selfheat=1
+ mode_rthcth=1


parameters
+ nde=(fmod(ng,2))
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+ ng_dmy=2*sti_dummy
+ ngeff=ng+ng_dmy
+ ndi_eff=(ngeff/2)
+ nsi_eff=((ngeff-2)/2)
+ ns_eff=(1+ngeff/2)

//reliability parameters
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pmos90b_vthratio    = 1.0*(-0.0091*pow(1/l,2)+0.0634*1/l+0.9953)
+    presto_pmos90b_ronratio    = 0.01/1.0/(0.1652*l+0.9967)


//calculation of junction instance parameters
+    lacts    = 0.375
+    ldrift   = 6
+    wdrift   = (w)
+    wnwx   = 9.8
+    lactd   = 1.32
+    lsplit=0.35

+    ldr1=0.45
+    as_i=(lacts*w)
+    ps_i=2*(lacts+w)
//+    ad_i=((ldr1+lsplit)+ldrift/2)*(w+2*wnwx)
//+    pd_i=(2*((ldr1+lsplit)+ldrift/2)+w+2*wnwx)
+    ad_i=(((ldr1+lsplit)+ldrift/2)*(w+2*wnwx)+1.2*1.2*(3.14159265358979323846-4)/2)
+    pd_i=(2*((ldr1+lsplit)+ldrift/2)+w+2*wnwx+1.2*(3.14159265358979323846-4))
+    ad2_i=(lactd/2+ldrift/2)*(w+2*wnwx)
+    pd2_i=(lactd+ldrift)

//calculation for nbl/psub junction
+    lg2pepi_s    = 4.065  // dt to poly end
+    lp2p_d    = 14.92 	   // drain nhv end to nhv end
+    lb2b_s    = 1.8	   // poly end to ploy at internal source
+    wg2pepi    = 13.8     // width active side to nhv end
+    xbody                       = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody                       = (wg2pepi*2+w)
+    abody                       = (xbody*ybody)
+    pbody                       = (2*(xbody+ybody))

//calculation of parasitic cap
+    length_m2m1                    = (w+8)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*length_m2m1+width_m2m1)
+    csb_pmos90b_10hv_m2m1_par      = ((1-lpe)*((cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)*(ns_eff)+(xbody-3*2)*cfr_m2_m1)+lpe*1e-20)
//+    cgs_pmos90b_10hv_m2m1_par      = ((1-lpe)*((l+0.5*lp2p_d)*ng*cfr_m2_m1)+lpe*1e-20)

+    aplyfld_d  		    = (lp2p_d*(w+wnwx*2)+1.2*1.2*(3.14159265358979323846-4)-8.12*(w+5.1*2)-0.7*(w+3.2*2)*2-ldr1*w*2)/2*ng
+    aplyfld_b  		    = ((lp2p_d+2*l)*(w+2*11.3)- (lp2p_d*(w+wnwx*2)+1.2*1.2*(3.14159265358979323846-4))-2*w*l)/2*ng

//parasitic field c for dummy
+    aplyfld_d_dmy  		    = (lp2p_d*(w+wnwx*2)+1.2*1.2*(3.14159265358979323846-4)-8.12*(w+5.1*2)-0.7*(w+3.2*2)*2-ldr1*w*2)/2*ng_dmy
+    aplyfld_b_dmy  		    = ((lp2p_d+2*l)*(w+2*11.3)- (lp2p_d*(w+wnwx*2)+1.2*1.2*(3.14159265358979323846-4))-2*w*l)/2*ng_dmy


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_pmos90b_sphv_10hv+tc2_ecrit_pmos90b_sphv_10hv*(temp-tnom))*(temp-tnom)

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+1)-2/(2+1))*0.1836)
+ fac_a_ng_vfbo= -((ngeff/(ngeff+1.0)-2/(2+1.0))*0.02052)
+ fac_a_ng_mumb= ((ngeff/(ngeff+1.0)-2/(2+1.0))*0.03)
+ fac_r_ng_ecrit=(1+(ngeff/(ngeff+1)-2/(2+1))*0.3)
+ fac_r_ng_uo=(1+(ngeff/(ngeff+0.2)-2/(2+0.2))*(-0.2479))


//**thermal res/cap calculation
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pmos90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pmos90b_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff


// parameters for process variations
+ nsmm_delr_tox_pmos90b_sphv_10hv  = tmp_nsmm_delr_tox_pmos90b_sphv_10hv
+ nsmm_delr_uch_pmos90b_sphv_10hv  = tmp_nsmm_delr_uch_pmos90b_sphv_10hv
+ nsmm_delr_res_pmos90b_sphv_10hv  = tmp_nsmm_delr_res_pmos90b_sphv_10hv
+ nsmm_dela_vfb_pmos90b_sphv_10hv  = tmp_nsmm_dela_vfb_pmos90b_sphv_10hv
+ nsmm_dela_vtw_pmos90b_sphv_10hv  = tmp_nsmm_dela_vtw_pmos90b_sphv_10hv
+ nsmm_delr_nsub_pmos90b_sphv_10hv = tmp_nsmm_delr_nsub_pmos90b_sphv_10hv
+ nsmm_dela_dw_pmos90b_sphv_10hv = tmp_nsmm_dela_dw_pmos90b_sphv_10hv

+ delr_tox_pmos90b_sphv_10hv = (nom_delr_tox_pmos90b_sphv_10hv*(1+sig_delr_tox_pmos90b_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_pmos90b_sphv_10hv*smm_delr_tox_pmos90b_sphv_10hv(l,w)/sqrt(ng/2)))
//+ delr_tox_pmos90b_sphv_10hv = (nom_delr_tox_pmos90b_sphv_10hv*(1+sig_delr_tox_pmos90b_sphv_10hv*nsig_delr_tox_pmos90b_sphv_10hv+nsmm_delr_tox_pmos90b_sphv_10hv*smm_delr_tox_pmos90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_uch_pmos90b_sphv_10hv = (nom_delr_uch_pmos90b_sphv_10hv*(1+sig_delr_uch_pmos90b_sphv_10hv*nsig_delr_uch_pmos90b_sphv_10hv+nsmm_delr_uch_pmos90b_sphv_10hv*smm_delr_uch_pmos90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pmos90b_sphv_10hv = (nom_delr_res_pmos90b_sphv_10hv*(1+sig_delr_res_pmos90b_sphv_10hv*nsig_delr_res_pmos90b_sphv_10hv+nsmm_delr_res_pmos90b_sphv_10hv*smm_delr_res_pmos90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pmos90b_sphv_10hv = (nom_dela_vfb_pmos90b_sphv_10hv+(sig_dela_vfb_pmos90b_sphv_10hv*nsig_dela_vfb_pmos90b_sphv_10hv)+nsmm_dela_vfb_pmos90b_sphv_10hv*smm_dela_vfb_pmos90b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pmos90b_sphv_10hv = (nom_dela_vtw_pmos90b_sphv_10hv+(sig_dela_vtw_pmos90b_sphv_10hv*nsig_dela_vtw_pmos90b_sphv_10hv)+nsmm_dela_vtw_pmos90b_sphv_10hv*smm_dela_vtw_pmos90b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtl_pmos90b_sphv_10hv = (nom_dela_vtl_pmos90b_sphv_10hv+(sig_dela_vtl_pmos90b_sphv_10hv*nsig_dela_vtl_pmos90b_sphv_10hv))
+ dela_dw_pmos90b_sphv_10hv = (nom_dela_dw_pmos90b_sphv_10hv+(sig_dela_dw_pmos90b_sphv_10hv*nsig_dela_dw_pmos90b_sphv_10hv)+(nsmm_dela_dw_pmos90b_sphv_10hv*smm_dela_dw_pmos90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_mueo_pmos90b_sphv_10hv = (nom_dela_mueo_pmos90b_sphv_10hv+(sig_dela_mueo_pmos90b_sphv_10hv*nsig_dela_mueo_pmos90b_sphv_10hv))
+ delr_nsub_pmos90b_sphv_10hv = (1+nsmm_delr_nsub_pmos90b_sphv_10hv*smm_delr_nsub_pmos90b_sphv_10hv(l,w)/sqrt(ng/2))

+ dela_vdscale_pmos90b_sphv_10hv =(nom_dela_vdscale_pmos90b_sphv_10hv+(sig_dela_vdscale_pmos90b_sphv_10hv*nsig_dela_vdscale_pmos90b_sphv_10hv))
+ dela_vdscalel_pmos90b_sphv_10hv =(nom_dela_vdscalel_pmos90b_sphv_10hv+(sig_dela_vdscalel_pmos90b_sphv_10hv*nsig_dela_vdscalel_pmos90b_sphv_10hv))
+ dela_vdscalew_pmos90b_sphv_10hv =(nom_dela_vdscalew_pmos90b_sphv_10hv+(sig_dela_vdscalew_pmos90b_sphv_10hv*nsig_dela_vdscalew_pmos90b_sphv_10hv))
+ dela_vdscalelw_pmos90b_sphv_10hv =(nom_dela_vdscalelw_pmos90b_sphv_10hv+(sig_dela_vdscalelw_pmos90b_sphv_10hv*nsig_dela_vdscalelw_pmos90b_sphv_10hv))

+ delr_cj_pmos90b_sphv_10hv = (nom_delr_cj_pmos90b_sphv_10hv*(1+sig_delr_cj_pmos90b_sphv_10hv*nsig_delr_cj_pmos90b_sphv_10hv))
+ delr_is_pmos90b_sphv_10hv = (nom_delr_is_pmos90b_sphv_10hv*exp(sig_delr_is_pmos90b_sphv_10hv*nsig_delr_is_pmos90b_sphv_10hv))
+ delr_is2_pmos90b_sphv_10hv = (nom_delr_is2_pmos90b_sphv_10hv*exp(sig_delr_is2_pmos90b_sphv_10hv*nsig_delr_is2_pmos90b_sphv_10hv))
+ delr_ir_pmos90b_sphv_10hv = (nom_delr_ir_pmos90b_sphv_10hv*exp(sig_delr_ir_pmos90b_sphv_10hv*nsig_delr_ir_pmos90b_sphv_10hv))


+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_pmos90b_sphv_10hv)
+    cox                            = (epsox/tox)
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)



cgd_fld_d (g d) capacitor c=(cpp_ply_fld*aplyfld_d)
cgb_fld_b (g b) capacitor c=(cpp_ply_fld*aplyfld_b + 5e-15*ng)

ccsb_pmos90b_10hv_m2m1_par (s b) capacitor c=csb_pmos90b_10hv_m2m1_par
cgs_par (g s) capacitor c=(7e-16*ng)
xcdgoptub_box_sub_10hv (b sub) cdgoptub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

mamost (d g s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


if (ng_dmy >= 2) {

cgd_fld_d_dmy (s d) capacitor c=(cpp_ply_fld*aplyfld_d_dmy)
cgb_fld_b_dmy (s b) capacitor c=(cpp_ply_fld*aplyfld_b_dmy + 5e-15*ng_dmy)

mamost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


}


model sphvt_simkit sphvt
+ type           = p
+ tr           = 27
+ vdscale      = (vdscale_pmos90b_sphv_10hv+dela_vdscale_pmos90b_sphv_10hv+(vdscalel_pmos90b_sphv_10hv+dela_vdscalel_pmos90b_sphv_10hv)/l+(vdscalew_pmos90b_sphv_10hv+dela_vdscalew_pmos90b_sphv_10hv)/w+(vdscalelw_pmos90b_sphv_10hv+dela_vdscalelw_pmos90b_sphv_10hv)/w/l)
+ vdscaleb      = (vdscaleb_pmos90b_sphv_10hv*(l+vdscalebl_pmos90b_sphv_10hv)/l)
+ stvdscale      = stvdscale_pmos90b_sphv_10hv
+ ctgo      = ctgo_pmos90b_sphv_10hv
+ ctbo      = ctbo_pmos90b_sphv_10hv
+ stcto      = stcto_pmos90b_sphv_10hv
+ mumb      = mumb_pmos90b_sphv_10hv+fac_a_ng_mumb
+ mumbexp   = mumbexp_pmos90b_sphv_10hv
+ mumbvclmp      = mumbvclmp_pmos90b_sphv_10hv
+ swdrlin           = 0
+ swgeo        	= 1
+ swigate      	  = 0
+ swimpact     	   = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	    = 1
+ swshe        	= selfheat*enable_selfheat
+ swtcec      	  = 1
+ swimpdr      	  = 1
+ swexp        	= 0
+ swdelvtac    	    = 1
+ swnud        	= 0
+ swptest      	  = 0
+ swgedi      	  = 1
+ xvsat           = xvsat_pmos90b_sphv_10hv
+ qmc           = qmc_pmos90b_sphv_10hv
+ lvaro        	= lvaro_pmos90b_sphv_10hv
+ lvarl        	= lvarl_pmos90b_sphv_10hv
+ lvarw        	= lvarw_pmos90b_sphv_10hv
+ lap           = lap_pmos90b_sphv_10hv
+ wvaro        	= (wvaro_pmos90b_sphv_10hv+1e-6*dela_dw_pmos90b_sphv_10hv)
+ wvarl        	= (wvarl_pmos90b_sphv_10hv)
+ wvarw        	= (wvarw_pmos90b_sphv_10hv)
+ wot           = wot_pmos90b_sphv_10hv
+ dlq           = dlq_pmos90b_sphv_10hv
+ dwq           = dwq_pmos90b_sphv_10hv
+ vfbo           = (vfbo_pmos90b_sphv_10hv+fac_a_ng_vfbo+dela_vfb_pmos90b_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pmos90b_vthratio)
+ vfbl           = (vfbl_pmos90b_sphv_10hv+dela_vtl_pmos90b_sphv_10hv)
+ vfbw           = (vfbw_pmos90b_sphv_10hv+dela_vtw_pmos90b_sphv_10hv)
+ vfblw        	= (vfblw_pmos90b_sphv_10hv)
+ stvfbo       	 = stvfbo_pmos90b_sphv_10hv
+ stvfbl       	 = stvfbl_pmos90b_sphv_10hv
+ stvfbw       	 = stvfbw_pmos90b_sphv_10hv
+ stvfblw      	  = stvfblw_pmos90b_sphv_10hv
+ toxo           = toxo_pmos90b_sphv_10hv*delr_tox_pmos90b_sphv_10hv
+ epsroxo      	  = epsroxo_pmos90b_sphv_10hv
+ nsubo        	= nsubo_pmos90b_sphv_10hv*delr_nsub_pmos90b_sphv_10hv
+ nsubw        	= nsubw_pmos90b_sphv_10hv
+ wseg           = wseg_pmos90b_sphv_10hv
+ npck           = npck_pmos90b_sphv_10hv
+ npckw        	= npckw_pmos90b_sphv_10hv
+ wsegp        	= wsegp_pmos90b_sphv_10hv
+ lpck           = lpck_pmos90b_sphv_10hv
+ lpckw        	= lpckw_pmos90b_sphv_10hv
+ fol1           = fol1_pmos90b_sphv_10hv
+ fol2           = fol2_pmos90b_sphv_10hv
+ facneffaco   	     = facneffaco_pmos90b_sphv_10hv
+ facneffacl   	     = facneffacl_pmos90b_sphv_10hv
+ facneffacw   	     = facneffacw_pmos90b_sphv_10hv
+ facneffaclw  	      = facneffaclw_pmos90b_sphv_10hv
+ gfacnudo     	   = gfacnudo_pmos90b_sphv_10hv
+ gfacnudl     	   = gfacnudl_pmos90b_sphv_10hv
+ gfacnudlexp  	      = gfacnudlexp_pmos90b_sphv_10hv
+ gfacnudw     	   = gfacnudw_pmos90b_sphv_10hv
+ gfacnudlw    	    = gfacnudlw_pmos90b_sphv_10hv
+ vsbnudo      	  = vsbnudo_pmos90b_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_pmos90b_sphv_10hv
+ vnsubo       	 = vnsubo_pmos90b_sphv_10hv
+ nslpo        	= nslpo_pmos90b_sphv_10hv
+ dnsubo       	 = dnsubo_pmos90b_sphv_10hv
+ dphibo       	 = dphibo_pmos90b_sphv_10hv
+ dphibl       	 = dphibl_pmos90b_sphv_10hv
+ dphiblexp    	    = dphiblexp_pmos90b_sphv_10hv
+ dphibw       	 = (dphibw_pmos90b_sphv_10hv)
+ dphiblw      	  = (dphiblw_pmos90b_sphv_10hv)
+ delvtaco     	   = delvtaco_pmos90b_sphv_10hv
+ delvtacl     	   = delvtacl_pmos90b_sphv_10hv
+ delvtaclexp  	      = delvtaclexp_pmos90b_sphv_10hv
+ delvtacw     	   = delvtacw_pmos90b_sphv_10hv
+ delvtaclw    	    = delvtaclw_pmos90b_sphv_10hv
+ npo           = npo_pmos90b_sphv_10hv
+ npl           = npl_pmos90b_sphv_10hv
+ cto           = cto_pmos90b_sphv_10hv
+ ctl           = ctl_pmos90b_sphv_10hv
+ ctlexp       	 = ctlexp_pmos90b_sphv_10hv
+ ctw           = ctw_pmos90b_sphv_10hv
+ ctlw           = ctlw_pmos90b_sphv_10hv
+ toxovo       	 = toxovo_pmos90b_sphv_10hv*delr_tox_pmos90b_sphv_10hv
+ toxovdo      	  = toxovdo_pmos90b_sphv_10hv*delr_tox_pmos90b_sphv_10hv
+ lov           = lov_pmos90b_sphv_10hv
+ dlovd        	= dlovd_pmos90b_sphv_10hv
+ novo           = novo_pmos90b_sphv_10hv
+ novdo        	= novdo_pmos90b_sphv_10hv
+ cfl           = cfl_pmos90b_sphv_10hv
+ cflexp       	 = cflexp_pmos90b_sphv_10hv
+ cfw           = cfw_pmos90b_sphv_10hv
+ cfbo           = cfbo_pmos90b_sphv_10hv
+ uo           = (uo_pmos90b_sphv_10hv*delr_uch_pmos90b_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1        	= fbet1_pmos90b_sphv_10hv
+ fbet1w       	 = fbet1w_pmos90b_sphv_10hv
+ lp1           = lp1_pmos90b_sphv_10hv
+ lp1w           = lp1w_pmos90b_sphv_10hv
+ fbet2        	= fbet2_pmos90b_sphv_10hv
+ lp2           = lp2_pmos90b_sphv_10hv
+ betw1        	= betw1_pmos90b_sphv_10hv
+ betw2        	= betw2_pmos90b_sphv_10hv
+ wbet           = wbet_pmos90b_sphv_10hv
+ stbeto       	 = stbeto_pmos90b_sphv_10hv
+ stbetl       	 = stbetl_pmos90b_sphv_10hv
+ stbetw       	 = stbetw_pmos90b_sphv_10hv
+ stbetlw      	  = stbetlw_pmos90b_sphv_10hv
+ mueo           = (mueo_pmos90b_sphv_10hv+dela_mueo_pmos90b_sphv_10hv)
+ muew           = muew_pmos90b_sphv_10hv
+ stmueo       	 = stmueo_pmos90b_sphv_10hv
+ themuo       	 = themuo_pmos90b_sphv_10hv
+ stthemuo     	   = stthemuo_pmos90b_sphv_10hv
+ cso           = cso_pmos90b_sphv_10hv
+ csl           = csl_pmos90b_sphv_10hv
+ cslexp       	 = cslexp_pmos90b_sphv_10hv
+ csw           = csw_pmos90b_sphv_10hv
+ cslw           = cslw_pmos90b_sphv_10hv
+ stcso        	= stcso_pmos90b_sphv_10hv
+ xcoro        	= xcoro_pmos90b_sphv_10hv
+ xcorl        	= xcorl_pmos90b_sphv_10hv
+ xcorw        	= xcorw_pmos90b_sphv_10hv
+ xcorlw       	 = xcorlw_pmos90b_sphv_10hv
+ stxcoro      	  = stxcoro_pmos90b_sphv_10hv
+ fetao        	= fetao_pmos90b_sphv_10hv
+ rsw1           = rsw1_pmos90b_sphv_10hv
+ rsw2           = rsw2_pmos90b_sphv_10hv
+ strso        	= strso_pmos90b_sphv_10hv
+ rsbo           = rsbo_pmos90b_sphv_10hv
+ rsgo           = rsgo_pmos90b_sphv_10hv
+ thesato      	  = (thesato_pmos90b_sphv_10hv)
+ thesatl      	  = thesatl_pmos90b_sphv_10hv
+ thesatlexp   	     = thesatlexp_pmos90b_sphv_10hv
+ thesatw      	  = (thesatw_pmos90b_sphv_10hv)
+ thesatlw     	   = thesatlw_pmos90b_sphv_10hv
+ stthesato    	    = stthesato_pmos90b_sphv_10hv
+ stthesatl    	    = stthesatl_pmos90b_sphv_10hv
+ stthesatw    	    = stthesatw_pmos90b_sphv_10hv
+ stthesatlw   	     = stthesatlw_pmos90b_sphv_10hv
+ thesatbo     	   = thesatbo_pmos90b_sphv_10hv
+ thesatgo     	   = thesatgo_pmos90b_sphv_10hv
+ thesatgl     	   = thesatgl_pmos90b_sphv_10hv
+ thesatgw     	   = thesatgw_pmos90b_sphv_10hv
+ axo           = axo_pmos90b_sphv_10hv
+ axl           = axl_pmos90b_sphv_10hv
+ alpl           = alpl_pmos90b_sphv_10hv
+ alplexp      	  = alplexp_pmos90b_sphv_10hv
+ alpw           = alpw_pmos90b_sphv_10hv
+ alp1l1       	 = alp1l1_pmos90b_sphv_10hv
+ alp1lexp     	   = alp1lexp_pmos90b_sphv_10hv
+ alp1l2       	 = alp1l2_pmos90b_sphv_10hv
+ alp1w        	= alp1w_pmos90b_sphv_10hv
+ alp2l1       	 = alp2l1_pmos90b_sphv_10hv
+ alp2lexp     	   = alp2lexp_pmos90b_sphv_10hv
+ alp2l2       	 = alp2l2_pmos90b_sphv_10hv
+ alp2w        	= alp2w_pmos90b_sphv_10hv
+ vpo           = vpo_pmos90b_sphv_10hv
+ a1o           = a1o_pmos90b_sphv_10hv
+ a1l           = a1l_pmos90b_sphv_10hv
+ a1w           = a1w_pmos90b_sphv_10hv
+ a2o           = a2o_pmos90b_sphv_10hv
+ sta2o        	= sta2o_pmos90b_sphv_10hv
+ a3o           = a3o_pmos90b_sphv_10hv
+ a3l           = a3l_pmos90b_sphv_10hv
+ a3w           = a3w_pmos90b_sphv_10hv
+ a4o           = a4o_pmos90b_sphv_10hv
+ a4l           = a4l_pmos90b_sphv_10hv
+ a4w           = a4w_pmos90b_sphv_10hv
+ gcoo           = gcoo_pmos90b_sphv_10hv
+ iginvlw      	  = iginvlw_pmos90b_sphv_10hv
+ igovw        	= igovw_pmos90b_sphv_10hv
+ igovdw       	 = igovdw_pmos90b_sphv_10hv
+ stigo        	= stigo_pmos90b_sphv_10hv
+ gc2o           = gc2o_pmos90b_sphv_10hv
+ gc3o           = gc3o_pmos90b_sphv_10hv
+ chibo        	= chibo_pmos90b_sphv_10hv
+ agidlw       	 = agidlw_pmos90b_sphv_10hv
+ agidldw      	  = agidldw_pmos90b_sphv_10hv
+ bgidlo       	 = bgidlo_pmos90b_sphv_10hv
+ bgidldo      	  = bgidldo_pmos90b_sphv_10hv
+ stbgidlo     	   = stbgidlo_pmos90b_sphv_10hv
+ stbgidldo    	    = stbgidldo_pmos90b_sphv_10hv
+ cgidlo       	 = cgidlo_pmos90b_sphv_10hv
+ cgidldo      	  = cgidldo_pmos90b_sphv_10hv
+ cgbovl       	 = cgbovl_pmos90b_sphv_10hv
+ cfrw           = cfrw_pmos90b_sphv_10hv
+ cfrdw        	= cfrdw_pmos90b_sphv_10hv
+ fnto           = fnto_pmos90b_sphv_10hv
+ nfalw        	= nfalw_pmos90b_sphv_10hv
+ nfblw        	= nfblw_pmos90b_sphv_10hv
+ nfclw        	= nfclw_pmos90b_sphv_10hv
+ efo           = efo_pmos90b_sphv_10hv
+ lintnoi      	  = lintnoi_pmos90b_sphv_10hv
+ alpnoi       	 = alpnoi_pmos90b_sphv_10hv
+ kvthoweo     	   = kvthoweo_pmos90b_sphv_10hv
+ kvthowel     	   = kvthowel_pmos90b_sphv_10hv
+ kvthowew     	   = kvthowew_pmos90b_sphv_10hv
+ kvthowelw    	    = kvthowelw_pmos90b_sphv_10hv
+ kuoweo       	 = kuoweo_pmos90b_sphv_10hv
+ kuowel       	 = kuowel_pmos90b_sphv_10hv
+ kuowew       	 = kuowew_pmos90b_sphv_10hv
+ kuowelw      	  = kuowelw_pmos90b_sphv_10hv
+ rgo           = rgo_pmos90b_sphv_10hv
+ rsh           = rsh_pmos90b_sphv_10hv
+ rbulko       	 = rbulko_pmos90b_sphv_10hv
+ rwello       	 = rwello_pmos90b_sphv_10hv
+ rjunso       	 = rjunso_pmos90b_sphv_10hv/(w+dwrjunso_pmos90b_sphv_10hv)
+ rjundo       	 = rjundo_pmos90b_sphv_10hv/(w+dwrjundo_pmos90b_sphv_10hv)*sqrt(l)/(sqrt(l)+3.0)
+ rint           = rint_pmos90b_sphv_10hv
+ rvpoly       	 = rvpoly_pmos90b_sphv_10hv
+ rshg           = rshg_pmos90b_sphv_10hv
+ dlsil        	= dlsil_pmos90b_sphv_10hv
+ saref        	= saref_pmos90b_sphv_10hv
+ sbref        	= sbref_pmos90b_sphv_10hv
+ wlod           = wlod_pmos90b_sphv_10hv
+ kuo           = kuo_pmos90b_sphv_10hv
+ kvsat        	= kvsat_pmos90b_sphv_10hv
+ tkuo           = tkuo_pmos90b_sphv_10hv
+ lkuo           = lkuo_pmos90b_sphv_10hv
+ wkuo           = wkuo_pmos90b_sphv_10hv
+ pkuo           = pkuo_pmos90b_sphv_10hv
+ llodkuo      	  = llodkuo_pmos90b_sphv_10hv
+ wlodkuo      	  = wlodkuo_pmos90b_sphv_10hv
+ kvtho        	= kvtho_pmos90b_sphv_10hv
+ lkvtho       	 = lkvtho_pmos90b_sphv_10hv
+ wkvtho       	 = wkvtho_pmos90b_sphv_10hv
+ pkvtho       	 = pkvtho_pmos90b_sphv_10hv
+ llodvth      	  = llodvth_pmos90b_sphv_10hv
+ wlodvth      	  = wlodvth_pmos90b_sphv_10hv
+ stetao       	 = stetao_pmos90b_sphv_10hv
+ lodetao      	  = lodetao_pmos90b_sphv_10hv
+ scref        	= scref_pmos90b_sphv_10hv
+ web           = web_pmos90b_sphv_10hv
+ wec           = wec_pmos90b_sphv_10hv
+ adr1o        	= adr1o_pmos90b_sphv_10hv
+ adr1l        	= adr1l_pmos90b_sphv_10hv
+ adr1w        	= adr1w_pmos90b_sphv_10hv
+ adr2o        	= adr2o_pmos90b_sphv_10hv
+ stadr2o      	  = stadr2o_pmos90b_sphv_10hv
+ adr3o        	= adr3o_pmos90b_sphv_10hv
+ adr3l        	= adr3l_pmos90b_sphv_10hv
+ adr3w        	= adr3w_pmos90b_sphv_10hv
+ adr4o        	= adr4o_pmos90b_sphv_10hv
+ adr4l        	= adr4l_pmos90b_sphv_10hv
+ adr4w        	= adr4w_pmos90b_sphv_10hv
+ adr5o        	= adr5o_pmos90b_sphv_10hv
+ adr5l        	= adr5l_pmos90b_sphv_10hv
+ adr5w        	= adr5w_pmos90b_sphv_10hv
+ bidr1o       	 = bidr1o_pmos90b_sphv_10hv
+ bidr1l       	 = bidr1l_pmos90b_sphv_10hv
+ bidr1w       	 = bidr1w_pmos90b_sphv_10hv
+ bidr2o       	 = bidr2o_pmos90b_sphv_10hv
+ bidr2w       	 = bidr2w_pmos90b_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	= 0
+ strtho       	 = strtho_pmos90b_sphv_10hv
+ strthao       	 = strthao_pmos90b_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	= 0
+ rshldd       	 = (rshldd_pmos90b_sphv_10hv*fac_r_ng_rshldd*delr_res_pmos90b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pmos90b_ronratio))
+ xw           = (xw_pmos90b_sphv_10hv)
+ nwxw           = (nwxw_pmos90b_sphv_10hv)
+ xl           = xl_pmos90b_sphv_10hv
+ xlw           = xlw_pmos90b_sphv_10hv
+ dxlsat       	 = dxlsat_pmos90b_sphv_10hv
+ nst           = nst_pmos90b_sphv_10hv
+ ats           = ats_pmos90b_sphv_10hv
+ dfinf        	= dfinf_pmos90b_sphv_10hv
+ dfw           = dfw_pmos90b_sphv_10hv
+ dfl           = dfl_pmos90b_sphv_10hv
+ dflw           = dflw_pmos90b_sphv_10hv
+ dp           = dp_pmos90b_sphv_10hv
+ ecrit        	= ecrit_pmos90b_sphv_10hv*fac_r_ng_ecrit*tfact_ecrit*(1+1/w)
+ ecorn        	= ecorn_pmos90b_sphv_10hv*fac_r_ng_ecrit*tfact_ecrit*(1+1/w)
+ du           = du_pmos90b_sphv_10hv
+ tc1           = tc1_pmos90b_sphv_10hv
+ tc2           = tc2_pmos90b_sphv_10hv
+ tc1l           = tc1l_pmos90b_sphv_10hv
+ tc2l           = tc2l_pmos90b_sphv_10hv
+ tc1w           = tc1w_pmos90b_sphv_10hv
+ tc2w           = tc2w_pmos90b_sphv_10hv
+ theacc       	 = theacc_pmos90b_sphv_10hv
+ theacc2      	  = theacc2_pmos90b_sphv_10hv
+ rva           = rva_pmos90b_sphv_10hv
+ dta           = dta_pmos90b_sphv_10hv
+ trj           = trj_pmos90b_sphv_10hv
+ cjarea       	 = cjarea_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ cjlsti       	 = cjlsti_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ cjlgat       	 = cjlgat_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ vbiarea      	  = vbiarea_pmos90b_sphv_10hv
+ vbisti       	 = vbisti_pmos90b_sphv_10hv
+ vbigat       	 = vbigat_pmos90b_sphv_10hv
+ parea        	= parea_pmos90b_sphv_10hv
+ psti           = psti_pmos90b_sphv_10hv
+ pgat           = pgat_pmos90b_sphv_10hv
+ is1area      	  = is1area_pmos90b_sphv_10hv*delr_is_pmos90b_sphv_10hv
+ ttarea       	 = ttarea_pmos90b_sphv_10hv
+ is2area      	  = is2area_pmos90b_sphv_10hv*delr_is2_pmos90b_sphv_10hv
+ irarea       	 = irarea_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1area    	    = stis1area_pmos90b_sphv_10hv
+ stis2area    	    = stis2area_pmos90b_sphv_10hv
+ stirarea     	   = stirarea_pmos90b_sphv_10hv
+ n1area       	 = n1area_pmos90b_sphv_10hv
+ n2area       	 = n2area_pmos90b_sphv_10hv
+ nrarea       	 = nrarea_pmos90b_sphv_10hv
+ is1lsti      	  = is1lsti_pmos90b_sphv_10hv*delr_is_pmos90b_sphv_10hv
+ ttlsti       	 = ttlsti_pmos90b_sphv_10hv
+ is2lsti      	  = is2lsti_pmos90b_sphv_10hv*delr_is2_pmos90b_sphv_10hv
+ irlsti       	 = irlsti_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1sti     	   = stis1sti_pmos90b_sphv_10hv
+ stis2sti     	   = stis2sti_pmos90b_sphv_10hv
+ stirsti      	  = stirsti_pmos90b_sphv_10hv
+ n1sti        	= n1sti_pmos90b_sphv_10hv
+ n2sti        	= n2sti_pmos90b_sphv_10hv
+ nrsti        	= nrsti_pmos90b_sphv_10hv
+ is1lgat      	  = is1lgat_pmos90b_sphv_10hv*delr_is_pmos90b_sphv_10hv
+ ttlgat       	 = ttlgat_pmos90b_sphv_10hv
+ is2lgat      	  = is2lgat_pmos90b_sphv_10hv*delr_is2_pmos90b_sphv_10hv
+ irlgat       	 = irlgat_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1gat     	   = stis1gat_pmos90b_sphv_10hv
+ stis2gat     	   = stis2gat_pmos90b_sphv_10hv
+ stirgat      	  = stirgat_pmos90b_sphv_10hv
+ n1gat        	= n1gat_pmos90b_sphv_10hv
+ n2gat        	= n2gat_pmos90b_sphv_10hv
+ nrgat        	= nrgat_pmos90b_sphv_10hv
+ cjaread      	  = cjaread_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ cjlstid      	  = cjlstid_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ cjlgatd      	  = cjlgatd_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ vbiaread     	   = vbiaread_pmos90b_sphv_10hv
+ vbistid      	  = vbistid_pmos90b_sphv_10hv
+ vbigatd      	  = vbigatd_pmos90b_sphv_10hv
+ paread       	 = paread_pmos90b_sphv_10hv
+ pstid        	= pstid_pmos90b_sphv_10hv
+ pgatd        	= pgatd_pmos90b_sphv_10hv
+ is1aread     	   = is1aread_pmos90b_sphv_10hv*delr_is_pmos90b_sphv_10hv
+ ttaread      	  = ttaread_pmos90b_sphv_10hv
+ is2aread     	   = is2aread_pmos90b_sphv_10hv*delr_is2_pmos90b_sphv_10hv
+ iraread      	  = iraread_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1aread   	     = stis1aread_pmos90b_sphv_10hv
+ stis2aread   	     = stis2aread_pmos90b_sphv_10hv
+ stiraread    	    = stiraread_pmos90b_sphv_10hv
+ n1aread      	  = n1aread_pmos90b_sphv_10hv
+ n2aread      	  = n2aread_pmos90b_sphv_10hv
+ nraread      	  = nraread_pmos90b_sphv_10hv
+ is1lstid     	   = is1aread_pmos90b_sphv_10hv*djunc*1e-10*delr_is_pmos90b_sphv_10hv
+ ttlstid      	  = ttlstid_pmos90b_sphv_10hv
+ is2lstid     	   = is2aread_pmos90b_sphv_10hv*djunc*1e-10*delr_is2_pmos90b_sphv_10hv
+ irlstid      	  = irlstid_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1stid    	    = stis1stid_pmos90b_sphv_10hv
+ stis2stid    	    = stis2stid_pmos90b_sphv_10hv
+ stirstid     	   = stirstid_pmos90b_sphv_10hv
+ n1stid       	 = n1stid_pmos90b_sphv_10hv
+ n2stid       	 = n2stid_pmos90b_sphv_10hv
+ nrstid       	 = nrstid_pmos90b_sphv_10hv
+ is1lgatd     	   = is1aread_pmos90b_sphv_10hv*djunc*delr_is_pmos90b_sphv_10hv
+ ttlgatd      	  = ttlgatd_pmos90b_sphv_10hv
+ is2lgatd     	   = is2aread_pmos90b_sphv_10hv*djunc*delr_is2_pmos90b_sphv_10hv
+ irlgatd      	  = irlgatd_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1gatd    	    = stis1gatd_pmos90b_sphv_10hv
+ stis2gatd    	    = stis2gatd_pmos90b_sphv_10hv
+ stirgatd     	   = stirgatd_pmos90b_sphv_10hv
+ n1gatd       	 = n1gatd_pmos90b_sphv_10hv
+ n2gatd       	 = n2gatd_pmos90b_sphv_10hv
+ nrgatd       	 = nrgatd_pmos90b_sphv_10hv
+ cjaread2     	   = cjaread_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ cjlstid2     	   = cjlstid_pmos90b_sphv_10hv*delr_cj_pmos90b_sphv_10hv
+ vbiaread2    	    = vbiaread2_pmos90b_sphv_10hv
+ vbistid2     	   = vbistid2_pmos90b_sphv_10hv
+ paread2      	  = paread2_pmos90b_sphv_10hv
+ pstid2       	 = pstid2_pmos90b_sphv_10hv
+ is1aread2    	    = is1aread_pmos90b_sphv_10hv*delr_is_pmos90b_sphv_10hv
+ ttaread2     	   = ttaread2_pmos90b_sphv_10hv
+ is2aread2    	    = is2aread_pmos90b_sphv_10hv*delr_is2_pmos90b_sphv_10hv
+ iraread2     	   = iraread2_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1aread2  	      = stis1aread_pmos90b_sphv_10hv
+ stis2aread2  	      = stis2aread_pmos90b_sphv_10hv
+ stiraread2   	     = stiraread2_pmos90b_sphv_10hv
+ n1aread2     	   = n1aread2_pmos90b_sphv_10hv
+ n2aread2     	   = n2aread2_pmos90b_sphv_10hv
+ nraread2     	   = nraread2_pmos90b_sphv_10hv
+ is1lstid2    	    = is1aread_pmos90b_sphv_10hv*djunc*delr_is_pmos90b_sphv_10hv
+ ttlstid2     	   = ttlstid2_pmos90b_sphv_10hv
+ is2lstid2    	    = is2aread_pmos90b_sphv_10hv*djunc*delr_is2_pmos90b_sphv_10hv
+ irlstid2     	   = irlstid2_pmos90b_sphv_10hv*delr_ir_pmos90b_sphv_10hv
+ stis1stid2   	     = stis1stid2_pmos90b_sphv_10hv
+ stis2stid2   	     = stis2stid2_pmos90b_sphv_10hv
+ stirstid2    	    = stirstid2_pmos90b_sphv_10hv
+ n1stid2      	  = n1stid2_pmos90b_sphv_10hv
+ n2stid2      	  = n2stid2_pmos90b_sphv_10hv
+ nrstid2      	  = nrstid2_pmos90b_sphv_10hv
+ aacc              = aacc_pmos90b_sphv_10hv
+ eais1area=eais1area_pmos90b_sphv_10hv
+ eais2area=eais2area_pmos90b_sphv_10hv
+ eairarea=eairarea_pmos90b_sphv_10hv
+ eais1sti=eais1sti_pmos90b_sphv_10hv
+ eais2sti=eais2sti_pmos90b_sphv_10hv
+ eairsti=eairsti_pmos90b_sphv_10hv
+ eais1gat=eais1gat_pmos90b_sphv_10hv
+ eais2gat=eais2gat_pmos90b_sphv_10hv
+ eairgat=eairgat_pmos90b_sphv_10hv
+ eais1aread=eais1aread_pmos90b_sphv_10hv
+ eais2aread=eais2aread_pmos90b_sphv_10hv
+ eairaread=eairaread_pmos90b_sphv_10hv
+ eais1stid=eais1stid_pmos90b_sphv_10hv
+ eais2stid=eais2stid_pmos90b_sphv_10hv
+ eairstid=eairstid_pmos90b_sphv_10hv
+ eais1gatd=eais1gatd_pmos90b_sphv_10hv
+ eais2gatd=eais2gatd_pmos90b_sphv_10hv
+ eairgatd=eairgatd_pmos90b_sphv_10hv
+ eais1aread2=eais1aread2_pmos90b_sphv_10hv
+ eais2aread2=eais2aread2_pmos90b_sphv_10hv
+ eairaread2=eairaread2_pmos90b_sphv_10hv
+ eais1stid2=eais1stid2_pmos90b_sphv_10hv
+ eais2stid2=eais2stid2_pmos90b_sphv_10hv
+ eairstid2=eairstid2_pmos90b_sphv_10hv
+ ikfarea               = ikfarea_pmos90b_sphv_10hv
+ ikflsti               = ikfarea_pmos90b_sphv_10hv*djunc
+ ikflgat               = ikfarea_pmos90b_sphv_10hv*djunc
+ stikfarea              = stikfarea_pmos90b_sphv_10hv
+ stikfsti              = stikfarea_pmos90b_sphv_10hv
+ stikfgat              = stikfarea_pmos90b_sphv_10hv
+ ikfaread              = ikfaread_pmos90b_sphv_10hv*(w/(w+dwikfaread_pmos90b_sphv_10hv))
+ ikflstid              = ikfaread_pmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos90b_sphv_10hv))
+ ikflgatd              = ikfaread_pmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos90b_sphv_10hv))
+ ikfaread2             = ikfaread_pmos90b_sphv_10hv*(w/(w+dwikfaread_pmos90b_sphv_10hv))
+ ikflstid2             = ikfaread_pmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_pmos90b_sphv_10hv))
+ stikfaread             = stikfaread_pmos90b_sphv_10hv
+ stikfstid             = stikfaread_pmos90b_sphv_10hv
+ stikfgatd             = stikfaread_pmos90b_sphv_10hv
+ stikfaread2            = stikfaread_pmos90b_sphv_10hv
+ stikfstid2            = stikfaread_pmos90b_sphv_10hv




include "./smos10hv_ade_dfrt.scs" section=pmos90b_10hv_dfrt
ends

// nmos10_10hv



//ahdl_include "./veriloga/sphv_v2.0.4/sphv.va"

subckt nmos10_10hv (d g s b sub)
parameters
+ l               = 0.5
+ w               = 0.69
+ ng              = 1
+ lpe             = 0
+ ring            = 1
+ soa             = 1
+ sa              = 0
+ sb              = 0
+ body_location   = 0
//the following two paras are not in ams3.8
+ selfheat        = 1
+ mode_rthcth     = 1

parameters
+	 lmin		  = 0.5
+	 wmin		  = 0.69
+    nde          = (fmod(ng,2))
+    nse          = (2-nde)
+    nd           = ((ng+nde)/2)
+    ns           = (1-nde+nd)
+    ndi          = (nd-nde)
+    nsi          = (ns-nse)
+    ngtotal      = (ng)


//reliability parameters
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     =(0.0)
+    nbtivthdegr 		    =(0.0)
+    pbtidamage			    =(0.0)
+    pbtivthdegr		    =(0.0)
+    hcidamage			    =(0.0)
+    hcivthdegr		            =(0.0)
+    hcibetdegrfac                  =(0.0)
+    presto_nmos10_vthratio         = (1.0)
+    presto_nmos10_betaratio        = (1.0)
+    relimo_ratio1_a_hci_nmos10_10hv = (0.123986648)
+    relimo_ratio1_b_hci_nmos10_10hv = (-1.217559847)

// moved from instance parameter into inside because lpe will not extract them
+ as              = 0
+ ps              = 0
+ ad              = 0
+ pd              = 0


//calculation of junction instance parameters
+    lacts_e        = 0.375
+    lacts_i        = 0.42
+    lactd_e        = 0.45
+    lactd_i        = 0.57
+    ldrift         = 0.35
+    wdrift         = (w)
+    wnwx           = 0.6
+    lsplit         = 0.0
+    ldr1           = 0.8
+    lactd2nhv_e    = 0.6

+    default_as_i   = ((lacts_i*w)*nsi/ng)
+    default_as_e   = ((lacts_e*w)*nse/ng)
+    default_ps_i   = (2*(lacts_i+w)*nsi/ng)
+    default_ps_e   = (2*(lacts_e+w)*nse/ng)
+    default_ad_i   = ((ldr1+ldrift/2)*(w+2*wnwx)*2*ndi/ng)
+    default_ad_e   = ((ldr1+ldrift/2)*(w+2*wnwx)*nde/ng)
+    default_pd_i   = ((2*(ldr1+ldrift/2)+w+2*wnwx)*2*ndi/ng)
+    default_pd_e   = ((2*(ldr1+ldrift/2)+w+2*wnwx)*nde/ng)
+    default_ad2_i  = ((lactd_i+ldrift)*(w+2*wnwx)*ndi/ng)
+    default_ad2_e  = ((ldrift/2+lactd_e+lactd2nhv_e)*(w+2*wnwx)*nde/ng)
+    default_pd2_i  = ((lactd_i+ldrift)*2*ndi/ng)
+    default_pd2_e  = ((ldrift+lactd_e*2+lactd2nhv_e*2+w+2*wnwx)*nde/ng)


+    default_as     = ((as/ng)+(as==0)*(default_as_i+default_as_e))
+    default_ps     = ((ps/ng)+(ps==0)*(default_ps_i+default_ps_e))
+    default_ad     = ((ad/ng/2.0)+(ad==0)*(default_ad_i+default_ad_e))
+    default_pd     = ((pd/ng/2.0)+(pd==0)*(default_pd_i+default_pd_e))
+    default_ad2    = ((ad/ng/2.0)+(ad==0)*(default_ad2_i+default_ad2_e))
+    default_pd2    = ((pd/ng/2.0)+(pd==0)*(default_pd2_i+default_pd2_e))

// parameters for cap between b and sub
+    lp2dt_s_left    = (2.175)
+    lp2dt_s_right   = (1.485)
+    lp2dt_d         = (2.00)
+    lg2g_d          = (2.87)
+    lg2g_s          = (0.42)
+    wp2dt_top       = (1.3)
+    wp2dt_bottom    = (1.3)
+    liso            = (lp2dt_s_left+lp2dt_s_right*(nse-1)+l*ng+lg2g_d*ndi+lg2g_s*nsi+lp2dt_d*nde)
+    wiso            = (wp2dt_top+wp2dt_bottom+w)
+    aiso            = (liso*wiso)
+    piso            = (2*(liso+wiso))

//calculation of parasitic cap


+    djunc          = (2.5e-6)

//**parameters for multi ng
//  aux_ng represents a normalized STI-stress scaling caused by mult-ng
//  - for ng=1 aux_ng is 0 (not affecting model for ng=1)
//  - maximum aux_ng is 1 (for infinite ng and mimimum l)
+ aux_ng 			= 2.5*(1/(1+l)-1/(ng+l))
+ facr_ng_rth		= 1 + aux_ng*fac_rth_ng_nmos10_sphv_10hv

//**parameters for sti saeff and sbeff calculation; dummy is not supported yet
//+  ng_a=int_round(ng/2)+1
+  ng_a=int_round(ng/2)+mod(ng,2)
+  ng_b=ng-ng_a

//layout info
+  sa_out=0.375
+  sb_out=0.375
+  sds=0.42
+  sdd=2.87
+  sbx=1.6

+  sdeff=sds+sdd+l
+  saeffa=sa_val_10hv(sa_out,l,ng_a,sdeff)
+  sab=sa_out+l+sdd
+  saeffb=sa_val_10hv(sab,l,ng_b,sdeff)
+  saeff=ng/(ng_a/(saeffa+l/2)+ng_b/(saeffb+l/2))-l/2

//distinguish even or odd ng
+  ng_odd=mod(ng,2)
// even ng
+  sbeffb=sa_val_10hv(sb_out,l,ng_b,sdeff)
+  sba=sb_out+l+sdd
+  sbeffa=sa_val_10hv(sba,l,ng_a,sdeff)
+  sbeff_even=ng/(ng_a/(sbeffa+l/2)+ng_b/(sbeffb+l/2))-l/2

//odd ng
+  sbxb=sbx+l+sds
+  sbeffbo=sa_val_10hv(sbxb,l,ng_b,sdeff)
+  sbeffao=sa_val_10hv(sbx,l,ng_a,sdeff)
+  sbeff_odd=ng/(ng_a/(sbeffao+l/2)+ng_b/(sbeffbo+l/2))-l/2

//sum up even and odd for sbeff
+  sbeff=ng_odd*sbeff_odd+(1-ng_odd)*sbeff_even


+  sa_i                           = (sa+(sa==0)*(saeff))
+  sb_i                           = (sb+(sb==0)*(sbeff))
+  stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+  stress0                        = (1/(0.5*l+0.375)+1/(0.5*l+1.6))

+  nmos10_astivfb                 = (-0.00535*0.6)
+  nmos10_bstivfb                 = (-2.28e-4*15)
//+  nmos10_astinsub                = (-1.4e-5*0.0)
+  nmos10_astiuchref               = (-0.072*0.6)
+  nmos10_bstiuchref               = (-0.001*0.0)
+  nmos10_cstiuchref               = (0.009*0.0)
+  nmos10_astirshldd              = (0.03)
+  sti_pcell_true                 = ((sa_i==0.375)*(sb_i==0.375)+(sa_i==0.375)*(sb_i==1.6))
+  stimod_on                      = ((1-sti_pcell_true)*(enable_sti==1))
+  nmos10_10hv_stivfb             = ((stimod_on)*((nmos10_astivfb+nmos10_bstivfb/sqrt(w))*(stress-stress0)))
//+  nmos10_10hv_stinsub            = ((stimod_on)*((1+nmos10_astinsub*stress)/(1+nmos10_astinsub*stress0))+(1-stimod_on))
+  nmos10_10hv_stiuchref           = ((stimod_on)*(((1+(nmos10_astiuchref+l*nmos10_bstiuchref)*stress+(nmos10_cstiuchref/sqrt(w)))/(1+(nmos10_astiuchref+l*nmos10_bstiuchref)*stress0+(nmos10_cstiuchref/sqrt(w)))))+(1-stimod_on))
+  nmos10_10hv_stirshldd          = ((stimod_on)*((1+nmos10_astirshldd*stress)/(1+nmos10_astirshldd*stress0))+(1-stimod_on))


//**thermal res/cap calculation
+    w_heat         = w
+    l_heat         = (l*ng+lg2g_d*ndi+lg2g_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f          = ((mode_rthcth==0)*1e12+((mode_rthcth==1)+(mode_rthcth==2))*rth*fac_rth_nmos10_sphv_10hv*facr_ng_rth)*ng
+    cth_f          = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng


// parameters for process variations
+ nsmm_delr_tox_nmos10_sphv_10hv  = tmp_nsmm_delr_tox_nmos10_sphv_10hv
+ nsmm_delr_uch_nmos10_sphv_10hv  = tmp_nsmm_delr_uch_nmos10_sphv_10hv
+ nsmm_delr_res_nmos10_sphv_10hv  = tmp_nsmm_delr_res_nmos10_sphv_10hv
+ nsmm_dela_vfb_nmos10_sphv_10hv  = tmp_nsmm_dela_vfb_nmos10_sphv_10hv
+ nsmm_dela_vtw_nmos10_sphv_10hv  = tmp_nsmm_dela_vtw_nmos10_sphv_10hv
+ nsmm_delr_nsub_nmos10_sphv_10hv = tmp_nsmm_delr_nsub_nmos10_sphv_10hv
+ nsmm_dela_dw_nmos10_sphv_10hv   = tmp_nsmm_dela_dw_nmos10_sphv_10hv
+ delr_tox_nmos10_sphv_10hv       = (nom_delr_tox_nmos10_sphv_10hv*(1+sig_delr_tox_nmos10_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_nmos10_sphv_10hv*smm_delr_tox_nmos10_sphv_10hv(l,w,ng)))
//+ delr_tox_nmos10_sphv_10hv       = (nom_delr_tox_nmos10_sphv_10hv*(1+sig_delr_tox_nmos10_sphv_10hv*nsig_delr_tox_nmos10_sphv_10hv+nsmm_delr_tox_nmos10_sphv_10hv*smm_delr_tox_nmos10_sphv_10hv(l,w,ng)))
+ delr_uch_nmos10_sphv_10hv       = (nom_delr_uch_nmos10_sphv_10hv*(1*nmos10_10hv_stiuchref+sig_delr_uch_nmos10_sphv_10hv*nsig_delr_uch_nmos10_sphv_10hv+nsmm_delr_uch_nmos10_sphv_10hv*smm_delr_uch_nmos10_sphv_10hv(l,w,ng)))
+ delr_res_nmos10_sphv_10hv       = (1*nmos10_10hv_stirshldd+nsmm_delr_res_nmos10_sphv_10hv*smm_delr_res_nmos10_sphv_10hv(l,w,ng))
+ dela_vfb_nmos10_sphv_10hv       = (nom_dela_vfb_nmos10_sphv_10hv+nmos10_10hv_stivfb+(sig_dela_vfb_nmos10_sphv_10hv*nsig_dela_vfb_nmos10_sphv_10hv)+nsmm_dela_vfb_nmos10_sphv_10hv*smm_dela_vfb_nmos10_sphv_10hv(l,w,ng))
+ dela_vtl_nmos10_sphv_10hv       = (nom_dela_vtl_nmos10_sphv_10hv+sig_dela_vtl_nmos10_sphv_10hv*nsig_dela_vtl_nmos10_sphv_10hv)
+ dela_vtw_nmos10_sphv_10hv       = (nom_dela_vtw_nmos10_sphv_10hv+sig_dela_vtw_nmos10_sphv_10hv*nsig_dela_vtw_nmos10_sphv_10hv+nsmm_dela_vtw_nmos10_sphv_10hv*smm_dela_vtw_nmos10_sphv_10hv(l,w,ng))
+ dela_dw_nmos10_sphv_10hv        = (nsmm_dela_dw_nmos10_sphv_10hv*smm_dela_dw_nmos10_sphv_10hv(l,w,ng))
+ delr_nsub_nmos10_sphv_10hv      = (1+nsmm_delr_nsub_nmos10_sphv_10hv*smm_delr_nsub_nmos10_sphv_10hv(l,w,ng))
+ delr_thesatl_nmos10_sphv_10hv   = (nom_delr_thesatl_nmos10_sphv_10hv*(1+sig_delr_thesatl_nmos10_sphv_10hv*nsig_delr_thesatl_nmos10_sphv_10hv))
+ delr_thesatlw_nmos10_sphv_10hv  = (nom_delr_thesatlw_nmos10_sphv_10hv*(1+sig_delr_thesatlw_nmos10_sphv_10hv*nsig_delr_thesatlw_nmos10_sphv_10hv))
+ dela_vdscale_nmos10_sphv_10hv   = (nom_dela_vdscale_nmos10_sphv_10hv+sig_dela_vdscale_nmos10_sphv_10hv*nsig_dela_vdscale_nmos10_sphv_10hv)
+ dela_lvaro_nmos10_sphv_10hv     = (nom_dela_lvaro_nmos10_sphv_10hv+(sig_dela_lvaro_nmos10_sphv_10hv*nsig_dela_lvaro_nmos10_sphv_10hv))
+ delr_cj_nmos10_sphv_10hv        = (nom_delr_cj_nmos10_sphv_10hv*(1+sig_delr_cj_nmos10_sphv_10hv*nsig_delr_cj_nmos10_sphv_10hv))
+ delr_is_nmos10_sphv_10hv        = (nom_delr_is_nmos10_sphv_10hv*exp(sig_delr_is_nmos10_sphv_10hv*nsig_delr_is_nmos10_sphv_10hv))
+ delr_is2_nmos10_sphv_10hv       = (nom_delr_is2_nmos10_sphv_10hv*exp(sig_delr_is2_nmos10_sphv_10hv*nsig_delr_is2_nmos10_sphv_10hv))
+ delr_ir_nmos10_sphv_10hv        = (nom_delr_ir_nmos10_sphv_10hv*exp(sig_delr_ir_nmos10_sphv_10hv*nsig_delr_ir_nmos10_sphv_10hv))
+    epsox                        = (3.9*8.85e-12)
+    tox                          = (1.316e-08*delr_tox_nmos10_sphv_10hv)
+    cox                          = (epsox/tox)
+    tn                           = (27.0)
+    tkr                          = (tn+273.15)
+    tkd                          = (temp+273.15)


//ccsb_nmos10_10hv_m2m1_par (s b) capacitor c=csb_nmos10_10hv_m2m1_par
//ccgs_nmos10_10hv_m2m1_par (g s) capacitor c=cgs_nmos10_10hv_m2m1_par
xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=1


mamost (d g s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=default_ad pd=default_pd as=default_as ps=default_ps ad2=default_ad2 pd2=default_pd2

model sphvt_simkit sphvt
+ type           = n
+ vdscale   	   = (vdscale_nmos10_sphv_10hv+dela_vdscale_nmos10_sphv_10hv)
+ ctgo           = 0
+ stcto          = 0
+ stvdscale      = 0
+ strthao        = 0
+ tr             = 27
+ swgeo          = 1
+ swigate        = 0
+ swimpact       = 1
+ swgidl         = 1
+ swjunc         = 2
+ swjunasym      = 1
+ swshe          = selfheat*enable_selfheat
+ swimpdr        = 1
+ swexp          = 0
+ swdelvtac      = 1
+ swnud          = 0
+ swptest        = 0
+ swtcec		   = 1
+ swgedi		   = 1
+ qmc            = qmc_nmos10_sphv_10hv
+ lvaro          = (lvaro_nmos10_sphv_10hv+dela_lvaro_nmos10_sphv_10hv)
+ lvarl          = lvarl_nmos10_sphv_10hv
+ lvarw          = lvarw_nmos10_sphv_10hv
+ lap            = lap_nmos10_sphv_10hv
+ wvaro          = (wvaro_nmos10_sphv_10hv+dela_dw_nmos10_sphv_10hv)
+ wvarl        = (wvarl_nmos10_sphv_10hv)
+ wvarw        	= (wvarw_nmos10_sphv_10hv)
+ wot           = wot_nmos10_sphv_10hv
+ dlq           = dlq_nmos10_sphv_10hv
+ dwq           = dwq_nmos10_sphv_10hv
+ vfbo           = (vfbo_nmos10_sphv_10hv+dela_vfb_nmos10_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos10_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos10_10hv-relimo_ratio1_b_hci_nmos10_10hv))
+ vfbl           = (vfbl_nmos10_sphv_10hv+dela_vtl_nmos10_sphv_10hv)
+ vfbw           = (vfbw_nmos10_sphv_10hv+dela_vtw_nmos10_sphv_10hv)
+ vfblw        	= (vfblw_nmos10_sphv_10hv)
+ stvfbo       	 = stvfbo_nmos10_sphv_10hv
+ stvfbl       	 = stvfbl_nmos10_sphv_10hv
+ stvfbw       	 = stvfbw_nmos10_sphv_10hv
+ stvfblw      	  = stvfblw_nmos10_sphv_10hv
+ toxo           = toxo_nmos10_sphv_10hv*delr_tox_nmos10_sphv_10hv
+ epsroxo      	  = epsroxo_nmos10_sphv_10hv
+ nsubo        	= nsubo_nmos10_sphv_10hv*delr_nsub_nmos10_sphv_10hv
+ nsubw        	= nsubw_nmos10_sphv_10hv
+ wseg           = wseg_nmos10_sphv_10hv
+ npck           = npck_nmos10_sphv_10hv
+ npckw        	= npckw_nmos10_sphv_10hv
+ wsegp        	= wsegp_nmos10_sphv_10hv
+ lpck           = lpck_nmos10_sphv_10hv
+ lpckw        	= lpckw_nmos10_sphv_10hv
+ fol1           = fol1_nmos10_sphv_10hv
+ fol2           = fol2_nmos10_sphv_10hv
+ facneffaco   	     = facneffaco_nmos10_sphv_10hv
+ facneffacl   	     = facneffacl_nmos10_sphv_10hv
+ facneffacw   	     = facneffacw_nmos10_sphv_10hv
+ facneffaclw  	      = facneffaclw_nmos10_sphv_10hv
+ gfacnudo     	   = gfacnudo_nmos10_sphv_10hv
+ gfacnudl     	   = gfacnudl_nmos10_sphv_10hv
+ gfacnudlexp  	      = gfacnudlexp_nmos10_sphv_10hv
+ gfacnudw     	   = gfacnudw_nmos10_sphv_10hv
+ gfacnudlw    	    = gfacnudlw_nmos10_sphv_10hv
+ vsbnudo      	  = vsbnudo_nmos10_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_nmos10_sphv_10hv
+ vnsubo       	 = vnsubo_nmos10_sphv_10hv
+ nslpo        	= nslpo_nmos10_sphv_10hv
+ dnsubo       	 = dnsubo_nmos10_sphv_10hv
+ dphibo       	 = dphibo_nmos10_sphv_10hv
+ dphibl       	 = dphibl_nmos10_sphv_10hv
+ dphiblexp    	    = dphiblexp_nmos10_sphv_10hv
+ dphibw       	 = (dphibw_nmos10_sphv_10hv)
+ dphiblw      	  = (dphiblw_nmos10_sphv_10hv)
+ delvtaco     	   = delvtaco_nmos10_sphv_10hv
+ delvtacl     	   = delvtacl_nmos10_sphv_10hv
+ delvtaclexp  	      = delvtaclexp_nmos10_sphv_10hv
+ delvtacw     	   = delvtacw_nmos10_sphv_10hv
+ delvtaclw    	    = delvtaclw_nmos10_sphv_10hv
+ npo           = npo_nmos10_sphv_10hv
+ npl           = npl_nmos10_sphv_10hv
+ cto           = cto_nmos10_sphv_10hv
+ ctl           = ctl_nmos10_sphv_10hv
+ ctlexp       	 = ctlexp_nmos10_sphv_10hv
+ ctw           = ctw_nmos10_sphv_10hv
+ ctlw           = ctlw_nmos10_sphv_10hv
+ toxovo       	 = toxovo_nmos10_sphv_10hv*delr_tox_nmos10_sphv_10hv
+ toxovdo      	  = toxovdo_nmos10_sphv_10hv*delr_tox_nmos10_sphv_10hv
+ lov           = lov_nmos10_sphv_10hv
+ dlovd        	= dlovd_nmos10_sphv_10hv
+ novo           = novo_nmos10_sphv_10hv*(1+novw_nmos10_sphv_10hv*wmin/w)
+ novdo        	= novdo_nmos10_sphv_10hv*(1+novdw_nmos10_sphv_10hv*wmin/w)
+ cfl           = cfl_nmos10_sphv_10hv
+ cflexp       	 = cflexp_nmos10_sphv_10hv
+ cfw           = cfw_nmos10_sphv_10hv
+ cfbo           = cfbo_nmos10_sphv_10hv
+ uo           = (uo_nmos10_sphv_10hv*delr_uch_nmos10_sphv_10hv*delr_u0_relimo)
+ fbet1        	= fbet1_nmos10_sphv_10hv
+ fbet1w       	 = fbet1w_nmos10_sphv_10hv
+ lp1           = lp1_nmos10_sphv_10hv
+ lp1w           = lp1w_nmos10_sphv_10hv
+ fbet2        	= fbet2_nmos10_sphv_10hv
+ lp2           = lp2_nmos10_sphv_10hv
+ betw1        	= betw1_nmos10_sphv_10hv
+ betw2        	= betw2_nmos10_sphv_10hv
+ wbet           = wbet_nmos10_sphv_10hv
+ stbeto       	 = stbeto_nmos10_sphv_10hv
+ stbetl       	 = stbetl_nmos10_sphv_10hv
+ stbetw       	 = stbetw_nmos10_sphv_10hv
+ stbetlw      	  = stbetlw_nmos10_sphv_10hv
+ mueo           = mueo_nmos10_sphv_10hv
+ muew           = muew_nmos10_sphv_10hv
+ stmueo       	 = stmueo_nmos10_sphv_10hv
+ themuo       	 = themuo_nmos10_sphv_10hv
+ stthemuo     	   = stthemuo_nmos10_sphv_10hv
+ cso           = cso_nmos10_sphv_10hv
+ csl           = csl_nmos10_sphv_10hv
+ cslexp       	 = cslexp_nmos10_sphv_10hv
+ csw           = csw_nmos10_sphv_10hv
+ cslw           = cslw_nmos10_sphv_10hv
+ stcso        	= stcso_nmos10_sphv_10hv
+ xcoro        	= xcoro_nmos10_sphv_10hv
+ xcorl        	= xcorl_nmos10_sphv_10hv
+ xcorw        	= xcorw_nmos10_sphv_10hv
+ xcorlw       	 = xcorlw_nmos10_sphv_10hv
+ stxcoro      	  = stxcoro_nmos10_sphv_10hv
+ fetao        	= fetao_nmos10_sphv_10hv
+ rsw1           = rsw1_nmos10_sphv_10hv
+ rsw2           = rsw2_nmos10_sphv_10hv
+ strso        	= strso_nmos10_sphv_10hv
+ rsbo           = rsbo_nmos10_sphv_10hv
+ rsgo           = rsgo_nmos10_sphv_10hv
+ thesato      	  = thesato_nmos10_sphv_10hv
+ thesatl      	  = thesatl_nmos10_sphv_10hv*delr_thesatl_nmos10_sphv_10hv
+ thesatlexp   	     = thesatlexp_nmos10_sphv_10hv
+ thesatw      	  = thesatw_nmos10_sphv_10hv
+ thesatlw     	   = (thesatlw_nmos10_sphv_10hv*delr_thesatlw_nmos10_sphv_10hv)
+ stthesato    	    = stthesato_nmos10_sphv_10hv
+ stthesatl    	    = stthesatl_nmos10_sphv_10hv
+ stthesatw    	    = stthesatw_nmos10_sphv_10hv
+ stthesatlw   	     = stthesatlw_nmos10_sphv_10hv
+ thesatbo     	   = thesatbo_nmos10_sphv_10hv
+ thesatgo     	   = thesatgo_nmos10_sphv_10hv
+ thesatgl     	   = thesatgl_nmos10_sphv_10hv
+ thesatgw     	   = thesatgw_nmos10_sphv_10hv
+ axo           = axo_nmos10_sphv_10hv
+ axl           = axl_nmos10_sphv_10hv
+ alpl           = alpl_nmos10_sphv_10hv
+ alplexp      	  = alplexp_nmos10_sphv_10hv
+ alpw           = alpw_nmos10_sphv_10hv
+ alp1l1       	 = alp1l1_nmos10_sphv_10hv
+ alp1lexp     	   = alp1lexp_nmos10_sphv_10hv
+ alp1l2       	 = alp1l2_nmos10_sphv_10hv
+ alp1w        	= alp1w_nmos10_sphv_10hv
+ alp2l1       	 = alp2l1_nmos10_sphv_10hv
+ alp2lexp     	   = alp2lexp_nmos10_sphv_10hv
+ alp2l2       	 = alp2l2_nmos10_sphv_10hv
+ alp2w        	= alp2w_nmos10_sphv_10hv
+ vpo           = vpo_nmos10_sphv_10hv
+ a1o           = a1o_nmos10_sphv_10hv
+ a1l           = a1l_nmos10_sphv_10hv
+ a1w           = a1w_nmos10_sphv_10hv
+ a2o           = a2o_nmos10_sphv_10hv
+ sta2o        	= sta2o_nmos10_sphv_10hv
+ a3o           = a3o_nmos10_sphv_10hv
+ a3l           = a3l_nmos10_sphv_10hv
+ a3w           = a3w_nmos10_sphv_10hv
+ a4o           = a4o_nmos10_sphv_10hv
+ a4l           = a4l_nmos10_sphv_10hv
+ a4w           = a4w_nmos10_sphv_10hv
+ gcoo           = gcoo_nmos10_sphv_10hv
+ iginvlw      	  = iginvlw_nmos10_sphv_10hv
+ igovw        	= igovw_nmos10_sphv_10hv
+ igovdw       	 = igovdw_nmos10_sphv_10hv
+ stigo        	= stigo_nmos10_sphv_10hv
+ gc2o           = gc2o_nmos10_sphv_10hv
+ gc3o           = gc3o_nmos10_sphv_10hv
+ chibo        	= chibo_nmos10_sphv_10hv
+ agidlw       	 = agidlw_nmos10_sphv_10hv
+ agidldw      	  = agidldw_nmos10_sphv_10hv
+ bgidlo       	 = bgidlo_nmos10_sphv_10hv
+ bgidldo      	  = bgidldo_nmos10_sphv_10hv
+ stbgidlo     	   = stbgidlo_nmos10_sphv_10hv
+ stbgidldo    	    = stbgidldo_nmos10_sphv_10hv
+ cgidlo       	 = cgidlo_nmos10_sphv_10hv
+ cgidldo      	  = cgidldo_nmos10_sphv_10hv
+ cgbovl       	 = cgbovlo_nmos10_sphv_10hv*(1 + cgbovll_nmos10_sphv_10hv*lmin/l)
+ cfrw           = cfrwo_nmos10_sphv_10hv*(1 + cfrww_nmos10_sphv_10hv*wmin/w)
+ cfrdw        	= cfrdwo_nmos10_sphv_10hv*(1 + cfrdww_nmos10_sphv_10hv*wmin/w)
+ fnto           = fnto_nmos10_sphv_10hv
+ nfalw        	= nfalw_nmos10_sphv_10hv
+ nfblw        	= nfblw_nmos10_sphv_10hv
+ nfclw        	= nfclw_nmos10_sphv_10hv
+ efo           = efo_nmos10_sphv_10hv
+ lintnoi      	  = lintnoi_nmos10_sphv_10hv
+ alpnoi       	 = alpnoi_nmos10_sphv_10hv
+ kvthoweo     	   = kvthoweo_nmos10_sphv_10hv
+ kvthowel     	   = kvthowel_nmos10_sphv_10hv
+ kvthowew     	   = kvthowew_nmos10_sphv_10hv
+ kvthowelw    	    = kvthowelw_nmos10_sphv_10hv
+ kuoweo       	 = kuoweo_nmos10_sphv_10hv
+ kuowel       	 = kuowel_nmos10_sphv_10hv
+ kuowew       	 = kuowew_nmos10_sphv_10hv
+ kuowelw      	  = kuowelw_nmos10_sphv_10hv
+ rgo           = rgo_nmos10_sphv_10hv
+ rsh           = rsh_nmos10_sphv_10hv
+ rbulko       	 = rbulko_nmos10_sphv_10hv
+ rwello       	 = rwello_nmos10_sphv_10hv
+ rjunso       	 = rjunso_nmos10_sphv_10hv/(w+dwrjunso_nmos10_sphv_10hv)
+ rjundo       	 = rjundo_nmos10_sphv_10hv/(w+dwrjundo_nmos10_sphv_10hv)*l/(l+4.0)
+ rint           = rint_nmos10_sphv_10hv
+ rvpoly       	 = rvpoly_nmos10_sphv_10hv
+ rshg           = rshg_nmos10_sphv_10hv
+ dlsil        	= dlsil_nmos10_sphv_10hv
+ saref        	= saref_nmos10_sphv_10hv
+ sbref        	= sbref_nmos10_sphv_10hv
+ wlod           = wlod_nmos10_sphv_10hv
+ kuo           = kuo_nmos10_sphv_10hv
+ kvsat        	= kvsat_nmos10_sphv_10hv
+ tkuo           = tkuo_nmos10_sphv_10hv
+ lkuo           = lkuo_nmos10_sphv_10hv
+ wkuo           = wkuo_nmos10_sphv_10hv
+ pkuo           = pkuo_nmos10_sphv_10hv
+ llodkuo      	  = llodkuo_nmos10_sphv_10hv
+ wlodkuo      	  = wlodkuo_nmos10_sphv_10hv
+ kvtho        	= kvtho_nmos10_sphv_10hv
+ lkvtho       	 = lkvtho_nmos10_sphv_10hv
+ wkvtho       	 = wkvtho_nmos10_sphv_10hv
+ pkvtho       	 = pkvtho_nmos10_sphv_10hv
+ llodvth      	  = llodvth_nmos10_sphv_10hv
+ wlodvth      	  = wlodvth_nmos10_sphv_10hv
+ stetao       	 = stetao_nmos10_sphv_10hv
+ lodetao      	  = lodetao_nmos10_sphv_10hv
+ scref        	= scref_nmos10_sphv_10hv
+ web           = web_nmos10_sphv_10hv
+ wec           = wec_nmos10_sphv_10hv
+ adr1o        	= adr1o_nmos10_sphv_10hv
+ adr1l        	= adr1l_nmos10_sphv_10hv
+ adr1w        	= adr1w_nmos10_sphv_10hv
+ adr2o        	= adr2o_nmos10_sphv_10hv
+ stadr2o      	  = stadr2o_nmos10_sphv_10hv
+ adr3o        	= adr3o_nmos10_sphv_10hv
+ adr3l        	= adr3l_nmos10_sphv_10hv
+ adr3w        	= adr3w_nmos10_sphv_10hv
+ adr4o        	= adr4o_nmos10_sphv_10hv
+ adr4l        	= adr4l_nmos10_sphv_10hv
+ adr4w        	= adr4w_nmos10_sphv_10hv
+ adr5o        	= adr5o_nmos10_sphv_10hv
+ adr5l        	= adr5l_nmos10_sphv_10hv
+ adr5w        	= adr5w_nmos10_sphv_10hv
+ bidr1o       	 = bidr1o_nmos10_sphv_10hv
+ bidr1l       	 = bidr1l_nmos10_sphv_10hv
+ bidr1w       	 = bidr1w_nmos10_sphv_10hv
+ bidr2o       	 = bidr2o_nmos10_sphv_10hv
+ bidr2w       	 = bidr2w_nmos10_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	= 0
+ strtho       	 = strtho_nmos10_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	= 0
+ rshldd       	 = (rshldd_nmos10_sphv_10hv*delr_res_nmos10_sphv_10hv*delr_rdsw_relimo)
+ xw           = (xw_nmos10_sphv_10hv)
+ nwxw           = (nwxw_nmos10_sphv_10hv)
+ xl           = xl_nmos10_sphv_10hv
+ xlw           = xlw_nmos10_sphv_10hv
+ dxlsat       	 = dxlsat_nmos10_sphv_10hv
+ nst           = nst_nmos10_sphv_10hv
+ ats           = ats_nmos10_sphv_10hv
+ dfinf        	= dfinf_nmos10_sphv_10hv
+ dfw           = dfw_nmos10_sphv_10hv
+ dfl           = dfl_nmos10_sphv_10hv
+ dflw           = dflw_nmos10_sphv_10hv
+ dp           = dp_nmos10_sphv_10hv
+ xvsat		 = xvsat_nmos10_sphv_10hv
+ ecrit        	= ecrit_nmos10_sphv_10hv
+ ecorn        	= ecorn_nmos10_sphv_10hv
+ du           = du_nmos10_sphv_10hv
+ tc1           = tc1_nmos10_sphv_10hv
+ tc2           = tc2_nmos10_sphv_10hv
+ tc1l           = tc1l_nmos10_sphv_10hv
+ tc2l           = tc2l_nmos10_sphv_10hv
+ tc1w           = tc1w_nmos10_sphv_10hv
+ tc2w           = tc2w_nmos10_sphv_10hv
+ theacc       	 = theacc_nmos10_sphv_10hv
+ theacc2      	  = theacc2_nmos10_sphv_10hv
+ rva           = rva_nmos10_sphv_10hv
+ dta           = dta_nmos10_sphv_10hv
+ trj           = trj_nmos10_sphv_10hv
+ cjarea       	 = cjarea_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ cjlsti       	 = cjlsti_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ cjlgat       	 = cjlgat_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ vbiarea      	  = vbiarea_nmos10_sphv_10hv
+ vbisti       	 = vbisti_nmos10_sphv_10hv
+ vbigat       	 = vbigat_nmos10_sphv_10hv
+ parea        	= parea_nmos10_sphv_10hv
+ psti           = psti_nmos10_sphv_10hv
+ pgat           = pgat_nmos10_sphv_10hv
+ is1area      	  = is1area_nmos10_sphv_10hv*delr_is_nmos10_sphv_10hv
+ ttarea       	 = ttarea_nmos10_sphv_10hv
+ is2area      	  = is2area_nmos10_sphv_10hv*delr_is2_nmos10_sphv_10hv
+ irarea       	 = irarea_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1area    	    = stis1area_nmos10_sphv_10hv
+ stis2area    	    = stis2area_nmos10_sphv_10hv
+ stirarea     	   = stirarea_nmos10_sphv_10hv
+ n1area       	 = n1area_nmos10_sphv_10hv
+ n2area       	 = n2area_nmos10_sphv_10hv
+ nrarea       	 = nrarea_nmos10_sphv_10hv
+ is1lsti      	  = is1lsti_nmos10_sphv_10hv*delr_is_nmos10_sphv_10hv
+ ttlsti       	 = ttlsti_nmos10_sphv_10hv
+ is2lsti      	  = is2lsti_nmos10_sphv_10hv*delr_is2_nmos10_sphv_10hv
+ irlsti       	 = irlsti_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1sti     	   = stis1sti_nmos10_sphv_10hv
+ stis2sti     	   = stis2sti_nmos10_sphv_10hv
+ stirsti      	  = stirsti_nmos10_sphv_10hv
+ n1sti        	= n1sti_nmos10_sphv_10hv
+ n2sti        	= n2sti_nmos10_sphv_10hv
+ nrsti        	= nrsti_nmos10_sphv_10hv
+ is1lgat      	  = is1lgat_nmos10_sphv_10hv*delr_is_nmos10_sphv_10hv
+ ttlgat       	 = ttlgat_nmos10_sphv_10hv
+ is2lgat      	  = is2lgat_nmos10_sphv_10hv*delr_is2_nmos10_sphv_10hv
+ irlgat       	 = irlgat_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1gat     	   = stis1gat_nmos10_sphv_10hv
+ stis2gat     	   = stis2gat_nmos10_sphv_10hv
+ stirgat      	  = stirgat_nmos10_sphv_10hv
+ n1gat        	= n1gat_nmos10_sphv_10hv
+ n2gat        	= n2gat_nmos10_sphv_10hv
+ nrgat        	= nrgat_nmos10_sphv_10hv
+ cjaread      	  = cjaread_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ cjlstid      	  = cjlstid_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ cjlgatd      	  = cjlgatd_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ vbiaread     	   = vbiaread_nmos10_sphv_10hv
+ vbistid      	  = vbistid_nmos10_sphv_10hv
+ vbigatd      	  = vbigatd_nmos10_sphv_10hv
+ paread       	 = paread_nmos10_sphv_10hv
+ pstid        	= pstid_nmos10_sphv_10hv
+ pgatd        	= pgatd_nmos10_sphv_10hv
+ is1aread     	   = is1aread_nmos10_sphv_10hv*delr_is_nmos10_sphv_10hv
+ ttaread      	  = ttaread_nmos10_sphv_10hv
+ is2aread     	   = is2aread_nmos10_sphv_10hv*delr_is2_nmos10_sphv_10hv
+ iraread      	  = iraread_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1aread   	     = stis1aread_nmos10_sphv_10hv
+ stis2aread   	     = stis2aread_nmos10_sphv_10hv
+ stiraread    	    = stiraread_nmos10_sphv_10hv
+ n1aread      	  = n1aread_nmos10_sphv_10hv
+ n2aread      	  = n2aread_nmos10_sphv_10hv
+ nraread      	  = nraread_nmos10_sphv_10hv
+ is1lstid     	   = is1aread_nmos10_sphv_10hv*djunc*delr_is_nmos10_sphv_10hv
+ ttlstid      	  = ttlstid_nmos10_sphv_10hv
+ is2lstid     	   = is2aread_nmos10_sphv_10hv*djunc*delr_is2_nmos10_sphv_10hv
+ irlstid      	  = irlstid_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1stid    	    = stis1stid_nmos10_sphv_10hv
+ stis2stid    	    = stis2stid_nmos10_sphv_10hv
+ stirstid     	   = stirstid_nmos10_sphv_10hv
+ n1stid       	 = n1stid_nmos10_sphv_10hv
+ n2stid       	 = n2stid_nmos10_sphv_10hv
+ nrstid       	 = nrstid_nmos10_sphv_10hv
+ is1lgatd     	   = is1aread_nmos10_sphv_10hv*djunc*delr_is_nmos10_sphv_10hv
+ ttlgatd      	  = ttlgatd_nmos10_sphv_10hv
+ is2lgatd     	   = is2aread_nmos10_sphv_10hv*djunc*delr_is2_nmos10_sphv_10hv
+ irlgatd      	  = irlgatd_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1gatd    	    = stis1gatd_nmos10_sphv_10hv
+ stis2gatd    	    = stis2gatd_nmos10_sphv_10hv
+ stirgatd     	   = stirgatd_nmos10_sphv_10hv
+ n1gatd       	 = n1gatd_nmos10_sphv_10hv
+ n2gatd       	 = n2gatd_nmos10_sphv_10hv
+ nrgatd       	 = nrgatd_nmos10_sphv_10hv
+ cjaread2     	   = cjaread_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ cjlstid2     	   = cjlstid_nmos10_sphv_10hv*delr_cj_nmos10_sphv_10hv
+ vbiaread2    	    = vbiaread2_nmos10_sphv_10hv
+ vbistid2     	   = vbistid2_nmos10_sphv_10hv
+ paread2      	  = paread2_nmos10_sphv_10hv
+ pstid2       	 = pstid2_nmos10_sphv_10hv
+ is1aread2    	    = is1aread_nmos10_sphv_10hv*delr_is_nmos10_sphv_10hv
+ ttaread2     	   = ttaread2_nmos10_sphv_10hv
+ is2aread2    	    = is2aread_nmos10_sphv_10hv*delr_is2_nmos10_sphv_10hv
+ iraread2     	   = iraread2_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1aread2  	      = stis1aread_nmos10_sphv_10hv
+ stis2aread2  	      = stis2aread_nmos10_sphv_10hv
+ stiraread2   	     = stiraread2_nmos10_sphv_10hv
+ n1aread2     	   = n1aread2_nmos10_sphv_10hv
+ n2aread2     	   = n2aread2_nmos10_sphv_10hv
+ nraread2     	   = nraread2_nmos10_sphv_10hv
+ is1lstid2    	  = is1aread_nmos10_sphv_10hv*djunc*delr_is_nmos10_sphv_10hv
+ ttlstid2     	  = ttlstid2_nmos10_sphv_10hv
+ is2lstid2    	  = is2aread_nmos10_sphv_10hv*djunc*delr_is2_nmos10_sphv_10hv
+ irlstid2     	  = irlstid2_nmos10_sphv_10hv*delr_ir_nmos10_sphv_10hv
+ stis1stid2   	  = stis1stid2_nmos10_sphv_10hv
+ stis2stid2   	  = stis2stid2_nmos10_sphv_10hv
+ stirstid2    	  = stirstid2_nmos10_sphv_10hv
+ n1stid2      	  = n1stid2_nmos10_sphv_10hv
+ n2stid2      	  = n2stid2_nmos10_sphv_10hv
+ nrstid2      	  = nrstid2_nmos10_sphv_10hv
+ aacc              = aacc_nmos10_sphv_10hv
+ eais1area         = eais1area_nmos10_sphv_10hv
+ eais2area         = eais2area_nmos10_sphv_10hv
+ eairarea          = eairarea_nmos10_sphv_10hv
+ eais1sti          = eais1sti_nmos10_sphv_10hv
+ eais2sti          = eais2sti_nmos10_sphv_10hv
+ eairsti           = eairsti_nmos10_sphv_10hv
+ eais1gat          = eais1gat_nmos10_sphv_10hv
+ eais2gat          = eais2gat_nmos10_sphv_10hv
+ eairgat           = eairgat_nmos10_sphv_10hv
+ eais1aread        = eais1aread_nmos10_sphv_10hv
+ eais2aread        = eais2aread_nmos10_sphv_10hv
+ eairaread         = eairaread_nmos10_sphv_10hv
+ eais1stid         = eais1stid_nmos10_sphv_10hv
+ eais2stid         = eais2stid_nmos10_sphv_10hv
+ eairstid          = eairstid_nmos10_sphv_10hv
+ eais1gatd         = eais1gatd_nmos10_sphv_10hv
+ eais2gatd         = eais2gatd_nmos10_sphv_10hv
+ eairgatd          = eairgatd_nmos10_sphv_10hv
+ eais1aread2       = eais1aread2_nmos10_sphv_10hv
+ eais2aread2       = eais2aread2_nmos10_sphv_10hv
+ eairaread2        = eairaread2_nmos10_sphv_10hv
+ eais1stid2        = eais1stid2_nmos10_sphv_10hv
+ eais2stid2        = eais2stid2_nmos10_sphv_10hv
+ eairstid2         = eairstid2_nmos10_sphv_10hv
+ ikfarea               = ikfarea_nmos10_sphv_10hv
+ ikflsti               = ikfarea_nmos10_sphv_10hv*djunc
+ ikflgat               = ikfarea_nmos10_sphv_10hv*djunc
+ stikfarea              = stikfarea_nmos10_sphv_10hv
+ stikfsti              = stikfarea_nmos10_sphv_10hv
+ stikfgat              = stikfarea_nmos10_sphv_10hv
+ ikfaread              = ikfaread_nmos10_sphv_10hv*(w/(w+dwikfaread_nmos10_sphv_10hv))
+ ikflstid              = ikfaread_nmos10_sphv_10hv*djunc*(w/(w+dwikfaread_nmos10_sphv_10hv))
+ ikflgatd              = ikfaread_nmos10_sphv_10hv*djunc*(w/(w+dwikfaread_nmos10_sphv_10hv))
+ ikfaread2             = ikfaread_nmos10_sphv_10hv*(w/(w+dwikfaread_nmos10_sphv_10hv))
+ ikflstid2             = ikfaread_nmos10_sphv_10hv*djunc*(w/(w+dwikfaread_nmos10_sphv_10hv))
+ stikfaread             = stikfaread_nmos10_sphv_10hv
+ stikfstid             = stikfaread_nmos10_sphv_10hv
+ stikfgatd             = stikfaread_nmos10_sphv_10hv
+ stikfaread2            = stikfaread_nmos10_sphv_10hv
+ stikfstid2            = stikfaread_nmos10_sphv_10hv



include "./smos10hv_ade_dfrt.scs" section=nmos10_10hv_dfrt
ends

// nmos90b_10hv



//ahdl_include "./veriloga/sphv_v2.0.16/sphv.va"


subckt nmos90b_10hv (d g s b sub)
parameters
+ l=1.5
+ w=2.0
+ ng=2
+ sti_dummy=0
+ lpe=0
+ soa=1
+ selfheat=1
+ mode_rthcth=1


parameters
+ nde=(fmod(ng,2))
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+ ng_dmy=2*sti_dummy
+ ngeff=ng+ng_dmy
+ ndi_eff=(ngeff/2)
+ nsi_eff=((ngeff-2)/2)

//reliability parameters
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+ presto_device_active           = (1)
+ hcirondegrfac                 = (0.0)
+ offrondegrfac                  = (0.0)
+ hvgsvthdegr                    = (0.0)
+ hcidamage1                     = (0.0)
+ hcidamage2                     = (0.0)
+ offdamage1                     = (0.0)
+ offdamage2                     = (0.0)
+ hvgsdamage                     = (0.0)
+ presto_nmos90b_vthratio        = (1.0)
+ presto_nmos90b_ronratio        = (0.01/0.74)

//calculation of junction instance parameters
+    lacts    = 0.375
+    ldrift   = 5.5
+    wdrift   = (w)
+    wnwx   = 6.7
+    lactd   = 1.41
+    lsplit=0.35

+    ldr1=1.0
+    as_i=(lacts*w)
+    ps_i=2*(lacts+w)
+    ad_i=((ldr1+lsplit)+ldrift/2)*(w+2*wnwx)
+    pd_i=(2*((ldr1+lsplit)+ldrift/2)+w+2*wnwx)
+    ad2_i=(lactd/2+ldrift/2)*(w+2*wnwx)
+    pd2_i=(lactd+ldrift)

//calculation for nbl/psub junction
+    lg2pepi_s    = 2.175     // dt to poly end
+    lp2p_d    = 15.11        // drain nhv end to nhv end
+    lb2b_s    = 1.8          // poly end to ploy at internal source
+    wg2pepi    = 8.96        // width active side to nhv end
+    xbody                       = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody                       = (wg2pepi*2+w)
+    abody                       = (xbody*ybody)
+    pbody                       = (2*(xbody+ybody))

//calculation of parasitic cap
+    length_m2m1                    = (ybody-2.88-8.4)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*(length_m2m1+width_m2m1))
+    csb_nmos90b_10hv_m2m1_par      = ((1-lpe)*((cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)*(ngeff/2+1))+lpe*1e-20)
+    cgs_nmos90b_10hv_m2m1_par      = ((1-lpe)*((l+0.5*lp2p_d)*ng*cfr_m2_m1)+lpe*1e-20)


//+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)

+ ncom2ncom=14.81  //ncom to ncom in length direction
+ inner_p2p=7.01   //inner poly to poly end, small hole
+ poly_split=0.7   //poly split length
+ inner_w_a2p=4.2  //active to poly(hole) in width direction
+ w_a2p=7.35       //active to poly in width direction
+ ncom2poly=0.85   //ncom to poly in length direction

+ aplyfld_d=(ncom2ncom*(w+2*wnwx)-(inner_p2p+2*poly_split)*(w+2*inner_w_a2p) - ncom2poly*w*2 )*ng/2
+ aplyfld_b=((lp2p_d+2*l)*(w+2*w_a2p)-ncom2ncom*(w+2*wnwx)-w*l*2)*ng/2

//parasitic field c for dummy
+ aplyfld_d_dmy=(ncom2ncom*(w+2*wnwx)-(inner_p2p+2*poly_split)*(w+2*inner_w_a2p) - ncom2poly*w*2 )*ng_dmy/2
+ aplyfld_b_dmy=((lp2p_d+2*l)*(w+2*w_a2p)-ncom2ncom*(w+2*wnwx)-w*l*2)*ng_dmy/2


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_nmos90b_sphv_10hv+tc2_ecrit_nmos90b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ dwecrit=dwecrit_nmos90b_sphv_10hv
+ dwecritw=dwecritw_nmos90b_sphv_10hv

+ tfact_rs=((temp+273.15)/(tnom+273.15))**0.1
+ tfact_tt=((temp+273.15)/(tnom+273.15))**1

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*0.09)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+0.2)-2/(2+0.2))*0.195*(w/(w+1.7)))
+ fac_a_ng_vdscalel= -((ngeff/(ngeff+0.2)-2/(2+0.2))*1.0)

//**thermal res/cap calculation
+    she_fit=(1/(1+ng_dmy/(ng_dmy+1)/ng*0.7))
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nmos90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nmos90b_sphv_10hv)*ngeff*she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff/she_fit


// parameters for process variations
+ nsmm_delr_tox_nmos90b_sphv_10hv  = tmp_nsmm_delr_tox_nmos90b_sphv_10hv
+ nsmm_delr_uch_nmos90b_sphv_10hv  = tmp_nsmm_delr_uch_nmos90b_sphv_10hv
+ nsmm_delr_res_nmos90b_sphv_10hv  = tmp_nsmm_delr_res_nmos90b_sphv_10hv
+ nsmm_dela_vfb_nmos90b_sphv_10hv  = tmp_nsmm_dela_vfb_nmos90b_sphv_10hv
+ nsmm_dela_vtw_nmos90b_sphv_10hv  = tmp_nsmm_dela_vtw_nmos90b_sphv_10hv
+ nsmm_delr_nsub_nmos90b_sphv_10hv = tmp_nsmm_delr_nsub_nmos90b_sphv_10hv
+ tc_vfb_mm                          = (1+(temp-27)*(-2.0e-3))
+ delr_tox_nmos90b_sphv_10hv = (nom_delr_tox_nmos90b_sphv_10hv*(1+sig_delr_tox_nmos90b_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_nmos90b_sphv_10hv*smm_delr_tox_nmos90b_sphv_10hv(l,w,ng)))
//+ delr_tox_nmos90b_sphv_10hv = (nom_delr_tox_nmos90b_sphv_10hv*(1+sig_delr_tox_nmos90b_sphv_10hv*nsig_delr_tox_nmos90b_sphv_10hv+nsmm_delr_tox_nmos90b_sphv_10hv*smm_delr_tox_nmos90b_sphv_10hv(l,w,ng)))
+ delr_uch_nmos90b_sphv_10hv = (nom_delr_uch_nmos90b_sphv_10hv*(1+sig_delr_uch_nmos90b_sphv_10hv*nsig_delr_uch_nmos90b_sphv_10hv+nsmm_delr_uch_nmos90b_sphv_10hv*smm_delr_uch_nmos90b_sphv_10hv(l,w,ng)))
+ delr_res_nmos90b_sphv_10hv = (nom_delr_res_nmos90b_sphv_10hv*(1+sig_delr_res_nmos90b_sphv_10hv*nsig_delr_res_nmos90b_sphv_10hv+nsmm_delr_res_nmos90b_sphv_10hv*smm_delr_res_nmos90b_sphv_10hv(l,w,ng)))
+ dela_vfb_nmos90b_sphv_10hv = (nom_dela_vfb_nmos90b_sphv_10hv+(sig_dela_vfb_nmos90b_sphv_10hv*nsig_dela_vfb_nmos90b_sphv_10hv)+tc_vfb_mm*nsmm_dela_vfb_nmos90b_sphv_10hv*smm_dela_vfb_nmos90b_sphv_10hv(l,w,ng))
+ dela_vtl_nmos90b_sphv_10hv = (nom_dela_vtl_nmos90b_sphv_10hv+(sig_dela_vtl_nmos90b_sphv_10hv*nsig_dela_vtl_nmos90b_sphv_10hv))
+ dela_vtw_nmos90b_sphv_10hv = (nom_dela_vtw_nmos90b_sphv_10hv+(sig_dela_vtw_nmos90b_sphv_10hv*nsig_dela_vtw_nmos90b_sphv_10hv)+nsmm_dela_vtw_nmos90b_sphv_10hv*smm_dela_vtw_nmos90b_sphv_10hv(l,w,ng))
+ dela_dw_nmos90b_sphv_10hv = (nom_dela_dw_nmos90b_sphv_10hv+(sig_dela_dw_nmos90b_sphv_10hv*nsig_dela_dw_nmos90b_sphv_10hv))
+ dela_lvaro_nmos90b_sphv_10hv = (nom_dela_lvaro_nmos90b_sphv_10hv+(sig_dela_lvaro_nmos90b_sphv_10hv*nsig_dela_lvaro_nmos90b_sphv_10hv))
+ delr_nsub_nmos90b_sphv_10hv = (1+nsmm_delr_nsub_nmos90b_sphv_10hv*smm_delr_nsub_nmos90b_sphv_10hv(l,w,ng))
+ dela_vdscalel_nmos90b_sphv_10hv =(nom_dela_vdscalel_nmos90b_sphv_10hv+(sig_dela_vdscalel_nmos90b_sphv_10hv*nsig_dela_vdscalel_nmos90b_sphv_10hv))
+ dela_thesato_nmos90b_sphv_10hv = (nom_dela_thesato_nmos90b_sphv_10hv+(sig_dela_thesato_nmos90b_sphv_10hv*nsig_dela_thesato_nmos90b_sphv_10hv))
+ delr_cj_nmos90b_sphv_10hv = (nom_delr_cj_nmos90b_sphv_10hv*(1+sig_delr_cj_nmos90b_sphv_10hv*nsig_delr_cj_nmos90b_sphv_10hv))
+ delr_is_nmos90b_sphv_10hv = (nom_delr_is_nmos90b_sphv_10hv*exp(sig_delr_is_nmos90b_sphv_10hv*nsig_delr_is_nmos90b_sphv_10hv))
+ delr_is2_nmos90b_sphv_10hv = (nom_delr_is2_nmos90b_sphv_10hv*exp(sig_delr_is2_nmos90b_sphv_10hv*nsig_delr_is2_nmos90b_sphv_10hv))
+ delr_ir_nmos90b_sphv_10hv = (nom_delr_ir_nmos90b_sphv_10hv*exp(sig_delr_ir_nmos90b_sphv_10hv*nsig_delr_ir_nmos90b_sphv_10hv))

+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_nmos90b_sphv_10hv)
+    cox                            = (epsox/tox)
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)


cgd_fld_d (g d) capacitor c=(coxfield*aplyfld_d)
cgb_fld_b (g b) capacitor c=(coxfield*aplyfld_b + 4e-15*ng)

ccsb_nmos90b_10hv_m2m1_par (s b) capacitor c=csb_nmos90b_10hv_m2m1_par
ccgs_nmos90b_10hv_m2m1_par (g s) capacitor c=cgs_nmos90b_10hv_m2m1_par
xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1


mamost (d g s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


if (ng_dmy >= 2) {

cgd_fld_d_dmy (s d) capacitor c=(coxfield*aplyfld_d_dmy)
cgb_fld_b_dmy (s b) capacitor c=(coxfield*aplyfld_b_dmy + 4e-15*ng_dmy)

mamost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


}



model sphvt_simkit sphvt
+ type           = n
+ tr           = 27
+ vdscale      = (vdscale_nmos90b_sphv_10hv+(vdscalel_nmos90b_sphv_10hv+dela_vdscalel_nmos90b_sphv_10hv+fac_a_ng_vdscalel)/l+vdscalew_nmos90b_sphv_10hv/w+vdscalelw_nmos90b_sphv_10hv/w/l)
+ vdscaleb      = (vdscaleb_nmos90b_sphv_10hv*(l+vdscalebl_nmos90b_sphv_10hv)/l)
+ stvdscale      = stvdscale_nmos90b_sphv_10hv
+ swdrlin           = 0
+ swgeo        	= 1
+ swigate      	  = 0
+ swimpact     	   = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	    = 1
+ swshe        	= selfheat*enable_selfheat
+ swtcec      	  = 1
+ swimpdr      	  = 0
+ swexp        	= 0
+ swdelvtac    	    = 1
+ swnud        	= 0
+ swptest      	  = 0
+ swgedi      	  = 1
+ xvsat           = xvsat_nmos90b_sphv_10hv
+ qmc           = qmc_nmos90b_sphv_10hv
+ lvaro        	= (lvaro_nmos90b_sphv_10hv+1e-6*dela_lvaro_nmos90b_sphv_10hv)
+ lvarl        	= lvarl_nmos90b_sphv_10hv
+ lvarw        	= lvarw_nmos90b_sphv_10hv
+ lap           = lap_nmos90b_sphv_10hv
+ wvaro        	= (wvaro_nmos90b_sphv_10hv+1e-6*dela_dw_nmos90b_sphv_10hv)
+ wvarl        	= (wvarl_nmos90b_sphv_10hv)
+ wvarw        	= (wvarw_nmos90b_sphv_10hv)
+ wot           = wot_nmos90b_sphv_10hv
+ dlq           = dlq_nmos90b_sphv_10hv
+ dwq           = dwq_nmos90b_sphv_10hv
+ vfbo           = (vfbo_nmos90b_sphv_10hv+fac_a_ng_vfbo+dela_vfb_nmos90b_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nmos90b_vthratio)
+ vfbl           = vfbl_nmos90b_sphv_10hv+dela_vtl_nmos90b_sphv_10hv
+ vfbw           = (vfbw_nmos90b_sphv_10hv+dela_vtw_nmos90b_sphv_10hv)
+ vfblw        	= (vfblw_nmos90b_sphv_10hv)
+ stvfbo       	 = stvfbo_nmos90b_sphv_10hv
+ stvfbl       	 = stvfbl_nmos90b_sphv_10hv
+ stvfbw       	 = stvfbw_nmos90b_sphv_10hv
+ stvfblw      	  = stvfblw_nmos90b_sphv_10hv
+ toxo           = toxo_nmos90b_sphv_10hv*delr_tox_nmos90b_sphv_10hv
+ epsroxo      	  = epsroxo_nmos90b_sphv_10hv
+ nsubo        	= nsubo_nmos90b_sphv_10hv*delr_nsub_nmos90b_sphv_10hv
+ nsubw        	= nsubw_nmos90b_sphv_10hv
+ wseg           = wseg_nmos90b_sphv_10hv
+ npck           = npck_nmos90b_sphv_10hv
+ npckw        	= npckw_nmos90b_sphv_10hv
+ wsegp        	= wsegp_nmos90b_sphv_10hv
+ lpck           = lpck_nmos90b_sphv_10hv
+ lpckw        	= lpckw_nmos90b_sphv_10hv
+ fol1           = fol1_nmos90b_sphv_10hv
+ fol2           = fol2_nmos90b_sphv_10hv
+ facneffaco   	     = facneffaco_nmos90b_sphv_10hv
+ facneffacl   	     = facneffacl_nmos90b_sphv_10hv
+ facneffacw   	     = facneffacw_nmos90b_sphv_10hv
+ facneffaclw  	      = facneffaclw_nmos90b_sphv_10hv
+ gfacnudo     	   = gfacnudo_nmos90b_sphv_10hv
+ gfacnudl     	   = gfacnudl_nmos90b_sphv_10hv
+ gfacnudlexp  	      = gfacnudlexp_nmos90b_sphv_10hv
+ gfacnudw     	   = gfacnudw_nmos90b_sphv_10hv
+ gfacnudlw    	    = gfacnudlw_nmos90b_sphv_10hv
+ vsbnudo      	  = vsbnudo_nmos90b_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_nmos90b_sphv_10hv
+ vnsubo       	 = vnsubo_nmos90b_sphv_10hv
+ nslpo        	= nslpo_nmos90b_sphv_10hv
+ dnsubo       	 = dnsubo_nmos90b_sphv_10hv
+ dphibo       	 = dphibo_nmos90b_sphv_10hv
+ dphibl       	 = dphibl_nmos90b_sphv_10hv
+ dphiblexp    	    = dphiblexp_nmos90b_sphv_10hv
+ dphibw       	 = (dphibw_nmos90b_sphv_10hv)
+ dphiblw      	  = (dphiblw_nmos90b_sphv_10hv)
+ delvtaco     	   = delvtaco_nmos90b_sphv_10hv
+ delvtacl     	   = delvtacl_nmos90b_sphv_10hv
+ delvtaclexp  	      = delvtaclexp_nmos90b_sphv_10hv
+ delvtacw     	   = delvtacw_nmos90b_sphv_10hv
+ delvtaclw    	    = delvtaclw_nmos90b_sphv_10hv
+ npo           = npo_nmos90b_sphv_10hv
+ npl           = npl_nmos90b_sphv_10hv
+ cto           = cto_nmos90b_sphv_10hv
+ ctl           = ctl_nmos90b_sphv_10hv
+ ctlexp       	 = ctlexp_nmos90b_sphv_10hv
+ ctw           = ctw_nmos90b_sphv_10hv
+ ctlw           = ctlw_nmos90b_sphv_10hv
+ toxovo       	 = toxovo_nmos90b_sphv_10hv*delr_tox_nmos90b_sphv_10hv
+ toxovdo      	  = toxovdo_nmos90b_sphv_10hv*delr_tox_nmos90b_sphv_10hv
+ lov           = lov_nmos90b_sphv_10hv
+ dlovd        	= dlovd_nmos90b_sphv_10hv
+ novo           = novo_nmos90b_sphv_10hv
+ novdo        	= novdo_nmos90b_sphv_10hv
+ cfl           = cfl_nmos90b_sphv_10hv
+ cflexp       	 = cflexp_nmos90b_sphv_10hv
+ cfw           = cfw_nmos90b_sphv_10hv
+ cfbo           = cfbo_nmos90b_sphv_10hv
+ uo           = (uo_nmos90b_sphv_10hv*delr_uch_nmos90b_sphv_10hv*delr_u0_relimo)
+ fbet1        	= fbet1_nmos90b_sphv_10hv
+ fbet1w       	 = fbet1w_nmos90b_sphv_10hv
+ lp1           = lp1_nmos90b_sphv_10hv
+ lp1w           = lp1w_nmos90b_sphv_10hv
+ fbet2        	= fbet2_nmos90b_sphv_10hv
+ lp2           = lp2_nmos90b_sphv_10hv
+ betw1        	= betw1_nmos90b_sphv_10hv
+ betw2        	= betw2_nmos90b_sphv_10hv
+ wbet           = wbet_nmos90b_sphv_10hv
+ stbeto       	 = stbeto_nmos90b_sphv_10hv
+ stbetl       	 = stbetl_nmos90b_sphv_10hv
+ stbetw       	 = stbetw_nmos90b_sphv_10hv
+ stbetlw      	  = stbetlw_nmos90b_sphv_10hv
+ mueo           = mueo_nmos90b_sphv_10hv
+ muew           = muew_nmos90b_sphv_10hv
+ stmueo       	 = stmueo_nmos90b_sphv_10hv
+ themuo       	 = themuo_nmos90b_sphv_10hv
+ stthemuo     	   = stthemuo_nmos90b_sphv_10hv
+ cso           = cso_nmos90b_sphv_10hv
+ csl           = csl_nmos90b_sphv_10hv
+ cslexp       	 = cslexp_nmos90b_sphv_10hv
+ csw           = csw_nmos90b_sphv_10hv
+ cslw           = cslw_nmos90b_sphv_10hv
+ stcso        	= stcso_nmos90b_sphv_10hv
+ xcoro        	= xcoro_nmos90b_sphv_10hv
+ xcorl        	= xcorl_nmos90b_sphv_10hv
+ xcorw        	= xcorw_nmos90b_sphv_10hv
+ xcorlw       	 = xcorlw_nmos90b_sphv_10hv
+ stxcoro      	  = stxcoro_nmos90b_sphv_10hv
+ fetao        	= fetao_nmos90b_sphv_10hv
+ rsw1           = rsw1_nmos90b_sphv_10hv
+ rsw2           = rsw2_nmos90b_sphv_10hv
+ strso        	= strso_nmos90b_sphv_10hv
+ rsbo           = rsbo_nmos90b_sphv_10hv
+ rsgo           = rsgo_nmos90b_sphv_10hv
+ thesato      	  = (thesato_nmos90b_sphv_10hv+dela_thesato_nmos90b_sphv_10hv)
+ thesatl      	  = thesatl_nmos90b_sphv_10hv
+ thesatlexp   	     = thesatlexp_nmos90b_sphv_10hv
+ thesatw      	  = thesatw_nmos90b_sphv_10hv
+ thesatlw     	   = thesatlw_nmos90b_sphv_10hv
+ stthesato    	    = stthesato_nmos90b_sphv_10hv
+ stthesatl    	    = stthesatl_nmos90b_sphv_10hv
+ stthesatw    	    = stthesatw_nmos90b_sphv_10hv
+ stthesatlw   	     = stthesatlw_nmos90b_sphv_10hv
+ thesatbo     	   = thesatbo_nmos90b_sphv_10hv
+ thesatgo     	   = thesatgo_nmos90b_sphv_10hv
+ thesatgl     	   = thesatgl_nmos90b_sphv_10hv
+ thesatgw     	   = thesatgw_nmos90b_sphv_10hv
+ axo           = axo_nmos90b_sphv_10hv
+ axl           = axl_nmos90b_sphv_10hv
+ alpl           = alpl_nmos90b_sphv_10hv
+ alplexp      	  = alplexp_nmos90b_sphv_10hv
+ alpw           = alpw_nmos90b_sphv_10hv
+ alp1l1       	 = alp1l1_nmos90b_sphv_10hv
+ alp1lexp     	   = alp1lexp_nmos90b_sphv_10hv
+ alp1l2       	 = alp1l2_nmos90b_sphv_10hv
+ alp1w        	= alp1w_nmos90b_sphv_10hv
+ alp2l1       	 = alp2l1_nmos90b_sphv_10hv
+ alp2lexp     	   = alp2lexp_nmos90b_sphv_10hv
+ alp2l2       	 = alp2l2_nmos90b_sphv_10hv
+ alp2w        	= alp2w_nmos90b_sphv_10hv
+ vpo           = vpo_nmos90b_sphv_10hv
+ a1o           = a1o_nmos90b_sphv_10hv
+ a1l           = a1l_nmos90b_sphv_10hv
+ a1w           = a1w_nmos90b_sphv_10hv
+ a2o           = a2o_nmos90b_sphv_10hv
+ sta2o        	= sta2o_nmos90b_sphv_10hv
+ a3o           = a3o_nmos90b_sphv_10hv
+ a3l           = a3l_nmos90b_sphv_10hv
+ a3w           = a3w_nmos90b_sphv_10hv
+ a4o           = a4o_nmos90b_sphv_10hv
+ a4l           = a4l_nmos90b_sphv_10hv
+ a4w           = a4w_nmos90b_sphv_10hv
+ gcoo           = gcoo_nmos90b_sphv_10hv
+ iginvlw      	  = iginvlw_nmos90b_sphv_10hv
+ igovw        	= igovw_nmos90b_sphv_10hv
+ igovdw       	 = igovdw_nmos90b_sphv_10hv
+ stigo        	= stigo_nmos90b_sphv_10hv
+ gc2o           = gc2o_nmos90b_sphv_10hv
+ gc3o           = gc3o_nmos90b_sphv_10hv
+ chibo        	= chibo_nmos90b_sphv_10hv
+ agidlw       	 = agidlw_nmos90b_sphv_10hv
+ agidldw      	  = agidldw_nmos90b_sphv_10hv
+ bgidlo       	 = bgidlo_nmos90b_sphv_10hv
+ bgidldo      	  = bgidldo_nmos90b_sphv_10hv
+ stbgidlo     	   = stbgidlo_nmos90b_sphv_10hv
+ stbgidldo    	    = stbgidldo_nmos90b_sphv_10hv
+ cgidlo       	 = cgidlo_nmos90b_sphv_10hv
+ cgidldo      	  = cgidldo_nmos90b_sphv_10hv
+ cgbovl       	 = cgbovl_nmos90b_sphv_10hv
+ cfrw           = cfrw_nmos90b_sphv_10hv
+ cfrdw        	= cfrdw_nmos90b_sphv_10hv
+ fnto           = fnto_nmos90b_sphv_10hv
+ nfalw        	= nfalw_nmos90b_sphv_10hv
+ nfblw        	= nfblw_nmos90b_sphv_10hv
+ nfclw        	= nfclw_nmos90b_sphv_10hv
+ efo           = efo_nmos90b_sphv_10hv
+ lintnoi      	  = lintnoi_nmos90b_sphv_10hv
+ alpnoi       	 = alpnoi_nmos90b_sphv_10hv
+ kvthoweo     	   = kvthoweo_nmos90b_sphv_10hv
+ kvthowel     	   = kvthowel_nmos90b_sphv_10hv
+ kvthowew     	   = kvthowew_nmos90b_sphv_10hv
+ kvthowelw    	    = kvthowelw_nmos90b_sphv_10hv
+ kuoweo       	 = kuoweo_nmos90b_sphv_10hv
+ kuowel       	 = kuowel_nmos90b_sphv_10hv
+ kuowew       	 = kuowew_nmos90b_sphv_10hv
+ kuowelw      	  = kuowelw_nmos90b_sphv_10hv
+ rgo           = rgo_nmos90b_sphv_10hv
+ rsh           = rsh_nmos90b_sphv_10hv
+ rbulko       	 = rbulko_nmos90b_sphv_10hv
+ rwello       	 = rwello_nmos90b_sphv_10hv
+ rjunso       	 = rjunso_nmos90b_sphv_10hv/(w+dwrjunso_nmos90b_sphv_10hv)*tfact_rs
+ rjundo       	 = rjundo_nmos90b_sphv_10hv/(w+dwrjundo_nmos90b_sphv_10hv)*l/(l+2.0)*tfact_rs
+ rint           = rint_nmos90b_sphv_10hv
+ rvpoly       	 = rvpoly_nmos90b_sphv_10hv
+ rshg           = rshg_nmos90b_sphv_10hv
+ dlsil        	= dlsil_nmos90b_sphv_10hv
+ saref        	= saref_nmos90b_sphv_10hv
+ sbref        	= sbref_nmos90b_sphv_10hv
+ wlod           = wlod_nmos90b_sphv_10hv
+ kuo           = kuo_nmos90b_sphv_10hv
+ kvsat        	= kvsat_nmos90b_sphv_10hv
+ tkuo           = tkuo_nmos90b_sphv_10hv
+ lkuo           = lkuo_nmos90b_sphv_10hv
+ wkuo           = wkuo_nmos90b_sphv_10hv
+ pkuo           = pkuo_nmos90b_sphv_10hv
+ llodkuo      	  = llodkuo_nmos90b_sphv_10hv
+ wlodkuo      	  = wlodkuo_nmos90b_sphv_10hv
+ kvtho        	= kvtho_nmos90b_sphv_10hv
+ lkvtho       	 = lkvtho_nmos90b_sphv_10hv
+ wkvtho       	 = wkvtho_nmos90b_sphv_10hv
+ pkvtho       	 = pkvtho_nmos90b_sphv_10hv
+ llodvth      	  = llodvth_nmos90b_sphv_10hv
+ wlodvth      	  = wlodvth_nmos90b_sphv_10hv
+ stetao       	 = stetao_nmos90b_sphv_10hv
+ lodetao      	  = lodetao_nmos90b_sphv_10hv
+ scref        	= scref_nmos90b_sphv_10hv
+ web           = web_nmos90b_sphv_10hv
+ wec           = wec_nmos90b_sphv_10hv
+ adr1o        	= adr1o_nmos90b_sphv_10hv
+ adr1l        	= adr1l_nmos90b_sphv_10hv
+ adr1w        	= adr1w_nmos90b_sphv_10hv
+ adr2o        	= adr2o_nmos90b_sphv_10hv
+ stadr2o      	  = stadr2o_nmos90b_sphv_10hv
+ adr3o        	= adr3o_nmos90b_sphv_10hv
+ adr3l        	= adr3l_nmos90b_sphv_10hv
+ adr3w        	= adr3w_nmos90b_sphv_10hv
+ adr4o        	= adr4o_nmos90b_sphv_10hv
+ adr4l        	= adr4l_nmos90b_sphv_10hv
+ adr4w        	= adr4w_nmos90b_sphv_10hv
+ adr5o        	= adr5o_nmos90b_sphv_10hv
+ adr5l        	= adr5l_nmos90b_sphv_10hv
+ adr5w        	= adr5w_nmos90b_sphv_10hv
+ bidr1o       	 = bidr1o_nmos90b_sphv_10hv
+ bidr1l       	 = bidr1l_nmos90b_sphv_10hv
+ bidr1w       	 = bidr1w_nmos90b_sphv_10hv
+ bidr2o       	 = bidr2o_nmos90b_sphv_10hv
+ bidr2w       	 = bidr2w_nmos90b_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	= 0
+ strtho       	 = strtho_nmos90b_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	= 0
+ rshldd       	 = (rshldd_nmos90b_sphv_10hv*fac_r_ng_rshldd*delr_res_nmos90b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nmos90b_ronratio))
+ xw           = (xw_nmos90b_sphv_10hv)
+ nwxw           = (nwxw_nmos90b_sphv_10hv)
+ xl           = xl_nmos90b_sphv_10hv
+ xlw           = xlw_nmos90b_sphv_10hv
+ dxlsat       	 = dxlsat_nmos90b_sphv_10hv
+ nst           = nst_nmos90b_sphv_10hv
+ ats           = ats_nmos90b_sphv_10hv
+ dfinf        	= dfinf_nmos90b_sphv_10hv
+ dfw           = dfw_nmos90b_sphv_10hv
+ dfl           = dfl_nmos90b_sphv_10hv
+ dflw           = dflw_nmos90b_sphv_10hv
+ dp           = dp_nmos90b_sphv_10hv
+ ecrit        	= ecrit_nmos90b_sphv_10hv*tfact_ecrit*(1+dwecrit/w+dwecritw/(w*w))
+ ecorn        	= ecorn_nmos90b_sphv_10hv*tfact_ecrit*(1+dwecrit/w+dwecritw/(w*w))
+ du           = du_nmos90b_sphv_10hv
+ tc1           = tc1_nmos90b_sphv_10hv
+ tc2           = tc2_nmos90b_sphv_10hv
+ tc1l           = tc1l_nmos90b_sphv_10hv
+ tc2l           = tc2l_nmos90b_sphv_10hv
+ tc1w           = tc1w_nmos90b_sphv_10hv
+ tc2w           = tc2w_nmos90b_sphv_10hv
+ theacc       	 = theacc_nmos90b_sphv_10hv
+ theacc2      	  = theacc2_nmos90b_sphv_10hv
+ rva           = rva_nmos90b_sphv_10hv
+ dta           = dta_nmos90b_sphv_10hv
+ trj           = trj_nmos90b_sphv_10hv
+ cjarea       	 = cjarea_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ cjlsti       	 = cjlsti_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ cjlgat       	 = cjlgat_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ vbiarea      	  = vbiarea_nmos90b_sphv_10hv
+ vbisti       	 = vbisti_nmos90b_sphv_10hv
+ vbigat       	 = vbigat_nmos90b_sphv_10hv
+ parea        	= parea_nmos90b_sphv_10hv
+ psti           = psti_nmos90b_sphv_10hv
+ pgat           = pgat_nmos90b_sphv_10hv
+ is1area      	  = is1area_nmos90b_sphv_10hv*delr_is_nmos90b_sphv_10hv
+ ttarea       	 = ttarea_nmos90b_sphv_10hv
+ is2area      	  = is2area_nmos90b_sphv_10hv*delr_is2_nmos90b_sphv_10hv
+ irarea       	 = irarea_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1area    	    = stis1area_nmos90b_sphv_10hv
+ stis2area    	    = stis2area_nmos90b_sphv_10hv
+ stirarea     	   = stirarea_nmos90b_sphv_10hv
+ n1area       	 = n1area_nmos90b_sphv_10hv
+ n2area       	 = n2area_nmos90b_sphv_10hv
+ nrarea       	 = nrarea_nmos90b_sphv_10hv
+ is1lsti      	  = is1lsti_nmos90b_sphv_10hv*delr_is_nmos90b_sphv_10hv
+ ttlsti       	 = ttlsti_nmos90b_sphv_10hv
+ is2lsti      	  = is2lsti_nmos90b_sphv_10hv*delr_is2_nmos90b_sphv_10hv
+ irlsti       	 = irlsti_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1sti     	   = stis1sti_nmos90b_sphv_10hv
+ stis2sti     	   = stis2sti_nmos90b_sphv_10hv
+ stirsti      	  = stirsti_nmos90b_sphv_10hv
+ n1sti        	= n1sti_nmos90b_sphv_10hv
+ n2sti        	= n2sti_nmos90b_sphv_10hv
+ nrsti        	= nrsti_nmos90b_sphv_10hv
+ is1lgat      	  = is1lgat_nmos90b_sphv_10hv*delr_is_nmos90b_sphv_10hv
+ ttlgat       	 = ttlgat_nmos90b_sphv_10hv
+ is2lgat      	  = is2lgat_nmos90b_sphv_10hv*delr_is2_nmos90b_sphv_10hv
+ irlgat       	 = irlgat_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1gat     	   = stis1gat_nmos90b_sphv_10hv
+ stis2gat     	   = stis2gat_nmos90b_sphv_10hv
+ stirgat      	  = stirgat_nmos90b_sphv_10hv
+ n1gat        	= n1gat_nmos90b_sphv_10hv
+ n2gat        	= n2gat_nmos90b_sphv_10hv
+ nrgat        	= nrgat_nmos90b_sphv_10hv
+ cjaread      	  = cjaread_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ cjlstid      	  = cjlstid_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ cjlgatd      	  = cjlgatd_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ vbiaread     	   = vbiaread_nmos90b_sphv_10hv
+ vbistid      	  = vbistid_nmos90b_sphv_10hv
+ vbigatd      	  = vbigatd_nmos90b_sphv_10hv
+ paread       	 = paread_nmos90b_sphv_10hv
+ pstid        	= pstid_nmos90b_sphv_10hv
+ pgatd        	= pgatd_nmos90b_sphv_10hv
+ is1aread     	   = is1aread_nmos90b_sphv_10hv*delr_is_nmos90b_sphv_10hv
+ ttaread      	  = ttaread_nmos90b_sphv_10hv
+ is2aread     	   = is2aread_nmos90b_sphv_10hv*delr_is2_nmos90b_sphv_10hv
+ iraread      	  = iraread_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1aread   	     = stis1aread_nmos90b_sphv_10hv
+ stis2aread   	     = stis2aread_nmos90b_sphv_10hv
+ stiraread    	    = stiraread_nmos90b_sphv_10hv
+ n1aread      	  = n1aread_nmos90b_sphv_10hv
+ n2aread      	  = n2aread_nmos90b_sphv_10hv
+ nraread      	  = nraread_nmos90b_sphv_10hv
+ is1lstid     	   = is1aread_nmos90b_sphv_10hv*djunc*delr_is_nmos90b_sphv_10hv
+ ttlstid      	  = ttlstid_nmos90b_sphv_10hv
+ is2lstid     	   = is2aread_nmos90b_sphv_10hv*djunc*delr_is2_nmos90b_sphv_10hv
+ irlstid      	  = irlstid_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1stid    	    = stis1stid_nmos90b_sphv_10hv
+ stis2stid    	    = stis2stid_nmos90b_sphv_10hv
+ stirstid     	   = stirstid_nmos90b_sphv_10hv
+ n1stid       	 = n1stid_nmos90b_sphv_10hv
+ n2stid       	 = n2stid_nmos90b_sphv_10hv
+ nrstid       	 = nrstid_nmos90b_sphv_10hv
+ is1lgatd     	   = is1aread_nmos90b_sphv_10hv*djunc*delr_is_nmos90b_sphv_10hv
+ ttlgatd      	  = ttlgatd_nmos90b_sphv_10hv
+ is2lgatd     	   = is2aread_nmos90b_sphv_10hv*djunc*delr_is2_nmos90b_sphv_10hv
+ irlgatd      	  = irlgatd_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1gatd    	    = stis1gatd_nmos90b_sphv_10hv
+ stis2gatd    	    = stis2gatd_nmos90b_sphv_10hv
+ stirgatd     	   = stirgatd_nmos90b_sphv_10hv
+ n1gatd       	 = n1gatd_nmos90b_sphv_10hv
+ n2gatd       	 = n2gatd_nmos90b_sphv_10hv
+ nrgatd       	 = nrgatd_nmos90b_sphv_10hv
+ cjaread2     	   = cjaread_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ cjlstid2     	   = cjlstid_nmos90b_sphv_10hv*delr_cj_nmos90b_sphv_10hv
+ vbiaread2    	    = vbiaread2_nmos90b_sphv_10hv
+ vbistid2     	   = vbistid2_nmos90b_sphv_10hv
+ paread2      	  = paread2_nmos90b_sphv_10hv
+ pstid2       	 = pstid2_nmos90b_sphv_10hv
+ is1aread2    	    = is1aread_nmos90b_sphv_10hv*delr_is_nmos90b_sphv_10hv
+ ttaread2     	   = ttaread2_nmos90b_sphv_10hv
+ is2aread2    	    = is2aread_nmos90b_sphv_10hv*delr_is2_nmos90b_sphv_10hv
+ iraread2     	   = iraread2_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1aread2  	      = stis1aread_nmos90b_sphv_10hv
+ stis2aread2  	      = stis2aread_nmos90b_sphv_10hv
+ stiraread2   	     = stiraread2_nmos90b_sphv_10hv
+ n1aread2     	   = n1aread2_nmos90b_sphv_10hv
+ n2aread2     	   = n2aread2_nmos90b_sphv_10hv
+ nraread2     	   = nraread2_nmos90b_sphv_10hv
+ is1lstid2    	    = is1aread_nmos90b_sphv_10hv*djunc*delr_is_nmos90b_sphv_10hv
+ ttlstid2     	   = ttlstid2_nmos90b_sphv_10hv
+ is2lstid2    	    = is2aread_nmos90b_sphv_10hv*djunc*delr_is2_nmos90b_sphv_10hv
+ irlstid2     	   = irlstid2_nmos90b_sphv_10hv*delr_ir_nmos90b_sphv_10hv
+ stis1stid2   	     = stis1stid2_nmos90b_sphv_10hv
+ stis2stid2   	     = stis2stid2_nmos90b_sphv_10hv
+ stirstid2    	    = stirstid2_nmos90b_sphv_10hv
+ n1stid2      	  = n1stid2_nmos90b_sphv_10hv
+ n2stid2      	  = n2stid2_nmos90b_sphv_10hv
+ nrstid2      	  = nrstid2_nmos90b_sphv_10hv
+ aacc              = aacc_nmos90b_sphv_10hv
+ eais1area=eais1area_nmos90b_sphv_10hv
+ eais2area=eais2area_nmos90b_sphv_10hv
+ eairarea=eairarea_nmos90b_sphv_10hv
+ eais1sti=eais1sti_nmos90b_sphv_10hv
+ eais2sti=eais2sti_nmos90b_sphv_10hv
+ eairsti=eairsti_nmos90b_sphv_10hv
+ eais1gat=eais1gat_nmos90b_sphv_10hv
+ eais2gat=eais2gat_nmos90b_sphv_10hv
+ eairgat=eairgat_nmos90b_sphv_10hv
+ eais1aread=eais1aread_nmos90b_sphv_10hv
+ eais2aread=eais2aread_nmos90b_sphv_10hv
+ eairaread=eairaread_nmos90b_sphv_10hv
+ eais1stid=eais1stid_nmos90b_sphv_10hv
+ eais2stid=eais2stid_nmos90b_sphv_10hv
+ eairstid=eairstid_nmos90b_sphv_10hv
+ eais1gatd=eais1gatd_nmos90b_sphv_10hv
+ eais2gatd=eais2gatd_nmos90b_sphv_10hv
+ eairgatd=eairgatd_nmos90b_sphv_10hv
+ eais1aread2=eais1aread2_nmos90b_sphv_10hv
+ eais2aread2=eais2aread2_nmos90b_sphv_10hv
+ eairaread2=eairaread2_nmos90b_sphv_10hv
+ eais1stid2=eais1stid2_nmos90b_sphv_10hv
+ eais2stid2=eais2stid2_nmos90b_sphv_10hv
+ eairstid2=eairstid2_nmos90b_sphv_10hv
+ ikfarea               = ikfarea_nmos90b_sphv_10hv
+ ikflsti               = ikfarea_nmos90b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nmos90b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nmos90b_sphv_10hv
+ stikfsti              = stikfarea_nmos90b_sphv_10hv
+ stikfgat              = stikfarea_nmos90b_sphv_10hv
+ ikfaread              = ikfaread_nmos90b_sphv_10hv*(w/(w+dwikfaread_nmos90b_sphv_10hv))
+ ikflstid              = ikfaread_nmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos90b_sphv_10hv))
+ ikflgatd              = ikfaread_nmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos90b_sphv_10hv))
+ ikfaread2             = ikfaread_nmos90b_sphv_10hv*(w/(w+dwikfaread_nmos90b_sphv_10hv))
+ ikflstid2             = ikfaread_nmos90b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos90b_sphv_10hv))
+ stikfaread             = stikfaread_nmos90b_sphv_10hv
+ stikfstid             = stikfaread_nmos90b_sphv_10hv
+ stikfgatd             = stikfaread_nmos90b_sphv_10hv
+ stikfaread2            = stikfaread_nmos90b_sphv_10hv
+ stikfstid2            = stikfaread_nmos90b_sphv_10hv





include "./smos10hv_ade_dfrt.scs" section=nmos90b_10hv_dfrt
ends

// nmos120_10hv



//ahdl_include "./veriloga/sphv_v2.0.16/sphv.va"


subckt nmos120_10hv (d g s b sub)
parameters
+ l           = 1.5
+ w           = 2.5
+ ng          = 2
+ sti_dummy   = 0
+ lpe         = 0
+ fem         = 0
+ soa         = 1
+ selfheat    = 1
+ mode_rthcth = 1


parameters
+ nde         = (fmod(ng,2))
+ nse         = (2-nde)
+ nd          = ((ng+nde)/2)
+ ns          = (1-nde+nd)
+ ndi         = (nd-nde)
+ nsi         = (ns-nse)

//dummy parameters
+ ng_dmy      = 2*sti_dummy
+ ngeff       = ng+ng_dmy
+ ndi_eff     = (ngeff/2)
+ nsi_eff     = ((ngeff-2)/2)

//reliability parameters
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+ presto_device_active           = (1)
+ hcirondegrfac                  = (0.0)
+ offrondegrfac                  = (0.0)
+ hvgsvthdegr                    = (0.0)
+ hcidamage1                     = (0.0)
+ hcidamage2                     = (0.0)
+ offdamage1                     = (0.0)
+ offdamage2                     = (0.0)
+ hvgsdamage                     = (0.0)
+ presto_nmos120_vthratio        = (1.0)
+ presto_nmos120_ronratio        = (0.01/0.74)


//*simple model factor, copied from nld90b
+ swdrlin  = (0)
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.825)

//calculation of junction instance parameters
+    lacts    = 0.375
+    ldrift   = 7.5
+    wdrift   = (w)
+    w2ncom   = 11.575
+    lactd    = 1.21
+    lsplit   = 0.35

+    ldr1     = 0.75
+    as_i     = (lacts*w)
+    ps_i     = 2*(lacts*(1-fem)+w)
+    ad_i     = ((ldr1+lsplit)+ldrift/2)*(w+2*w2ncom*(1-fem))
+    pd_i     = (2*((ldr1+lsplit)+ldrift/2)*(1-fem)+w+2*w2ncom*(1-fem))
+    ad2_i    = (lactd/2+ldrift/2)*(w+2*w2ncom*(1-fem))
+    pd2_i    = (lactd+ldrift)*(1-fem)

//calculation for pepi/substrate cap
+    lg2pepi_s    = 2.175        // dt to poly end
+    lp2p_d       = 18.41        // drain phv end to phv end
+    lb2b_s       = 1.8          // poly end to ploy at internal source
+    wg2pepi      = 14.835       // width active side to nhv end
+    xbody                       = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody                       = (wg2pepi*2*(1-fem)+w)
+    abody                       = (xbody*ybody)
+    pbody                       = (2*(xbody*(1-fem)+ybody))

//calculation of parasitic cap
//m2(source) to m1(body), csb. m2(source) to m1(gate), cgs. So csb_nmos120_10hv_m2m1_par & cgs_nmos120_10hv_m2m1_par should be off later, not in pcell model.
//from test structures(p03n)

//+ cpp_m2_m1 = 6.72904e-17
//+ cfr_m2_m1 = 4.12247297137e-17
//+ cfr_m2_ply = 3.28181197349e-17
//+ cpp_m2_fld = 1.8943555433e-17
//+ cfr_m2_fld = 3.08291760167e-17
//+ cpp_m1_ply = 7.32520933333e-17
//+ cfr_m1_ply = 4.15527948957e-17
//+ cpp_m1_fld = 3.40874629812e-17
//+ cfr_m1_fld = 3.5330129938e-17
//+ cpp_ply_fld = 9.22291666667e-17
//+ cfr_ply_fld = 4.2429385448e-17
+    ncom2ncom=18.11
+    w_a2p=12.725
//+    width_m2m1                     = ((11.455+0.555-1)*(1-fem)+w)
//+    length_m2m1                    = (0.33)
//+    area_m2m1                      = (length_m2m1*width_m2m1)
//+    area_m2m1_smllrect             = (1*1.71*(1-fem))
//+    perim_m2m1                     = (2*(length_m2m1*(1-fem)+width_m2m1))
//+    perim_m2m1_smllrect            = ((1+1.71+1+1.71-0.33)*(1-fem))
//+    csb_nmos120_10hv_m2m1_par      = (((cfr_m2_m1*(perim_m2m1+perim_m2m1_smllrect)+cpp_m2_m1*(area_m2m1+area_m2m1_smllrect))*ns))
//+    area_m2fld                     = ((0.555*(1-fem)+w+14.835*(1-fem))*1.71-area_m2m1-area_m2m1_smllrect)*ns+(18.41+2*l+2*0.045)*1.565*(1-fem)*nd
//+    perim_m2fld                    = ((0.555*(1-fem)+w+14.835*(1-fem)+1.71)*2-1.51*(1-fem))*nse+((0.555*(1-fem)+w+14.835*(1-fem)+1.71)*2-1.51*2*(1-fem))*nsi-2*ns+(18.41+2*l+2*0.045)*2*(1-fem)*nd
//+    csb_nmos120_10hv_m2fld_par     = (cpp_m2_fld*area_m2fld+cfr_m2_fld*perim_m2fld*0.07)
//+    cgs_nmos120_10hv_m2m1_par      = (((l+0.5*lp2p_d)*ng*cfr_m2_m1)*0+(w_a2p+w+0.555)*ng*cfr_m2_ply)+(18.41+2*l+2*0.045)*nd*cfr_m2_ply+0.94e-15*ng
//+    cgb_nmos120_10hv_m1ply_par     = (((ncom2ncom+2*l)*1)*cpp_m1_ply+(ncom2ncom+2*l+1)*2*cfr_m1_ply)*ng/2


//*******************************************************************************************************
//*global and process variables
//*******************************************************************************************************
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)

+    delt                           = (tkd-tkr)


+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_nmos120_sphv_10hv)
+    cox                            = (epsox/tox)

// pcell parasitic cap
//+    cox                          = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)

+ inner_p2p=9.91
+ poly_split=0.7
+ w_inner_a2p=6.525
+ ncom2poly=0.6
+ radiusply=0.93
+ lgm1_dhole=4.81
+ w_a2gm1=2.7
+ archedge=radiusply*radiusply*(4-3.1415926)
+ aplyfld_gb=((lp2p_d+2*l)*(w+2*w_a2p*(1-fem))-ncom2ncom*(w+2*w2ncom*(1-fem))-w*l*2)*ng/2
+ pplyfld_gb=((lp2p_d+2*l+2*w_a2p)*2)*(1-fem)*ng/2
//+ aplyfld_gd=(ncom2ncom*(w+2*w2ncom*(1-fem))-(inner_p2p+2*poly_split)*(w+2*w_inner_a2p*(1-fem))- ldr1*w*2+archedge*(1-fem))*ng/2
//+ pplyfld_gd=((inner_p2p*(1-fem)+w+2*w_inner_a2p*(1-fem))*2- radiusply*(8-2*3.1415926)*(1-fem))*ng/2
//+ a_gm1fld_gd=(inner_p2p*(w+2*w_inner_a2p*(1-fem))-archedge*(1-fem)-(lgm1_dhole*(w_a2gm1*(1-fem)*2+w)-archedge*(1-fem)))*ng/2
//+ p_gm1fld_gd=((lgm1_dhole*2*(1-fem)+(w_a2gm1*(1-fem)*2+w)*2-radiusply*8*(1-fem)+radiusply*2*3.1415926*(1-fem)))*ng/2

//parasitic field c for dummy
+ aplyfld_gb_dmy=((lp2p_d+2*l)*(w+2*w_a2p*(1-fem))-ncom2ncom*(w+2*w2ncom*(1-fem))-w*l*2)*ng_dmy/2
+ pplyfld_gb_dmy=((lp2p_d+2*l+2*w_a2p)*2)*(1-fem)*ng_dmy/2
//+ aplyfld_gd_dmy=(ncom2ncom*(w+2*w2ncom*(1-fem))-(inner_p2p+2*poly_split)*(w+2*w_inner_a2p*(1-fem))- ldr1*w*2+archedge*(1-fem))*ng_dmy/2
//+ pplyfld_gd_dmy=((inner_p2p*(1-fem)+w+2*w_inner_a2p*(1-fem))*2- radiusply*(8-2*3.1415926)*(1-fem))*ng_dmy/2
//+ a_gm1fld_gd_dmy=(inner_p2p*(w+2*w_inner_a2p*(1-fem))-archedge*(1-fem)-(lgm1_dhole*(w_a2gm1*(1-fem)*2+w)-archedge*(1-fem)))*ng_dmy/2
//+ p_gm1fld_gd_dmy=((lgm1_dhole*2*(1-fem)+(w_a2gm1*(1-fem)*2+w)*2-radiusply*8*(1-fem)+radiusply*2*3.1415926*(1-fem)))*ng_dmy/2

+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_nmos120_sphv_10hv+tc1l_ecrit_nmos120_sphv_10hv/l+(tc2l_ecrit_nmos120_sphv_10hv/l+tc2lw_ecrit_nmos120_sphv_10hv/l/w*(1-fem))*(temp-tnom)+tc1w_ecrit_nmos120_sphv_10hv/w*(1-fem)+tc1lw_ecrit_nmos120_sphv_10hv/l/w*(1-fem)+tc2_ecrit_nmos120_sphv_10hv*(temp-tnom))*(temp-tnom)
+ dwecrit=dwecrit_nmos120_sphv_10hv*(1-fem)
+ dwecritw=dwecritw_nmos120_sphv_10hv*(1-fem)

+ tfact_rs=((temp+273.15)/(tnom+273.15))**0.4
+ tfact_tt=((temp+273.15)/(tnom+273.15))**1

//**parameters for multi ng
+ fac_r_ng_rshldd      = (1+(ngeff/(ngeff+2*2*(1-fem))-2/(2+2*1))*0.02173/(w/(w+0.3*(1-fem))*l/(l+1.1)))
+ fac_a_ng_vfbo        = ((ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*0.083*(w/(w+0.351*(1-fem)))/(l/(l+1.35)))
+ fac_r_ng_uo          = (1+(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*0.40*(w/(w+0.18*(1-fem)))*l/(l+0.4))
+ fac_a_ng_vdscalel    = ((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*0.0189)
+ fac_a_ng_thesato     = ((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*(-0.55))
+ fac_a_ng_thesatw     = ((ngeff/(ngeff+0.2*4*(1-fem))-2/(2+0.2*4))*1.3)
+ fac_r_ng_thesatgo    = 1/(1+((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*12))
+ fac_r_ng_thesatgl    = 1/(1+((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*15))
+ fac_r_ng_thesatgw    = 1+((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*60)
+ fac_r_ng_thesatglw   = 1+((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*64)
+ fac_r_ng_strtho      = 1e-3*(1+5*((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))))
+ fac_r_ng_stthesatglw = 1+((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))*5)
+ fac_r_ng_adr1lw      = 1/(1+20*((ngeff/(ngeff+0.2*1*(1-fem))-2/(2+0.2*1))))
+ fac_ng_stbidr1o      = (1-0.825/(l*w)*(1-fem)*(min(max(temp,-40),tnom)-tnom)*(ngeff/(ngeff+0.2*1)-2/(2+0.2*1)))

//**thermal res/cap calculation
+    she_fit=(1/(1+ng_dmy/(ng_dmy+1)/ng*0.7))
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nmos120_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nmos120_sphv_10hv)*ngeff*she_fit
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff/she_fit

//*poly gate resistance calculations

+ lflap 	   = (2.8)
+ w_ploycont2act   = (12.725)
+ rs_poly_gate     = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply             = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ rgate            = (rply*(w+2*w_ploycont2act*(1-fem))/((l+ldr1+lflap)*3))

// parameters for process variations
+ nsmm_delr_tox_nmos120_sphv_10hv  = tmp_nsmm_delr_tox_nmos120_sphv_10hv
+ nsmm_delr_uch_nmos120_sphv_10hv  = tmp_nsmm_delr_uch_nmos120_sphv_10hv
+ nsmm_delr_res_nmos120_sphv_10hv  = tmp_nsmm_delr_res_nmos120_sphv_10hv
+ nsmm_dela_vfb_nmos120_sphv_10hv  = tmp_nsmm_dela_vfb_nmos120_sphv_10hv
+ nsmm_dela_vtw_nmos120_sphv_10hv  = tmp_nsmm_dela_vtw_nmos120_sphv_10hv
+ nsmm_delr_nsub_nmos120_sphv_10hv = tmp_nsmm_delr_nsub_nmos120_sphv_10hv
+ tc_vfb_mm                          = (1+(temp-27)*(-2.0e-3))
+ delr_tox_nmos120_sphv_10hv = (nom_delr_tox_nmos120_sphv_10hv*(1+sig_delr_tox_nmos120_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_tox_nmos120_sphv_10hv*smm_delr_tox_nmos120_sphv_10hv(l,w,ng)))
//+ delr_tox_nmos120_sphv_10hv = (nom_delr_tox_nmos120_sphv_10hv*(1+sig_delr_tox_nmos120_sphv_10hv*nsig_delr_tox_nmos120_sphv_10hv+nsmm_delr_tox_nmos120_sphv_10hv*smm_delr_tox_nmos120_sphv_10hv(l,w,ng)))
+ delr_uch_nmos120_sphv_10hv = (nom_delr_uch_nmos120_sphv_10hv*(1+sig_delr_uch_nmos120_sphv_10hv*nsig_delr_uch_nmos120_sphv_10hv+nsmm_delr_uch_nmos120_sphv_10hv*smm_delr_uch_nmos120_sphv_10hv(l,w,ng)))
+ delr_res_nmos120_sphv_10hv = (nom_delr_res_nmos120_sphv_10hv*(1+sig_delr_res_nmos120_sphv_10hv*nsig_delr_res_nmos120_sphv_10hv+nsmm_delr_res_nmos120_sphv_10hv*smm_delr_res_nmos120_sphv_10hv(l,w,ng)))
+ dela_vfb_nmos120_sphv_10hv = (nom_dela_vfb_nmos120_sphv_10hv+(sig_dela_vfb_nmos120_sphv_10hv*nsig_dela_vfb_nmos120_sphv_10hv)+tc_vfb_mm*nsmm_dela_vfb_nmos120_sphv_10hv*smm_dela_vfb_nmos120_sphv_10hv(l,w,ng))
+ dela_vtl_nmos120_sphv_10hv = (nom_dela_vtl_nmos120_sphv_10hv+(sig_dela_vtl_nmos120_sphv_10hv*nsig_dela_vtl_nmos120_sphv_10hv))
+ dela_vtw_nmos120_sphv_10hv = (nom_dela_vtw_nmos120_sphv_10hv+(sig_dela_vtw_nmos120_sphv_10hv*nsig_dela_vtw_nmos120_sphv_10hv)+nsmm_dela_vtw_nmos120_sphv_10hv*smm_dela_vtw_nmos120_sphv_10hv(l,w,ng))
+ dela_vtlw_nmos120_sphv_10hv = (nom_dela_vtlw_nmos120_sphv_10hv+(sig_dela_vtlw_nmos120_sphv_10hv*nsig_dela_vtlw_nmos120_sphv_10hv))
+ dela_dw_nmos120_sphv_10hv = (nom_dela_dw_nmos120_sphv_10hv+(sig_dela_dw_nmos120_sphv_10hv*nsig_dela_dw_nmos120_sphv_10hv))
+ dela_lvaro_nmos120_sphv_10hv = (nom_dela_lvaro_nmos120_sphv_10hv+(sig_dela_lvaro_nmos120_sphv_10hv*nsig_dela_lvaro_nmos120_sphv_10hv))
+ dela_lvarw_nmos120_sphv_10hv = (nom_dela_lvarw_nmos120_sphv_10hv+(sig_dela_lvarw_nmos120_sphv_10hv*nsig_dela_lvarw_nmos120_sphv_10hv))
+ delr_nsub_nmos120_sphv_10hv = (1+nsmm_delr_nsub_nmos120_sphv_10hv*smm_delr_nsub_nmos120_sphv_10hv(l,w,ng))
+ dela_vdscale_nmos120_sphv_10hv =(nom_dela_vdscale_nmos120_sphv_10hv+(sig_dela_vdscale_nmos120_sphv_10hv*nsig_dela_vdscale_nmos120_sphv_10hv))
+ dela_vdscalel_nmos120_sphv_10hv =(nom_dela_vdscalel_nmos120_sphv_10hv+(sig_dela_vdscalel_nmos120_sphv_10hv*nsig_dela_vdscalel_nmos120_sphv_10hv))
+ dela_vdscalew_nmos120_sphv_10hv =(nom_dela_vdscalew_nmos120_sphv_10hv+(sig_dela_vdscalew_nmos120_sphv_10hv*nsig_dela_vdscalew_nmos120_sphv_10hv))
+ dela_vdscalelw_nmos120_sphv_10hv =(nom_dela_vdscalelw_nmos120_sphv_10hv+(sig_dela_vdscalelw_nmos120_sphv_10hv*nsig_dela_vdscalelw_nmos120_sphv_10hv))
+ dela_thesato_nmos120_sphv_10hv = (nom_dela_thesato_nmos120_sphv_10hv+(sig_dela_thesato_nmos120_sphv_10hv*nsig_dela_thesato_nmos120_sphv_10hv))
+ dela_thesatw_nmos120_sphv_10hv = (nom_dela_thesatw_nmos120_sphv_10hv+(sig_dela_thesatw_nmos120_sphv_10hv*nsig_dela_thesatw_nmos120_sphv_10hv))
+ dela_thesatl_nmos120_sphv_10hv = (nom_dela_thesatl_nmos120_sphv_10hv+(sig_dela_thesatl_nmos120_sphv_10hv*nsig_dela_thesatl_nmos120_sphv_10hv))
+ dela_thesatlw_nmos120_sphv_10hv = (nom_dela_thesatlw_nmos120_sphv_10hv+(sig_dela_thesatlw_nmos120_sphv_10hv*nsig_dela_thesatlw_nmos120_sphv_10hv))
+ dela_xw_nmos120_sphv_10hv = (nom_dela_xw_nmos120_sphv_10hv+(sig_dela_xw_nmos120_sphv_10hv*nsig_dela_xw_nmos120_sphv_10hv))
+ delr_cj_nmos120_sphv_10hv = (nom_delr_cj_nmos120_sphv_10hv*(1+sig_delr_cj_nmos120_sphv_10hv*nsig_delr_cj_nmos120_sphv_10hv))
+ delr_is_nmos120_sphv_10hv = (nom_delr_is_nmos120_sphv_10hv*exp(sig_delr_is_nmos120_sphv_10hv*nsig_delr_is_nmos120_sphv_10hv))
+ delr_is2_nmos120_sphv_10hv = (nom_delr_is2_nmos120_sphv_10hv*exp(sig_delr_is2_nmos120_sphv_10hv*nsig_delr_is2_nmos120_sphv_10hv))
+ delr_ir_nmos120_sphv_10hv = (nom_delr_ir_nmos120_sphv_10hv*exp(sig_delr_ir_nmos120_sphv_10hv*nsig_delr_ir_nmos120_sphv_10hv))
+ delr_uchl_nmos120_sphv_10hv = 1  //(nom_delr_uchl_nmos120_sphv_10hv+(sig_delr_uchl_nmos120_sphv_10hv*nsig_delr_uchl_nmos120_sphv_10hv))

// calculation for poly over field parasitic capaciance
+ dwcgdfldmoscap=41.5*(1-fem)
+ dwcgd_ply_fld=25*(1-fem)
+ cgd_ply_fld=0.85e-16*(w+dwcgd_ply_fld)

// parameters for veriloga
+ vp_nmos120_10hv = (35)
+ dvp_nmos120_10hv = (11)
+ type_nmos120_10hv = (1)

// parameters for the BV diode
+ dcbv_nmos120_10hv = (155)

// BV diode model card:
model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt   = (1e12)
+ tnom    = (27)
+ is      = (1e-30)
+ n       = (1.0)
+ cj      = (1e-30)
+ pta     = (0)
+ tlevc   = (2)
+ tlev    = (2)
//+ bv      = (dcbv_nmos120_10hv+bvdss_shift)    bvdss_shift belong to 2 powermosbvdss_default/off
+ bv      = (dcbv_nmos120_10hv)
+ ibv     = (1e-5/1e-12)

model pspmoscap psp103t type=n
+ tr     = 27
+ toxo   = toxo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ dphibo = dphibo_nmos120_sphv_10hv-0.35
+ dphibw = (dphibw_nmos120_sphv_10hv+3.75)*(1-fem)
+ vfbo   = vfbo_nmos120_sphv_10hv+dela_vfb_nmos120_sphv_10hv-0.2
+ nsubo  = nsubo_nmos120_sphv_10hv
+ nsubw  = (nsubw_nmos120_sphv_10hv-1.4)*(1-fem)
+ rtho   = 1e18
+ ctho   = 0
+ dwq    = (0*(1-fem))

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=p
+    tr    = 27
+    toxo  = 400e-9
+    vfbo  = 0
+    nsubo = 4.5e22
+    npck  = 1e22
+    lpck  = 1e-6
+    rtho  = 1e18
+    ctho  = 0
+    uo    = 0


mcgdcap (b gi b di dtemp) cgdfldmoscap l=2.8 w=(w+dwcgdfldmoscap) mult=ng
avdclip (d di gi) vdclip vp=vp_nmos120_10hv dvp=dvp_nmos120_10hv type=type_nmos120_10hv


//cgd_fld_d (gi d) capacitor c=coxfield*aplyfld_gd+pplyfld_gd*cfr_ply_fld+cpp_m1_fld*a_gm1fld_gd+cfr_m1_fld*p_gm1fld_gd
cgd_fld (gi d) capacitor c=(cgd_ply_fld)  m=ng   //from moscap cgd
cgb_fld_b (gi b) capacitor c=coxfield*aplyfld_gb+pplyfld_gb*cfr_ply_fld*0+4e-15*ng

//---parasitic cap from p03n test structure
//ccsb_nmos120_10hv_m2m1_par (s b) capacitor c=csb_nmos120_10hv_m2m1_par+csb_nmos120_10hv_m2fld_par
//ccgs_nmos120_10hv_m2m1_par (gi s) capacitor c=cgs_nmos120_10hv_m2m1_par+1.5e-15
//ccgb_nmos120_10hv_m1ply_par (gi b) capacitor c=cgb_nmos120_10hv_m1ply_par
rgate     (g gi) resistor r=rgate m=ng
xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

dbodyBV (b rb)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rb d)   resistor r=0.01

mamost (d gi s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
if (fem <= 0.5) {
mamost_edge (d gi s b dtemp2) sphvt_simkit_edge w=0.1*(1-fem) l=l ldrift=ldrift wdrift=0.1 ldr1=ldr1 mult=ng ad=0 pd=0 as=0 ps=0 ad2=0 pd2=0
}
//qsbd (s b d)    npnd_lateral  area=(ad_i+ad2_i) m=ng


if (ng_dmy >= 2) {

mcgdcap_dmy (b s b di_dmy dtemp) cgdfldmoscap l=2.8 w=(w+dwcgdfldmoscap) mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip vp=vp_nmos120_10hv dvp=dvp_nmos120_10hv type=type_nmos120_10hv

cgd_fld_dmy (s d) capacitor c=(cgd_ply_fld)  m=ng_dmy   //from moscap cgd
cgb_fld_b_dmy (s b) capacitor c=coxfield*aplyfld_gb_dmy+cfr_ply_fld*pplyfld_gb_dmy*0+4e-15*ng_dmy


mamost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
if (fem <= 0.5) {
mamost_dmy_edge (d s s b dtemp3) sphvt_simkit_edge w=0.1*(1-fem) l=l ldrift=ldrift wdrift=0.1 ldr1=ldr1 mult=ng ad=0 pd=0 as=0 ps=0 ad2=0 pd2=0
}
}



model sphvt_simkit sphvt
+ type           = n
+ tr           = 27
+ vdscale      = (vdscale_nmos120_sphv_10hv+dela_vdscale_nmos120_sphv_10hv+(vdscalel_nmos120_sphv_10hv+dela_vdscalel_nmos120_sphv_10hv+fac_a_ng_vdscalel)/l+(vdscalew_nmos120_sphv_10hv+dela_vdscalew_nmos120_sphv_10hv)*(1-fem)/w+(vdscalelw_nmos120_sphv_10hv+dela_vdscalelw_nmos120_sphv_10hv)*(1-fem)/(w+4.5*(1-fem))/l)
+ vdscaleb      = (vdscaleb_nmos120_sphv_10hv*(l+vdscalebl_nmos120_sphv_10hv)/l)
+ stvdscale      = stvdscale_nmos120_sphv_10hv
+ swdrlin           = (swdrlin)
+ swgeo        	= 1
+ swigate      	  = 0
+ swimpact     	   = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	    = 1
+ swshe        	= selfheat*enable_selfheat
+ swimpdr      	  = 1
+ swexp        	= 1
+ swdelvtac    	    = 0
+ swnud        	= 0
+ swptest      	  = 0
+ swgedi      	  = 1
+ swtcec      	  = 1
+ xvsat           = xvsat_nmos120_sphv_10hv
+ qmc             = qmc_nmos120_sphv_10hv
+ lvaro        	= (lvaro_nmos120_sphv_10hv+1e-6*dela_lvaro_nmos120_sphv_10hv)
+ lvarl        	= lvarl_nmos120_sphv_10hv
+ lvarw        	= (lvarw_nmos120_sphv_10hv+dela_lvarw_nmos120_sphv_10hv)*(1-fem)
+ lap             = lap_nmos120_sphv_10hv
+ wvaro        	= (wvaro_nmos120_sphv_10hv+1e-6*dela_dw_nmos120_sphv_10hv)*(1-fem)
+ wvarl        	= (wvarl_nmos120_sphv_10hv)*(1-fem)
+ wvarw        	= (wvarw_nmos120_sphv_10hv)*(1-fem)
+ wot             = wot_nmos120_sphv_10hv*(1-fem)
+ dlq             = dlq_nmos120_sphv_10hv
+ dwq             = dwq_nmos120_sphv_10hv*(1-fem)
+ vfbo            = (vfbo_nmos120_sphv_10hv+fac_a_ng_vfbo+dela_vfb_nmos120_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nmos120_vthratio)
+ vfbl            = vfbl_nmos120_sphv_10hv+dela_vtl_nmos120_sphv_10hv
+ vfbw            = (vfbw_nmos120_sphv_10hv+dela_vtw_nmos120_sphv_10hv)*(1-fem)
+ vfblw        	= (vfblw_nmos120_sphv_10hv+dela_vtlw_nmos120_sphv_10hv)*(1-fem)
+ stvfbo       	 = stvfbo_nmos120_sphv_10hv
+ stvfbl       	 = stvfbl_nmos120_sphv_10hv
+ stvfbw       	 = stvfbw_nmos120_sphv_10hv*(1-fem)
+ stvfblw      	 = stvfblw_nmos120_sphv_10hv*(1-fem)
+ toxo             = toxo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ epsroxo      	 = epsroxo_nmos120_sphv_10hv
+ nsubo        	 = nsubo_nmos120_sphv_10hv*delr_nsub_nmos120_sphv_10hv
+ nsubw        	 = nsubw_nmos120_sphv_10hv*(1-fem)
+ wseg             = wseg_nmos120_sphv_10hv
+ npck             = npck_nmos120_sphv_10hv
+ npckw        	= npckw_nmos120_sphv_10hv*(1-fem)
+ wsegp        	= wsegp_nmos120_sphv_10hv
+ lpck            = lpck_nmos120_sphv_10hv
+ lpckw        	= lpckw_nmos120_sphv_10hv*(1-fem)
+ fol1            = fol1_nmos120_sphv_10hv
+ fol2            = fol2_nmos120_sphv_10hv
+ facneffaco   	     = facneffaco_nmos120_sphv_10hv
+ facneffacl   	     = facneffacl_nmos120_sphv_10hv
+ facneffacw   	     = facneffacw_nmos120_sphv_10hv*(1-fem)
+ facneffaclw  	     = facneffaclw_nmos120_sphv_10hv*(1-fem)
+ gfacnudo     	   = gfacnudo_nmos120_sphv_10hv
+ gfacnudl     	   = gfacnudl_nmos120_sphv_10hv
+ gfacnudlexp  	   = gfacnudlexp_nmos120_sphv_10hv
+ gfacnudw     	   = gfacnudw_nmos120_sphv_10hv*(1-fem)
+ gfacnudlw    	   = gfacnudlw_nmos120_sphv_10hv*(1-fem)
+ vsbnudo      	   = vsbnudo_nmos120_sphv_10hv
+ dvsbnudo     	   = dvsbnudo_nmos120_sphv_10hv
+ vnsubo       	 = vnsubo_nmos120_sphv_10hv
+ nslpo        	 = nslpo_nmos120_sphv_10hv
+ dnsubo       	 = dnsubo_nmos120_sphv_10hv
+ dphibo       	 = dphibo_nmos120_sphv_10hv
+ dphibl       	 = dphibl_nmos120_sphv_10hv
+ dphiblexp    	 = dphiblexp_nmos120_sphv_10hv
+ dphibw       	 = (dphibw_nmos120_sphv_10hv)*(1-fem)
+ dphiblw      	 = (dphiblw_nmos120_sphv_10hv)*(1-fem)
+ delvtaco     	   = delvtaco_nmos120_sphv_10hv
+ delvtacl     	   = delvtacl_nmos120_sphv_10hv
+ delvtaclexp  	   = delvtaclexp_nmos120_sphv_10hv
+ delvtacw     	   = delvtacw_nmos120_sphv_10hv*(1-fem)
+ delvtaclw    	   = delvtaclw_nmos120_sphv_10hv*(1-fem)
+ npo           = npo_nmos120_sphv_10hv
+ npl           = npl_nmos120_sphv_10hv
+ cto           = cto_nmos120_sphv_10hv
+ ctl           = ctl_nmos120_sphv_10hv
+ ctlexp        = ctlexp_nmos120_sphv_10hv
+ ctw           = ctw_nmos120_sphv_10hv*(1-fem)
+ ctlw          = ctlw_nmos120_sphv_10hv*(1-fem)
+ toxovo        = toxovo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ toxovdo       = toxovdo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ lov           = lov_nmos120_sphv_10hv
+ dlovd         = dlovd_nmos120_sphv_10hv
+ novo          = novo_nmos120_sphv_10hv
+ novdo         = novdo_nmos120_sphv_10hv
+ cfl           = cfl_nmos120_sphv_10hv
+ cflexp        = cflexp_nmos120_sphv_10hv
+ cfw           = cfw_nmos120_sphv_10hv*(1-fem)
+ cfbo          = cfbo_nmos120_sphv_10hv
+ uo           = (uo_nmos120_sphv_10hv*delr_uch_nmos120_sphv_10hv*delr_uchl_nmos120_sphv_10hv*delr_u0_relimo/fac_r_ng_uo)
+ fbet1        = fbet1_nmos120_sphv_10hv
+ fbet1w       = fbet1w_nmos120_sphv_10hv*(1-fem)
+ lp1           = lp1_nmos120_sphv_10hv
+ lp1w          = lp1w_nmos120_sphv_10hv*(1-fem)
+ fbet2         = fbet2_nmos120_sphv_10hv
+ lp2           = lp2_nmos120_sphv_10hv
+ betw1         = betw1_nmos120_sphv_10hv*(1-fem)
+ betw2         = betw2_nmos120_sphv_10hv*(1-fem)
+ wbet          = wbet_nmos120_sphv_10hv
+ stbeto       	 = stbeto_nmos120_sphv_10hv
+ stbetl       	 = stbetl_nmos120_sphv_10hv
+ stbetw       	 = stbetw_nmos120_sphv_10hv*(1-fem)
+ stbetlw      	 = stbetlw_nmos120_sphv_10hv*(1-fem)
+ mueo           = mueo_nmos120_sphv_10hv
+ muew           = muew_nmos120_sphv_10hv*(1-fem)
+ stmueo       	 = stmueo_nmos120_sphv_10hv
+ themuo       	 = themuo_nmos120_sphv_10hv
+ stthemuo     	 = stthemuo_nmos120_sphv_10hv
+ cso           = cso_nmos120_sphv_10hv
+ csl           = csl_nmos120_sphv_10hv
+ cslexp        = cslexp_nmos120_sphv_10hv
+ csw           = csw_nmos120_sphv_10hv*(1-fem)
+ cslw          = cslw_nmos120_sphv_10hv*(1-fem)
+ stcso        	= stcso_nmos120_sphv_10hv
+ xcoro        	= xcoro_nmos120_sphv_10hv
+ xcorl        	= xcorl_nmos120_sphv_10hv
+ xcorw        	= xcorw_nmos120_sphv_10hv*(1-fem)
+ xcorlw          = xcorlw_nmos120_sphv_10hv*(1-fem)
+ stxcoro      	= stxcoro_nmos120_sphv_10hv*(1-2/l/w*(1-fem))+(0.005+0.7*0.010/w*(1-fem))*(temp-tnom)
+ fetao        	= fetao_nmos120_sphv_10hv
+ rsw1            = rsw1_nmos120_sphv_10hv
+ rsw2            = rsw2_nmos120_sphv_10hv*(1-fem)
+ strso        	= strso_nmos120_sphv_10hv
+ rsbo            = rsbo_nmos120_sphv_10hv
+ rsgo            = rsgo_nmos120_sphv_10hv
+ thesato      	  = (thesato_nmos120_sphv_10hv+dela_thesato_nmos120_sphv_10hv+fac_a_ng_thesato)+(2e-3*(3-l)*(min(max(10,w*(1-fem)),50)-10))
+ thesatl      	  = (thesatl_nmos120_sphv_10hv+dela_thesatl_nmos120_sphv_10hv)
+ thesatlexp   	  = thesatlexp_nmos120_sphv_10hv
+ thesatw      	  = (thesatw_nmos120_sphv_10hv+dela_thesatw_nmos120_sphv_10hv+fac_a_ng_thesatw)*(1-fem)
+ thesatlw     	  = (thesatlw_nmos120_sphv_10hv+dela_thesatlw_nmos120_sphv_10hv)*(1-fem)
+ stthesato    	    = stthesato_nmos120_sphv_10hv
+ stthesatl    	    = stthesatl_nmos120_sphv_10hv
+ stthesatw    	    = stthesatw_nmos120_sphv_10hv*(1-fem)
+ stthesatlw   	    = stthesatlw_nmos120_sphv_10hv*(1-fem)
+ thesatbo     	   = (thesatbo_nmos120_sphv_10hv+thesatbl_nmos120_sphv_10hv/l+thesatbw_nmos120_sphv_10hv/w*(1-fem)+thesatblw_nmos120_sphv_10hv/l/w*(1-fem))
+ thesatgo     	   = (thesatgo_nmos120_sphv_10hv+thesatglw_nmos120_sphv_10hv/l/w*(1-fem)*fac_r_ng_thesatglw)*fac_r_ng_thesatgo*(1+(stthesatgo_nmos120_sphv_10hv+stthesatgl_nmos120_sphv_10hv/l+stthesatgw_nmos120_sphv_10hv*(1-fem)/w+(stthesatglw_nmos120_sphv_10hv-0.0007*(min(temp,tnom)-tnom))*(1-fem)/l/w*fac_r_ng_stthesatglw)*(temp-tnom))
+ thesatgl     	   = thesatgl_nmos120_sphv_10hv*fac_r_ng_thesatgl
+ thesatgw     	   = thesatgw_nmos120_sphv_10hv*(1-fem)*fac_r_ng_thesatgw
+ axo           = axo_nmos120_sphv_10hv
+ axl           = axl_nmos120_sphv_10hv
+ alpl          = alpl_nmos120_sphv_10hv
+ alplexp       = alplexp_nmos120_sphv_10hv
+ alpw          = alpw_nmos120_sphv_10hv*(1-fem)
+ alp1l1        = alp1l1_nmos120_sphv_10hv
+ alp1lexp      = alp1lexp_nmos120_sphv_10hv
+ alp1l2        = alp1l2_nmos120_sphv_10hv
+ alp1w         = alp1w_nmos120_sphv_10hv*(1-fem)
+ alp2l1        = alp2l1_nmos120_sphv_10hv
+ alp2lexp      = alp2lexp_nmos120_sphv_10hv
+ alp2l2        = alp2l2_nmos120_sphv_10hv
+ alp2w         = alp2w_nmos120_sphv_10hv*(1-fem)
+ vpo           = vpo_nmos120_sphv_10hv
+ a1o           = a1o_nmos120_sphv_10hv
+ a1l           = a1l_nmos120_sphv_10hv
+ a1w           = a1w_nmos120_sphv_10hv*(1-fem)
+ a2o           = a2o_nmos120_sphv_10hv
+ sta2o         = sta2o_nmos120_sphv_10hv
+ a3o           = a3o_nmos120_sphv_10hv
+ a3l           = a3l_nmos120_sphv_10hv
+ a3w           = a3w_nmos120_sphv_10hv*(1-fem)
+ a4o           = a4o_nmos120_sphv_10hv
+ a4l           = a4l_nmos120_sphv_10hv
+ a4w           = a4w_nmos120_sphv_10hv*(1-fem)
+ gcoo          = gcoo_nmos120_sphv_10hv
+ iginvlw      	= iginvlw_nmos120_sphv_10hv
+ igovw        	= igovw_nmos120_sphv_10hv
+ igovdw       	= igovdw_nmos120_sphv_10hv
+ stigo        	= stigo_nmos120_sphv_10hv
+ gc2o            = gc2o_nmos120_sphv_10hv
+ gc3o            = gc3o_nmos120_sphv_10hv
+ chibo        	= chibo_nmos120_sphv_10hv
+ agidlw       	= agidlw_nmos120_sphv_10hv
+ agidldw      	= agidldw_nmos120_sphv_10hv
+ bgidlo       	= bgidlo_nmos120_sphv_10hv
+ bgidldo      	= bgidldo_nmos120_sphv_10hv
+ stbgidlo     	= stbgidlo_nmos120_sphv_10hv
+ stbgidldo    	= stbgidldo_nmos120_sphv_10hv
+ cgidlo       	= cgidlo_nmos120_sphv_10hv
+ cgidldo      	= cgidldo_nmos120_sphv_10hv
+ cgbovl       	= cgbovl_nmos120_sphv_10hv
+ cfrw            = cfrw_nmos120_sphv_10hv*(1-fem)
+ cfrdw        	= cfrdw_nmos120_sphv_10hv*(1-fem)
+ fnto            = fnto_nmos120_sphv_10hv
+ nfalw        	= nfalw_nmos120_sphv_10hv
+ nfblw        	= nfblw_nmos120_sphv_10hv
+ nfclw        	= nfclw_nmos120_sphv_10hv
+ efo             = efo_nmos120_sphv_10hv
+ lintnoi      	  = lintnoi_nmos120_sphv_10hv
+ alpnoi       	  = alpnoi_nmos120_sphv_10hv
+ kvthoweo     	   = kvthoweo_nmos120_sphv_10hv
+ kvthowel     	   = kvthowel_nmos120_sphv_10hv
+ kvthowew     	   = kvthowew_nmos120_sphv_10hv*(1-fem)
+ kvthowelw    	   = kvthowelw_nmos120_sphv_10hv*(1-fem)
+ kuoweo       	 = kuoweo_nmos120_sphv_10hv
+ kuowel       	 = kuowel_nmos120_sphv_10hv
+ kuowew       	 = kuowew_nmos120_sphv_10hv*(1-fem)
+ kuowelw      	 = kuowelw_nmos120_sphv_10hv*(1-fem)
+ rgo           = rgo_nmos120_sphv_10hv
+ rsh           = rsh_nmos120_sphv_10hv
+ rbulko       	 = rbulko_nmos120_sphv_10hv
+ rwello       	 = rwello_nmos120_sphv_10hv
+ rjunso       	 = rjunso_nmos120_sphv_10hv/(w+dwrjunso_nmos120_sphv_10hv*(1-fem))*tfact_rs
+ rjundo       	 = rjundo_nmos120_sphv_10hv/(w+dwrjundo_nmos120_sphv_10hv*(1-fem))*l/(l+0.25)*tfact_rs
+ rint           = rint_nmos120_sphv_10hv
+ rvpoly       	 = rvpoly_nmos120_sphv_10hv
+ rshg           = rshg_nmos120_sphv_10hv
+ dlsil        	= dlsil_nmos120_sphv_10hv
+ saref        	= saref_nmos120_sphv_10hv
+ sbref        	= sbref_nmos120_sphv_10hv
+ wlod           = wlod_nmos120_sphv_10hv
+ kuo           = kuo_nmos120_sphv_10hv
+ kvsat        	= kvsat_nmos120_sphv_10hv
+ tkuo           = tkuo_nmos120_sphv_10hv
+ lkuo           = lkuo_nmos120_sphv_10hv
+ wkuo           = wkuo_nmos120_sphv_10hv*(1-fem)
+ pkuo           = pkuo_nmos120_sphv_10hv*(1-fem)
+ llodkuo      	  = llodkuo_nmos120_sphv_10hv
+ wlodkuo      	  = wlodkuo_nmos120_sphv_10hv
+ kvtho        	 = kvtho_nmos120_sphv_10hv
+ lkvtho       	 = lkvtho_nmos120_sphv_10hv
+ wkvtho       	 = wkvtho_nmos120_sphv_10hv*(1-fem)
+ pkvtho       	 = pkvtho_nmos120_sphv_10hv*(1-fem)
+ llodvth      	 = llodvth_nmos120_sphv_10hv
+ wlodvth      	 = wlodvth_nmos120_sphv_10hv
+ stetao       	 = stetao_nmos120_sphv_10hv
+ lodetao      	 = lodetao_nmos120_sphv_10hv
+ scref        	= scref_nmos120_sphv_10hv
+ web           = web_nmos120_sphv_10hv
+ wec           = wec_nmos120_sphv_10hv
+ adr1o        	= adr1o_nmos120_sphv_10hv+adr1lw_nmos120_sphv_10hv*(1-fem)/l/w*fac_r_ng_adr1lw
+ adr1l        	= adr1l_nmos120_sphv_10hv
+ adr1w        	= adr1w_nmos120_sphv_10hv*(1-fem)
+ adr2o        	= adr2o_nmos120_sphv_10hv
+ stadr2o      	= stadr2o_nmos120_sphv_10hv
+ adr3o        	= adr3o_nmos120_sphv_10hv
+ adr3l        	= adr3l_nmos120_sphv_10hv
+ adr3w        	= adr3w_nmos120_sphv_10hv*(1-fem)
+ adr4o        	= adr4o_nmos120_sphv_10hv
+ adr4l        	= adr4l_nmos120_sphv_10hv
+ adr4w        	= adr4w_nmos120_sphv_10hv*(1-fem)
+ adr5o        	= adr5o_nmos120_sphv_10hv
+ adr5l        	= adr5l_nmos120_sphv_10hv
+ adr5w        	= adr5w_nmos120_sphv_10hv*(1-fem)
+ bidr1o       	 = bidr1o_nmos120_sphv_10hv*fac_ng_stbidr1o
+ bidr1l       	 = bidr1l_nmos120_sphv_10hv
+ bidr1w       	 = bidr1w_nmos120_sphv_10hv*(1-fem)
+ bidr2o       	 = bidr2o_nmos120_sphv_10hv
+ bidr2w       	 = bidr2w_nmos120_sphv_10hv*(1-fem)
+ rtho           = rth_f*(1+0.4/l)/(1+4.0/l/w*(1-fem))*(1+2.0*(temp-tnom)*fac_r_ng_strtho+1*strtho_nmos120_sphv_10hv*(temp-tnom)**2*(1+0.9/l))
+ rthl           = 0
+ rthw           = 0
+ rthlw          = 0
+ strtho         = strtho_nmos120_sphv_10hv*0
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw          = 0
+ rshldd         = (rshldd_nmos120_sphv_10hv*fac_r_ng_rshldd*delr_res_nmos120_sphv_10hv*fac_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nmos120_ronratio))
+ xw             = ((xw_nmos120_sphv_10hv+dela_xw_nmos120_sphv_10hv)*(1-fem))
+ nwxw           = (nwxw_nmos120_sphv_10hv*(1-fem))
+ xl             = xl_nmos120_sphv_10hv
+ xlw            = xlw_nmos120_sphv_10hv*(1-fem)
+ dxlsat         = dxlsat_nmos120_sphv_10hv
+ nst            = nst_nmos120_sphv_10hv
+ ats            = ats_nmos120_sphv_10hv
+ dfinf          = dfinf_nmos120_sphv_10hv
+ dfw            = dfw_nmos120_sphv_10hv*(1-fem)
+ dfl            = dfl_nmos120_sphv_10hv
+ dflw           = dflw_nmos120_sphv_10hv*(1-fem)
+ dp             = dp_nmos120_sphv_10hv
+ ecrit          = ecrit_nmos120_sphv_10hv*tfact_ecrit*(1-3.0*0.05/l+dwecrit*(1-fem)/w+dwecritw*(1-fem)/(w*w))
+ ecorn          = ecorn_nmos120_sphv_10hv*tfact_ecrit*(1+dwecrit*(1-fem)/w+dwecritw*(1-fem)/(w*w))
+ du             = du_nmos120_sphv_10hv
+ tc1            = tc1_nmos120_sphv_10hv+tc1lw_nmos120_sphv_10hv*(1-fem)/l/w
+ tc2            = tc2_nmos120_sphv_10hv+tc2lw_nmos120_sphv_10hv*(1-fem)/l/w
+ tc1l           = tc1l_nmos120_sphv_10hv
+ tc2l           = tc2l_nmos120_sphv_10hv
+ tc1w           = tc1w_nmos120_sphv_10hv*(1-fem)
+ tc2w           = tc2w_nmos120_sphv_10hv*(1-fem)
+ theacc         = theacc_nmos120_sphv_10hv
+ theacc2        = theacc2_nmos120_sphv_10hv
+ rva           = rva_nmos120_sphv_10hv
+ dta           = dta_nmos120_sphv_10hv
+ trj           = trj_nmos120_sphv_10hv
+ cjarea       	 = cjarea_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ cjlsti       	 = cjlsti_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ cjlgat       	 = cjlgat_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ vbiarea          = vbiarea_nmos120_sphv_10hv
+ vbisti       	 = vbisti_nmos120_sphv_10hv
+ vbigat       	 = vbigat_nmos120_sphv_10hv
+ parea        	 = parea_nmos120_sphv_10hv
+ psti             = psti_nmos120_sphv_10hv
+ pgat             = pgat_nmos120_sphv_10hv
+ is1area      	 = is1area_nmos120_sphv_10hv*delr_is_nmos120_sphv_10hv
+ ttarea       	 = ttarea_nmos120_sphv_10hv
+ is2area      	 = is2area_nmos120_sphv_10hv*delr_is2_nmos120_sphv_10hv
+ irarea       	 = irarea_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1area    	    = stis1area_nmos120_sphv_10hv
+ stis2area    	    = stis2area_nmos120_sphv_10hv
+ stirarea     	   = stirarea_nmos120_sphv_10hv
+ n1area       	 = n1area_nmos120_sphv_10hv
+ n2area       	 = n2area_nmos120_sphv_10hv
+ nrarea       	 = nrarea_nmos120_sphv_10hv
+ is1lsti      	  = is1lsti_nmos120_sphv_10hv*delr_is_nmos120_sphv_10hv
+ ttlsti       	 = ttlsti_nmos120_sphv_10hv
+ is2lsti      	  = is2lsti_nmos120_sphv_10hv*delr_is2_nmos120_sphv_10hv
+ irlsti       	 = irlsti_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1sti     	   = stis1sti_nmos120_sphv_10hv
+ stis2sti     	   = stis2sti_nmos120_sphv_10hv
+ stirsti      	  = stirsti_nmos120_sphv_10hv
+ n1sti        	= n1sti_nmos120_sphv_10hv
+ n2sti        	= n2sti_nmos120_sphv_10hv
+ nrsti        	= nrsti_nmos120_sphv_10hv
+ is1lgat      	  = is1lgat_nmos120_sphv_10hv*delr_is_nmos120_sphv_10hv
+ ttlgat       	 = ttlgat_nmos120_sphv_10hv
+ is2lgat      	  = is2lgat_nmos120_sphv_10hv*delr_is2_nmos120_sphv_10hv
+ irlgat       	 = irlgat_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1gat     	   = stis1gat_nmos120_sphv_10hv
+ stis2gat     	   = stis2gat_nmos120_sphv_10hv
+ stirgat      	  = stirgat_nmos120_sphv_10hv
+ n1gat        	= n1gat_nmos120_sphv_10hv
+ n2gat        	= n2gat_nmos120_sphv_10hv
+ nrgat        	= nrgat_nmos120_sphv_10hv
+ cjaread      	  = cjaread_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ cjlstid      	  = cjlstid_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ cjlgatd      	  = cjlgatd_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ vbiaread     	   = vbiaread_nmos120_sphv_10hv
+ vbistid      	  = vbistid_nmos120_sphv_10hv
+ vbigatd      	  = vbigatd_nmos120_sphv_10hv
+ paread       	 = paread_nmos120_sphv_10hv
+ pstid        	= pstid_nmos120_sphv_10hv
+ pgatd        	= pgatd_nmos120_sphv_10hv
+ is1aread     	   = is1aread_nmos120_sphv_10hv*delr_is_nmos120_sphv_10hv
+ ttaread      	  = ttaread_nmos120_sphv_10hv
+ is2aread     	   = is2aread_nmos120_sphv_10hv*delr_is2_nmos120_sphv_10hv
+ iraread      	  = iraread_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1aread   	     = stis1aread_nmos120_sphv_10hv
+ stis2aread   	     = stis2aread_nmos120_sphv_10hv
+ stiraread    	    = stiraread_nmos120_sphv_10hv
+ n1aread      	  = n1aread_nmos120_sphv_10hv
+ n2aread      	  = n2aread_nmos120_sphv_10hv
+ nraread      	  = nraread_nmos120_sphv_10hv
+ is1lstid     	   = is1aread_nmos120_sphv_10hv*djunc*delr_is_nmos120_sphv_10hv
+ ttlstid      	  = ttlstid_nmos120_sphv_10hv
+ is2lstid     	   = is2lstid_nmos120_sphv_10hv*djunc*delr_is2_nmos120_sphv_10hv
+ irlstid      	  = irlstid_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1stid    	    = stis1stid_nmos120_sphv_10hv
+ stis2stid    	    = stis2stid_nmos120_sphv_10hv
+ stirstid     	   = stirstid_nmos120_sphv_10hv
+ n1stid       	 = n1stid_nmos120_sphv_10hv
+ n2stid       	 = n2stid_nmos120_sphv_10hv
+ nrstid       	 = nrstid_nmos120_sphv_10hv
+ is1lgatd     	   = is1aread_nmos120_sphv_10hv*djunc*delr_is_nmos120_sphv_10hv
+ ttlgatd      	  = ttlgatd_nmos120_sphv_10hv
+ is2lgatd     	   = is2lgatd_nmos120_sphv_10hv*djunc*delr_is2_nmos120_sphv_10hv
+ irlgatd      	  = irlgatd_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1gatd    	    = stis1gatd_nmos120_sphv_10hv
+ stis2gatd    	    = stis2gatd_nmos120_sphv_10hv
+ stirgatd     	   = stirgatd_nmos120_sphv_10hv
+ n1gatd       	 = n1gatd_nmos120_sphv_10hv
+ n2gatd       	 = n2gatd_nmos120_sphv_10hv
+ nrgatd       	 = nrgatd_nmos120_sphv_10hv
+ cjaread2     	   = cjaread_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ cjlstid2     	   = cjlstid_nmos120_sphv_10hv*delr_cj_nmos120_sphv_10hv
+ vbiaread2    	    = vbiaread2_nmos120_sphv_10hv
+ vbistid2     	   = vbistid2_nmos120_sphv_10hv
+ paread2      	  = paread2_nmos120_sphv_10hv
+ pstid2       	 = pstid2_nmos120_sphv_10hv
+ is1aread2    	    = is1aread_nmos120_sphv_10hv*delr_is_nmos120_sphv_10hv
+ ttaread2     	   = ttaread2_nmos120_sphv_10hv
+ is2aread2    	    = is2aread2_nmos120_sphv_10hv*delr_is2_nmos120_sphv_10hv
+ iraread2     	   = iraread2_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1aread2  	      = stis1aread_nmos120_sphv_10hv
+ stis2aread2  	      = stis2aread_nmos120_sphv_10hv
+ stiraread2   	     = stiraread2_nmos120_sphv_10hv
+ n1aread2     	   = n1aread2_nmos120_sphv_10hv
+ n2aread2     	   = n2aread2_nmos120_sphv_10hv
+ nraread2     	   = nraread2_nmos120_sphv_10hv
+ is1lstid2    	    = is1aread_nmos120_sphv_10hv*djunc*delr_is_nmos120_sphv_10hv
+ ttlstid2     	   = ttlstid2_nmos120_sphv_10hv
+ is2lstid2    	    = is2lstid2_nmos120_sphv_10hv*djunc*delr_is2_nmos120_sphv_10hv
+ irlstid2     	   = irlstid2_nmos120_sphv_10hv*delr_ir_nmos120_sphv_10hv
+ stis1stid2   	     = stis1stid2_nmos120_sphv_10hv
+ stis2stid2   	     = stis2stid2_nmos120_sphv_10hv
+ stirstid2    	    = stirstid2_nmos120_sphv_10hv
+ n1stid2      	  = n1stid2_nmos120_sphv_10hv
+ n2stid2      	  = n2stid2_nmos120_sphv_10hv
+ nrstid2      	  = nrstid2_nmos120_sphv_10hv
+ aacc              = aacc_nmos120_sphv_10hv
+ eais1area         =eais1area_nmos120_sphv_10hv
+ eais2area         =eais2area_nmos120_sphv_10hv
+ eairarea          =eairarea_nmos120_sphv_10hv
+ eais1sti          =eais1sti_nmos120_sphv_10hv
+ eais2sti          =eais2sti_nmos120_sphv_10hv
+ eairsti           =eairsti_nmos120_sphv_10hv
+ eais1gat          =eais1gat_nmos120_sphv_10hv
+ eais2gat          =eais2gat_nmos120_sphv_10hv
+ eairgat           =eairgat_nmos120_sphv_10hv
+ eais1aread        =eais1aread_nmos120_sphv_10hv
+ eais2aread        =eais2aread_nmos120_sphv_10hv
+ eairaread         =eairaread_nmos120_sphv_10hv
+ eais1stid         =eais1stid_nmos120_sphv_10hv
+ eais2stid         =eais2stid_nmos120_sphv_10hv
+ eairstid          =eairstid_nmos120_sphv_10hv
+ eais1gatd         =eais1gatd_nmos120_sphv_10hv
+ eais2gatd         =eais2gatd_nmos120_sphv_10hv
+ eairgatd          =eairgatd_nmos120_sphv_10hv
+ eais1aread2       =eais1aread2_nmos120_sphv_10hv
+ eais2aread2       =eais2aread2_nmos120_sphv_10hv
+ eairaread2        =eairaread2_nmos120_sphv_10hv
+ eais1stid2        =eais1stid2_nmos120_sphv_10hv
+ eais2stid2        =eais2stid2_nmos120_sphv_10hv
+ eairstid2         =eairstid2_nmos120_sphv_10hv
+ ikfarea               = ikfarea_nmos120_sphv_10hv
+ ikflsti               = ikfarea_nmos120_sphv_10hv*djunc
+ ikflgat               = ikfarea_nmos120_sphv_10hv*djunc
+ stikfarea             = stikfarea_nmos120_sphv_10hv
+ stikfsti              = stikfarea_nmos120_sphv_10hv
+ stikfgat              = stikfarea_nmos120_sphv_10hv
+ ikfaread              = ikfaread_nmos120_sphv_10hv*(w/(w+dwikfaread_nmos120_sphv_10hv*(1-fem)))
+ ikflstid              = ikfaread_nmos120_sphv_10hv*djunc*(w/(w+dwikfaread_nmos120_sphv_10hv*(1-fem)))
+ ikflgatd              = ikfaread_nmos120_sphv_10hv*djunc*(w/(w+dwikfaread_nmos120_sphv_10hv*(1-fem)))
+ ikfaread2             = ikfaread_nmos120_sphv_10hv*(w/(w+dwikfaread_nmos120_sphv_10hv*(1-fem)))
+ ikflstid2             = ikfaread_nmos120_sphv_10hv*djunc*(w/(w+dwikfaread_nmos120_sphv_10hv*(1-fem)))
+ stikfaread            = stikfaread_nmos120_sphv_10hv
+ stikfstid             = stikfaread_nmos120_sphv_10hv
+ stikfgatd             = stikfaread_nmos120_sphv_10hv
+ stikfaread2           = stikfaread_nmos120_sphv_10hv
+ stikfstid2            = stikfaread_nmos120_sphv_10hv

model sphvt_simkit_edge sphvt
+ type           = n
+ tr             = 27
+ swdrlin        = (swdrlin)
+ swgeo          = 1
+ swigate        = 0
+ swimpact       = 0
+ swgidl         = 0
+ swjunc         = 2
+ swjunasym      = 1
+ swshe          = 0
+ swimpdr        = 0
+ swexp          = 0
+ swdelvtac      = 0
+ swnud          = 0
+ swptest        = 0
+ swgedi         = 1
+ swtcec         = 1
+ xvsat          = xvsat_nmos120_sphv_10hv
+ qmc            = qmc_nmos120_sphv_10hv
+ lvaro          = (lvaro_nmos120_sphv_10hv+1e-6*dela_lvaro_nmos120_sphv_10hv)
+ lvarl          = lvarl_nmos120_sphv_10hv
+ vfbo           = -0.01-0.08+(vfbo_nmos120_sphv_10hv+fac_a_ng_vfbo+dela_vfb_nmos120_sphv_10hv+dela_vth_relimo+hvgsvthdegr*presto_nmos120_vthratio)
+ vfbl           = vfbl_nmos120_sphv_10hv+dela_vtl_nmos120_sphv_10hv
+ stvfbo         = stvfbo_nmos120_sphv_10hv+200e-6
+ stvfbl         = stvfbl_nmos120_sphv_10hv
+ toxo           = toxo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ nsubo          = nsubo_nmos120_sphv_10hv*delr_nsub_nmos120_sphv_10hv
+ npck           = npck_nmos120_sphv_10hv
+ dphibo         = dphibo_nmos120_sphv_10hv
+ dphibl         = dphibl_nmos120_sphv_10hv
+ dphiblexp      = dphiblexp_nmos120_sphv_10hv
+ toxovo         = toxovo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ toxovdo        = toxovdo_nmos120_sphv_10hv*delr_tox_nmos120_sphv_10hv
+ uo             = (uo_nmos120_sphv_10hv/fac_r_ng_uo)
+ stbeto         = stbeto_nmos120_sphv_10hv
+ stbetl         = stbetl_nmos120_sphv_10hv
+ mueo           = mueo_nmos120_sphv_10hv
+ stmueo         = stmueo_nmos120_sphv_10hv
+ themuo         = themuo_nmos120_sphv_10hv
+ stthemuo       = stthemuo_nmos120_sphv_10hv
+ xcoro          = xcoro_nmos120_sphv_10hv
+ xcorl          = xcorl_nmos120_sphv_10hv
+ stxcoro        = stxcoro_nmos120_sphv_10hv
+ strso          = strso_nmos120_sphv_10hv
+ thesato        = (10+thesato_nmos120_sphv_10hv)
+ thesatl        = thesatl_nmos120_sphv_10hv
+ thesatlexp     = thesatlexp_nmos120_sphv_10hv
+ thesatgo       = 10+(thesatgo_nmos120_sphv_10hv+thesatglw_nmos120_sphv_10hv*(1-fem)/l/w*fac_r_ng_thesatglw)*fac_r_ng_thesatgo
+ thesatgl       = 10+thesatgl_nmos120_sphv_10hv*fac_r_ng_thesatgl
+ rtho           = rth_f*(1+0.1/l)*(1+2.0*(temp-tnom)*fac_r_ng_strtho+1*strtho_nmos120_sphv_10hv*(temp-tnom)**2*(1+0.9/l))
+ rshldd         = (rshldd_nmos120_sphv_10hv*fac_r_ng_rshldd)
+ dfinf          = dfinf_nmos120_sphv_10hv
+ dp             = dp_nmos120_sphv_10hv
+ tc1            = tc1_nmos120_sphv_10hv
+ tc2            = tc2_nmos120_sphv_10hv
+ rjunso       	 = rjunso_nmos120_sphv_10hv/(w+dwrjunso_nmos120_sphv_10hv*(1-fem))*tfact_rs*10
+ rjundo       	 = rjundo_nmos120_sphv_10hv/(w+dwrjundo_nmos120_sphv_10hv*(1-fem))*l/(l+0.25)*tfact_rs

//model npnd_lateral bjt
//+ type         = (npn)
//+ struct       = (lateral)
//+ tnom         = (27)
//+ imax         = (100)
//+ is	       = 1e-18*0.04
//+ bf	       = 1e8
//+ nf	       = 1
//+ br	       = 1e8
//+ nr	       = 1
//+ xtb	       = 0
//+ eg	       = 1.11
//+ xti	       = 3*1.0
//+ re	       = 74000



include "./smos10hv_ade_dfrt.scs" section=nmos120_10hv_dfrt
ends

// pmos10_10hv



//ahdl_include "./veriloga/sphv_v2.0.4/sphv.va"

subckt pmos10_10hv (d g s b sub)
parameters
+ l               = 1.0
+ w               = 0.69
+ ng              = 1
+ sti_dummy       = 0
+ gt_90v          = 0
+ lpe             = 0
+ ring            = 1
+ soa             = 1
+ body_location   = 0
+ selfheat        = 1
+ mode_rthcth     = 1

+ nsmm_delr_gox_pmos10_sphv_10hv  = tmp_nsmm_delr_gox_pmos10_sphv_10hv
+ nsmm_delr_uch_pmos10_sphv_10hv  = tmp_nsmm_delr_uch_pmos10_sphv_10hv
+ nsmm_delr_res_pmos10_sphv_10hv  = tmp_nsmm_delr_res_pmos10_sphv_10hv
+ nsmm_dela_vfb_pmos10_sphv_10hv  = tmp_nsmm_dela_vfb_pmos10_sphv_10hv
+ nsmm_dela_vtl_pmos10_sphv_10hv  = tmp_nsmm_dela_vtl_pmos10_sphv_10hv
+ nsmm_dela_vtw_pmos10_sphv_10hv  = tmp_nsmm_dela_vtw_pmos10_sphv_10hv
+ nsmm_dela_dl_pmos10_sphv_10hv   = tmp_nsmm_dela_dl_pmos10_sphv_10hv
+ nsmm_dela_dw_pmos10_sphv_10hv   = tmp_nsmm_dela_dw_pmos10_sphv_10hv

//dummy parameters
+    ng_dmy         = 2*sti_dummy
+    ngeff          = ng+ng_dmy

parameters
+    nde            = (fmod(ng,2))
+    nse            = (2-nde)
+    nd             = ((ng+nde)/2)
+    ns             = (1-nde+nd)
+    ndi            = (nd-nde)
+    nsi            = (ns-nse)
+    nde_eff        = (fmod(ngeff,2))
+    nse_eff        = (2-nde_eff)
+    nd_eff         = ((ngeff+nde_eff)/2)
+    ns_eff         = (1-nde_eff+nd_eff)
+    ndi_eff        = (nd_eff-nde_eff)
+    nsi_eff        = (ns_eff-nse_eff)

// moved from instance parameter into inside because lpe will not extract them
+ as              = (0)
+ ps              = (0)
+ ad              = (0)
+ pd              = (0)



//layout parameters

+    lacts_e        = (0.375)
+    lacts_i        = (0.42)
+    lactd_e        = (0.33)
+    lactd_i        = (0.33)
+    ldrift         = (0.4)
+    lsplit         = (0.0)
+    ldr1           = (0.45)
+    lply2          = (0.225)
+    lply           = (l+ldr1+lply2)
+    lactd2nhv_e    = (0.675)
+    lg2pepi_s_b    = (2.175)
+    lg2pepi_s      = (1.485)
+    lg2pepi_d      = (1.93)
+    lp2p_d         = (2.03)
+    lp2p_s         = (0.42)
+    lactd2p_e      = (0.175)
+    wdrift         = (w)
+    wply           = (0.3)
+    wd2g           = (0.345)
+    wnwx           = (0.6)
+    wg2pepi        = (1.35)
+    wg2pepi_b      = (2.805)

//calculation of junction instance parameters
+    as_i_eff           = ((lacts_i*w)*nsi_eff)
+    as_e_eff           = ((lacts_e*w)*nse_eff)
+    ps_i_eff           = (2*(lacts_i+w)*nsi_eff)
+    ps_e_eff           = (2*(lacts_e+w)*nse_eff)
+    ad_i_eff           = ((ldr1+ldrift/2)*(w+2*wnwx)*2*ndi_eff)
+    ad_e_eff           = ((ldr1+ldrift/2)*(w+2*wnwx)*nde_eff)
+    pd_i_eff           = ((2*(ldr1+ldrift/2)+w+2*wnwx)*2*ndi_eff)
+    pd_e_eff           = ((2*(ldr1+ldrift/2)+w+2*wnwx)*nde_eff)
+    ad2_i_eff          = ((lactd_i+ldrift)*(w+2*wnwx)*ndi_eff)
+    ad2_e_eff          = ((ldrift/2+lactd_e+lactd2nhv_e)*(w+2*wnwx)*nde_eff)
+    pd2_i_eff          = ((lactd_i+ldrift)*2*ndi_eff)
+    pd2_e_eff          = ((ldrift+lactd_e*2+lactd2nhv_e*2+w+2*wnwx)*nde_eff)

+    sphv_as_eff        = (as_i_eff+as_e_eff)
+    sphv_ps_eff        = (ps_i_eff+ps_e_eff)
+    sphv_ad_eff        = (ad_i_eff+ad_e_eff)
+    sphv_pd_eff        = (pd_i_eff+pd_e_eff)
+    sphv_ad2_eff       = (ad2_i_eff+ad2_e_eff)
+    sphv_pd2_eff       = (pd2_i_eff+pd2_e_eff)
+    as_i               = ((lacts_i*w)*nsi)
+    as_e               = ((lacts_i*w)*nse)
+    ps_i               = (2*(lacts_i+w)*nsi)
+    ps_e               = (2*(lacts_i+w)*nse)
+    ad_i               = ((ldr1+ldrift/2)*(w+2*wnwx)*2*ndi)
+    ad_e               = ((ldr1+ldrift/2)*(w+2*wnwx)*nde)
+    pd_i               = ((2*(ldr1+ldrift/2)+w+2*wnwx)*2*ndi)
+    pd_e               = ((2*(ldr1+ldrift/2)+w+2*wnwx)*nde)
+    ad2_i              = ((lactd_i+ldrift)*(w+2*wnwx)*ndi)
+    ad2_e              = ((lactd_i+ldrift)*(w+2*wnwx)*nde)
+    pd2_i              = ((lactd_i+ldrift)*2*ndi)
+    pd2_e              = ((lactd_i+ldrift)*2*nde)

+    sphv_as            = (as_i+as_e)
+    sphv_ps            = (ps_i+ps_e)
+    sphv_ad            = (ad_i+ad_e)
+    sphv_pd            = (pd_i+pd_e)
+    sphv_ad2           = (ad2_i+ad2_e)
+    sphv_pd2           = (pd2_i+pd2_e)

+    sphv_as_dmy        = 1.0e-18+(sti_dummy >= 2)*(sphv_as_eff-sphv_as)/ng_dmy
+    sphv_ps_dmy        = 1.0e-18+(sti_dummy >= 2)*(sphv_ps_eff-sphv_ps)/ng_dmy
+    sphv_ad_dmy        = 1.0e-18+(sti_dummy >= 2)*(sphv_ad_eff-sphv_ad)/ng_dmy
+    sphv_pd_dmy        = 1.0e-18+(sti_dummy >= 2)*(sphv_pd_eff-sphv_pd)/ng_dmy
+    sphv_ad2_dmy       = 1.0e-18+(sti_dummy >= 2)*(sphv_ad2_eff-sphv_ad2)/ng_dmy
+    sphv_pd2_dmy       = 1.0e-18+(sti_dummy >= 2)*(sphv_pd2_eff-sphv_pd2)/ng_dmy

+    sphv_as_main       = (sti_dummy == 0)*sphv_as_eff/ngeff+(1-(sti_dummy == 0))*sphv_as/ng
+    sphv_ps_main       = (sti_dummy == 0)*sphv_ps_eff/ngeff+(1-(sti_dummy == 0))*sphv_ps/ng
+    sphv_ad_main       = (sti_dummy == 0)*sphv_ad_eff/ngeff+(1-(sti_dummy == 0))*sphv_ad/ng
+    sphv_pd_main       = (sti_dummy == 0)*sphv_pd_eff/ngeff+(1-(sti_dummy == 0))*sphv_pd/ng
+    sphv_ad2_main      = (sti_dummy == 0)*sphv_ad2_eff/ngeff+(1-(sti_dummy == 0))*sphv_ad2/ng
+    sphv_pd2_main      = (sti_dummy == 0)*sphv_pd2_eff/ngeff+(1-(sti_dummy == 0))*sphv_pd2/ng

+    sphv_as_mainfet    = ((as/ng)+(as==0)*sphv_as_main)
+    sphv_ps_mainfet    = ((ps/ng)+(ps==0)*sphv_ps_main)
+    sphv_ad_mainfet    = ((ad/2.0/ng)+(ad==0)*sphv_ad_main)
+    sphv_pd_mainfet    = ((pd/2.0/ng)+(pd==0)*sphv_pd_main)
+    sphv_ad2_mainfet   = ((ad/2.0/ng)+(ad==0)*sphv_ad2_main)
+    sphv_pd2_mainfet   = ((pd/2.0/ng)+(pd==0)*sphv_pd2_main)

// parameters for cap between b and sub
+    liso_left          = (lg2pepi_s_b)
+    liso_mid           = (lply*ngeff+(lp2p_d-2*ldr1-2*lply2)*ndi_eff+lacts_i*nsi_eff)
+    liso_right         = (lg2pepi_s*(nse_eff-1)+lg2pepi_d*nde_eff)
+    liso               = (liso_left+liso_mid+liso_right)
+    wiso               = (wg2pepi*2+w)
+    aiso               = (liso*wiso)
+    piso               = (2*(liso+wiso))

//calculation of parasitic cap
+    djunc              = (2.5e-6)
//thermal VS calculation
+    tfact_ecrit        = (1+(tc1_ecrit_pmos10_sphv_10hv+tc2_ecrit_pmos10_sphv_10hv*(temp-tnom))*(temp-tnom))




//**parameters for multi ng based on median
+ fac_r_ng_rshldd       = (1+(ngeff/(ngeff+0.3)-1/(1+0.3))*1.5*(w/(w+0.7)))
+ fac_a_ng_vfbl         = ((ngeff/(ngeff+0.3)-1/(1+0.3))*-0.045)*(w/(w+0.005))
+ fac_a_ng_fbet1        = ((1/(ngeff+0.1)-1/(1+0.1))*-4*(1+0.15/w))

//**thermal res/cap calculation
+    w_heat             = w
+    l_heat             = (lply*ng+(lp2p_d-2*ldr1-2*lply2)*ndi+lacts_i*nsi+(ldrift-lply2)*nde)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f              = ((mode_rthcth==0)*1e12+((mode_rthcth==1)+(mode_rthcth==2))*rth*fac_rth_pmos10_sphv_10hv)*ngeff
+    cth_f              = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

//calculation of parasitic cap of poly gate to fld(overlap) (fringe cap is small, no added).

+    pply_fld_cgb       = ((wd2g+wply)*2+l*2*ng+(wd2g*2+lacts_i+lacts_i)*2*nsi+(nse==2)*(wd2g+wply)*2+lp2p_d*2*ndi+(ldr1+lply2)*2*nde)
+    aply_fld_cgb       = (((wd2g+wply)*l*2)*ng+wply*lacts_i*2*nsi+(wd2g+wply-wnwx)*lp2p_d*2*ndi+(wd2g+wply-wnwx)*(ldr1+lply2)*2*nde)
+    cgb_ply_fld        = ((cfr_ply_fld*pply_fld_cgb)+(cpp_ply_fld*aply_fld_cgb))

+    pply_fld_cgd       = (((lactd_i+2.0*(ldrift-lply2))+wd2g*2+w*1)*2*ndi+(wnwx*2+w)*nde)
+    aply_fld_cgd       = ((wnwx*lp2p_d-wd2g*(lactd_i+2*(ldrift-lply2)))*2+w*lply2*2)*ndi+(wnwx*(ldr1+lply2)*2+w*lply2)*nde
+    cgd_ply_fld        = ((cfr_ply_fld*pply_fld_cgd)+(cpp_ply_fld*aply_fld_cgd))

//calculate dummy mosfet ply2fld parasitic cap. valid only for sti_dummy=even number, otherwise left dummy is not equal to right dummy
+    ng_dmy1side                  = (sti_dummy)
+    nde_dmy1side                 = (fmod(ng_dmy1side,2))
+    nse_dmy1side                 = (0.0+(sti_dummy>=2)*(2-nde_dmy1side))
+    nd_dmy1side                  = ((ng_dmy1side+nde_dmy1side)/2)
+    ns_dmy1side                  = (1-nde_dmy1side+nd_dmy1side)
+    ndi_dmy1side                 = (nd_dmy1side-nde_dmy1side)
+    nsi_dmy1side                 = (ns_dmy1side-nse_dmy1side)

+    pply_fld_cgb_dmy1side        = ((wd2g+wply)*2+l*2*ng_dmy1side+(wd2g*2+lacts_i+lacts_i)*2*nsi_dmy1side+(nse_dmy1side==2)*(wd2g+wply)*2+lp2p_d*2*ndi_dmy1side+(ldr1+lply2)*2*nde_dmy1side)
+    aply_fld_cgb_dmy1side        = (((wd2g+wply)*l*2)*ng_dmy1side+wply*lacts_i*2*nsi_dmy1side+(wd2g+wply-wnwx)*lp2p_d*2*ndi_dmy1side+(wd2g+wply-wnwx)*(ldr1+lply2)*2*nde_dmy1side)
+    cgb_ply_fld_dmy              = (1.0e-18+(sti_dummy>=2)*((cfr_ply_fld*pply_fld_cgb_dmy1side)*2.0+(cpp_ply_fld*aply_fld_cgb_dmy1side)*2.0))

+    pply_fld_cgd_dmy1side        = (((lactd_i+2.0*(ldrift-lply2))+wd2g*2+w*1)*2*ndi_dmy1side+(wnwx*2+w)*nde_dmy1side)
+    aply_fld_cgd_dmy1side        = ((wnwx*lp2p_d-wd2g*(lactd_i+2*(ldrift-lply2)))*2+w*lply2*2)*ndi_dmy1side+(wnwx*(ldr1+lply2)*2+w*lply2)*nde_dmy1side
+    cgd_ply_fld_dmy              = (1.0e-18+(sti_dummy>=2)*((cfr_ply_fld*pply_fld_cgd_dmy1side)*2.0+(cpp_ply_fld*aply_fld_cgd_dmy1side)*2.0))

// parameters for process variations
+ delr_tox_pmos10_sphv_10hv       = (nom_delr_tox_pmos10_sphv_10hv*(1+sig_delr_tox_pmos10_sphv_10hv*nsig_delr_mosfet_thick_tox+nsmm_delr_gox_pmos10_sphv_10hv*smm_delr_gox_pmos10_sphv_10hv(l,w,ng)))
//+ delr_tox_pmos10_sphv_10hv       = (nom_delr_tox_pmos10_sphv_10hv*(1+sig_delr_tox_pmos10_sphv_10hv*nsig_delr_tox_pmos10_sphv_10hv+nsmm_delr_gox_pmos10_sphv_10hv*smm_delr_gox_pmos10_sphv_10hv(l,w,ng)))
+ delr_uch_pmos10_sphv_10hv       = (nom_delr_uch_pmos10_sphv_10hv*(1+sig_delr_uch_pmos10_sphv_10hv*nsig_delr_uch_pmos10_sphv_10hv+nsmm_delr_uch_pmos10_sphv_10hv*smm_delr_uch_pmos10_sphv_10hv(l,w,ng)))
+ delr_res_pmos10_sphv_10hv       = (nom_delr_res_pmos10_sphv_10hv*(1+sig_delr_res_pmos10_sphv_10hv*nsig_delr_res_pmos10_sphv_10hv+nsmm_delr_res_pmos10_sphv_10hv*smm_delr_res_pmos10_sphv_10hv(l,w,ng)))
+ dela_dw_pmos10_sphv_10hv        = (nom_dela_dw_pmos10_sphv_10hv+(sig_dela_dw_pmos10_sphv_10hv*nsig_dela_dw_pmos10_sphv_10hv)+(nsmm_dela_dw_pmos10_sphv_10hv*smm_dela_dw_pmos10_sphv_10hv(l,w,ng)))
+ dela_dl_pmos10_sphv_10hv        = (nom_dela_dl_pmos10_sphv_10hv+(sig_dela_dl_pmos10_sphv_10hv*nsig_dela_dl_pmos10_sphv_10hv)+(nsmm_dela_dl_pmos10_sphv_10hv*smm_dela_dl_pmos10_sphv_10hv(l,w,ng)))
+ dela_dlw_pmos10_sphv_10hv       = (nom_dela_dlw_pmos10_sphv_10hv+(sig_dela_dlw_pmos10_sphv_10hv*nsig_dela_dlw_pmos10_sphv_10hv))
+ dela_vfb_pmos10_sphv_10hv       = (nom_dela_vfb_pmos10_sphv_10hv+(sig_dela_vfb_pmos10_sphv_10hv*nsig_dela_vfb_pmos10_sphv_10hv)+nsmm_dela_vfb_pmos10_sphv_10hv*smm_dela_vfb_pmos10_sphv_10hv(l,w,ng))
+ dela_vtw_pmos10_sphv_10hv       = (nom_dela_vtw_pmos10_sphv_10hv+(sig_dela_vtw_pmos10_sphv_10hv*nsig_dela_vtw_pmos10_sphv_10hv)+nsmm_dela_vtw_pmos10_sphv_10hv*smm_dela_vtw_pmos10_sphv_10hv(l,w,ng))
+ dela_vtl_pmos10_sphv_10hv       = (nom_dela_vtl_pmos10_sphv_10hv+(sig_dela_vtl_pmos10_sphv_10hv*nsig_dela_vtl_pmos10_sphv_10hv)+nsmm_dela_vtl_pmos10_sphv_10hv*smm_dela_vtl_pmos10_sphv_10hv(l,w,ng))
+ dela_vtlw_pmos10_sphv_10hv      = (nom_dela_vtlw_pmos10_sphv_10hv+(sig_dela_vtlw_pmos10_sphv_10hv*nsig_dela_vtlw_pmos10_sphv_10hv))
+ dela_thesato_pmos10_sphv_10hv   = (nom_dela_thesato_pmos10_sphv_10hv+(sig_dela_thesato_pmos10_sphv_10hv*nsig_dela_thesato_pmos10_sphv_10hv))
+ dela_thesatw_pmos10_sphv_10hv   = (nom_dela_thesatw_pmos10_sphv_10hv+(sig_dela_thesatw_pmos10_sphv_10hv*nsig_dela_thesatw_pmos10_sphv_10hv))
+ dela_thesatl_pmos10_sphv_10hv   = (nom_dela_thesatl_pmos10_sphv_10hv+(sig_dela_thesatl_pmos10_sphv_10hv*nsig_dela_thesatl_pmos10_sphv_10hv))
+ dela_thesatlw_pmos10_sphv_10hv  = (nom_dela_thesatlw_pmos10_sphv_10hv+(sig_dela_thesatlw_pmos10_sphv_10hv*nsig_dela_thesatlw_pmos10_sphv_10hv))
+ delr_cj_pmos10_sphv_10hv        = (nom_delr_cj_pmos10_sphv_10hv*(1+sig_delr_cj_pmos10_sphv_10hv*nsig_delr_cj_pmos10_sphv_10hv))
+ delr_is_pmos10_sphv_10hv        = (nom_delr_is_pmos10_sphv_10hv*exp(sig_delr_is_pmos10_sphv_10hv*nsig_delr_is_pmos10_sphv_10hv))
+ delr_is2_pmos10_sphv_10hv       = (nom_delr_is2_pmos10_sphv_10hv*exp(sig_delr_is2_pmos10_sphv_10hv*nsig_delr_is2_pmos10_sphv_10hv))
+ delr_ir_pmos10_sphv_10hv        = (nom_delr_ir_pmos10_sphv_10hv*exp(sig_delr_ir_pmos10_sphv_10hv*nsig_delr_ir_pmos10_sphv_10hv))
+ dela_vdscaleo_pmos10_sphv_10hv  = (nom_dela_vdscaleo_pmos10_sphv_10hv+(sig_dela_vdscaleo_pmos10_sphv_10hv*nsig_dela_vdscaleo_pmos10_sphv_10hv))
+ dela_vdscalel_pmos10_sphv_10hv  = (nom_dela_vdscalel_pmos10_sphv_10hv+(sig_dela_vdscalel_pmos10_sphv_10hv*nsig_dela_vdscalel_pmos10_sphv_10hv))


+    epsox                        = (3.9*8.85e-12)
+    tox                          = (1.316e-08*delr_tox_pmos10_sphv_10hv)
+    cox                          = (epsox/tox)
+    tn                           = (27.0)
+    tkr                          = (tn+273.15)
+    tkd                          = (temp+273.15)

//parameters for relimo
+    dela_vth_relimo              = (0)
+    dela_vth_relimo_mod          = (0)
+    delr_u0_relimo               = (1)
+    delr_rdsw_relimo             = (1)
+    delr_a0_relimo               = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos10_vthratio = 1.0
+    presto_pmos10_betaratio = 1.0
+    relimo_ratio1_a_hci_pmos10_10hv = (0.37819571)
+    relimo_ratio1_b_hci_pmos10_10hv = (-0.890202586)


+    tfact_tt                     = ((temp+273.15)/(tnom+273.15))**1.0

xcdgoptub_sub (b sub)      cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
cgb_plyfld    (g b)        capacitor c=(cgb_ply_fld*0.6+1.0e-18)
cgd_plyfld    (g d)        capacitor c=(cgd_ply_fld+1.0e-18)
cgd_extra     (g d)        capacitor c=(w*l*ng)*0.3e-17

mamost (d g s b dtemp) sphva_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=sphv_ad_mainfet pd=sphv_pd_mainfet as=sphv_as_mainfet ps=sphv_ps_mainfet ad2=sphv_ad2_mainfet pd2=sphv_pd2_mainfet

model sphva_simkit sphvt
+ type           = (p)  stvdscale=0 ctgo=0 ctbo=0 stcto=1.0
+ vdscale        = (vdscale_pmos10_sphv_10hv*(1.0+(vdscaleo_pmos10_sphv_10hv+dela_vdscaleo_pmos10_sphv_10hv)+(vdscalel_pmos10_sphv_10hv+dela_vdscalel_pmos10_sphv_10hv)/l))
+ vdscaleb       = (vdscalebo_pmos10_sphv_10hv*(1.0+vdscalebl_pmos10_sphv_10hv/l))
+ tr             = (27)
+ swdrlin        = (0)
+ swgeo          = (1)
+ swigate        = (0)
+ swimpact       = (1)
+ swgidl         = (1)
+ swjunc         = (2)
+ swjunasym      = (1)
+ swshe          = (selfheat*enable_selfheat)
+ swtcec         = (1)
+ swimpdr        = (0)
+ swexp          = (0)
+ swdelvtac      = (1)
+ swnud          = (0)
+ swptest        = (0)
+ swgedi         = (1)
+ xvsat          = xvsat_pmos10_sphv_10hv
+ qmc            = qmc_pmos10_sphv_10hv
+ lvaro          = lvaro_pmos10_sphv_10hv+dela_dl_pmos10_sphv_10hv
+ lvarl          = lvarl_pmos10_sphv_10hv
+ lvarw          = lvarw_pmos10_sphv_10hv+dela_dlw_pmos10_sphv_10hv
+ lap            = lap_pmos10_sphv_10hv
+ wvaro          = (wvaro_pmos10_sphv_10hv+dela_dw_pmos10_sphv_10hv)
+ wvarl          = (wvarl_pmos10_sphv_10hv)
+ wvarw          = (wvarw_pmos10_sphv_10hv)
+ wot            = wot_pmos10_sphv_10hv
+ dlq            = dlq_pmos10_sphv_10hv
+ dwq            = dwq_pmos10_sphv_10hv/(1+0.20/l/w)
+ vfbo           = (vfbo_pmos10_sphv_10hv+dela_vfb_pmos10_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos10_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos10_10hv-relimo_ratio1_b_hci_pmos10_10hv))
+ vfbl           = vfbl_pmos10_sphv_10hv+dela_vtl_pmos10_sphv_10hv+fac_a_ng_vfbl
+ vfbw           = (vfbw_pmos10_sphv_10hv+dela_vtw_pmos10_sphv_10hv)
+ vfblw          = (vfblw_pmos10_sphv_10hv+dela_vtlw_pmos10_sphv_10hv)
+ stvfbo         = stvfbo_pmos10_sphv_10hv
+ stvfbl         = stvfbl_pmos10_sphv_10hv
+ stvfbw         = stvfbw_pmos10_sphv_10hv
+ stvfblw        = stvfblw_pmos10_sphv_10hv
+ toxo           = toxo_pmos10_sphv_10hv*delr_tox_pmos10_sphv_10hv
+ epsroxo        = epsroxo_pmos10_sphv_10hv
+ nsubo          = nsubo_pmos10_sphv_10hv
+ nsubw          = nsubw_pmos10_sphv_10hv
+ wseg           = wseg_pmos10_sphv_10hv
+ npck           = npck_pmos10_sphv_10hv
+ npckw          = npckw_pmos10_sphv_10hv
+ wsegp          = wsegp_pmos10_sphv_10hv
+ lpck           = lpck_pmos10_sphv_10hv
+ lpckw          = lpckw_pmos10_sphv_10hv
+ fol1           = fol1_pmos10_sphv_10hv
+ fol2           = fol2_pmos10_sphv_10hv
+ facneffaco     = facneffaco_pmos10_sphv_10hv
+ facneffacl     = facneffacl_pmos10_sphv_10hv
+ facneffacw     = facneffacw_pmos10_sphv_10hv
+ facneffaclw    = facneffaclw_pmos10_sphv_10hv
+ gfacnudo       = gfacnudo_pmos10_sphv_10hv
+ gfacnudl       = gfacnudl_pmos10_sphv_10hv
+ gfacnudlexp    = gfacnudlexp_pmos10_sphv_10hv
+ gfacnudw       = gfacnudw_pmos10_sphv_10hv
+ gfacnudlw      = gfacnudlw_pmos10_sphv_10hv
+ vsbnudo        = vsbnudo_pmos10_sphv_10hv
+ dvsbnudo       = dvsbnudo_pmos10_sphv_10hv
+ vnsubo         = vnsubo_pmos10_sphv_10hv
+ nslpo          = nslpo_pmos10_sphv_10hv
+ dnsubo         = dnsubo_pmos10_sphv_10hv
+ dphibo         = dphibo_pmos10_sphv_10hv
+ dphibl         = dphibl_pmos10_sphv_10hv
+ dphiblexp      = dphiblexp_pmos10_sphv_10hv
+ dphibw         = (dphibw_pmos10_sphv_10hv)
+ dphiblw        = (dphiblw_pmos10_sphv_10hv)
+ delvtaco       = delvtaco_pmos10_sphv_10hv
+ delvtacl       = delvtacl_pmos10_sphv_10hv
+ delvtaclexp    = delvtaclexp_pmos10_sphv_10hv
+ delvtacw       = delvtacw_pmos10_sphv_10hv
+ delvtaclw      = delvtaclw_pmos10_sphv_10hv
+ npo            = npo_pmos10_sphv_10hv
+ npl            = npl_pmos10_sphv_10hv
+ cto            = cto_pmos10_sphv_10hv
+ ctl            = ctl_pmos10_sphv_10hv
+ ctlexp         = ctlexp_pmos10_sphv_10hv
+ ctw            = ctw_pmos10_sphv_10hv
+ ctlw           = ctlw_pmos10_sphv_10hv
+ toxovo         = toxovo_pmos10_sphv_10hv*delr_tox_pmos10_sphv_10hv
+ toxovdo        = toxovdo_pmos10_sphv_10hv*delr_tox_pmos10_sphv_10hv
+ lov            = lov_pmos10_sphv_10hv
+ dlovd          = dlovd_pmos10_sphv_10hv
+ novo           = novo_pmos10_sphv_10hv
+ novdo          = novdo_pmos10_sphv_10hv
+ cfl            = cfl_pmos10_sphv_10hv
+ cflexp         = cflexp_pmos10_sphv_10hv
+ cfw            = cfw_pmos10_sphv_10hv
+ cfbo           = cfbo_pmos10_sphv_10hv
+ uo             = (uo_pmos10_sphv_10hv*delr_uch_pmos10_sphv_10hv*delr_u0_relimo)
+ fbet1          = fbet1_pmos10_sphv_10hv+fac_a_ng_fbet1
+ fbet1w         = fbet1w_pmos10_sphv_10hv
+ lp1            = lp1_pmos10_sphv_10hv
+ lp1w           = lp1w_pmos10_sphv_10hv
+ fbet2          = fbet2_pmos10_sphv_10hv
+ lp2            = lp2_pmos10_sphv_10hv
+ betw1          = betw1_pmos10_sphv_10hv
+ betw2          = betw2_pmos10_sphv_10hv
+ wbet           = wbet_pmos10_sphv_10hv
+ stbeto         = stbeto_pmos10_sphv_10hv
+ stbetl         = stbetl_pmos10_sphv_10hv
+ stbetw         = stbetw_pmos10_sphv_10hv
+ stbetlw        = stbetlw_pmos10_sphv_10hv
+ mueo           = mueo_pmos10_sphv_10hv
+ muew           = muew_pmos10_sphv_10hv
+ stmueo         = stmueo_pmos10_sphv_10hv
+ themuo         = themuo_pmos10_sphv_10hv
+ stthemuo       = stthemuo_pmos10_sphv_10hv
+ cso            = cso_pmos10_sphv_10hv
+ csl            = csl_pmos10_sphv_10hv
+ cslexp         = cslexp_pmos10_sphv_10hv
+ csw            = csw_pmos10_sphv_10hv
+ cslw           = cslw_pmos10_sphv_10hv
+ stcso          = stcso_pmos10_sphv_10hv
+ xcoro          = xcoro_pmos10_sphv_10hv
+ xcorl          = xcorl_pmos10_sphv_10hv
+ xcorw          = xcorw_pmos10_sphv_10hv
+ xcorlw         = xcorlw_pmos10_sphv_10hv
+ stxcoro        = stxcoro_pmos10_sphv_10hv
+ fetao          = fetao_pmos10_sphv_10hv
+ rsw1           = rsw1_pmos10_sphv_10hv
+ rsw2           = rsw2_pmos10_sphv_10hv
+ strso          = strso_pmos10_sphv_10hv
+ rsbo           = rsbo_pmos10_sphv_10hv
+ rsgo           = rsgo_pmos10_sphv_10hv
+ thesato        = (thesato_pmos10_sphv_10hv+dela_thesato_pmos10_sphv_10hv)
+ thesatl        = (thesatl_pmos10_sphv_10hv+dela_thesatl_pmos10_sphv_10hv)
+ thesatlexp     = thesatlexp_pmos10_sphv_10hv
+ thesatw        = (thesatw_pmos10_sphv_10hv+dela_thesatw_pmos10_sphv_10hv)
+ thesatlw       = thesatlw_pmos10_sphv_10hv+dela_thesatlw_pmos10_sphv_10hv
+ stthesato      = stthesato_pmos10_sphv_10hv
+ stthesatl      = stthesatl_pmos10_sphv_10hv
+ stthesatw      = stthesatw_pmos10_sphv_10hv
+ stthesatlw     = stthesatlw_pmos10_sphv_10hv
+ thesatbo       = thesatbo_pmos10_sphv_10hv
+ thesatgo       = thesatgo_pmos10_sphv_10hv
+ thesatgl       = thesatgl_pmos10_sphv_10hv
+ thesatgw       = thesatgw_pmos10_sphv_10hv
+ axo            = axo_pmos10_sphv_10hv
+ axl            = axl_pmos10_sphv_10hv
+ alpl           = alpl_pmos10_sphv_10hv
+ alplexp        = alplexp_pmos10_sphv_10hv
+ alpw           = alpw_pmos10_sphv_10hv
+ alp1l1         = alp1l1_pmos10_sphv_10hv
+ alp1lexp       = alp1lexp_pmos10_sphv_10hv
+ alp1l2         = alp1l2_pmos10_sphv_10hv
+ alp1w          = alp1w_pmos10_sphv_10hv
+ alp2l1         = alp2l1_pmos10_sphv_10hv
+ alp2lexp       = alp2lexp_pmos10_sphv_10hv
+ alp2l2         = alp2l2_pmos10_sphv_10hv
+ alp2w          = alp2w_pmos10_sphv_10hv
+ vpo            = vpo_pmos10_sphv_10hv
+ a1o            = a1o_pmos10_sphv_10hv
+ a1l            = a1l_pmos10_sphv_10hv
+ a1w            = a1w_pmos10_sphv_10hv
+ a2o            = a2o_pmos10_sphv_10hv
+ sta2o          = sta2o_pmos10_sphv_10hv
+ a3o            = a3o_pmos10_sphv_10hv
+ a3l            = a3l_pmos10_sphv_10hv
+ a3w            = a3w_pmos10_sphv_10hv
+ a4o            = a4o_pmos10_sphv_10hv
+ a4l            = a4l_pmos10_sphv_10hv
+ a4w            = a4w_pmos10_sphv_10hv
+ gcoo           = gcoo_pmos10_sphv_10hv
+ iginvlw        = iginvlw_pmos10_sphv_10hv
+ igovw          = igovw_pmos10_sphv_10hv
+ igovdw         = igovdw_pmos10_sphv_10hv
+ stigo          = stigo_pmos10_sphv_10hv
+ gc2o           = gc2o_pmos10_sphv_10hv
+ gc3o           = gc3o_pmos10_sphv_10hv
+ chibo          = chibo_pmos10_sphv_10hv
+ agidlw         = agidlw_pmos10_sphv_10hv
+ agidldw        = agidldw_pmos10_sphv_10hv
+ bgidlo         = bgidlo_pmos10_sphv_10hv
+ bgidldo        = bgidldo_pmos10_sphv_10hv
+ stbgidlo       = stbgidlo_pmos10_sphv_10hv
+ stbgidldo      = stbgidldo_pmos10_sphv_10hv
+ cgidlo         = cgidlo_pmos10_sphv_10hv
+ cgidldo        = cgidldo_pmos10_sphv_10hv
+ cgbovl         = cgbovl_pmos10_sphv_10hv
+ cfrw           = cfrw_pmos10_sphv_10hv
+ cfrdw          = cfrdw_pmos10_sphv_10hv
+ fnto           = fnto_pmos10_sphv_10hv
+ nfalw          = nfalw_pmos10_sphv_10hv
+ nfblw          = nfblw_pmos10_sphv_10hv
+ nfclw          = nfclw_pmos10_sphv_10hv
+ efo            = efo_pmos10_sphv_10hv
+ lintnoi        = lintnoi_pmos10_sphv_10hv
+ alpnoi         = alpnoi_pmos10_sphv_10hv
+ kvthoweo       = kvthoweo_pmos10_sphv_10hv
+ kvthowel       = kvthowel_pmos10_sphv_10hv
+ kvthowew       = kvthowew_pmos10_sphv_10hv
+ kvthowelw      = kvthowelw_pmos10_sphv_10hv
+ kuoweo         = kuoweo_pmos10_sphv_10hv
+ kuowel         = kuowel_pmos10_sphv_10hv
+ kuowew         = kuowew_pmos10_sphv_10hv
+ kuowelw        = kuowelw_pmos10_sphv_10hv
+ rgo            = rgo_pmos10_sphv_10hv
+ rsh            = rsh_pmos10_sphv_10hv
+ rbulko         = rbulko_pmos10_sphv_10hv
+ rwello         = (rwello_pmos10_sphv_10hv)
+ rjunso         = rjunso_pmos10_sphv_10hv/(w+dwrjunso_pmos10_sphv_10hv)/(1.0+0.75/l)*(1.0+1.0/w/l)*(tfact_tt)**0.5
+ rjundo         = rjundo_pmos10_sphv_10hv/(w+dwrjundo_pmos10_sphv_10hv)/(1.0+20.0/(l+3.0))*(1.0+0.12/w/l)*(tfact_tt)**0.3
+ rint           = rint_pmos10_sphv_10hv
+ rvpoly         = rvpoly_pmos10_sphv_10hv
+ rshg           = rshg_pmos10_sphv_10hv
+ dlsil          = dlsil_pmos10_sphv_10hv
+ saref          = saref_pmos10_sphv_10hv
+ sbref          = sbref_pmos10_sphv_10hv
+ wlod           = wlod_pmos10_sphv_10hv
+ kuo            = kuo_pmos10_sphv_10hv
+ kvsat          = kvsat_pmos10_sphv_10hv
+ tkuo           = tkuo_pmos10_sphv_10hv
+ lkuo           = lkuo_pmos10_sphv_10hv
+ wkuo           = wkuo_pmos10_sphv_10hv
+ pkuo           = pkuo_pmos10_sphv_10hv
+ llodkuo        = llodkuo_pmos10_sphv_10hv
+ wlodkuo        = wlodkuo_pmos10_sphv_10hv
+ kvtho          = kvtho_pmos10_sphv_10hv
+ lkvtho         = lkvtho_pmos10_sphv_10hv
+ wkvtho         = wkvtho_pmos10_sphv_10hv
+ pkvtho         = pkvtho_pmos10_sphv_10hv
+ llodvth        = llodvth_pmos10_sphv_10hv
+ wlodvth        = wlodvth_pmos10_sphv_10hv
+ stetao         = stetao_pmos10_sphv_10hv
+ lodetao        = lodetao_pmos10_sphv_10hv
+ scref          = scref_pmos10_sphv_10hv
+ web            = web_pmos10_sphv_10hv
+ wec            = wec_pmos10_sphv_10hv
+ adr1o          = adr1o_pmos10_sphv_10hv
+ adr1l          = adr1l_pmos10_sphv_10hv
+ adr1w          = adr1w_pmos10_sphv_10hv
+ adr2o          = adr2o_pmos10_sphv_10hv
+ stadr2o        = stadr2o_pmos10_sphv_10hv
+ adr3o          = adr3o_pmos10_sphv_10hv
+ adr3l          = adr3l_pmos10_sphv_10hv
+ adr3w          = adr3w_pmos10_sphv_10hv
+ adr4o          = adr4o_pmos10_sphv_10hv
+ adr4l          = adr4l_pmos10_sphv_10hv
+ adr4w          = adr4w_pmos10_sphv_10hv
+ adr5o          = adr5o_pmos10_sphv_10hv
+ adr5l          = adr5l_pmos10_sphv_10hv
+ adr5w          = adr5w_pmos10_sphv_10hv
+ bidr1o         = bidr1o_pmos10_sphv_10hv
+ bidr1l         = bidr1l_pmos10_sphv_10hv
+ bidr1w         = bidr1w_pmos10_sphv_10hv
+ bidr2o         = bidr2o_pmos10_sphv_10hv
+ bidr2w         = bidr2w_pmos10_sphv_10hv
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw          = 0
+ strtho         = strtho_pmos10_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw          = 0
+ rshldd         = (rshldd_pmos10_sphv_10hv*fac_r_ng_rshldd*delr_res_pmos10_sphv_10hv*delr_rdsw_relimo)
+ xw             = (xw_pmos10_sphv_10hv)
+ nwxw           = (nwxw_pmos10_sphv_10hv)
+ xl             = xl_pmos10_sphv_10hv
+ xlw            = xlw_pmos10_sphv_10hv
+ dxlsat         = dxlsat_pmos10_sphv_10hv
+ nst            = nst_pmos10_sphv_10hv
+ ats            = ats_pmos10_sphv_10hv
+ dfinf          = dfinf_pmos10_sphv_10hv
+ dfw            = dfw_pmos10_sphv_10hv
+ dfl            = dfl_pmos10_sphv_10hv
+ dflw           = dflw_pmos10_sphv_10hv
+ dp             = dp_pmos10_sphv_10hv
+ ecrit          = ecrit_pmos10_sphv_10hv*tfact_ecrit*(1+dwecrit_pmos10_sphv_10hv/w+dwecritw_pmos10_sphv_10hv/(w*w))
+ ecorn          = ecorn_pmos10_sphv_10hv*tfact_ecrit*(1+dwecrit_pmos10_sphv_10hv/w+dwecritw_pmos10_sphv_10hv/(w*w))
+ du             = du_pmos10_sphv_10hv
+ tc1            = tc1_pmos10_sphv_10hv
+ tc2            = tc2_pmos10_sphv_10hv
+ tc1l           = tc1l_pmos10_sphv_10hv
+ tc2l           = tc2l_pmos10_sphv_10hv
+ tc1w           = tc1w_pmos10_sphv_10hv
+ tc2w           = tc2w_pmos10_sphv_10hv
+ theacc         = theacc_pmos10_sphv_10hv
+ theacc2        = theacc2_pmos10_sphv_10hv
+ rva            = rva_pmos10_sphv_10hv
+ dta            = dta_pmos10_sphv_10hv
+ trj            = trj_pmos10_sphv_10hv
+ cjarea         = cjarea_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ cjlsti         = cjlsti_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ cjlgat         = cjlgat_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ vbiarea        = vbiarea_pmos10_sphv_10hv
+ vbisti         = vbisti_pmos10_sphv_10hv
+ vbigat         = vbigat_pmos10_sphv_10hv
+ parea          = parea_pmos10_sphv_10hv
+ psti           = psti_pmos10_sphv_10hv
+ pgat           = pgat_pmos10_sphv_10hv
+ is1area      	 = is1area_pmos10_sphv_10hv*delr_is_pmos10_sphv_10hv
+ ttarea       	 = ttarea_pmos10_sphv_10hv
+ is2area      	 = is2area_pmos10_sphv_10hv*delr_is2_pmos10_sphv_10hv
+ irarea       	 = irarea_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1area    	 = stis1area_pmos10_sphv_10hv
+ stis2area    	 = stis2area_pmos10_sphv_10hv
+ stirarea     	 = stirarea_pmos10_sphv_10hv
+ n1area       	 = n1area_pmos10_sphv_10hv
+ n2area       	 = n2area_pmos10_sphv_10hv
+ nrarea       	 = nrarea_pmos10_sphv_10hv
+ is1lsti      	 = is1lsti_pmos10_sphv_10hv*delr_is_pmos10_sphv_10hv/(1.0+2.0/l/w)
+ ttlsti       	 = ttlsti_pmos10_sphv_10hv
+ is2lsti      	 = is2lsti_pmos10_sphv_10hv*delr_is2_pmos10_sphv_10hv
+ irlsti       	 = irlsti_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1sti     	 = stis1sti_pmos10_sphv_10hv
+ stis2sti     	 = stis2sti_pmos10_sphv_10hv
+ stirsti      	 = stirsti_pmos10_sphv_10hv
+ n1sti        	 = n1sti_pmos10_sphv_10hv
+ n2sti        	 = n2sti_pmos10_sphv_10hv
+ nrsti        	 = nrsti_pmos10_sphv_10hv
+ is1lgat      	 = is1lgat_pmos10_sphv_10hv*delr_is_pmos10_sphv_10hv
+ ttlgat       	 = ttlgat_pmos10_sphv_10hv
+ is2lgat      	 = is2lgat_pmos10_sphv_10hv*delr_is2_pmos10_sphv_10hv
+ irlgat       	 = irlgat_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1gat     	 = stis1gat_pmos10_sphv_10hv
+ stis2gat     	 = stis2gat_pmos10_sphv_10hv
+ stirgat      	 = stirgat_pmos10_sphv_10hv
+ n1gat        	 = n1gat_pmos10_sphv_10hv
+ n2gat        	 = n2gat_pmos10_sphv_10hv
+ nrgat        	 = nrgat_pmos10_sphv_10hv
+ cjaread      	 = cjaread_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ cjlstid      	 = cjlstid_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ cjlgatd      	 = cjlgatd_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ vbiaread     	 = vbiaread_pmos10_sphv_10hv
+ vbistid      	 = vbistid_pmos10_sphv_10hv
+ vbigatd      	 = vbigatd_pmos10_sphv_10hv
+ paread       	 = paread_pmos10_sphv_10hv
+ pstid        	 = pstid_pmos10_sphv_10hv
+ pgatd        	 = pgatd_pmos10_sphv_10hv
+ is1aread     	 = is1aread_pmos10_sphv_10hv*delr_is_pmos10_sphv_10hv
+ ttaread      	 = ttaread_pmos10_sphv_10hv
+ is2aread     	 = is2aread_pmos10_sphv_10hv*delr_is2_pmos10_sphv_10hv
+ iraread      	 = iraread_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1aread   	 = stis1aread_pmos10_sphv_10hv
+ stis2aread   	 = stis2aread_pmos10_sphv_10hv
+ stiraread    	 = stiraread_pmos10_sphv_10hv
+ n1aread      	 = n1aread_pmos10_sphv_10hv
+ n2aread      	 = n2aread_pmos10_sphv_10hv
+ nraread      	 = nraread_pmos10_sphv_10hv
+ is1lstid     	 = is1lstid_pmos10_sphv_10hv*djunc*delr_is_pmos10_sphv_10hv/(1+5/l/w)
+ ttlstid      	 = ttlstid_pmos10_sphv_10hv
+ is2lstid     	 = is2lstid_pmos10_sphv_10hv*djunc*delr_is2_pmos10_sphv_10hv
+ irlstid      	 = irlstid_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1stid    	 = stis1stid_pmos10_sphv_10hv
+ stis2stid    	 = stis2stid_pmos10_sphv_10hv
+ stirstid     	 = stirstid_pmos10_sphv_10hv
+ n1stid       	 = n1stid_pmos10_sphv_10hv
+ n2stid       	 = n2stid_pmos10_sphv_10hv
+ nrstid       	 = nrstid_pmos10_sphv_10hv
+ is1lgatd     	 = is1lgatd_pmos10_sphv_10hv*djunc*delr_is_pmos10_sphv_10hv/(1+5/l/w)
+ ttlgatd      	 = ttlgatd_pmos10_sphv_10hv
+ is2lgatd     	 = is2lgatd_pmos10_sphv_10hv*djunc*delr_is2_pmos10_sphv_10hv
+ irlgatd      	 = irlgatd_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1gatd    	 = stis1gatd_pmos10_sphv_10hv
+ stis2gatd    	 = stis2gatd_pmos10_sphv_10hv
+ stirgatd     	 = stirgatd_pmos10_sphv_10hv
+ n1gatd       	 = n1gatd_pmos10_sphv_10hv
+ n2gatd       	 = n2gatd_pmos10_sphv_10hv
+ nrgatd       	 = nrgatd_pmos10_sphv_10hv
+ cjaread2     	 = cjaread2_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ cjlstid2     	 = cjlstid2_pmos10_sphv_10hv*delr_cj_pmos10_sphv_10hv
+ vbiaread2    	 = vbiaread2_pmos10_sphv_10hv
+ vbistid2     	 = vbistid2_pmos10_sphv_10hv
+ paread2      	 = paread2_pmos10_sphv_10hv
+ pstid2       	 = pstid2_pmos10_sphv_10hv
+ is1aread2    	 = is1aread2_pmos10_sphv_10hv*delr_is_pmos10_sphv_10hv
+ ttaread2     	 = ttaread2_pmos10_sphv_10hv
+ is2aread2    	 = is2aread_pmos10_sphv_10hv*delr_is2_pmos10_sphv_10hv
+ iraread2     	 = iraread2_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1aread2  	 = stis1aread_pmos10_sphv_10hv
+ stis2aread2  	 = stis2aread_pmos10_sphv_10hv
+ stiraread2   	 = stiraread2_pmos10_sphv_10hv
+ n1aread2     	 = n1aread2_pmos10_sphv_10hv
+ n2aread2     	 = n2aread2_pmos10_sphv_10hv
+ nraread2     	 = nraread2_pmos10_sphv_10hv
+ is1lstid2    	 = is1lstid2_pmos10_sphv_10hv*djunc*delr_is_pmos10_sphv_10hv
+ ttlstid2     	 = ttlstid2_pmos10_sphv_10hv
+ is2lstid2    	 = is2lstid_pmos10_sphv_10hv*djunc*delr_is2_pmos10_sphv_10hv
+ irlstid2     	 = irlstid2_pmos10_sphv_10hv*delr_ir_pmos10_sphv_10hv
+ stis1stid2   	 = stis1stid2_pmos10_sphv_10hv
+ stis2stid2   	 = stis2stid2_pmos10_sphv_10hv
+ stirstid2    	 = stirstid2_pmos10_sphv_10hv
+ n1stid2      	 = n1stid2_pmos10_sphv_10hv
+ n2stid2      	 = n2stid2_pmos10_sphv_10hv
+ nrstid2      	 = nrstid2_pmos10_sphv_10hv
+ aacc           = aacc_pmos10_sphv_10hv
+ eais1area      = eais1area_pmos10_sphv_10hv
+ eais2area      = eais2area_pmos10_sphv_10hv
+ eairarea       = eairarea_pmos10_sphv_10hv
+ eais1sti       = eais1sti_pmos10_sphv_10hv
+ eais2sti       = eais2sti_pmos10_sphv_10hv
+ eairsti        = eairsti_pmos10_sphv_10hv
+ eais1gat       = eais1gat_pmos10_sphv_10hv
+ eais2gat       = eais2gat_pmos10_sphv_10hv
+ eairgat        = eairgat_pmos10_sphv_10hv
+ eais1aread     = eais1aread_pmos10_sphv_10hv
+ eais2aread     = eais2aread_pmos10_sphv_10hv
+ eairaread      = eairaread_pmos10_sphv_10hv
+ eais1stid      = eais1stid_pmos10_sphv_10hv
+ eais2stid      = eais2stid_pmos10_sphv_10hv
+ eairstid       = eairstid_pmos10_sphv_10hv
+ eais1gatd      = eais1gatd_pmos10_sphv_10hv
+ eais2gatd      = eais2gatd_pmos10_sphv_10hv
+ eairgatd       = eairgatd_pmos10_sphv_10hv
+ eais1aread2    = eais1aread2_pmos10_sphv_10hv
+ eais2aread2    = eais2aread2_pmos10_sphv_10hv
+ eairaread2     = eairaread2_pmos10_sphv_10hv
+ eais1stid2     = eais1stid2_pmos10_sphv_10hv
+ eais2stid2     = eais2stid2_pmos10_sphv_10hv
+ eairstid2      = eairstid2_pmos10_sphv_10hv
+ ikfarea        = ikfarea_pmos10_sphv_10hv
+ ikflsti        = ikfarea_pmos10_sphv_10hv*djunc
+ ikflgat        = ikfarea_pmos10_sphv_10hv*djunc
+ stikfarea      = stikfarea_pmos10_sphv_10hv
+ stikfsti       = stikfarea_pmos10_sphv_10hv
+ stikfgat       = stikfarea_pmos10_sphv_10hv
+ ikfaread       = ikfaread_pmos10_sphv_10hv*(w/(w+dwikfaread_pmos10_sphv_10hv))
+ ikflstid       = ikfaread_pmos10_sphv_10hv*djunc*(w/(w+dwikfaread_pmos10_sphv_10hv))
+ ikflgatd       = ikfaread_pmos10_sphv_10hv*djunc*(w/(w+dwikfaread_pmos10_sphv_10hv))
+ ikfaread2      = ikfaread_pmos10_sphv_10hv*(w/(w+dwikfaread_pmos10_sphv_10hv))
+ ikflstid2      = ikfaread_pmos10_sphv_10hv*djunc*(w/(w+dwikfaread_pmos10_sphv_10hv))
+ stikfaread     = stikfaread_pmos10_sphv_10hv
+ stikfstid      = stikfaread_pmos10_sphv_10hv
+ stikfgatd      = stikfaread_pmos10_sphv_10hv
+ stikfaread2    = stikfaread_pmos10_sphv_10hv
+ stikfstid2     = stikfaread_pmos10_sphv_10hv



if (ng_dmy >= 2) {

cgb_plyfld_dmy (s b)           capacitor c=(cgb_ply_fld_dmy*0.6+1.0e-18)
cgd_plyfld_dmy (s d)           capacitor c=(cgd_ply_fld_dmy+1.0e-18)

mamost_dmy     (d s s b dtemp) sphva_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=sphv_ad_dmy pd=sphv_pd_dmy as=sphv_as_dmy ps=sphv_ps_dmy ad2=sphv_ad2_dmy pd2=sphv_pd2_dmy

}


include "./smos10hv_ade_dfrt.scs" section=pmos10_10hv_dfrt
ends


//***********************************************************
endsection mosfet
//***********************************************************

//***********************************************************
section process_params
//***********************************************************


real smm_delr_gox_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0.688e-05/(l*w))) ;
}

real smm_delr_nsub_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(3.396e-05/(l*w))) ;
}

real smm_dela_vtl_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(2.358e-07/(w))) ;
}

real smm_dela_dl_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(9.119e-07/(w))) ;
}

real smm_dela_dwox_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_nmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(1.947e-05/(l*w))) ;
}

real smm_delr_nsub_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(4.48e-05/(l*w))) ;
}

real smm_dela_vtl_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_nmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0.6*2.303301e-05/(l*w))) ;
}

real smm_delr_nsub_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(2e-4/(w))) ;
}

real smm_dela_dl_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0.6*3.75e-7/(l))) ;
}

real smm_delr_voff_nmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(16e-03/((l+0.3)*(w+0.42)))) ;
}

real smm_delr_gox_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(5.6e-06/(l*w))) ;
}

real smm_delr_nsub_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(2.253e-05/(l*w))) ;
}

real smm_dela_vtl_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(2.491e-06/(w))) ;
}

real smm_dela_dl_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(4.207e-06/(l*w))) ;
}

real smm_delr_rdsw_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0.00013/(w))) ;
}

real smm_dela_vtw_nmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_tox_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(3.768e-06/(w)) ;
}

real smm_dela_vfb_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(2.878e-06/(w)) ;
}

real smm_delr_nsub_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0/(w)) ;
}

real smm_dela_vtl_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0.000158/(w)) ;
}

real smm_dela_dl_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0/(w)) ;
}

real smm_dela_dwox_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0/(l)) ;
}

real smm_delr_ubref_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(6.105e-06/(w)) ;
}

real smm_delr_rsh_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0.0002708/(w)) ;
}

real smm_dela_vtw_nmos3_zvt_10hv_bsim3v3(real l, real w) {
    return sqrt(0/(l)) ;
}

real smm_delr_gox_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0.62e-04/(l*w))) ;
}

real smm_delr_nsub_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(5.082e-06/(l*w))) ;
}

real smm_dela_vtl_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(2e-5/(w))) ;
}

real smm_dela_dl_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0.069e-06/(l*w))) ;
}

real smm_delr_rsh_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_nmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.244e-06/(l*w))) ;
}

real smm_dela_vfb_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nsub_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(7.807e-05/(l*w))) ;
}

real smm_dela_vtl_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(7.068e-06/(l*w))) ;
}

real smm_delr_rsh_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_nmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(8.881e-05/(l*w))) ;
}

real smm_delr_nsub_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.882e-05/(l*w))) ;
}

real smm_dela_vtl_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.798e-05/(l*w))) ;
}

real smm_delr_rsh_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.001007/(w))) ;
}

real smm_dela_vtw_nmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(8.881e-05/(l*w))) ;
}

real smm_delr_nsub_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.882e-05/(l*w))) ;
}

real smm_dela_vtl_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.798e-05/(l*w))) ;
}

real smm_delr_rsh_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.001007/(w))) ;
}

real smm_dela_vtw_nmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.836e-05/(l*w))) ;
}

real smm_delr_nsub_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.003336/(w))) ;
}

real smm_dela_vtw_nmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.836e-05/(l*w))) ;
}

real smm_delr_nsub_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.003336/(w))) ;
}

real smm_dela_vtw_nmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.161e-05/(l*w))) ;
}

real smm_delr_nsub_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(2.966e-05/(l*w))) ;
}

real smm_dela_vtl_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(3.953e-07/(w))) ;
}

real smm_dela_dl_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.002716/(w))) ;
}

real smm_dela_vtw_nsrampg_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.161e-05/(l*w))) ;
}

real smm_delr_nsub_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(2.966e-05/(l*w))) ;
}

real smm_dela_vtl_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(3.953e-07/(w))) ;
}

real smm_dela_dl_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.002716/(w))) ;
}

real smm_dela_vtw_nsrampd_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(7.084e-06/(l*w))) ;
}

real smm_dela_vfb_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(6.315e-06/(l*w))) ;
}

real smm_delr_nsub_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(1.67e-06/(w))) ;
}

real smm_dela_dwox_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(5.145e-07/(l*w))) ;
}

real smm_delr_rsh_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(0.002166/(w))) ;
}

real smm_dela_vtw_pmos_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(1.13e-05/(l*w))) ;
}

real smm_delr_nsub_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(1.008e-05/(l*w))) ;
}

real smm_delr_rsh_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0.001926/(w))) ;
}

real smm_dela_vtw_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_k1_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0.00008/(l*0.1))) ;
}

real smm_delr_jtss_pmos_ll_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*1e-06))) ;
}

real smm_delr_gox_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(1.8*1.13e-05/(l*w))) ;
}

real smm_delr_nsub_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_k1_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*0.1))) ;
}

real smm_delr_jtss_pmos_ull_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*1e-06))) ;
}

real smm_delr_gox_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0.43e-06/(l*w))) ;
}

real smm_delr_nsub_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(8.99e-06/(l*w))) ;
}

real smm_dela_vtl_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0.0001284/(w))) ;
}

real smm_dela_dwox_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(1.926e-06/(l*w))) ;
}

real smm_delr_rsh_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0.000713/(w))) ;
}

real smm_dela_vtw_pmos_ana_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(3.5e-05/(l*w))) ;
}

real smm_delr_nsub_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(2.268e-06/(l*w))) ;
}

real smm_dela_vtl_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(1.161e-06/(l*w))) ;
}

real smm_delr_rsh_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_vtw_pmos5_10hv_bsim4(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(2.434e-06/(l*w))) ;
}

real smm_dela_vfb_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(2.539e-05/(l*w))) ;
}

real smm_delr_nsub_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.296e-05/(l*w))) ;
}

real smm_delr_rsh_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(8.09e-05/(w))) ;
}

real smm_dela_vtw_pmos10_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(5.66e-05/(l*w))) ;
}

real smm_delr_nsub_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(8.949e-05/(l*w))) ;
}

real smm_delr_rsh_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.004367/(w))) ;
}

real smm_dela_vtw_pmos45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(5.66e-05/(l*w))) ;
}

real smm_delr_nsub_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(8.949e-05/(l*w))) ;
}

real smm_delr_rsh_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.004367/(w))) ;
}

real smm_dela_vtw_pmos45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(5.046e-05/(l*w))) ;
}

real smm_delr_nsub_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.626e-06/(l*w))) ;
}

real smm_dela_vtl_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(3.958e-05/(l*w))) ;
}

real smm_delr_rsh_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.01014/(w))) ;
}

real smm_dela_vtw_pmoshs45_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vfb_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(5.046e-05/(l*w))) ;
}

real smm_delr_nsub_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.626e-06/(l*w))) ;
}

real smm_dela_vtl_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(3.958e-05/(l*w))) ;
}

real smm_delr_rsh_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.01014/(w))) ;
}

real smm_dela_vtw_pmoshs45b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.336e-05/(l*w))) ;
}

real smm_dela_vfb_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.0001097/(l*w))) ;
}

real smm_delr_nsub_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.008184/(w))) ;
}

real smm_dela_vtw_pmos90_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.336e-05/(l*w))) ;
}

real smm_dela_vfb_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.0001097/(l*w))) ;
}

real smm_delr_nsub_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dwox_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_rsh_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.008184/(w))) ;
}

real smm_dela_vtw_pmos90b_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(7.084e-06/(l*w))) ;
}

real smm_dela_vfb_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(6.315e-06/(l*w))) ;
}

real smm_delr_nsub_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_vtl_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_dl_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(1.67e-06/(w))) ;
}

real smm_dela_dwox_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_ubref_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(5.145e-07/(l*w))) ;
}

real smm_delr_rsh_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(0.002166/(w))) ;
}

real smm_dela_vtw_psrampu_10hv_bsim3v3(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld65_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld65_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld65_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld65_10hv_vtl(real l, real w) {
    return (sqrt(0.0001534/(w))) ;
}

real smm_dela_nld65_10hv_dwox(real l, real w) {
    return (sqrt(3.053e-06/(l))) ;
}

real smm_delr_nld65_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld65_10hv_rsh(real l, real w) {
    return (sqrt(4.202e-05/(w))) ;
}

real smm_dela_nld65_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld65b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld65b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld65b_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld65b_10hv_vtl(real l, real w) {
    return (sqrt(0.0001534/(w))) ;
}

real smm_dela_nld65b_10hv_dwox(real l, real w) {
    return (sqrt(3.053e-06/(l))) ;
}

real smm_delr_nld65b_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld65b_10hv_rsh(real l, real w) {
    return (sqrt(4.202e-05/(w))) ;
}

real smm_dela_nld65b_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld90_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld90_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld90_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld90_10hv_vtl(real l, real w) {
    return (sqrt(0.0001912/(w))) ;
}

real smm_delr_nld90_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld90_10hv_rsh(real l, real w) {
    return (sqrt(1.913e-05/(w))) ;
}

real smm_dela_nld90_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld90b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld90b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld90b_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld90b_10hv_vtl(real l, real w) {
    return (sqrt(0.0001912/(w))) ;
}

real smm_delr_nld90b_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld90b_10hv_rsh(real l, real w) {
    return (sqrt(1.913e-05/(w))) ;
}

real smm_dela_nld90b_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld30_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld30_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld30_10hv_nsub(real l, real w) {
    return (sqrt(0.0005018/(l*w))) ;
}

real smm_dela_nld30_10hv_vtl(real l, real w) {
    return (sqrt(2.11e-06/(w))) ;
}

real smm_dela_nld30_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld30_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld30_10hv_rsh(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_nld30_10hv_vtw(real l, real w) {
    return (sqrt(0.0002215/(l))) ;
}

real smm_delr_nld30b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld30b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld30b_10hv_nsub(real l, real w) {
    return (sqrt(0.0005018/(l*w))) ;
}

real smm_dela_nld30b_10hv_vtl(real l, real w) {
    return (sqrt(2.11e-06/(w))) ;
}

real smm_dela_nld30b_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld30b_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld30b_10hv_rsh(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_nld30b_10hv_vtw(real l, real w) {
    return (sqrt(0.0002215/(l))) ;
}

real smm_delr_nld45_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166*1.6*1.05/(w)+0.00017*1.05/(w**2))) ;
}

real smm_dela_nld45_10hv_cit(real l, real w) {
    return (sqrt(2.4e-8/(l*w))) ;
}

real smm_delr_nld45_10hv_vsat(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_dela_nld45_10hv_dwox(real l, real w) {
    return (sqrt(4.415e-06/(l))) ;
}

real smm_delr_nld45_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_delr_nld45b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_10hv_dwox(real l, real w) {
    return (sqrt(4.415e-06/(l))) ;
}

real smm_delr_nld45b_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45b_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_dela_nld45b_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166*1.6*1.05/(w)+0.00017*1.05/(w**2))) ;
}

real smm_dela_nld45b_10hv_cit(real l, real w) {
    return (sqrt(2.4e-8/(l*w))) ;
}

real smm_delr_nld45b_10hv_vsat(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_delr_pld5_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld5_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld5_10hv_nsub(real l, real w) {
    return (sqrt(0.000903/(l*w))) ;
}

real smm_dela_pld5_10hv_vtl(real l, real w) {
    return (sqrt(3.742e-05/(w))) ;
}

real smm_dela_pld5_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld5_10hv_ubref(real l, real w) {
    return (sqrt(3.452e-05/(l*w))) ;
}

real smm_delr_pld5_10hv_rsh(real l, real w) {
    return (sqrt(0.002331/(w))) ;
}

real smm_dela_pld5_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld5_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld5_10hv_vfb(real l, real w) {
    return (sqrt(0.0005578/(l*w))) ;
}

real smm_delr_nld5_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld5_10hv_vtl(real l, real w) {
    return (sqrt(0.0002624/(w))) ;
}

real smm_dela_nld5_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld5_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld5_10hv_rsh(real l, real w) {
    return (sqrt(0.0006/(w))) ;
}

real smm_dela_nld5_10hv_vtw(real l, real w) {
    return (sqrt(6.66e-05/(l))) ;
}

real smm_delr_nld5_lvt_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld5_lvt_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld5_lvt_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld5_lvt_10hv_vtl(real l, real w) {
    return (sqrt(0.0002920/(w))) ;
}

real smm_dela_nld5_lvt_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld5_lvt_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld5_lvt_10hv_rsh(real l, real w) {
    return (sqrt(0.001201/(w))) ;
}

real smm_dela_nld5_lvt_10hv_vtw(real l, real w) {
    return (sqrt(6.66e-05/(l))) ;
}

real smm_delr_pld10_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld10_10hv_vfb(real l, real w) {
    return (sqrt(0.0002178/(l*w))) ;
}

real smm_delr_pld10_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld10_10hv_vtl(real l, real w) {
    return (sqrt(5.122e-07/(w))) ;
}

real smm_dela_pld10_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld10_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld10_10hv_rsh(real l, real w) {
    return (sqrt(0.0002057/(w))) ;
}

real smm_dela_pld10_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_gox_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(4.6e-07/(l*w))) ;
}

real smm_dela_dw_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_dela_vfb_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(0.0001837/(l*w))) ;
}

real smm_delr_nsub_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_mobref_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(1.331e-07/(l*w))) ;
}

real smm_delr_rshl_pld10b_sphv_10hv(real l, real w) {
    return (sqrt(6.296e-05/(w))) ;
}

real smm_delr_pld30_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld30_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld30_10hv_nsub(real l, real w) {
    return (sqrt(0.0003221/(l*w))) ;
}

real smm_dela_pld30_10hv_vtl(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_pld30_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld30_10hv_ubref(real l, real w) {
    return (sqrt(9.515e-05/(l*w))) ;
}

real smm_delr_pld30_10hv_rsh(real l, real w) {
    return (sqrt(7.511e-05/(w))) ;
}

real smm_dela_pld30_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld30b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld30b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld30b_10hv_nsub(real l, real w) {
    return (sqrt(0.0003221/6/(l*w))) ;
}

real smm_dela_pld30b_10hv_vtl(real l, real w) {
    return (sqrt(0/(w))) ;
}

real smm_dela_pld30b_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld30b_10hv_ubref(real l, real w) {
    return (sqrt(9.515e-05/(l*w))) ;
}

real smm_delr_pld30b_10hv_rsh(real l, real w) {
    return (sqrt(7.511e-05/(w))) ;
}

real smm_dela_pld30b_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld45_10hv_gox(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_pld45_10hv_vfb(real l, real w, real ng) {
    return (sqrt(0.0001584/(l*w*ng)+0/(l*w*w*ng))) ;
}

real smm_delr_pld45_10hv_nsub(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_pld45_10hv_vtl(real l, real w, real ng) {
    return (sqrt(0/(w*ng))) ;
}

real smm_dela_pld45_10hv_dwox(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_pld45_10hv_ubref(real l, real w, real ng) {
    return (sqrt(0.0001109/(l*w*ng))) ;
}

real smm_delr_pld45_10hv_rsh(real l, real w, real ng) {
    return (sqrt(5.684e-05/(w*ng))) ;
}

real smm_dela_pld45_10hv_vtw(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_pld45b_10hv_gox(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_pld45b_10hv_vfb(real l, real w, real ng) {
    return (sqrt(0.0001194/(l*w*ng)+0/(l*w*w*ng))) ;
}

real smm_delr_pld45b_10hv_nsub(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_dela_pld45b_10hv_vtl(real l, real w, real ng) {
    return (sqrt(0/(w*ng))) ;
}

real smm_dela_pld45b_10hv_dwox(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_pld45b_10hv_ubref(real l, real w, real ng) {
    return (sqrt(0/(l*w*ng))) ;
}

real smm_delr_pld45b_10hv_rsh(real l, real w, real ng) {
    return (sqrt(6.693e-05/(w*ng))) ;
}

real smm_dela_pld45b_10hv_vtw(real l, real w, real ng) {
    return (sqrt(0/(l*ng))) ;
}

real smm_delr_pld90_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld90_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld90_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld90_10hv_vtl(real l, real w) {
    return (sqrt(0.0001912/(w))) ;
}

real smm_delr_pld90_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld90_10hv_rsh(real l, real w) {
    return (sqrt(1.913e-05/(w))) ;
}

real smm_dela_pld90_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_pld90b_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld90b_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld90b_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_pld90b_10hv_vtl(real l, real w) {
    return (sqrt(0.0001912/(w))) ;
}

real smm_delr_pld90b_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_pld90b_10hv_rsh(real l, real w) {
    return (sqrt(1.913e-05/(w))) ;
}

real smm_dela_pld90b_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld10_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld10_10hv_vfb(real l, real w) {
    return (sqrt(0.0002178/(l*w))) ;
}

real smm_delr_nld10_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld10_10hv_vtl(real l, real w) {
    return (sqrt(5.122e-07/(w))) ;
}

real smm_dela_nld10_10hv_dwox(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld10_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld10_10hv_rsh(real l, real w) {
    return (sqrt(0.0002057/(w))) ;
}

real smm_dela_nld10_10hv_vtw(real l, real w) {
    return (sqrt(0/(l))) ;
}

real smm_delr_nld45_he_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_he_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_he_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_he_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_dela_nld45_he_10hv_dwox(real l, real w) {
    return (sqrt(4.415e-06/(l))) ;
}

real smm_delr_nld45_he_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_he_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45_he_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_delr_nld45b_he_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_he_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_he_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_he_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_dela_nld45b_he_10hv_dwox(real l, real w) {
    return (sqrt(4.415e-06/(l))) ;
}

real smm_delr_nld45b_he_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_he_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45b_he_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_delr_nld45_tlp_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_tlp_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_tlp_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45_tlp_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_delr_nld45_tlp_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45_tlp_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45_tlp_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_delr_nld45b_tlp_10hv_gox(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_tlp_10hv_vfb(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_tlp_10hv_nsub(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_dela_nld45b_tlp_10hv_vtl(real l, real w) {
    return (sqrt(0.0001166/(w))) ;
}

real smm_delr_nld45b_tlp_10hv_ubref(real l, real w) {
    return (sqrt(0/(l*w))) ;
}

real smm_delr_nld45b_tlp_10hv_rsh(real l, real w) {
    return (sqrt(4.172e-05/(w))) ;
}

real smm_dela_nld45b_tlp_10hv_vtw(real l, real w) {
    return (sqrt(0.0004002/(l))) ;
}

real smm_dela_dle_npn_10hv_vbic(real le, real we) {
    return (2.2*(sqrt(2.157e-05/sqrt(sqrt(le))+2.089e-05/sqrt(sqrt(we))))) ;
}

real smm_delr_psbe_npn_10hv_vbic(real le, real we) {
    return (sqrt(2.0*3.408e-05/(we+le))) ;
}

real smm_delr_psb_npn_10hv_vbic(real le, real we) {
    return (sqrt(0.001963/(le)+0.02616/(we*le*le))) ;
}

real smm_delr_jbei_npn_10hv_vbic(real le, real we) {
    return (1.62*(sqrt(0.002142/(we*we*le)+0.0002111/sqrt(le)+0.000109/sqrt(sqrt(le))))) ;
}

real smm_delr_jben_npn_10hv_vbic(real le, real we) {
    return (1.45*(sqrt(0.0005204/(le)+0.01233/(we+le)))) ;
}

real smm_dela_dle_npn_b_10hv_vbic(real le, real we) {
    return (0.5*2.2*(sqrt(2.157e-05/sqrt(sqrt(le))+2.089e-05/sqrt(sqrt(we))))) ;
}

real smm_delr_psbe_npn_b_10hv_vbic(real le, real we) {
    return (sqrt(2.0*3.408e-05/(we+le))) ;
}

real smm_delr_psb_npn_b_10hv_vbic(real le, real we) {
    return (sqrt(0.001963/(le)+0.02616/(we*le*le))) ;
}

real smm_delr_jbei_npn_b_10hv_vbic(real le, real we) {
    return (1.7*(sqrt(0.002142/(we*we*le)+0.0002111/sqrt(le)+0.000109/sqrt(sqrt(le))))) ;
}

real smm_delr_jben_npn_b_10hv_vbic(real le, real we) {
    return (1.45*(sqrt(0.0005204/(le)+0.01233/(we+le)))) ;
}

real smm_dela_dle_pnp_10hv_vbic(real le, real we) {
    return (sqrt(3.929e-06/sqrt(sqrt(we)))) ;
}

real smm_delr_psbe_pnp_10hv_vbic(real le, real we) {
    return (sqrt(1.973e-05/(le)+6.252e-05/(we+le)+1.327e-06/sqrt(le))) ;
}

real smm_delr_psb_pnp_10hv_vbic(real le, real we) {
    return (sqrt(0.1464/(le))) ;
}

real smm_delr_jbei_pnp_10hv_vbic(real le, real we) {
    return (sqrt(0.0003718/(le)+8.021e-06/(we)+6.522e-05/sqrt(le))) ;
}

real smm_delr_jben_pnp_10hv_vbic(real le, real we) {
    return (sqrt(0.02103/(we)+0.3375/(we*le)+0.005/(we+le))) ;
}

real smm_delr_is_dpplus_10hv(real l, real w) {
    return ((0.01466/sqrt(l*w))) ;
}

real smm_delr_is_dnplus_10hv(real l, real w) {
    return ((0.0122/sqrt(l*w))) ;
}

real smm_dela_dle_pnp_iso_10hv_vbic(real le, real we) {
    return (sqrt(3.929e-06/sqrt(sqrt(we)))) ;
}

real smm_delr_psbe_pnp_iso_10hv_vbic(real le, real we) {
    return (sqrt(1.973e-05/(le)+6.252e-05/(we+le)+1.327e-06/sqrt(le))) ;
}

real smm_delr_psb_pnp_iso_10hv_vbic(real le, real we) {
    return (sqrt(0.1464/(le))) ;
}

real smm_delr_jbei_pnp_iso_10hv_vbic(real le, real we) {
    return (sqrt(0.0003718/(le)+8.021e-06/(we)+6.522e-05/sqrt(le))) ;
}

real smm_delr_jben_pnp_iso_10hv_vbic(real le, real we) {
    return (sqrt(0.02103/(we)+0.3375/(we*le)+0.005/(we+le))) ;
}

real smm_delr_rpoly_10hv_r3(real l, real w) {
    return (sqrt(0.0002637/(l*w)+0/(l*l*w)+0/(w*w*l))) ;
}

real smm_delr_rpoly_1meg_10hv_r3(real l, real w) {
    return (sqrt(0.0006641/(l*w)+0/(l*l*w)+0/(w*w*l))) ;
}

real smm_delr_rpoly0_10hv_r3(real l, real w) {
    return (sqrt(0.0012111/(l*w)+0/(l*l*w)+0.001065195/(w*w*l))) ;
}

real smm_delr_rhvpw_10hv_r3(real l, real w) {
    return (sqrt(7.36365e-05/(l*w)+0/(l*l*w)+0/(w*w*l))) ;
}

real smm_delr_rphv_10hv_r3(real l, real w) {
    return (sqrt(0.0003705/((l+4.0)*(w+4.0))+0/(l*l*w)+0/(w*w*l))) ;
}

real smm_delr_rm1_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.05*0.0055111/(l*w)+0/(l*l*w)+0*0.005065195/(w*w*l)))) ;
}

real smm_delr_rm2_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.05*0.0055111/(l*w)+0/(l*l*w)+0*0.005065195/(w*w*l)))) ;
}

real smm_delr_rm3_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.05*0.0055111/(l*w)+0/(l*l*w)+0*0.005065195/(w*w*l)))) ;
}

real smm_delr_rm4_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.05*0.0055111/(l*w)+0/(l*l*w)+0*0.005065195/(w*w*l)))) ;
}

real smm_delr_ralcap_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.0055111/(l*w)+0/(l*l*w)+0.005065195/(w*w*l)))) ;
}

real smm_delr_rulm_10hv(real l, real w) {
    return (((w==0)||(l==0))?0.0:(sqrt(0.0055111/(l*w)+0/(l*l*w)+0.005065195/(w*w*l)))) ;
}

real smm_delr_cfrlv_10hv(real l, real nf) {
    return (sqrt(1.664e-4/((l-1.2)*nf))) ;
}

real smm_delr_cfrlv_m1m2m3_10hv(real l, real nf) {
    return (sqrt(1.168e-4/((l-2.1)*nf))) ;
}

real smm_delr_cfr45_10hv(real l, real nf) {
    return (sqrt(8.96e-5/((l-2.08)*nf))) ;
}

real smm_delr_cfr45_m1m2m3_10hv(real l, real nf) {
    return (sqrt(2.368e-4/((l-1.5)*nf))) ;
}

real smm_delr_cfr90_10hv(real l, real nf) {
    return (sqrt(2.72e-4/((l-2.0)*nf))) ;
}

real smm_delr_cfr90_m1m2m3_10hv(real l, real nf) {
    return (sqrt(4.64e-4/((l-2.3)*nf))) ;
}

real smm_delr_cfr120_10hv(real l, real nf, real finger_spacing) {
    return (sqrt(1.0860e-04/((l-2.745)*nf))*(finger_spacing==0.7)+sqrt(1.6450e-03/((l-1.945)*nf))*(finger_spacing==1.0)+sqrt(2.7700e-03/((l-1.71)*nf))*(finger_spacing==1.3)+sqrt(7.9300e-03/((l-0)*nf))*(finger_spacing==1.6)) ;
}

real smm_delr_cfr120_m1m2m3_10hv(real l, real nf, real finger_spacing) {
    return (sqrt(7.6500e-04/((l-2.602)*nf))*(finger_spacing==0.7)+sqrt(4.9300e-03/((l-2.006)*nf))*(finger_spacing==1.0)+sqrt(7.7800e-03/((l-1.65)*nf))*(finger_spacing==1.3)+sqrt(1.3600e-02/((l-1.32)*nf))*(finger_spacing==1.6)) ;
}

real smm_delr_cdp_10hv(real l, real w) {
    return (sqrt(7.12073e-06/((l-1.0)*(w-1.0)))) ;
}

real smm_delr_cdpf_10hv(real w, real nf) {
    return (sqrt(1.39917e-05/(nf*(w-1.3)))) ;
}

real smm_delr_cdpf_m1m2m3_10hv(real w, real nf) {
    return (sqrt(1.6790e-05/(nf*(w-0.8)))) ;
}

real smm_delr_cglv_10hv_tox(real l, real w) {
    return (sqrt(6.4e-6/(l*w))) ;
}

real smm_delr_cghv_10hv_tox(real l, real w) {
    return (sqrt(6.96e-06/((l-0.8)*(w-0.8)))) ;
}

real smm_delr_cghvf_10hv(real w, real nf) {
    return (sqrt(1.55e-5/(nf*(w-0.45)))) ;
}

real smm_delr_cghvf_m1m2m3_10hv(real w, real nf) {
    return (sqrt(1.8e-5/(nf*(w-0.6)))) ;
}

real smm_dela_bv_dz5_10hv(real w) {
    return (sqrt(1.915e-05/(w))) ;
}

real smm_delr_isr_dz5_10hv(real w) {
    return (sqrt(1.383e-02/(w))) ;
}

real smm_dela_bv_dz5b_10hv(real w) {
    return (sqrt(1.525e-05/(w))) ;
}

real smm_delr_isr_dz5b_10hv(real w) {
    return (sqrt(1.481e-02/(w))) ;
}
parameters
+    wemin_nmos_10hv                = (0.3)
+    lg2ct_nmos_10hv                = (0.105)
+    lg2aa_nmos_10hv                = (0.345)
+    laa2iso_left_nmos_10hv         = (1.77)
+    laa2iso_right_nmos_10hv        = (1.11)
+    wg2iso_nmos_10hv               = (1.11)
+    samin_nmos_10hv                = (0.345)
+    sbmin_nmos_10hv                = (0.345)
+    samin_dogbone_nmos_10hv        = (0.435)
+    sbmin_dogbone_nmos_10hv        = (0.435)
+    sdfix_nmos_10hv                = (0.39)
+    sdfix_dogbone_nmos_10hv        = (0.57)
+    wmax_dogbone_nmos_10hv         = (0.3)
+    wpmxdis_nmos_10hv              = (40)
+    wsc1ref_nmos_10hv              = (40)
+    wsc2ref_nmos_10hv              = (40)
+    wsc3ref_nmos_10hv              = (40)
+    wsc4ref_nmos_10hv              = (40)
+    wemin_nmos_ll_10hv             = (0.3)
+    lg2ct_nmos_ll_10hv             = (0.105)
+    lg2aa_nmos_ll_10hv             = (0.345)
+    laa2iso_left_nmos_ll_10hv      = (1.77)
+    laa2iso_right_nmos_ll_10hv     = (1.11)
+    wg2iso_nmos_ll_10hv            = (1.11)
+    samin_nmos_ll_10hv             = (0.345)
+    sbmin_nmos_ll_10hv             = (0.345)
+    samin_dogbone_nmos_ll_10hv     = (0.435)
+    sbmin_dogbone_nmos_ll_10hv     = (0.435)
+    sdfix_nmos_ll_10hv             = (0.39)
+    sdfix_dogbone_nmos_ll_10hv     = (0.57)
+    wmax_dogbone_nmos_ll_10hv      = (0.3)
+    wpmxdis_nmos_ll_10hv           = (40)
+    wsc1ref_nmos_ll_10hv           = (40)
+    wsc2ref_nmos_ll_10hv           = (40)
+    wsc3ref_nmos_ll_10hv           = (40)
+    wsc4ref_nmos_ll_10hv           = (40)
+    wemin_nmos_ull_10hv            = (0.3)
+    lg2ct_nmos_ull_10hv            = (0.105)
+    lg2aa_nmos_ull_10hv            = (0.345)
+    laa2iso_left_nmos_ull_10hv     = (1.77)
+    laa2iso_right_nmos_ull_10hv    = (1.11)
+    wg2iso_nmos_ull_10hv           = (1.11)
+    samin_nmos_ull_10hv            = (0.345)
+    sbmin_nmos_ull_10hv            = (0.345)
+    samin_dogbone_nmos_ull_10hv    = (0.435)
+    sbmin_dogbone_nmos_ull_10hv    = (0.435)
+    sdfix_nmos_ull_10hv            = (0.39)
+    sdfix_dogbone_nmos_ull_10hv    = (0.57)
+    wmax_dogbone_nmos_ull_10hv     = (0.3)
+    wpmxdis_nmos_ull_10hv          = (40)
+    wsc1ref_nmos_ull_10hv          = (40)
+    wsc2ref_nmos_ull_10hv          = (40)
+    wsc3ref_nmos_ull_10hv          = (40)
+    wsc4ref_nmos_ull_10hv          = (40)
+    lg2ct_nmos_ana_10hv            = (0.12)
+    lg2aa_nmos_ana_10hv            = (0.375)
+    lg2g_nmos_ana_10hv             = (0.42)
+    laa2iso_left_nmos_ana_10hv     = (1.8)
+    laa2iso_right_nmos_ana_10hv    = (1.11)
+    wg2iso_nmos_ana_10hv           = (1.11)
+    wemin_pmos_10hv                = (0.3)
+    lg2ct_pmos_10hv                = (0.105)
+    lg2aa_pmos_10hv                = (0.345)
+    laa2iso_left_pmos_10hv         = (1.77)
+    laa2iso_right_pmos_10hv        = (1.11)
+    wg2iso_pmos_10hv               = (1.11)
+    samin_pmos_10hv                = (0.345)
+    sbmin_pmos_10hv                = (0.345)
+    samin_dogbone_pmos_10hv        = (0.435)
+    sbmin_dogbone_pmos_10hv        = (0.435)
+    sdfix_pmos_10hv                = (0.39)
+    sdfix_dogbone_pmos_10hv        = (0.57)
+    wmax_dogbone_pmos_10hv         = (0.3)
+    wpmxdis_pmos_10hv              = (40)
+    wsc1ref_pmos_10hv              = (40)
+    wsc2ref_pmos_10hv              = (40)
+    wsc3ref_pmos_10hv              = (40)
+    wsc4ref_pmos_10hv              = (40)
+    wemin_pmos_ll_10hv             = (0.3)
+    lg2ct_pmos_ll_10hv             = (0.105)
+    lg2aa_pmos_ll_10hv             = (0.345)
+    laa2iso_left_pmos_ll_10hv      = (1.77)
+    laa2iso_right_pmos_ll_10hv     = (1.11)
+    wg2iso_pmos_ll_10hv            = (1.11)
+    samin_pmos_ll_10hv             = (0.345)
+    sbmin_pmos_ll_10hv             = (0.345)
+    samin_dogbone_pmos_ll_10hv     = (0.435)
+    sbmin_dogbone_pmos_ll_10hv     = (0.435)
+    sdfix_pmos_ll_10hv             = (0.39)
+    sdfix_dogbone_pmos_ll_10hv     = (0.57)
+    wmax_dogbone_pmos_ll_10hv      = (0.3)
+    wpmxdis_pmos_ll_10hv           = (40)
+    wsc1ref_pmos_ll_10hv           = (40)
+    wsc2ref_pmos_ll_10hv           = (40)
+    wsc3ref_pmos_ll_10hv           = (40)
+    wsc4ref_pmos_ll_10hv           = (40)
+    wemin_pmos_ull_10hv            = (0.3)
+    lg2ct_pmos_ull_10hv            = (0.105)
+    lg2aa_pmos_ull_10hv            = (0.345)
+    laa2iso_left_pmos_ull_10hv     = (1.77)
+    laa2iso_right_pmos_ull_10hv    = (1.11)
+    wg2iso_pmos_ull_10hv           = (1.11)
+    samin_pmos_ull_10hv            = (0.345)
+    sbmin_pmos_ull_10hv            = (0.345)
+    samin_dogbone_pmos_ull_10hv    = (0.435)
+    sbmin_dogbone_pmos_ull_10hv    = (0.435)
+    sdfix_pmos_ull_10hv            = (0.39)
+    sdfix_dogbone_pmos_ull_10hv    = (0.57)
+    wmax_dogbone_pmos_ull_10hv     = (0.3)
+    wpmxdis_pmos_ull_10hv          = (40)
+    wsc1ref_pmos_ull_10hv          = (40)
+    wsc2ref_pmos_ull_10hv          = (40)
+    wsc3ref_pmos_ull_10hv          = (40)
+    wsc4ref_pmos_ull_10hv          = (40)
+    lg2ct_pmos_ana_10hv            = (0.12)
+    lg2aa_pmos_ana_10hv            = (0.375)
+    lg2g_pmos_ana_10hv             = (0.42)
+    laa2iso_left_pmos_ana_10hv     = (1.8)
+    laa2iso_right_pmos_ana_10hv    = (1.11)
+    wg2iso_pmos_ana_10hv           = (1.11)
+    lg2ct_s_nmos3_zvt_10hv         = (0.465)
+    lg2ct_d_nmos3_zvt_10hv         = (0.195)
+    lg2aa_s_nmos3_zvt_10hv         = (0.72)
+    lg2aa_d_nmos3_zvt_10hv         = (0.72)
+    lg2g_s_nmos3_zvt_10hv          = (1.11)
+    lg2g_d_nmos3_zvt_10hv          = (1.11)
+    wg2aa_se_nmos3_zvt_10hv        = (0)
+    wg2aa_de_nmos3_zvt_10hv        = (0)
+    wg2aa_si_nmos3_zvt_10hv        = (0)
+    wg2aa_di_nmos3_zvt_10hv        = (0)
+    wg2trench_nmos3_zvt_10hv       = (2.31)
+    wemin_nsrampg_10hv             = (0.3)
+    lg2ct_nsrampg_10hv             = (0.105)
+    lg2aa_nsrampg_10hv             = (0.345)
+    laa2iso_left_nsrampg_10hv      = (1.77)
+    laa2iso_right_nsrampg_10hv     = (1.11)
+    wg2iso_nsrampg_10hv            = (1.11)
+    wemin_nsrampd_10hv             = (0.3)
+    lg2ct_nsrampd_10hv             = (0.105)
+    lg2aa_nsrampd_10hv             = (0.345)
+    laa2iso_left_nsrampd_10hv      = (1.77)
+    laa2iso_right_nsrampd_10hv     = (1.11)
+    wg2iso_nsrampd_10hv            = (1.11)
+    wemin_psrampu_10hv             = (0.3)
+    lg2ct_psrampu_10hv             = (0.105)
+    lg2aa_psrampu_10hv             = (0.345)
+    laa2iso_left_psrampu_10hv      = (1.77)
+    laa2iso_right_psrampu_10hv     = (1.11)
+    wg2iso_psrampu_10hv            = (1.11)
+    lg2ct_nmos5_10hv               = (0.12)
+    lg2aa_nmos5_10hv               = (0.375)
+    lg2g_nmos5_10hv                = (0.42)
+    lg_2nd_nmos5_10hv              = (0.38)
+    laa2iso_left_nmos5_10hv        = (1.8)
+    laa2iso_right_nmos5_10hv       = (1.11)
+    wg2iso_nmos5_10hv              = (1.11)
+    lg2ct_pmos5_10hv               = (0.12)
+    lg2aa_pmos5_10hv               = (0.375)
+    lg2g_pmos5_10hv                = (0.42)
+    laa2iso_left_pmos5_10hv        = (1.8)
+    laa2iso_right_pmos5_10hv       = (1.11)
+    wg2iso_pmos5_10hv              = (1.11)
+    lg2ct_s_nmos45_10hv            = (0.12)
+    lg2ct_d_nmos45_10hv            = (3.4)
+    lg2aa_s_nmos45_10hv            = (0.375)
+    lg2aa_d_nmos45_10hv            = (0)
+    lg2g_s_nmos45_10hv             = (0)
+    lg2g_d_nmos45_10hv             = (7.4)
+    wg2aa_se_nmos45_10hv           = (0)
+    wg2aa_de_nmos45_10hv           = (0)
+    wg2aa_si_nmos45_10hv           = (0)
+    wg2aa_di_nmos45_10hv           = (8.32)
+    wg2trench_nmos45_10hv          = (10.32)
+    trench2se_body_nmos45_10hv     = (1.8)
+    trench2se_nobody_nmos45_10hv   = (0)
+    trench2de_nmos45_10hv          = (0)
+    s2s_inside_nmos45_10hv         = (1.05)
+    lg2ct_d_pmos45_10hv            = (2.575)
+    lg2ct_s_pmos45_10hv            = (0.12)
+    lg2aa_s_pmos45_10hv            = (0.375)
+    lg2g_d_pmos45_10hv             = (5.69)
+    lg2g_s_pmos45_10hv             = (0.42)
+    wg2hvpw_pmos45_10hv            = (3.01)
+    lg2ct_d_pmoshs45_10hv          = (2.575)
+    lg2ct_s_pmoshs45_10hv          = (0.12)
+    lg2aa_s_pmoshs45_10hv          = (0.375)
+    lg2g_d_pmoshs45_10hv           = (5.69)
+    lg2g_s_pmoshs45_10hv           = (1.8)
+    lg2iso_pmoshs45_10hv           = (2.175)
+    wg2iso_pmoshs45_10hv           = (1.11)
+    lg2ct_s_nmos90_10hv            = (0.12)
+    lg2ct_d_nmos90_10hv            = (7.285)
+    lg2aa_s_nmos90_10hv            = (0.375)
+    lg2aa_d_nmos90_10hv            = (0)
+    lg2g_s_nmos90_10hv             = (0)
+    lg2g_d_nmos90_10hv             = (15.11)
+    wg2aa_se_nmos90_10hv           = (0)
+    wg2aa_de_nmos90_10hv           = (0)
+    wg2aa_si_nmos90_10hv           = (0)
+    wg2aa_di_nmos90_10hv           = (13.7)
+    wg2trench_nmos90_10hv          = (17.92)
+    trench2se_body_nmos90_10hv     = (1.8)
+    trench2se_nobody_nmos90_10hv   = (0)
+    trench2de_nmos90_10hv          = (0)
+    s2s_inside_nmos90_10hv         = (1.05)
+    lg2ct_s_pmos90_10hv            = (0.12)
+    lg2ct_d_pmos90_10hv            = (7.01)
+    lg2aa_s_pmos90_10hv            = (0.375)
+    lg2aa_d_pmos90_10hv            = (0)
+    lg2g_s_pmos90_10hv             = (0.375)
+    lg2g_d_pmos90_10hv             = (14.92)
+    wg2aa_se_pmos90_10hv           = (0)
+    wg2aa_de_pmos90_10hv           = (0)
+    wg2aa_si_pmos90_10hv           = (0)
+    wg2aa_di_pmos90_10hv           = (19.6)
+    wg2trench_pmos90_10hv          = (27.6)
+    trench2se_body_pmos90_10hv     = (3.69)
+    trench2se_nobody_pmos90_10hv   = (0)
+    trench2de_pmos90_10hv          = (0)
+    s2s_inside_pmos90_10hv         = (1.05)
+    wemin_rpoly0_10hv              = (0.96)
+    lend_rpoly0_10hv               = (0.75)
+    ldogbone2body_rpoly0_10hv      = (0)
+    lr2iso_left_rpoly0_10hv        = (2.985)
+    lr2iso_right_rpoly0_10hv       = (1.26)
+    w_r2r_rpoly0_10hv              = (0.75)
+    wr2iso_np_rpoly0_10hv          = (0.51)
+    con_en_min_rpoly0_10hv         = (0.375)
+    con_width_rpoly0_10hv          = (0.18)
+    con_space_rpoly0_10hv          = (0.18)
+    wemin_rpoly_10hv               = (0.3)
+    lend_rpoly_10hv                = (0.435)
+    lr2iso_left_rpoly_10hv         = (2.525)
+    lr2iso_right_rpoly_10hv        = (0.945)
+    w_r2r_rpoly_10hv               = (0.285)
+    wr2iso_rpoly_10hv              = (0.54)
+    wr2iso_np_rpoly_10hv           = (0.51)
+    con_en_min_rpoly_10hv          = (0.045)
+    con_width_rpoly_10hv           = (0.18)
+    con_space_rpoly_10hv           = (0.18)
+    wemin_rhvpw_10hv               = (1.2)
+    lend_nw_rhvpw_10hv             = (1.75)
+    wext_rhvpw_10hv                = (1.3)
+    lr2iso_left_rhvpw_10hv         = (3.49)
+    lr2iso_left_np_rhvpw_10hv      = (2.95)
+    lr2iso_right_rhvpw_10hv        = (2.95)
+    w_r2r_rhvpw_10hv               = (4.2)
+    wr2iso_rhvpw_10hv              = (2.5)
+    con_en_min_rhvpw_10hv          = (0.075)
+    con_width_rhvpw_10hv           = (0.18)
+    con_space_rhvpw_10hv           = (0.18)
+    wemin_rphv_10hv                = (1.2)
+    lend_nw_rphv_10hv              = (1.75)
+    wext_rphv_10hv                 = (1.3)
+    lr2iso_left_rphv_10hv          = (3.49)
+    lr2iso_left_np_rphv_10hv       = (2.95)
+    lr2iso_right_rphv_10hv         = (2.95)
+    w_r2r_rphv_10hv                = (4.2)
+    wr2iso_rphv_10hv               = (2.5)
+    con_en_min_rphv_10hv           = (0.075)
+    con_width_rphv_10hv            = (0.18)
+    con_space_rphv_10hv            = (0.18)
+    wemin_rpoly_1meg_10hv          = (0.27)
+    lend_rpoly_1meg_10hv           = (0.66)
+    liso_rpoly_1meg_10hv           = (8.54)
+    wiso_rpoly_1meg_10hv           = (3)
+    ldogbone2body_rpoly_1meg_10hv  = (0)
+    nom_rc_ncon                    = (9.09)
+    nom_delr_rc_ncon               = (1)
+    sig_delr_rc_ncon               = (12.13/100)
+    tcr_ncon                       = (1.723e-03)
+    tcr2_ncon                      = (2.797e-07)
+    nom_rc_plycon                  = (5.52)
+    nom_delr_rc_plycon             = (1)
+    sig_delr_rc_plycon             = (14.0/100)
+    tcr_plycon                     = (1.366e-03)
+    tcr2_plycon                    = (4.576e-07)
+    nom_rc_via1                    = (0.81)
+    nom_delr_rc_via1               = (1)
+    sig_delr_rc_via1               = (13.22/100)
+    tcr_via1                       = (1.298e-03)
+    tcr2_via1                      = (-1.067e-07)
+    nom_rc_via2                    = (0.85)
+    nom_delr_rc_via2               = (1)
+    sig_delr_rc_via2               = (14.16/100)
+    tcr_via2                       = (1.27e-03)
+    tcr2_via2                      = (-9.733e-07)
+    nom_rc_via3                    = (0.87)
+    nom_delr_rc_via3               = (1)
+    sig_delr_rc_via3               = (14.25/100)
+    tcr_via3                       = (3.180e-03)
+    tcr2_via3                      = (-9.757e-08)
+    nom_rc_lvia                    = (0.6004)
+    nom_delr_rc_lvia               = (1)
+    sig_delr_rc_lvia               = (14.15/100)
+    tcr_lvia                       = (8.091e-04)
+    tcr2_lvia                      = (-2.004e-06)
+    nom_rc_paswb                   = (0.1)
+    nom_delr_rc_paswb              = (1)
+    sig_delr_rc_paswb              = (11.96/100)
+    tcr_paswb                      = (3.420e-03)
+    tcr2_paswb                     = (-2.767e-07)
+    nom_rs_m1                      = (0.0918592)
+    nom_delr_rs_m1                 = (0.7503)
+    sig_delr_rs_m1                 = (12.15/100)
+    nom_dw_m1                      = (-0.0659376)
+    nom_dela_dw_m1                 = (0)
+    sig_dela_dw_m1                 = (0.0)
+    nom_dl_m1                      = (0)
+    nom_dela_dl_m1                 = (0)
+    sig_dela_dl_m1                 = (0.0)
+    tcr_m1                         = (2.986e-3)
+    tcr2_m1                        = (-3.452e-09)
+    nom_rs_m2                      = (0.133629/1.12048)
+    nom_delr_rs_m2                 = (0.913472)
+    sig_delr_rs_m2                 = (24.52/100)
+    nom_dw_m2                      = (-0.0086332)
+    nom_dela_dw_m2                 = (0)
+    sig_dela_dw_m2                 = (0.0)
+    nom_dl_m2                      = (0)
+    nom_dela_dl_m2                 = (0)
+    sig_dela_dl_m2                 = (0.0)
+    tcr_m2                         = (3.051e-03)
+    tcr2_m2                        = (-2.348e-08)
+    nom_rs_m3                      = (0.0858018/1.1161385)
+    nom_delr_rs_m3                 = (1.19045)
+    sig_delr_rs_m3                 = (17.57/100)
+    nom_dw_m3                      = (-0.04)
+    nom_dela_dw_m3                 = (0)
+    sig_dela_dw_m3                 = (0.0)
+    nom_dl_m3                      = (0)
+    nom_dela_dl_m3                 = (0)
+    sig_dela_dl_m3                 = (0.0)
+    tcr_m3                         = (3.155e-03)
+    tcr2_m3                        = (-5.493e-08)
+    nom_rs_m4                      = (0.07164/1.048426)
+    nom_delr_rs_m4                 = (1.23255)
+    sig_delr_rs_m4                 = (17.70/100)
+    nom_dw_m4                      = (-0.11)
+    nom_dela_dw_m4                 = (0)
+    sig_dela_dw_m4                 = (0.0)
+    nom_dl_m4                      = (0)
+    nom_dela_dl_m4                 = (0)
+    sig_dela_dl_m4                 = (0.0)
+    tcr_m4                         = (3.18e-03)
+    tcr2_m4                        = (-9.757e-08)
+    nom_rs_alcap                   = (0.01455)
+    nom_delr_rs_alcap              = (0.999258)
+    sig_delr_rs_alcap              = (7.95003/100)
+    nom_dw_alcap                   = (0)
+    nom_dela_dw_alcap              = (0)
+    sig_dela_dw_alcap              = (0.0)
+    nom_dl_alcap                   = (0)
+    nom_dela_dl_alcap              = (0)
+    sig_dela_dl_alcap              = (0.0)
+    tcr_alcap                      = (3.889e-03)
+    tcr2_alcap                     = (-2.812e-07)
+    nom_rs_ulm                     = (0.00500)
+    nom_delr_rs_ulm                = (0.881)
+    sig_delr_rs_ulm                = (8.1/100)
+    nom_dw_ulm                     = (0)
+    nom_dela_dw_ulm                = (0)
+    sig_dela_dw_ulm                = (0.0)
+    nom_dl_ulm                     = (0)
+    nom_dela_dl_ulm                = (0)
+    sig_dela_dl_ulm                = (0.0)
+    tcr_ulm                        = (3.752e-03)
+    tcr2_ulm                       = (2.301e-07)
+    nom_rs_poly_silicide           = (10.49)
+    nom_delr_rs_poly_silicide      = (1)
+    sig_delr_rs_poly_silicide      = (12.34/100)
+    nom_dw_poly_silicide           = (0.0)
+    nom_dela_dw_poly_silicide      = (0.0)
+    sig_dela_dw_poly_silicide      = (0000)
+    nom_dl_poly_silicide           = (0)
+    nom_dela_dl_poly_silicide      = (0)
+    sig_dela_dl_poly_silicide      = (0.0)
+    tcr_inf_poly_silicide          = (3.04e-03)
+    tcr2_inf_poly_silicide         = (4.49e-07)
+    nom_delr_rs_poly_1meg_r3       = (0.909687)
+    sig_delr_rs_poly_1meg_r3       = (0.138811)
+    xw_poly_1meg_r3                = (0)
+    nwxw_poly_1meg_r3              = (0)
+    xl_poly_1meg_r3                = (0)
+    xlw_poly_1meg_r3               = (0)
+    kf_poly_1meg                   = (0.45e-8)
+    af_poly_1meg                   = (1.97)
+    fexp_poly_1meg                 = (0.97)
+    nom_rs_poly_1meg               = (6750.37508806862)
+    tcr_poly_1meg                  = (-0.00270656138368973)
+    tcr2_poly_1meg                 = (6.67739801825248e-06)
+    ldexp_poly_1meg                = (0)
+    wdexp_poly_1meg                = (0)
+    leexp_poly_1meg                = (1)
+    weexp_poly_1meg                = (1)
+    nom_on_antifuse_t              = (5000)
+    sig_on_antifuse_t              = (2000)
+    nom_off_antifuse_t             = (1.5e+13)
+    sig_off_antifuse_t             = (5e+12)
+    xw_poly0_r3                    = (-0.0910703501727513)
+    nwxw_poly0_r3                  = (-0.0814180544471529)
+    xl_poly0_r3                    = (0.0369027574911552)
+    xlw_poly0_r3                   = (0.299407613825368)
+    nom_delr_rs_poly0_r3           = (0.95874)
+    sig_delr_rs_poly0_r3           = (0.0525695)
+    nom_dela_dw_poly0_r3           = (0.03947)
+    sig_dela_dw_poly0_r3           = (0.008)
+    nom_dela_dl_poly0_r3           = (0.08932)
+    sig_dela_dl_poly0_r3           = (0.0035)
+    nom_dela_dlw_poly0_r3          = (-0.2364)
+    sig_dela_dlw_poly0_r3          = (0.09267)
+    nom_dela_tc1_poly0_r3          = (4.68e-5)
+    sig_dela_tc1_poly0_r3          = (2.0e-5)
+    nom_dela_tc1la_poly0_r3        = (2.296e-4)
+    sig_dela_tc1la_poly0_r3        = (2.1e-6)
+    nom_dela_tc1lb_poly0_r3        = (-8.775e-5)
+    sig_dela_tc1lb_poly0_r3        = (0.0)
+    nom_dela_tc1w_poly0_r3         = (-6.52e-6)
+    sig_dela_tc1w_poly0_r3         = (5.0e-6)
+    nom_dela_tc1area1_poly0_r3     = (4e-4)
+    sig_dela_tc1area1_poly0_r3     = (7.0e-5)
+    nom_dela_tc1area2_poly0_r3     = (6.0)
+    sig_dela_tc1area2_poly0_r3     = (1.5)
+    nom_dela_tc1wlratio_poly0_r3   = (-2.8e-5)
+    sig_dela_tc1wlratio_poly0_r3   = (4.0e-7)
+    nom_dela_tc2_poly0_r3          = (0.0)
+    sig_dela_tc2_poly0_r3          = (2.0e-8)
+    nom_dela_tc2la_poly0_r3        = (0.0)
+    sig_dela_tc2la_poly0_r3        = (4.5e-9)
+    nom_dela_tc2lb_poly0_r3        = (8.22e-9)
+    sig_dela_tc2lb_poly0_r3        = (0.0)
+    nom_dela_tc2w_poly0_r3         = (2.056e-8)
+    sig_dela_tc2w_poly0_r3         = (1.1e-8)
+    nom_dela_tc2area1_poly0_r3     = (0.0)
+    sig_dela_tc2area1_poly0_r3     = (1.0e-8)
+    nom_dela_tc2area2_poly0_r3     = (0.0)
+    sig_dela_tc2area2_poly0_r3     = (0.2)
+    nom_dela_tc2wlratio_poly0_r3   = (2.0e-8)
+    sig_dela_tc2wlratio_poly0_r3   = (8.0e-10)
+    xw_poly_r3                     = (-0.107054232283681)
+    nwxw_poly_r3                   = (0.00292817899999513)
+    xl_poly_r3                     = (-0.193391145210718)
+    xlw_poly_r3                    = (-0.0258638963018823)
+    nom_delr_rs_poly_r3            = (0.979126)
+    sig_delr_rs_poly_r3            = (0.0522885)
+    nom_dela_dw_poly_r3            = (0.00454172)
+    sig_dela_dw_poly_r3            = (0.0114037)
+    nom_dela_dl_poly_r3            = (0.0139976)
+    sig_dela_dl_poly_r3            = (0.0755172)
+    xw_hvpw_nbl_r3                 = (-0.148833911273294)
+    nwxw_hvpw_nbl_r3               = (0.257879573285435)
+    xl_hvpw_nbl_r3                 = (0.274398617298933)
+    xlw_hvpw_nbl_r3                = (0.263430288884649)
+    nom_delr_rs_hvpw_nbl_r3        = (0.985736)
+    sig_delr_rs_hvpw_nbl_r3        = (0.0134689)
+    nom_dela_dw_hvpw_nbl_r3        = (0.0525145)
+    sig_dela_dw_hvpw_nbl_r3        = (0.0391266)
+    nom_dela_dl_hvpw_nbl_r3        = (0.070848)
+    sig_dela_dl_hvpw_nbl_r3        = (0.0443959)
+    xw_phv_nbl_r3                  = (0.320372509807191)
+    nwxw_phv_nbl_r3                = (0.217495598329079)
+    xl_phv_nbl_r3                  = (1.35068846765772)
+    xlw_phv_nbl_r3                 = (0.828578670697703)
+    nom_delr_rs_phv_nbl_r3         = (1.01505)
+    sig_delr_rs_phv_nbl_r3         = (0.0251858)
+    nom_dela_dw_phv_nbl_r3         = (0.0526519)
+    sig_dela_dw_phv_nbl_r3         = (0.0358776)
+    nom_dela_dl_phv_nbl_r3         = (0.0672626)
+    sig_dela_dl_phv_nbl_r3         = (0.114815)
+    nom_rs_nwell_pepi              = (218.353)
+    nom_delr_rs_nwell_pepi         = (0.99416)
+    sig_delr_rs_nwell_pepi         = (0.0227212)
+    nom_dw_nwell_pepi              = (-0.3935)
+    nom_dela_dw_nwell_pepi         = (0.0204778)
+    sig_dela_dw_nwell_pepi         = (0.0280193)
+    nom_dl_nwell_pepi              = (2.5147)
+    nom_dela_dl_nwell_pepi         = (1.73234)
+    sig_dela_dl_nwell_pepi         = (0.49623)
+    tcr_inf_nwell_pepi             = (1.073e-03)
+    tcr2_inf_nwell_pepi            = (9.389e-6)
+    tcr_l_nwell_pepi               = (3.237e-04)
+    tcr2_l_nwell_pepi              = (4.777e-06)
+    vtoinf_nwell_pepi              = (-764.459)
+    twoxj_nwell_pepi               = (9.824)
+    nom_delr_psbe_npn_10hv_vbic    = (0.979294)
+    sig_delr_psbe_npn_10hv_vbic    = (0.0488958)
+    nom_delr_psb_npn_10hv_vbic     = (1.0)
+    sig_delr_psb_npn_10hv_vbic     = (0.0)
+    nom_dela_dle_npn_10hv_vbic     = (0.144556)
+    sig_dela_dle_npn_10hv_vbic     = (0.0780545)
+    nom_delr_jbei_npn_10hv_vbic    = (0.950842)
+    sig_delr_jbei_npn_10hv_vbic    = (0.140127)
+    nom_delr_jben_npn_10hv_vbic    = (0.916417)
+    sig_delr_jben_npn_10hv_vbic    = (0.225141)
+    nom_delr_x_col_npn_10hv_vbic   = (1)
+    sig_delr_x_col_npn_10hv_vbic   = (0)
+    nom_delr_n_col_npn_10hv_vbic   = (1)
+    sig_delr_n_col_npn_10hv_vbic   = (0)
+    nom_delr_n_tub_npn_10hv_vbic   = (1)
+    sig_delr_n_tub_npn_10hv_vbic   = (0)
+    nom_delr_psbl_npn_10hv_vbic    = (1)
+    sig_delr_psbl_npn_10hv_vbic    = (0)
+    nom_delr_n_epi_npn_10hv_vbic   = (1)
+    sig_delr_n_epi_npn_10hv_vbic   = (0)
+    nom_delr_psbe_npn_b_10hv_vbic  = (0.99)
+    sig_delr_psbe_npn_b_10hv_vbic  = (0.0488958)
+    nom_delr_psb_npn_b_10hv_vbic   = (1.0)
+    sig_delr_psb_npn_b_10hv_vbic   = (0.0)
+    nom_dela_dle_npn_b_10hv_vbic   = (0.05)
+    sig_dela_dle_npn_b_10hv_vbic   = (0.048784063)
+    nom_delr_jbei_npn_b_10hv_vbic  = (1.05)
+    sig_delr_jbei_npn_b_10hv_vbic  = (0.140127)
+    nom_delr_jben_npn_b_10hv_vbic  = (1.2)
+    sig_delr_jben_npn_b_10hv_vbic  = (0.225141)
+    nom_delr_x_col_npn_b_10hv_vbic = (1)
+    sig_delr_x_col_npn_b_10hv_vbic = (0)
+    nom_delr_n_col_npn_b_10hv_vbic = (1)
+    sig_delr_n_col_npn_b_10hv_vbic = (0)
+    nom_delr_n_tub_npn_b_10hv_vbic = (1)
+    sig_delr_n_tub_npn_b_10hv_vbic = (0)
+    nom_delr_psbl_npn_b_10hv_vbic  = (1)
+    sig_delr_psbl_npn_b_10hv_vbic  = (0)
+    nom_delr_n_epi_npn_b_10hv_vbic = (1)
+    sig_delr_n_epi_npn_b_10hv_vbic = (0)
+    nom_dela_dle_pnp_10hv_vbic     = (-0.00161348)
+    sig_dela_dle_pnp_10hv_vbic     = (0.0398648)
+    nom_delr_psbe_pnp_10hv_vbic    = (0.949464)
+    sig_delr_psbe_pnp_10hv_vbic    = (0.0539696)
+    nom_delr_psb_pnp_10hv_vbic     = (1)
+    sig_delr_psb_pnp_10hv_vbic     = (0)
+    nom_delr_jbei_pnp_10hv_vbic    = (1.09417)
+    sig_delr_jbei_pnp_10hv_vbic    = (0.0806401)
+    nom_delr_jben_pnp_10hv_vbic    = (0.524394)
+    sig_delr_jben_pnp_10hv_vbic    = (0.454189)
+    nom_delr_n_col_pnp_10hv_vbic   = (1)
+    sig_delr_n_col_pnp_10hv_vbic   = (0)
+    nom_delr_x_col_pnp_10hv_vbic   = (1)
+    sig_delr_x_col_pnp_10hv_vbic   = (0)
+    nom_dela_dle_pnp_iso_10hv_vbic = (0.0467754)
+    sig_dela_dle_pnp_iso_10hv_vbic = (0.0394847)
+    nom_delr_psbe_pnp_iso_10hv_vbic = (0.990951)
+    sig_delr_psbe_pnp_iso_10hv_vbic = (0.05424)
+    nom_delr_psb_pnp_iso_10hv_vbic = (1)
+    sig_delr_psb_pnp_iso_10hv_vbic = (0)
+    nom_delr_jbei_pnp_iso_10hv_vbic = (1.2595)
+    sig_delr_jbei_pnp_iso_10hv_vbic = (0.0813085)
+    nom_delr_jben_pnp_iso_10hv_vbic = (0.798572)
+    sig_delr_jben_pnp_iso_10hv_vbic = (0.395381)
+    nom_delr_n_col_pnp_iso_10hv_vbic = (1)
+    sig_delr_n_col_pnp_iso_10hv_vbic = (0)
+    nom_delr_x_col_pnp_iso_10hv_vbic = (1)
+    sig_delr_x_col_pnp_iso_10hv_vbic = (0)
+    nom_delr_tox_nmos_10hv_bsim4   = (0.989928466)
+    sig_delr_tox_nmos_10hv_bsim4   = (0.012)
+    nom_dela_cd_nmos_10hv_bsim4    = (0)
+    sig_dela_cd_nmos_10hv_bsim4    = (0.00818092)
+    nom_dela_dwox_nmos_10hv_bsim4  = (-0.0225012)
+    sig_dela_dwox_nmos_10hv_bsim4  = (0.003634675)
+    nom_dela_od_nmos_10hv_bsim4    = (0.000772681)
+    sig_dela_od_nmos_10hv_bsim4    = (0.00326666)
+    nom_dela_vfb_nmos_10hv_bsim4   = (0.00395058)
+    sig_dela_vfb_nmos_10hv_bsim4   = (0.0066269)
+    nom_delr_ubref_nmos_10hv_bsim4 = (1.0025)
+    sig_delr_ubref_nmos_10hv_bsim4 = (0.0224408)
+    nom_dela_vtl_nmos_10hv_bsim4   = (0.0136118)
+    sig_dela_vtl_nmos_10hv_bsim4   = (0.0359593)
+    nom_dela_vtw_nmos_10hv_bsim4   = (0.1178)
+    sig_dela_vtw_nmos_10hv_bsim4   = (0.198673)
+    nom_dela_vtm_nmos_10hv_bsim4   = (-0.000344008)
+    sig_dela_vtm_nmos_10hv_bsim4   = (0.00072027)
+    nom_delr_a0_nmos_10hv_bsim4    = (0.997412)
+    sig_delr_a0_nmos_10hv_bsim4    = (0.192094)
+    nom_delr_pvsat_nmos_10hv_bsim4 = (1.01159)
+    sig_delr_pvsat_nmos_10hv_bsim4 = (0.162787)
+    nom_dela_lvoff_nmos_10hv_bsim4 = (0.0012)
+    sig_dela_lvoff_nmos_10hv_bsim4 = (0)
+    nom_dela_pvoff_nmos_10hv_bsim4 = (-0.00021)
+    sig_dela_pvoff_nmos_10hv_bsim4 = (0)
+    noia_nmos_10hv_bsim4           = (2.374e+21*100/1.6e-19)
+    noib_nmos_10hv_bsim4           = (145257*100/1.6e-19)
+    noic_nmos_10hv_bsim4           = (0*1.07e-12*100/1.6e-19)
+    ef_nmos_10hv_bsim4             = (0.961)
+    em_nmos_10hv_bsim4             = (1e+6)
+    nom_delr_tox_nmos_ll_10hv_bsim4 = (1)
+    sig_delr_tox_nmos_ll_10hv_bsim4 = (0.012)
+    nom_dela_cd_nmos_ll_10hv_bsim4 = (0)
+    sig_dela_cd_nmos_ll_10hv_bsim4 = (0.00737882)
+    nom_dela_dwox_nmos_ll_10hv_bsim4 = (0)
+    sig_dela_dwox_nmos_ll_10hv_bsim4 = (0.00475)
+    nom_dela_vfb_nmos_ll_10hv_bsim4 = (0.00729379)
+    sig_dela_vfb_nmos_ll_10hv_bsim4 = (0.00964256)
+    nom_delr_ubref_nmos_ll_10hv_bsim4 = (1.02085)
+    sig_delr_ubref_nmos_ll_10hv_bsim4 = (0.0194357)
+    nom_dela_vtl_nmos_ll_10hv_bsim4 = (0.00327943)
+    sig_dela_vtl_nmos_ll_10hv_bsim4 = (0.0198324)
+    nom_dela_vtw_nmos_ll_10hv_bsim4 = (0.00074053)
+    sig_dela_vtw_nmos_ll_10hv_bsim4 = (0.00184304)
+    nom_dela_vtm_nmos_ll_10hv_bsim4 = (0.000728374)
+    sig_dela_vtm_nmos_ll_10hv_bsim4 = (0.000969171)
+    nom_delr_vsat_nmos_ll_10hv_bsim4 = (1.05353)
+    sig_delr_vsat_nmos_ll_10hv_bsim4 = (0.00921616)
+    nom_dela_od_nmos_ll_10hv_bsim4 = (-0.0089309)
+    sig_dela_od_nmos_ll_10hv_bsim4 = (0.00270514)
+    nom_dela_wwl_nmos_ll_10hv_bsim4 = (0.000339584)
+    sig_dela_wwl_nmos_ll_10hv_bsim4 = (0.000139557)
+    nom_dela_a0_nmos_ll_10hv_bsim4 = (0.0269853)
+    sig_dela_a0_nmos_ll_10hv_bsim4 = (0.0993331)
+    nom_dela_jtss_nmos_ll_10hv_bsim4 = (0)
+    sig_dela_jtss_nmos_ll_10hv_bsim4 = (0.70)
+    noia_nmos_ll_10hv_bsim4        = (8.903e+18*100/1.6e-19)
+    noib_nmos_ll_10hv_bsim4        = (115257*100/1.6e-19)
+    noic_nmos_ll_10hv_bsim4        = (1.37e-12*100/1.6e-19)
+    ef_nmos_ll_10hv_bsim4          = (0.97)
+    em_nmos_ll_10hv_bsim4          = (1e+6)
+    nom_delr_tox_nmos_ull_10hv_bsim4 = (1)
+    sig_delr_tox_nmos_ull_10hv_bsim4 = (0.012)
+    nom_dela_cd_nmos_ull_10hv_bsim4 = (0)
+    sig_dela_cd_nmos_ull_10hv_bsim4 = (0.00355141)
+    nom_dela_dwox_nmos_ull_10hv_bsim4 = (0.00932585)
+    sig_dela_dwox_nmos_ull_10hv_bsim4 = (0.0088061)
+    nom_dela_vfb_nmos_ull_10hv_bsim4 = (-0.0251195)
+    sig_dela_vfb_nmos_ull_10hv_bsim4 = (0.0121646)
+    nom_delr_ubref_nmos_ull_10hv_bsim4 = (0.964366)
+    sig_delr_ubref_nmos_ull_10hv_bsim4 = (0.00838752)
+    nom_dela_lu0_nmos_ull_10hv_bsim4 = (16.9394)
+    sig_dela_lu0_nmos_ull_10hv_bsim4 = (8.36235)
+    nom_dela_vtl_nmos_ull_10hv_bsim4 = (0.0570529)
+    sig_dela_vtl_nmos_ull_10hv_bsim4 = (0.0408363)
+    nom_dela_vtw_nmos_ull_10hv_bsim4 = (-3.1984e-05)
+    sig_dela_vtw_nmos_ull_10hv_bsim4 = (0.00990845)
+    nom_dela_vtm_nmos_ull_10hv_bsim4 = (-0.000951908)
+    sig_dela_vtm_nmos_ull_10hv_bsim4 = (0.00206161)
+    nom_dela_wwl_nmos_ull_10hv_bsim4 = (0.00019135)
+    sig_dela_wwl_nmos_ull_10hv_bsim4 = (4.91235e-05)
+    nom_delr_vsat_nmos_ull_10hv_bsim4 = (1.04654)
+    sig_delr_vsat_nmos_ull_10hv_bsim4 = (0.0514003)
+    nom_delr_wvsat_nmos_ull_10hv_bsim4 = (0.0222596)
+    sig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nom_dela_od_nmos_ull_10hv_bsim4 = (0)
+    sig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nom_dela_a0_nmos_ull_10hv_bsim4 = (0.548803)
+    sig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nom_dela_b0_nmos_ull_10hv_bsim4 = (0.0829889)
+    sig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nom_dela_jtss_nmos_ull_10hv_bsim4 = (0)
+    sig_dela_jtss_nmos_ull_10hv_bsim4 = (0.4)
+    nom_dela_agidl_nmos_ull_10hv_bsim4 = (0)
+    sig_dela_agidl_nmos_ull_10hv_bsim4 = (0.4)
+    nom_dela_wagidl_nmos_ull_10hv_bsim4 = (0.75)
+    sig_dela_wagidl_nmos_ull_10hv_bsim4 = (1.3)
+    nom_dela_pvoff_nmos_ull_10hv_bsim4 = (0)
+    sig_dela_pvoff_nmos_ull_10hv_bsim4 = (0.275)
+    noia_nmos_ull_10hv_bsim4       = (3.125e+44)
+    noib_nmos_ull_10hv_bsim4       = (1e+26)
+    noic_nmos_ull_10hv_bsim4       = (2e+11)
+    ef_nmos_ull_10hv_bsim4         = (0.97)
+    em_nmos_ull_10hv_bsim4         = (1e+6)
+    nom_delr_tox_nmos_ana_10hv_bsim4 = (1)
+    sig_delr_tox_nmos_ana_10hv_bsim4 = (0.012)
+    nom_dela_cd_nmos_ana_10hv_bsim4 = (0)
+    sig_dela_cd_nmos_ana_10hv_bsim4 = (0.215103)
+    nom_dela_dwox_nmos_ana_10hv_bsim4 = (-0.256457)
+    sig_dela_dwox_nmos_ana_10hv_bsim4 = (0.053848)
+    nom_dela_od_nmos_ana_10hv_bsim4 = (-0.084587)
+    sig_dela_od_nmos_ana_10hv_bsim4 = (0.180801)
+    nom_delr_ubref_nmos_ana_10hv_bsim4 = (0.942637)
+    sig_delr_ubref_nmos_ana_10hv_bsim4 = (0.0226958)
+    nom_dela_vfb_nmos_ana_10hv_bsim4 = (0.0155725)
+    sig_dela_vfb_nmos_ana_10hv_bsim4 = (0.010712)
+    nom_dela_vtl_nmos_ana_10hv_bsim4 = (0.00769916)
+    sig_dela_vtl_nmos_ana_10hv_bsim4 = (0.0372882)
+    nom_dela_vtw_nmos_ana_10hv_bsim4 = (0.00357701)
+    sig_dela_vtw_nmos_ana_10hv_bsim4 = (0.553943)
+    nom_dela_vtm_nmos_ana_10hv_bsim4 = (-0.000237925)
+    sig_dela_vtm_nmos_ana_10hv_bsim4 = (0.000213603)
+    nom_delr_vsat_nmos_ana_10hv_bsim4 = (1.03795)
+    sig_delr_vsat_nmos_ana_10hv_bsim4 = (0.04627665)
+    nom_delr_pvsat_nmos_ana_10hv_bsim4 = (0.093112)
+    sig_delr_pvsat_nmos_ana_10hv_bsim4 = (2.452295)
+    nom_dela_wwl_nmos_ana_10hv_bsim4 = (-2.64019e-07)
+    sig_dela_wwl_nmos_ana_10hv_bsim4 = (0.00165785)
+    nom_dela_voff_nmos_ana_10hv_bsim4 = (-0.002)
+    sig_dela_voff_nmos_ana_10hv_bsim4 = (0.0015)
+    nom_dela_lvoff_nmos_ana_10hv_bsim4 = (-0.002)
+    sig_dela_lvoff_nmos_ana_10hv_bsim4 = (0.0)
+    nom_dela_pvoff_nmos_ana_10hv_bsim4 = (0.005)
+    sig_dela_pvoff_nmos_ana_10hv_bsim4 = (0.002)
+    noia_nmos_ana_10hv_bsim4       = (1.603e+21*100/1.6e-19)
+    noib_nmos_ana_10hv_bsim4       = (0.0*185257*100/1.6e-19)
+    noic_nmos_ana_10hv_bsim4       = (8.1096e-13*100/1.6e-19)
+    ef_nmos_ana_10hv_bsim4         = (0.97)
+    em_nmos_ana_10hv_bsim4         = (1e+6)
+    nom_delr_tox_nmos3_zvt_10hv_bsim3v3 = (0.987006)
+    sig_delr_tox_nmos3_zvt_10hv_bsim3v3 = (0.012)
+    nom_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (0.0158789)
+    sig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (0.022501)
+    nom_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (0.00254744)
+    sig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (0.064501)
+    nom_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (-0.0225618)
+    sig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0.00936184)
+    nom_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (-0.0385862)
+    sig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (0.0164277)
+    nom_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (0.998027)
+    sig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (0.00750879)
+    nom_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0.0137889)
+    sig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0.109996)
+    nom_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (0.0429509)
+    sig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (0.0104642)
+    nom_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.459039)
+    sig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.066081)
+    noimod_nmos3_zvt_10hv_bsim3v3  = (2)
+    noia_nmos3_zvt_10hv_bsim3v3    = (1.03e+18*51)
+    noib_nmos3_zvt_10hv_bsim3v3    = (205257*0.6)
+    noic_nmos3_zvt_10hv_bsim3v3    = (0.0)
+    ef_nmos3_zvt_10hv_bsim3v3      = (0.97)
+    em_nmos3_zvt_10hv_bsim3v3      = (1e+6)
+    nom_delr_tox_nmos10_10hv_bsim3v3 = (1.0224924012)
+    sig_delr_tox_nmos10_10hv_bsim3v3 = (0.012)
+    nom_dela_vfb_nmos10_10hv_bsim3v3 = (0.0274392)
+    sig_dela_vfb_nmos10_10hv_bsim3v3 = (0.0419909)
+    nom_delr_ubref_nmos10_10hv_bsim3v3 = (1.01514)
+    sig_delr_ubref_nmos10_10hv_bsim3v3 = (0.0222793)
+    nom_dela_ags_nmos10_10hv_bsim3v3 = (-0.00414316)
+    sig_dela_ags_nmos10_10hv_bsim3v3 = (0.0393742)
+    nom_dela_vtl_nmos10_10hv_bsim3v3 = (-0.0114421)
+    sig_dela_vtl_nmos10_10hv_bsim3v3 = (0.00555965)
+    nom_dela_dl_nmos10_10hv_bsim3v3 = (0.000388625)
+    sig_dela_dl_nmos10_10hv_bsim3v3 = (0.0619548)
+    nom_delr_vsat_nmos10_10hv_bsim3v3 = (0.970609)
+    sig_delr_vsat_nmos10_10hv_bsim3v3 = (0.0439093)
+    nom_dela_k3_nmos10_10hv_bsim3v3 = (-0.314719)
+    sig_dela_k3_nmos10_10hv_bsim3v3 = (0.188906)
+    nom_dela_b0_nmos10_10hv_bsim3v3 = (-0.00263773)
+    sig_dela_b0_nmos10_10hv_bsim3v3 = (0.0117475)
+    nom_dela_dwox_nmos10_10hv_bsim3v3 = (0.00254871)
+    sig_dela_dwox_nmos10_10hv_bsim3v3 = (0.00632397)
+    nom_dela_vtm_nmos10_10hv_bsim3v3 = (0.00437134)
+    sig_dela_vtm_nmos10_10hv_bsim3v3 = (0.011151)
+    nom_dela_pu0_nmos10_10hv_bsim3v3 = (6.55971)
+    sig_dela_pu0_nmos10_10hv_bsim3v3 = (18.8361)
+    noimod_nmos10_10hv_bsim3v3     = (2)
+    noia_nmos10_10hv_bsim3v3       = (3.903e+20)
+    noib_nmos10_10hv_bsim3v3       = (385074)
+    noic_nmos10_10hv_bsim3v3       = (7.937e-12)
+    ef_nmos10_10hv_bsim3v3         = (0.961)
+    em_nmos10_10hv_bsim3v3         = (1e+8)
+    nom_delr_tox_nmos45_10hv_bsim3v3 = (1.02249)
+    sig_delr_tox_nmos45_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nmos45_10hv_bsim3v3 = (-0.0548838)
+    sig_dela_dwox_nmos45_10hv_bsim3v3 = (0)
+    nom_dela_vfb_nmos45_10hv_bsim3v3 = (0.0206157)
+    sig_dela_vfb_nmos45_10hv_bsim3v3 = (0.0434312)
+    nom_delr_ubref_nmos45_10hv_bsim3v3 = (1.03704)
+    sig_delr_ubref_nmos45_10hv_bsim3v3 = (0.0257455)
+    nom_dela_dl_nmos45_10hv_bsim3v3 = (0.0677721)
+    sig_dela_dl_nmos45_10hv_bsim3v3 = (0.0408491)
+    nom_dela_vtl_nmos45_10hv_bsim3v3 = (-0.0468654)
+    sig_dela_vtl_nmos45_10hv_bsim3v3 = (0.0238473)
+    nom_dela_vtw_nmos45_10hv_bsim3v3 = (-0.00300265)
+    sig_dela_vtw_nmos45_10hv_bsim3v3 = (0.0383998)
+    nom_dela_vtm_nmos45_10hv_bsim3v3 = (-0.192582)
+    sig_dela_vtm_nmos45_10hv_bsim3v3 = (0.0581714)
+    nom_dela_a0_nmos45_10hv_bsim3v3 = (0.127769)
+    sig_dela_a0_nmos45_10hv_bsim3v3 = (0.144539)
+    nom_dela_la0_nmos45_10hv_bsim3v3 = (0)
+    sig_dela_la0_nmos45_10hv_bsim3v3 = (0.0828217)
+    nom_dela_b0_nmos45_10hv_bsim3v3 = (-0.255815)
+    sig_dela_b0_nmos45_10hv_bsim3v3 = (0)
+    nom_delr_vsat_nmos45_10hv_bsim3v3 = (1.5962)
+    sig_delr_vsat_nmos45_10hv_bsim3v3 = (0)
+    nom_dela_pa0_nmos45_10hv_bsim3v3 = (-0.48517)
+    sig_dela_pa0_nmos45_10hv_bsim3v3 = (0)
+    noimod_nmos45_10hv_bsim3v3     = (2)
+    noia_nmos45_10hv_bsim3v3       = (4.13e+19)
+    noib_nmos45_10hv_bsim3v3       = (195074)
+    noic_nmos45_10hv_bsim3v3       = (5.937e-12)
+    ef_nmos45_10hv_bsim3v3         = (0.93)
+    em_nmos45_10hv_bsim3v3         = (1e+12)
+    nom_delr_tox_nmos45b_10hv_bsim3v3 = (1.02249)
+    sig_delr_tox_nmos45b_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nmos45b_10hv_bsim3v3 = (-0.0548838)
+    sig_dela_dwox_nmos45b_10hv_bsim3v3 = (0)
+    nom_dela_vfb_nmos45b_10hv_bsim3v3 = (0.0206157)
+    sig_dela_vfb_nmos45b_10hv_bsim3v3 = (0.0434312)
+    nom_delr_ubref_nmos45b_10hv_bsim3v3 = (1.03704)
+    sig_delr_ubref_nmos45b_10hv_bsim3v3 = (0.0257455)
+    nom_dela_dl_nmos45b_10hv_bsim3v3 = (0.0677721)
+    sig_dela_dl_nmos45b_10hv_bsim3v3 = (0.0408491)
+    nom_dela_vtl_nmos45b_10hv_bsim3v3 = (-0.0468654)
+    sig_dela_vtl_nmos45b_10hv_bsim3v3 = (0.0238473)
+    nom_dela_vtw_nmos45b_10hv_bsim3v3 = (-0.00300265)
+    sig_dela_vtw_nmos45b_10hv_bsim3v3 = (0.0383998)
+    nom_dela_vtm_nmos45b_10hv_bsim3v3 = (-0.192582)
+    sig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.0581714)
+    nom_dela_a0_nmos45b_10hv_bsim3v3 = (0.127769)
+    sig_dela_a0_nmos45b_10hv_bsim3v3 = (0.144539)
+    nom_dela_la0_nmos45b_10hv_bsim3v3 = (0)
+    sig_dela_la0_nmos45b_10hv_bsim3v3 = (0.0828217)
+    nom_dela_b0_nmos45b_10hv_bsim3v3 = (-0.255815)
+    sig_dela_b0_nmos45b_10hv_bsim3v3 = (0)
+    nom_delr_vsat_nmos45b_10hv_bsim3v3 = (1.5962)
+    sig_delr_vsat_nmos45b_10hv_bsim3v3 = (0)
+    nom_dela_pa0_nmos45b_10hv_bsim3v3 = (-0.48517)
+    sig_dela_pa0_nmos45b_10hv_bsim3v3 = (0)
+    noimod_nmos45b_10hv_bsim3v3    = (2)
+    noia_nmos45b_10hv_bsim3v3      = (4.13e+19)
+    noib_nmos45b_10hv_bsim3v3      = (195074)
+    noic_nmos45b_10hv_bsim3v3      = (5.937e-12)
+    ef_nmos45b_10hv_bsim3v3        = (0.93)
+    em_nmos45b_10hv_bsim3v3        = (1e+12)
+    nom_delr_tox_nmos90_10hv_bsim3v3 = (1.02249)
+    sig_delr_tox_nmos90_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nmos90_10hv_bsim3v3 = (-0.00622719)
+    sig_dela_dwox_nmos90_10hv_bsim3v3 = (0.112026)
+    nom_dela_vfb_nmos90_10hv_bsim3v3 = (0.0199709)
+    sig_dela_vfb_nmos90_10hv_bsim3v3 = (0.0415718)
+    nom_delr_ubref_nmos90_10hv_bsim3v3 = (1.004)
+    sig_delr_ubref_nmos90_10hv_bsim3v3 = (0.0313371)
+    nom_dela_dl_nmos90_10hv_bsim3v3 = (0.190725)
+    sig_dela_dl_nmos90_10hv_bsim3v3 = (0.0586511)
+    nom_dela_vtl_nmos90_10hv_bsim3v3 = (-0.131918)
+    sig_dela_vtl_nmos90_10hv_bsim3v3 = (0.03903)
+    nom_dela_vtw_nmos90_10hv_bsim3v3 = (0.0421876)
+    sig_dela_vtw_nmos90_10hv_bsim3v3 = (0.0773368)
+    nom_dela_vtm_nmos90_10hv_bsim3v3 = (0.629568)
+    sig_dela_vtm_nmos90_10hv_bsim3v3 = (0.211415)
+    nom_dela_a0_nmos90_10hv_bsim3v3 = (-0.021289)
+    sig_dela_a0_nmos90_10hv_bsim3v3 = (0)
+    nom_delr_rdsw_nmos90_10hv_bsim3v3 = (0.142539)
+    sig_delr_rdsw_nmos90_10hv_bsim3v3 = (0)
+    nom_dela_wwl_nmos90_10hv_bsim3v3 = (0)
+    sig_dela_wwl_nmos90_10hv_bsim3v3 = (0)
+    noimod_nmos90_10hv_bsim3v3     = (2)
+    noia_nmos90_10hv_bsim3v3       = (1.403e+18)
+    noib_nmos90_10hv_bsim3v3       = (215074)
+    noic_nmos90_10hv_bsim3v3       = (2.137e-11)
+    ef_nmos90_10hv_bsim3v3         = (0.99)
+    em_nmos90_10hv_bsim3v3         = (1e+8)
+    nom_delr_tox_nmos90b_10hv_bsim3v3 = (1.02249)
+    sig_delr_tox_nmos90b_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nmos90b_10hv_bsim3v3 = (-0.00622719)
+    sig_dela_dwox_nmos90b_10hv_bsim3v3 = (0.112026)
+    nom_dela_vfb_nmos90b_10hv_bsim3v3 = (0.0199709)
+    sig_dela_vfb_nmos90b_10hv_bsim3v3 = (0.0415718)
+    nom_delr_ubref_nmos90b_10hv_bsim3v3 = (1.004)
+    sig_delr_ubref_nmos90b_10hv_bsim3v3 = (0.0313371)
+    nom_dela_dl_nmos90b_10hv_bsim3v3 = (0.190725)
+    sig_dela_dl_nmos90b_10hv_bsim3v3 = (0.0586511)
+    nom_dela_vtl_nmos90b_10hv_bsim3v3 = (-0.131918)
+    sig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.03903)
+    nom_dela_vtw_nmos90b_10hv_bsim3v3 = (0.0421876)
+    sig_dela_vtw_nmos90b_10hv_bsim3v3 = (0.0773368)
+    nom_dela_vtm_nmos90b_10hv_bsim3v3 = (0.629568)
+    sig_dela_vtm_nmos90b_10hv_bsim3v3 = (0.211415)
+    nom_dela_a0_nmos90b_10hv_bsim3v3 = (-0.021289)
+    sig_dela_a0_nmos90b_10hv_bsim3v3 = (0)
+    nom_delr_rdsw_nmos90b_10hv_bsim3v3 = (0.142539)
+    sig_delr_rdsw_nmos90b_10hv_bsim3v3 = (0)
+    nom_dela_wwl_nmos90b_10hv_bsim3v3 = (0)
+    sig_dela_wwl_nmos90b_10hv_bsim3v3 = (0)
+    noimod_nmos90b_10hv_bsim3v3    = (2)
+    noia_nmos90b_10hv_bsim3v3      = (1.403e+18)
+    noib_nmos90b_10hv_bsim3v3      = (215074)
+    noic_nmos90b_10hv_bsim3v3      = (2.137e-11)
+    ef_nmos90b_10hv_bsim3v3        = (0.99)
+    em_nmos90b_10hv_bsim3v3        = (1e+8)
+    nom_delr_tox_nsrampg_10hv_bsim3v3 = (0.97493)
+    sig_delr_tox_nsrampg_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nsrampg_10hv_bsim3v3 = (0)
+    sig_dela_dwox_nsrampg_10hv_bsim3v3 = (0.0001)
+    nom_delr_ubref_nsrampg_10hv_bsim3v3 = (1.47861)
+    sig_delr_ubref_nsrampg_10hv_bsim3v3 = (0.0239362)
+    nom_dela_vtw_nsrampg_10hv_bsim3v3 = (0.00557326)
+    sig_dela_vtw_nsrampg_10hv_bsim3v3 = (0.0301275)
+    nom_dela_vtm_nsrampg_10hv_bsim3v3 = (-0.0781741)
+    sig_dela_vtm_nsrampg_10hv_bsim3v3 = (0.13221)
+    nom_dela_dwwl_nsrampg_10hv_bsim3v3 = (-0.183571)
+    sig_dela_dwwl_nsrampg_10hv_bsim3v3 = (0.0203176)
+    noimod_nsrampg_10hv_bsim3v3    = (2)
+    nom_delr_tox_nsrampd_10hv_bsim3v3 = (1)
+    sig_delr_tox_nsrampd_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_nsrampd_10hv_bsim3v3 = (-0.103895)
+    sig_dela_dwox_nsrampd_10hv_bsim3v3 = (0.00804109)
+    nom_dela_vfb_nsrampd_10hv_bsim3v3 = (0.011497)
+    sig_dela_vfb_nsrampd_10hv_bsim3v3 = (0.0265997)
+    nom_delr_ubref_nsrampd_10hv_bsim3v3 = (1.0048)
+    sig_delr_ubref_nsrampd_10hv_bsim3v3 = (0.0863161)
+    nom_dela_b0_nsrampd_10hv_bsim3v3 = (-0.461057)
+    sig_dela_b0_nsrampd_10hv_bsim3v3 = (0.0994621)
+    nom_dela_a0_nsrampd_10hv_bsim3v3 = (-0.84)
+    sig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nom_dela_dl_nsrampd_10hv_bsim3v3 = (-0.0030185)
+    sig_dela_dl_nsrampd_10hv_bsim3v3 = (0.0143578)
+    nom_dela_vtl_nsrampd_10hv_bsim3v3 = (0.09)
+    sig_dela_vtl_nsrampd_10hv_bsim3v3 = (0.683572)
+    nom_dela_vtw_nsrampd_10hv_bsim3v3 = (0.06)
+    sig_dela_vtw_nsrampd_10hv_bsim3v3 = (3.31413)
+    nom_dela_vtm_nsrampd_10hv_bsim3v3 = (-0.0460322)
+    sig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nom_dela_dwwl_nsrampd_10hv_bsim3v3 = (0.651044)
+    sig_dela_dwwl_nsrampd_10hv_bsim3v3 = (0.231949)
+    nom_delr_vsat_nsrampd_10hv_bsim3v3 = (1.00569)
+    sig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    noimod_nsrampd_10hv_bsim3v3    = (2)
+    nom_delr_tox_pmos_10hv_bsim4   = (0.99900457)
+    sig_delr_tox_pmos_10hv_bsim4   = (0.012)
+    nom_dela_cd_pmos_10hv_bsim4    = (0)
+    sig_dela_cd_pmos_10hv_bsim4    = (0.00818092)
+    nom_dela_dwox_pmos_10hv_bsim4  = (-0.0257024)
+    sig_dela_dwox_pmos_10hv_bsim4  = (0.0059905)
+    nom_dela_od_pmos_10hv_bsim4    = (0.00126295)
+    sig_dela_od_pmos_10hv_bsim4    = (0.0109108)
+    nom_dela_vfb_pmos_10hv_bsim4   = (-0.00722281)
+    sig_dela_vfb_pmos_10hv_bsim4   = (0.0179861)
+    nom_delr_ubref_pmos_10hv_bsim4 = (0.968747)
+    sig_delr_ubref_pmos_10hv_bsim4 = (0.01549365)
+    nom_dela_vtl_pmos_10hv_bsim4   = (0.0100705)
+    sig_dela_vtl_pmos_10hv_bsim4   = (0.0199707)
+    nom_dela_vtw_pmos_10hv_bsim4   = (0.0813218)
+    sig_dela_vtw_pmos_10hv_bsim4   = (0.351116)
+    nom_dela_vtm_pmos_10hv_bsim4   = (-0.000336945)
+    sig_dela_vtm_pmos_10hv_bsim4   = (0.00055242)
+    nom_dela_a0_pmos_10hv_bsim4    = (-0.00909989)
+    sig_dela_a0_pmos_10hv_bsim4    = (0.107603)
+    nom_dela_pu0_pmos_10hv_bsim4   = (-0.115929)
+    sig_dela_pu0_pmos_10hv_bsim4   = (0.2639755)
+    nom_dela_agidl_pmos_10hv_bsim4 = (0.1)
+    sig_dela_agidl_pmos_10hv_bsim4 = (1.738324)
+    noia_pmos_10hv_bsim4           = (2.671e+20*100/1.6e-19)
+    noib_pmos_10hv_bsim4           = (525771*100/1.6e-19)
+    noic_pmos_10hv_bsim4           = (1.481e-11*100/1.6e-19)
+    ef_pmos_10hv_bsim4             = (1.0)
+    em_pmos_10hv_bsim4             = (1e+8)
+    nom_delr_tox_pmos_ll_10hv_bsim4 = (1)
+    sig_delr_tox_pmos_ll_10hv_bsim4 = (0.012)
+    nom_dela_cd_pmos_ll_10hv_bsim4 = (0)
+    sig_dela_cd_pmos_ll_10hv_bsim4 = (0.00737882)
+    nom_dela_dwox_pmos_ll_10hv_bsim4 = (-0.0299282)
+    sig_dela_dwox_pmos_ll_10hv_bsim4 = (0.0039449)
+    nom_dela_vfb_pmos_ll_10hv_bsim4 = (-0.00012347)
+    sig_dela_vfb_pmos_ll_10hv_bsim4 = (0.016336)
+    nom_delr_ubref_pmos_ll_10hv_bsim4 = (1.00578)
+    sig_delr_ubref_pmos_ll_10hv_bsim4 = (0.0226813)
+    nom_dela_vtl_pmos_ll_10hv_bsim4 = (0.00956325)
+    sig_dela_vtl_pmos_ll_10hv_bsim4 = (0.005137)
+    nom_dela_vtw_pmos_ll_10hv_bsim4 = (0.013915)
+    sig_dela_vtw_pmos_ll_10hv_bsim4 = (0.0100761)
+    nom_dela_vtm_pmos_ll_10hv_bsim4 = (0.000541518)
+    sig_dela_vtm_pmos_ll_10hv_bsim4 = (0.000703488)
+    nom_dela_od_pmos_ll_10hv_bsim4 = (-0.0146227)
+    sig_dela_od_pmos_ll_10hv_bsim4 = (0.0059796)
+    nom_dela_ags_pmos_ll_10hv_bsim4 = (-0.00424537)
+    sig_dela_ags_pmos_ll_10hv_bsim4 = (0.0115407)
+    nom_dela_jtss_pmos_ll_10hv_bsim4 = (0)
+    sig_dela_jtss_pmos_ll_10hv_bsim4 = (1.243512)
+    noia_pmos_ll_10hv_bsim4        = (1.056e+42)
+    noib_pmos_ll_10hv_bsim4        = (3.095e+26)
+    noic_pmos_ll_10hv_bsim4        = (9.086e+9)
+    ef_pmos_ll_10hv_bsim4          = (0.981)
+    em_pmos_ll_10hv_bsim4          = (1e+8)
+    nom_delr_tox_pmos_ull_10hv_bsim4 = (1)
+    sig_delr_tox_pmos_ull_10hv_bsim4 = (0.012)
+    nom_dela_cd_pmos_ull_10hv_bsim4 = (0)
+    sig_dela_cd_pmos_ull_10hv_bsim4 = (0.00355141)
+    nom_dela_dwox_pmos_ull_10hv_bsim4 = (-0.0382388)
+    sig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nom_dela_vfb_pmos_ull_10hv_bsim4 = (-0.0220798)
+    sig_dela_vfb_pmos_ull_10hv_bsim4 = (0.0182109)
+    nom_delr_ubref_pmos_ull_10hv_bsim4 = (1.16873)
+    sig_delr_ubref_pmos_ull_10hv_bsim4 = (0.0265761)
+    nom_dela_wwl_pmos_ull_10hv_bsim4 = (-0.000110256)
+    sig_dela_wwl_pmos_ull_10hv_bsim4 = (1.093624e-05)
+    nom_dela_vtl_pmos_ull_10hv_bsim4 = (0.013398)
+    sig_dela_vtl_pmos_ull_10hv_bsim4 = (0.012290)
+    nom_dela_vtw_pmos_ull_10hv_bsim4 = (0.00420193)
+    sig_dela_vtw_pmos_ull_10hv_bsim4 = (0.0201999)
+    nom_dela_vtm_pmos_ull_10hv_bsim4 = (0.000330919)
+    sig_dela_vtm_pmos_ull_10hv_bsim4 = (2.76455e-05)
+    nom_dela_od_pmos_ull_10hv_bsim4 = (0.000622735)
+    sig_dela_od_pmos_ull_10hv_bsim4 = (0.00489532)
+    nom_dela_a0_pmos_ull_10hv_bsim4 = (-0.169529)
+    sig_dela_a0_pmos_ull_10hv_bsim4 = (0.0890795)
+    nom_dela_la0_pmos_ull_10hv_bsim4 = (-0.186401)
+    sig_dela_la0_pmos_ull_10hv_bsim4 = (0.01526908)
+    nom_dela_pa0_pmos_ull_10hv_bsim4 = (-0.0163362)
+    sig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nom_dela_b0_pmos_ull_10hv_bsim4 = (-0.0107456)
+    sig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nom_dela_jtss_pmos_ull_10hv_bsim4 = (0.67)
+    sig_dela_jtss_pmos_ull_10hv_bsim4 = (0.8075)
+    nom_dela_agidl_pmos_ull_10hv_bsim4 = (0.67)
+    sig_dela_agidl_pmos_ull_10hv_bsim4 = (0.8075)
+    nom_dela_wagidl_pmos_ull_10hv_bsim4 = (0.67)
+    sig_dela_wagidl_pmos_ull_10hv_bsim4 = (1.725)
+    noia_pmos_ull_10hv_bsim4       = (5e+42)
+    noib_pmos_ull_10hv_bsim4       = (1.25e+27)
+    noic_pmos_ull_10hv_bsim4       = (8.75)
+    ef_pmos_ull_10hv_bsim4         = (1.1)
+    em_pmos_ull_10hv_bsim4         = (4.1e+7)
+    nom_delr_tox_pmos_ana_10hv_bsim4 = (1)
+    sig_delr_tox_pmos_ana_10hv_bsim4 = (0.012)
+    nom_dela_cd_pmos_ana_10hv_bsim4 = (0)
+    sig_dela_cd_pmos_ana_10hv_bsim4 = (0.215103)
+    nom_dela_vfb_pmos_ana_10hv_bsim4 = (-0.00598195)
+    sig_dela_vfb_pmos_ana_10hv_bsim4 = (0.0122314)
+    nom_delr_ubref_pmos_ana_10hv_bsim4 = (0.987246)
+    sig_delr_ubref_pmos_ana_10hv_bsim4 = (0.0098964)
+    nom_dela_vtl_pmos_ana_10hv_bsim4 = (0.00105105)
+    sig_dela_vtl_pmos_ana_10hv_bsim4 = (0.001638166)
+    nom_dela_od_pmos_ana_10hv_bsim4 = (0.203239)
+    sig_dela_od_pmos_ana_10hv_bsim4 = (0.0867545)
+    nom_dela_vtw_pmos_ana_10hv_bsim4 = (0.0418476)
+    sig_dela_vtw_pmos_ana_10hv_bsim4 = (0.0037493)
+    nom_dela_dwox_pmos_ana_10hv_bsim4 = (0.0581428)
+    sig_dela_dwox_pmos_ana_10hv_bsim4 = (0.089118)
+    nom_dela_vtm_pmos_ana_10hv_bsim4 = (0.00652687)
+    sig_dela_vtm_pmos_ana_10hv_bsim4 = (0.001368923)
+    nom_dela_lwl_pmos_ana_10hv_bsim4 = (-0.000832779)
+    sig_dela_lwl_pmos_ana_10hv_bsim4 = (0.000276651)
+    nom_dela_a0_pmos_ana_10hv_bsim4 = (0.116133)
+    sig_dela_a0_pmos_ana_10hv_bsim4 = (0.086268)
+    nom_dela_wvoff_pmos_ana_10hv_bsim4 = (-0.015)
+    sig_dela_wvoff_pmos_ana_10hv_bsim4 = (0.009)
+    nom_dela_pvoff_pmos_ana_10hv_bsim4 = (0.015)
+    sig_dela_pvoff_pmos_ana_10hv_bsim4 = (0)
+    noia_pmos_ana_10hv_bsim4       = (7.004e+20*100/1.6e-19)
+    noib_pmos_ana_10hv_bsim4       = (1225398*100/1.6e-19)
+    noic_pmos_ana_10hv_bsim4       = (0*2.17e-10*100/1.6e-19)
+    ef_pmos_ana_10hv_bsim4         = (1.0)
+    em_pmos_ana_10hv_bsim4         = (1e+7)
+    nom_delr_tox_psrampu_10hv_bsim3v3 = (1.0)
+    sig_delr_tox_psrampu_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_psrampu_10hv_bsim3v3 = (-0.0176175)
+    sig_dela_dwox_psrampu_10hv_bsim3v3 = (0.00681599)
+    nom_dela_vfb_psrampu_10hv_bsim3v3 = (0.000311316)
+    sig_dela_vfb_psrampu_10hv_bsim3v3 = (0.0145605)
+    nom_delr_ubref_psrampu_10hv_bsim3v3 = (0.989437)
+    sig_delr_ubref_psrampu_10hv_bsim3v3 = (0.0249932)
+    nom_dela_dl_psrampu_10hv_bsim3v3 = (-0.00421792)
+    sig_dela_dl_psrampu_10hv_bsim3v3 = (0.00626072)
+    nom_dela_vtl_psrampu_10hv_bsim3v3 = (0.0104252)
+    sig_dela_vtl_psrampu_10hv_bsim3v3 = (0.0147505)
+    nom_dela_vtw_psrampu_10hv_bsim3v3 = (0.00221633)
+    sig_dela_vtw_psrampu_10hv_bsim3v3 = (0.0255662)
+    nom_dela_vtm_psrampu_10hv_bsim3v3 = (-0.356819)
+    sig_dela_vtm_psrampu_10hv_bsim3v3 = (0.109051)
+    nom_dela_a0_psrampu_10hv_bsim3v3 = (-2.71273)
+    sig_dela_a0_psrampu_10hv_bsim3v3 = (0.130459)
+    nom_dela_wwl_psrampu_10hv_bsim3v3 = (0.00561496)
+    sig_dela_wwl_psrampu_10hv_bsim3v3 = (0.00214605)
+    noimod_psrampu_10hv_bsim3v3    = (2)
+    nom_delr_tox_nmos5_10hv_bsim4  = (1.01939)
+    sig_delr_tox_nmos5_10hv_bsim4  = (0.012)
+    nom_dela_vfb_nmos5_10hv_bsim4  = (0.0252891)
+    sig_dela_vfb_nmos5_10hv_bsim4  = (0.0254744)
+    nom_delr_ubref_nmos5_10hv_bsim4 = (0.994504)
+    sig_delr_ubref_nmos5_10hv_bsim4 = (0.0205606)
+    nom_dela_ags_nmos5_10hv_bsim4  = (-0.00490527)
+    sig_dela_ags_nmos5_10hv_bsim4  = (0.0142446)
+    nom_dela_vtl_nmos5_10hv_bsim4  = (0.0161415)
+    sig_dela_vtl_nmos5_10hv_bsim4  = (0.0230042)
+    nom_dela_dl_nmos5_10hv_bsim4   = (0.289982)
+    sig_dela_dl_nmos5_10hv_bsim4   = (0.338003)
+    nom_delr_vsat_nmos5_10hv_bsim4 = (1.1309)
+    sig_delr_vsat_nmos5_10hv_bsim4 = (0.0172682)
+    nom_delr_pvsat_nmos5_10hv_bsim4 = (0.696822)
+    sig_delr_pvsat_nmos5_10hv_bsim4 = (0.0765093)
+    nom_dela_b0_nmos5_10hv_bsim4   = (0.402659)
+    sig_dela_b0_nmos5_10hv_bsim4   = (0.201967)
+    nom_dela_dwox_nmos5_10hv_bsim4 = (-0.195149)
+    sig_dela_dwox_nmos5_10hv_bsim4 = (0.152844)
+    nom_dela_k3_nmos5_10hv_bsim4   = (-0.344907)
+    sig_dela_k3_nmos5_10hv_bsim4   = (0.0604449)
+    nom_dela_vtm_nmos5_10hv_bsim4  = (-0.00454844)
+    sig_dela_vtm_nmos5_10hv_bsim4  = (0.00423749)
+    nom_dela_pu0_nmos5_10hv_bsim4  = (-0.453869)
+    sig_dela_pu0_nmos5_10hv_bsim4  = (1.32601)
+    nom_dela_jts_nmos5_10hv_bsim4  = (0.0)
+    sig_dela_jts_nmos5_10hv_bsim4  = (1.5)
+    noia_nmos5_10hv_bsim4          = (6.25e+41)
+    noib_nmos5_10hv_bsim4          = (6.25e+24)
+    noic_nmos5_10hv_bsim4          = (1.75e+9)
+    ef_nmos5_10hv_bsim4            = (1)
+    em_nmos5_10hv_bsim4            = (41000000.0)
+    nom_delr_tox_pmos5_10hv_bsim4  = (1.02562)
+    sig_delr_tox_pmos5_10hv_bsim4  = (0.012)
+    nom_dela_vfb_pmos5_10hv_bsim4  = (-0.0215271)
+    sig_dela_vfb_pmos5_10hv_bsim4  = (0.0221956)
+    nom_delr_ubref_pmos5_10hv_bsim4 = (0.994275)
+    sig_delr_ubref_pmos5_10hv_bsim4 = (0.0208537)
+    nom_dela_a0_pmos5_10hv_bsim4   = (-0.0770086)
+    sig_dela_a0_pmos5_10hv_bsim4   = (0.0701294)
+    nom_dela_vtl_pmos5_10hv_bsim4  = (0.0218438)
+    sig_dela_vtl_pmos5_10hv_bsim4  = (0.00877814)
+    nom_dela_dl_pmos5_10hv_bsim4   = (0.0240817)
+    sig_dela_dl_pmos5_10hv_bsim4   = (0.0160138)
+    nom_dela_vsat_pmos5_10hv_bsim4 = (0.716524)
+    sig_dela_vsat_pmos5_10hv_bsim4 = (0.185671)
+    nom_dela_vtw_pmos5_10hv_bsim4  = (0.0102282)
+    sig_dela_vtw_pmos5_10hv_bsim4  = (0.00560587)
+    nom_dela_dwox_pmos5_10hv_bsim4 = (0.038092)
+    sig_dela_dwox_pmos5_10hv_bsim4 = (0.0109816)
+    nom_dela_wags_pmos5_10hv_bsim4 = (0.0138426)
+    sig_dela_wags_pmos5_10hv_bsim4 = (0.00244183)
+    nom_dela_vtm_pmos5_10hv_bsim4  = (0.0135811)
+    sig_dela_vtm_pmos5_10hv_bsim4  = (0.00696227)
+    nom_dela_wwl_pmos5_10hv_bsim4  = (0.310679)
+    sig_dela_wwl_pmos5_10hv_bsim4  = (0.618023)
+    nom_delr_agidl_pmos5_10hv_bsim4 = (1.3)
+    sig_delr_agidl_pmos5_10hv_bsim4 = (0.494247)
+    noia_pmos5_10hv_bsim4          = (6.188e+40*3.2)
+    noib_pmos5_10hv_bsim4          = (1.5e+25)
+    noic_pmos5_10hv_bsim4          = (8.75e+9*0.5)
+    ef_pmos5_10hv_bsim4            = (1.0)
+    em_pmos5_10hv_bsim4            = (41000000)
+    nom_delr_tox_pmos10_10hv_bsim3v3 = (1.0256153846154)
+    sig_delr_tox_pmos10_10hv_bsim3v3 = (0.012)
+    nom_dela_vfb_pmos10_10hv_bsim3v3 = (-0.0264312)
+    sig_dela_vfb_pmos10_10hv_bsim3v3 = (0.020989)
+    nom_delr_ubref_pmos10_10hv_bsim3v3 = (1.01598)
+    sig_delr_ubref_pmos10_10hv_bsim3v3 = (0.0216552)
+    nom_dela_dl_pmos10_10hv_bsim3v3 = (-0.0189997)
+    sig_dela_dl_pmos10_10hv_bsim3v3 = (0.0408561)
+    nom_dela_vtw_pmos10_10hv_bsim3v3 = (0.0110805)
+    sig_dela_vtw_pmos10_10hv_bsim3v3 = (0.00362636)
+    nom_dela_vtm_pmos10_10hv_bsim3v3 = (0.0122233)
+    sig_dela_vtm_pmos10_10hv_bsim3v3 = (0.0181304)
+    nom_dela_a0_pmos10_10hv_bsim3v3 = (-0.0701509)
+    sig_dela_a0_pmos10_10hv_bsim3v3 = (0.071449)
+    nom_dela_lw_pmos10_10hv_bsim3v3 = (-0.361448)
+    sig_dela_lw_pmos10_10hv_bsim3v3 = (0.072847)
+    noimod_pmos10_10hv_bsim3v3     = (2)
+    noia_pmos10_10hv_bsim3v3       = (5.03e+19)
+    noib_pmos10_10hv_bsim3v3       = (95074)
+    noic_pmos10_10hv_bsim3v3       = (3.937e-12)
+    ef_pmos10_10hv_bsim3v3         = (0.961)
+    em_pmos10_10hv_bsim3v3         = (1e+8)
+    nom_delr_tox_pmos45_10hv_bsim3v3 = (1.01084155)
+    sig_delr_tox_pmos45_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_pmos45_10hv_bsim3v3 = (-0.048335)
+    sig_dela_dwox_pmos45_10hv_bsim3v3 = (0.0274813)
+    nom_dela_vfb_pmos45_10hv_bsim3v3 = (-0.0191236)
+    sig_dela_vfb_pmos45_10hv_bsim3v3 = (0.017743)
+    nom_delr_ubref_pmos45_10hv_bsim3v3 = (1.00803)
+    sig_delr_ubref_pmos45_10hv_bsim3v3 = (0.0213932)
+    nom_dela_dl_pmos45_10hv_bsim3v3 = (-0.0437973)
+    sig_dela_dl_pmos45_10hv_bsim3v3 = (0.0234742)
+    nom_dela_vtl_pmos45_10hv_bsim3v3 = (-0.0005042)
+    sig_dela_vtl_pmos45_10hv_bsim3v3 = (0.0330822)
+    nom_dela_vtw_pmos45_10hv_bsim3v3 = (0.0012481)
+    sig_dela_vtw_pmos45_10hv_bsim3v3 = (0.00806273)
+    nom_dela_vtm_pmos45_10hv_bsim3v3 = (-0.0194556)
+    sig_dela_vtm_pmos45_10hv_bsim3v3 = (0.00599874)
+    nom_dela_a0_pmos45_10hv_bsim3v3 = (-0.0561748)
+    sig_dela_a0_pmos45_10hv_bsim3v3 = (0.0473745)
+    nom_dela_b0_pmos45_10hv_bsim3v3 = (-0.0782875)
+    sig_dela_b0_pmos45_10hv_bsim3v3 = (0.0543302)
+    nom_dela_wwl_pmos45_10hv_bsim3v3 = (-0.0142012)
+    sig_dela_wwl_pmos45_10hv_bsim3v3 = (0.0141744)
+    nom_delr_prsh_pmos45_10hv_bsim3v3 = (1.15398)
+    sig_delr_prsh_pmos45_10hv_bsim3v3 = (0.0278506)
+    noimod_pmos45_10hv_bsim3v3     = (2)
+    noia_pmos45_10hv_bsim3v3       = (5.81e+19)
+    noib_pmos45_10hv_bsim3v3       = (97074)
+    noic_pmos45_10hv_bsim3v3       = (3.837e-12)
+    ef_pmos45_10hv_bsim3v3         = (0.961)
+    em_pmos45_10hv_bsim3v3         = (1e+8)
+    nom_delr_tox_pmos45b_10hv_bsim3v3 = (1)
+    sig_delr_tox_pmos45b_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_pmos45b_10hv_bsim3v3 = (0.0234823)
+    sig_dela_dwox_pmos45b_10hv_bsim3v3 = (0.0140889)
+    nom_dela_vfb_pmos45b_10hv_bsim3v3 = (0.00905087)
+    sig_dela_vfb_pmos45b_10hv_bsim3v3 = (0.0179457)
+    nom_delr_ubref_pmos45b_10hv_bsim3v3 = (0.95882)
+    sig_delr_ubref_pmos45b_10hv_bsim3v3 = (0.026167)
+    nom_dela_dl_pmos45b_10hv_bsim3v3 = (0.0435173)
+    sig_dela_dl_pmos45b_10hv_bsim3v3 = (0.0320231)
+    nom_dela_vtl_pmos45b_10hv_bsim3v3 = (-0.00811479)
+    sig_dela_vtl_pmos45b_10hv_bsim3v3 = (0.038072)
+    nom_dela_vtw_pmos45b_10hv_bsim3v3 = (0.00129492)
+    sig_dela_vtw_pmos45b_10hv_bsim3v3 = (0.00816572)
+    nom_dela_vtm_pmos45b_10hv_bsim3v3 = (0.000911434)
+    sig_dela_vtm_pmos45b_10hv_bsim3v3 = (0.009864)
+    nom_dela_a0_pmos45b_10hv_bsim3v3 = (-0.0630082)
+    sig_dela_a0_pmos45b_10hv_bsim3v3 = (0.00730976)
+    nom_dela_b0_pmos45b_10hv_bsim3v3 = (0.160955)
+    sig_dela_b0_pmos45b_10hv_bsim3v3 = (0.0404329)
+    nom_dela_wwl_pmos45b_10hv_bsim3v3 = (-0.060847)
+    sig_dela_wwl_pmos45b_10hv_bsim3v3 = (0.057338)
+    nom_delr_prsh_pmos45b_10hv_bsim3v3 = (1.00103)
+    sig_delr_prsh_pmos45b_10hv_bsim3v3 = (0.0341085)
+    noimod_pmos45b_10hv_bsim3v3    = (2)
+    noia_pmos45b_10hv_bsim3v3      = (5.81e+19)
+    noib_pmos45b_10hv_bsim3v3      = (97074)
+    noic_pmos45b_10hv_bsim3v3      = (3.837e-12)
+    ef_pmos45b_10hv_bsim3v3        = (0.961)
+    em_pmos45b_10hv_bsim3v3        = (1e+8)
+    nom_delr_tox_pmoshs45_10hv_bsim3v3 = (1.01084155)
+    sig_delr_tox_pmoshs45_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_pmoshs45_10hv_bsim3v3 = (-0.0351926)
+    sig_dela_dwox_pmoshs45_10hv_bsim3v3 = (0.0296052)
+    nom_dela_vfb_pmoshs45_10hv_bsim3v3 = (-0.0180924)
+    sig_dela_vfb_pmoshs45_10hv_bsim3v3 = (0.017699)
+    nom_delr_ubref_pmoshs45_10hv_bsim3v3 = (1.00759)
+    sig_delr_ubref_pmoshs45_10hv_bsim3v3 = (0.0213839)
+    nom_dela_dl_pmoshs45_10hv_bsim3v3 = (-0.0450017)
+    sig_dela_dl_pmoshs45_10hv_bsim3v3 = (0.0234439)
+    nom_dela_vtl_pmoshs45_10hv_bsim3v3 = (0.00135332)
+    sig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0.0327884)
+    nom_dela_vtw_pmoshs45_10hv_bsim3v3 = (-0.021226)
+    sig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0.0081612)
+    nom_dela_vtm_pmoshs45_10hv_bsim3v3 = (-0.0231445)
+    sig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.00588631)
+    nom_dela_a0_pmoshs45_10hv_bsim3v3 = (-0.0655395)
+    sig_dela_a0_pmoshs45_10hv_bsim3v3 = (0.04698)
+    nom_dela_wwl_pmoshs45_10hv_bsim3v3 = (-0.012731)
+    sig_dela_wwl_pmoshs45_10hv_bsim3v3 = (0.0140288)
+    nom_delr_prsh_pmoshs45_10hv_bsim3v3 = (1.15469)
+    sig_delr_prsh_pmoshs45_10hv_bsim3v3 = (0.029396)
+    noimod_pmoshs45_10hv_bsim3v3   = (2)
+    noia_pmoshs45_10hv_bsim3v3     = (4.3e+19)
+    noib_pmoshs45_10hv_bsim3v3     = (94074)
+    noic_pmoshs45_10hv_bsim3v3     = (4.37e-12)
+    ef_pmoshs45_10hv_bsim3v3       = (0.93)
+    em_pmoshs45_10hv_bsim3v3       = (1e+7)
+    nom_delr_tox_pmoshs45b_10hv_bsim3v3 = (1.01084155)
+    sig_delr_tox_pmoshs45b_10hv_bsim3v3 = (0.012)
+    nom_dela_dwox_pmoshs45b_10hv_bsim3v3 = (-0.032)
+    sig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0.0296052)
+    nom_dela_vfb_pmoshs45b_10hv_bsim3v3 = (-0.0047)
+    sig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (0.017699)
+    nom_delr_ubref_pmoshs45b_10hv_bsim3v3 = (0.995)
+    sig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (0.0213839)
+    nom_dela_dl_pmoshs45b_10hv_bsim3v3 = (-0.004)
+    sig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0.04)
+    nom_dela_vtl_pmoshs45b_10hv_bsim3v3 = (-0.0125)
+    sig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0.0327884)
+    nom_dela_vtw_pmoshs45b_10hv_bsim3v3 = (-0.0085)
+    sig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0.0081612)
+    nom_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.0225)
+    sig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.00588631)
+    nom_dela_a0_pmoshs45b_10hv_bsim3v3 = (-0.15)
+    sig_dela_a0_pmoshs45b_10hv_bsim3v3 = (0.04698)
+    nom_dela_wwl_pmoshs45b_10hv_bsim3v3 = (-0.045)
+    sig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0.08)
+    nom_delr_prsh_pmoshs45b_10hv_bsim3v3 = (1.15469)
+    sig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (0.029396)
+    noimod_pmoshs45b_10hv_bsim3v3  = (2)
+    noia_pmoshs45b_10hv_bsim3v3    = (4.3e+19)
+    noib_pmoshs45b_10hv_bsim3v3    = (94074)
+    noic_pmoshs45b_10hv_bsim3v3    = (4.37e-12)
+    ef_pmoshs45b_10hv_bsim3v3      = (0.93)
+    em_pmoshs45b_10hv_bsim3v3      = (1e+7)
+    nom_delr_tox_pmos90_10hv_bsim3v3 = (1)
+    sig_delr_tox_pmos90_10hv_bsim3v3 = (0.01)
+    nom_dela_dwox_pmos90_10hv_bsim3v3 = (-1.19539)
+    sig_dela_dwox_pmos90_10hv_bsim3v3 = (0.0636852)
+    nom_dela_vfb_pmos90_10hv_bsim3v3 = (-0.00374892)
+    sig_dela_vfb_pmos90_10hv_bsim3v3 = (0.022687)
+    nom_delr_ubref_pmos90_10hv_bsim3v3 = (1.06375)
+    sig_delr_ubref_pmos90_10hv_bsim3v3 = (0.024107)
+    nom_dela_dl_pmos90_10hv_bsim3v3 = (0.0830403)
+    sig_dela_dl_pmos90_10hv_bsim3v3 = (0.15424)
+    nom_dela_vtl_pmos90_10hv_bsim3v3 = (-0.0130428)
+    sig_dela_vtl_pmos90_10hv_bsim3v3 = (0.0978676)
+    nom_dela_vtw_pmos90_10hv_bsim3v3 = (0.10541)
+    sig_dela_vtw_pmos90_10hv_bsim3v3 = (0.0262434)
+    nom_dela_vtm_pmos90_10hv_bsim3v3 = (0.146917)
+    sig_dela_vtm_pmos90_10hv_bsim3v3 = (0.10785)
+    nom_dela_a0_pmos90_10hv_bsim3v3 = (0.124796)
+    sig_dela_a0_pmos90_10hv_bsim3v3 = (0.0583924)
+    nom_dela_b0_pmos90_10hv_bsim3v3 = (-2.6414)
+    sig_dela_b0_pmos90_10hv_bsim3v3 = (0.26956)
+    nom_dela_wwl_pmos90_10hv_bsim3v3 = (-0.111823)
+    sig_dela_wwl_pmos90_10hv_bsim3v3 = (0.0337595)
+    noimod_pmos90_10hv_bsim3v3     = (2)
+    noia_pmos90_10hv_bsim3v3       = (5.03e+19)
+    noib_pmos90_10hv_bsim3v3       = (94074)
+    noic_pmos90_10hv_bsim3v3       = (1.137e-11)
+    ef_pmos90_10hv_bsim3v3         = (0.921)
+    em_pmos90_10hv_bsim3v3         = (1e+8)
+    nom_delr_tox_pmos90b_10hv_bsim3v3 = (1)
+    sig_delr_tox_pmos90b_10hv_bsim3v3 = (0.01*1.2)
+    nom_dela_dwox_pmos90b_10hv_bsim3v3 = (-1.19539)
+    sig_dela_dwox_pmos90b_10hv_bsim3v3 = (0.0636852*1.5)
+    nom_dela_vfb_pmos90b_10hv_bsim3v3 = (-0.00374892)
+    sig_dela_vfb_pmos90b_10hv_bsim3v3 = (0.022687*1.5)
+    nom_delr_ubref_pmos90b_10hv_bsim3v3 = (1.06375)
+    sig_delr_ubref_pmos90b_10hv_bsim3v3 = (0.024107*1.5)
+    nom_dela_dl_pmos90b_10hv_bsim3v3 = (0.0830403)
+    sig_dela_dl_pmos90b_10hv_bsim3v3 = (0.15424*1.5)
+    nom_dela_vtl_pmos90b_10hv_bsim3v3 = (-0.0130428)
+    sig_dela_vtl_pmos90b_10hv_bsim3v3 = (0.0978676*1.5)
+    nom_dela_vtw_pmos90b_10hv_bsim3v3 = (0.10541)
+    sig_dela_vtw_pmos90b_10hv_bsim3v3 = (0.0262434*1.5)
+    nom_dela_vtm_pmos90b_10hv_bsim3v3 = (0.146917)
+    sig_dela_vtm_pmos90b_10hv_bsim3v3 = (0.10785*1.5)
+    nom_dela_a0_pmos90b_10hv_bsim3v3 = (0.124796)
+    sig_dela_a0_pmos90b_10hv_bsim3v3 = (0.0583924*1.5)
+    nom_dela_b0_pmos90b_10hv_bsim3v3 = (-2.6414)
+    sig_dela_b0_pmos90b_10hv_bsim3v3 = (0.26956*1.5)
+    nom_dela_wwl_pmos90b_10hv_bsim3v3 = (-0.111823)
+    sig_dela_wwl_pmos90b_10hv_bsim3v3 = (0.0337595*1.5)
+    noimod_pmos90b_10hv_bsim3v3    = (2)
+    noia_pmos90b_10hv_bsim3v3      = (5.03e+19)
+    noib_pmos90b_10hv_bsim3v3      = (94074)
+    noic_pmos90b_10hv_bsim3v3      = (1.137e-11)
+    ef_pmos90b_10hv_bsim3v3        = (0.921)
+    em_pmos90b_10hv_bsim3v3        = (1e+8)
+    nom_acj0_junc_psd_nw           = (1.395e-15)
+    nom_delr_acj0_junc_psd_nw      = (1)
+    sig_delr_acj0_junc_psd_nw      = (0.0333)
+    aphi_junc_psd_nw               = (0.879285)
+    pta_junc_psd_nw                = (1.357e-03)
+    aexm_junc_psd_nw               = (0.398591)
+    nom_ajs_junc_psd_nw            = (7.07393e-20)
+    nom_delr_ajs_junc_psd_nw       = (1)
+    sig_delr_ajs_junc_psd_nw       = (0.0333)
+    ajnd_junc_psd_nw               = (1.01151)
+    aeg_junc_psd_nw                = (1.188)
+    aalphaeg_junc_psd_nw           = (459.6e-06)
+    abetaeg_junc_psd_nw            = (601.5)
+    axti_junc_psd_nw               = (-0.1)
+    nom_pcj0_junc_psd_nw           = (9.40343e-17)
+    nom_delr_pcj0_junc_psd_nw      = (1)
+    sig_delr_pcj0_junc_psd_nw      = (0.0333)
+    ptp_junc_psd_nw                = (2.6207e-03)
+    pphi_junc_psd_nw               = (0.5)
+    pexm_junc_psd_nw               = (0.195259)
+    nom_pjs_junc_psd_nw            = (2.78723e-20)
+    nom_delr_pjs_junc_psd_nw       = (1)
+    sig_delr_pjs_junc_psd_nw       = (0.0333)
+    pjnd_junc_psd_nw               = (1.02766)
+    peg_junc_psd_nw                = (1.188)
+    palphaeg_junc_psd_nw           = (459.6e-06)
+    pbetaeg_junc_psd_nw            = (601.5)
+    pxti_junc_psd_nw               = (-0.1)
+    nom_acj0_junc_nsd_pw           = (1.29537e-15)
+    nom_delr_acj0_junc_nsd_pw      = (1)
+    sig_delr_acj0_junc_nsd_pw      = (0.0333)
+    aphi_junc_nsd_pw               = (0.816997)
+    pta_junc_nsd_pw                = (1.5646e-03)
+    aexm_junc_nsd_pw               = (0.401709)
+    nom_ajs_junc_nsd_pw            = (8.51633e-20)
+    nom_delr_ajs_junc_nsd_pw       = (1)
+    sig_delr_ajs_junc_nsd_pw       = (0.0333)
+    ajnd_junc_nsd_pw               = (1.01661)
+    aeg_junc_nsd_pw                = (1.188)
+    aalphaeg_junc_nsd_pw           = (459.6e-06)
+    abetaeg_junc_nsd_pw            = (601.5)
+    axti_junc_nsd_pw               = (-0.1)
+    nom_pcj0_junc_nsd_pw           = (5.73297e-17)
+    nom_delr_pcj0_junc_nsd_pw      = (1)
+    sig_delr_pcj0_junc_nsd_pw      = (0.0333)
+    ptp_junc_nsd_pw                = (2.6145e-03)
+    pphi_junc_nsd_pw               = (0.501869)
+    pexm_junc_nsd_pw               = (0.5)
+    nom_pjs_junc_nsd_pw            = (1.34864e-19)
+    nom_delr_pjs_junc_nsd_pw       = (1)
+    sig_delr_pjs_junc_nsd_pw       = (0.0333)
+    pjnd_junc_nsd_pw               = (1.08807)
+    peg_junc_nsd_pw                = (1.188)
+    palphaeg_junc_nsd_pw           = (459.6e-06)
+    pbetaeg_junc_nsd_pw            = (601.5)
+    pxti_junc_nsd_pw               = (-0.1)
+    nom_acj0_junc_psd_nhv          = (9.59617e-16)
+    nom_delr_acj0_junc_psd_nhv     = (1)
+    sig_delr_acj0_junc_psd_nhv     = (0.0333)
+    aphi_junc_psd_nhv              = (0.878291)
+    pta_junc_psd_nhv               = (1.3603e-03)
+    aexm_junc_psd_nhv              = (0.413719)
+    nom_ajs_junc_psd_nhv           = (1.48259e-19)
+    nom_delr_ajs_junc_psd_nhv      = (1)
+    sig_delr_ajs_junc_psd_nhv      = (0.0333)
+    ajnd_junc_psd_nhv              = (1.0344)
+    aeg_junc_psd_nhv               = (1.188)
+    aalphaeg_junc_psd_nhv          = (459.6e-06)
+    abetaeg_junc_psd_nhv           = (601.5)
+    axti_junc_psd_nhv              = (0.05)
+    nom_pcj0_junc_psd_nhv          = (1.0795e-16)
+    nom_delr_pcj0_junc_psd_nhv     = (1)
+    sig_delr_pcj0_junc_psd_nhv     = (0.0333)
+    ptp_junc_psd_nhv               = (1.9564e-03)
+    pphi_junc_psd_nhv              = (0.699385)
+    pexm_junc_psd_nhv              = (0.1)
+    nom_pjs_junc_psd_nhv           = (1.09397e-19)
+    nom_delr_pjs_junc_psd_nhv      = (1)
+    sig_delr_pjs_junc_psd_nhv      = (0.0333)
+    pjnd_junc_psd_nhv              = (1.05511)
+    peg_junc_psd_nhv               = (1.188)
+    palphaeg_junc_psd_nhv          = (459.6e-06)
+    pbetaeg_junc_psd_nhv           = (601.5)
+    pxti_junc_psd_nhv              = (0.05)
+    nom_acj0_junc_nsd_phv          = (8.29578e-16)
+    nom_delr_acj0_junc_nsd_phv     = (1)
+    sig_delr_acj0_junc_nsd_phv     = (0.0333)
+    aphi_junc_nsd_phv              = (0.69842)
+    pta_junc_nsd_phv               = (1.9596e-03)
+    aexm_junc_nsd_phv              = (0.318993)
+    nom_ajs_junc_nsd_phv           = (1.31178e-19)
+    nom_delr_ajs_junc_nsd_phv      = (1)
+    sig_delr_ajs_junc_nsd_phv      = (0.0333)
+    ajnd_junc_nsd_phv              = (1.03521)
+    aeg_junc_nsd_phv               = (1.188)
+    aalphaeg_junc_nsd_phv          = (459.6e-06)
+    abetaeg_junc_nsd_phv           = (601.5)
+    axti_junc_nsd_phv              = (0.24)
+    nom_pcj0_junc_nsd_phv          = (1.19233e-16)
+    nom_delr_pcj0_junc_nsd_phv     = (1)
+    sig_delr_pcj0_junc_nsd_phv     = (0.0333)
+    ptp_junc_nsd_phv               = (2.6207e-03)
+    pphi_junc_nsd_phv              = (0.5)
+    pexm_junc_nsd_phv              = (0.102469)
+    nom_pjs_junc_nsd_phv           = (3.70713e-19)
+    nom_delr_pjs_junc_nsd_phv      = (1)
+    sig_delr_pjs_junc_nsd_phv      = (0.0333)
+    pjnd_junc_nsd_phv              = (1.09863902)
+    peg_junc_nsd_phv               = (1.188)
+    palphaeg_junc_nsd_phv          = (459.6e-06)
+    pbetaeg_junc_nsd_phv           = (601.5)
+    pxti_junc_nsd_phv              = (0.24)
+    nom_acj0_junc_pepi_nbl         = (1.32491e-16)
+    nom_delr_acj0_junc_pepi_nbl    = (1)
+    sig_delr_acj0_junc_pepi_nbl    = (0.0333)
+    aphi_junc_pepi_nbl             = (0.62496)
+    pta_junc_pepi_nbl              = (2.2044e-03)
+    aexm_junc_pepi_nbl             = (0.453952)
+    nom_ajs_junc_pepi_nbl          = (6.10005e-20)
+    nom_delr_ajs_junc_pepi_nbl     = (1)
+    sig_delr_ajs_junc_pepi_nbl     = (0.0333)
+    ajnd_junc_pepi_nbl             = (1.17237)
+    aeg_junc_pepi_nbl              = (1.188)
+    aalphaeg_junc_pepi_nbl         = (459.6e-06)
+    abetaeg_junc_pepi_nbl          = (601.5)
+    axti_junc_pepi_nbl             = (0.5)
+    nom_pcj0_junc_pepi_nbl         = (3.43247e-16)
+    nom_delr_pcj0_junc_pepi_nbl    = (1)
+    sig_delr_pcj0_junc_pepi_nbl    = (0.0333)
+    ptp_junc_pepi_nbl              = (2.6207e-03)
+    pphi_junc_pepi_nbl             = (0.5)
+    pexm_junc_pepi_nbl             = (0.5)
+    nom_pjs_junc_pepi_nbl          = (1.07666e-18)
+    nom_delr_pjs_junc_pepi_nbl     = (1)
+    sig_delr_pjs_junc_pepi_nbl     = (0.0333)
+    pjnd_junc_pepi_nbl             = (1.17237)
+    peg_junc_pepi_nbl              = (1.188)
+    palphaeg_junc_pepi_nbl         = (459.6e-06)
+    pbetaeg_junc_pepi_nbl          = (601.5)
+    pxti_junc_pepi_nbl             = (0.5)
+    nom_acj0_junc_nw_pepi          = (1.08021e-16)
+    nom_delr_acj0_junc_nw_pepi     = (1)
+    sig_delr_acj0_junc_nw_pepi     = (0.0333)
+    aphi_junc_nw_pepi              = (0.810755)
+    pta_junc_nw_pepi               = (1.5853e-03)
+    aexm_junc_nw_pepi              = (0.5)
+    nom_ajs_junc_nw_pepi           = (4.44e-20)
+    nom_delr_ajs_junc_nw_pepi      = (1)
+    sig_delr_ajs_junc_nw_pepi      = (0.0333)
+    ajnd_junc_nw_pepi              = (1.05008)
+    aeg_junc_nw_pepi               = (1.188)
+    aalphaeg_junc_nw_pepi          = (459.6e-06)
+    abetaeg_junc_nw_pepi           = (601.5)
+    axti_junc_nw_pepi              = (0.5)
+    nom_pcj0_junc_nw_pepi          = (1.27749e-15)
+    nom_delr_pcj0_junc_nw_pepi     = (1)
+    sig_delr_pcj0_junc_nw_pepi     = (0.0333)
+    ptp_junc_nw_pepi               = (2.2503e-03)
+    pphi_junc_nw_pepi              = (0.611175)
+    pexm_junc_nw_pepi              = (0.349397)
+    nom_pjs_junc_nw_pepi           = (2.25459e-19)
+    nom_delr_pjs_junc_nw_pepi      = (1)
+    sig_delr_pjs_junc_nw_pepi      = (0.0333)
+    pjnd_junc_nw_pepi              = (1.05709)
+    peg_junc_nw_pepi               = (1.188)
+    palphaeg_junc_nw_pepi          = (459.6e-06)
+    pbetaeg_junc_nw_pepi           = (601.5)
+    pxti_junc_nw_pepi              = (0.5)
+    nom_acj0_junc_nw_pepi_tr       = (1.08022e-16)
+    nom_delr_acj0_junc_nw_pepi_tr  = (1)
+    sig_delr_acj0_junc_nw_pepi_tr  = (0.0333)
+    aphi_junc_nw_pepi_tr           = (0.5)
+    pta_junc_nw_pepi_tr            = (2.6207e-03)
+    aexm_junc_nw_pepi_tr           = (0.5)
+    nom_ajs_junc_nw_pepi_tr        = (1.06116e-19)
+    nom_delr_ajs_junc_nw_pepi_tr   = (1)
+    sig_delr_ajs_junc_nw_pepi_tr   = (0.0333)
+    ajnd_junc_nw_pepi_tr           = (1.1)
+    aeg_junc_nw_pepi_tr            = (1.188)
+    aalphaeg_junc_nw_pepi_tr       = (459.6e-06)
+    abetaeg_junc_nw_pepi_tr        = (601.5)
+    axti_junc_nw_pepi_tr           = (0.24)
+    nom_pcj0_junc_nw_pepi_tr       = (8.32892e-16)
+    nom_delr_pcj0_junc_nw_pepi_tr  = (1)
+    sig_delr_pcj0_junc_nw_pepi_tr  = (0.0333)
+    ptp_junc_nw_pepi_tr            = (2.6207e-03)
+    pphi_junc_nw_pepi_tr           = (0.5)
+    pexm_junc_nw_pepi_tr           = (0.5)
+    nom_pjs_junc_nw_pepi_tr        = (1.0402e-19)
+    nom_delr_pjs_junc_nw_pepi_tr   = (1)
+    sig_delr_pjs_junc_nw_pepi_tr   = (0.0333)
+    pjnd_junc_nw_pepi_tr           = (1.1)
+    peg_junc_nw_pepi_tr            = (1.188)
+    palphaeg_junc_nw_pepi_tr       = (459.6e-06)
+    pbetaeg_junc_nw_pepi_tr        = (601.5)
+    pxti_junc_nw_pepi_tr           = (0.24)
+    nom_acj0_junc_nhv_pepi_tr      = (1.13276e-16)
+    nom_delr_acj0_junc_nhv_pepi_tr = (1)
+    sig_delr_acj0_junc_nhv_pepi_tr = (0.0333)
+    aphi_junc_nhv_pepi_tr          = (0.5)
+    pta_junc_nhv_pepi_tr           = (2.6207e-03)
+    aexm_junc_nhv_pepi_tr          = (0.5)
+    nom_ajs_junc_nhv_pepi_tr       = (8.85036e-20)
+    nom_delr_ajs_junc_nhv_pepi_tr  = (1)
+    sig_delr_ajs_junc_nhv_pepi_tr  = (0.0333)
+    ajnd_junc_nhv_pepi_tr          = (1.06879)
+    aeg_junc_nhv_pepi_tr           = (1.188)
+    aalphaeg_junc_nhv_pepi_tr      = (459.6e-06)
+    abetaeg_junc_nhv_pepi_tr       = (601.5)
+    axti_junc_nhv_pepi_tr          = (0.24)
+    nom_pcj0_junc_nhv_pepi_tr      = (2.16077e-16)
+    nom_delr_pcj0_junc_nhv_pepi_tr = (1)
+    sig_delr_pcj0_junc_nhv_pepi_tr = (0.0333)
+    ptp_junc_nhv_pepi_tr           = (2.6207e-03)
+    pphi_junc_nhv_pepi_tr          = (0.5)
+    pexm_junc_nhv_pepi_tr          = (0.5)
+    nom_pjs_junc_nhv_pepi_tr       = (1e-23)
+    nom_delr_pjs_junc_nhv_pepi_tr  = (1)
+    sig_delr_pjs_junc_nhv_pepi_tr  = (0.0333)
+    pjnd_junc_nhv_pepi_tr          = (1.1)
+    peg_junc_nhv_pepi_tr           = (1.188)
+    palphaeg_junc_nhv_pepi_tr      = (459.6e-06)
+    pbetaeg_junc_nhv_pepi_tr       = (601.5)
+    pxti_junc_nhv_pepi_tr          = (0.24)
+    nom_acj0_junc_nbl_pepi_tr      = (1.32491e-16)
+    nom_delr_acj0_junc_nbl_pepi_tr = (1)
+    sig_delr_acj0_junc_nbl_pepi_tr = (0.0333)
+    aphi_junc_nbl_pepi_tr          = (0.62496)
+    pta_junc_nbl_pepi_tr           = (2.2044e-03)
+    aexm_junc_nbl_pepi_tr          = (0.453952)
+    nom_ajs_junc_nbl_pepi_tr       = (6.10005e-20)
+    nom_delr_ajs_junc_nbl_pepi_tr  = (1)
+    sig_delr_ajs_junc_nbl_pepi_tr  = (0.0333)
+    ajnd_junc_nbl_pepi_tr          = (1.17237)
+    aeg_junc_nbl_pepi_tr           = (1.188)
+    aalphaeg_junc_nbl_pepi_tr      = (459.6e-06)
+    abetaeg_junc_nbl_pepi_tr       = (601.5)
+    axti_junc_nbl_pepi_tr          = (0.5)
+    nom_pcj0_junc_nbl_pepi_tr      = (8.32892e-16)
+    nom_delr_pcj0_junc_nbl_pepi_tr = (1)
+    sig_delr_pcj0_junc_nbl_pepi_tr = (0.0333)
+    ptp_junc_nbl_pepi_tr           = (2.6207e-03)
+    pphi_junc_nbl_pepi_tr          = (0.5)
+    pexm_junc_nbl_pepi_tr          = (0.5)
+    nom_pjs_junc_nbl_pepi_tr       = (1.0402e-19)
+    nom_delr_pjs_junc_nbl_pepi_tr  = (1)
+    sig_delr_pjs_junc_nbl_pepi_tr  = (0.0333)
+    pjnd_junc_nbl_pepi_tr          = (1.1)
+    peg_junc_nbl_pepi_tr           = (1.188)
+    palphaeg_junc_nbl_pepi_tr      = (459.6e-06)
+    pbetaeg_junc_nbl_pepi_tr       = (601.5)
+    pxti_junc_nbl_pepi_tr          = (0.24)
+    nom_acj0_junc_nmos_sd_body     = (1.29889e-15)
+    nom_delr_acj0_junc_nmos_sd_body = (1)
+    sig_delr_acj0_junc_nmos_sd_body = (0.0333)
+    aphi_junc_nmos_sd_body         = (0.9)
+    pta_junc_nmos_sd_body          = (1.288e-03)
+    aexm_junc_nmos_sd_body         = (0.43)
+    nom_ajs_junc_nmos_sd_body      = (6.71375e-20)
+    nom_delr_ajs_junc_nmos_sd_body = (1)
+    sig_delr_ajs_junc_nmos_sd_body = (0.0333)
+    ajnd_junc_nmos_sd_body         = (1.01749)
+    aeg_junc_nmos_sd_body          = (1.188)
+    aalphaeg_junc_nmos_sd_body     = (459.6e-06)
+    abetaeg_junc_nmos_sd_body      = (601.5)
+    axti_junc_nmos_sd_body         = (2.342)
+    nom_pcj0_junc_nmos_sd_body     = (1.04559e-16)
+    nom_delr_pcj0_junc_nmos_sd_body = (1)
+    sig_delr_pcj0_junc_nmos_sd_body = (0.0333)
+    ptp_junc_nmos_sd_body          = (1.288e-03)
+    pphi_junc_nmos_sd_body         = (0.9)
+    pexm_junc_nmos_sd_body         = (0.4)
+    nom_pjs_junc_nmos_sd_body      = (2.07546e-19)
+    nom_delr_pjs_junc_nmos_sd_body = (1)
+    sig_delr_pjs_junc_nmos_sd_body = (0.0333)
+    pjnd_junc_nmos_sd_body         = (1.1)
+    peg_junc_nmos_sd_body          = (1.188)
+    palphaeg_junc_nmos_sd_body     = (459.6e-06)
+    pbetaeg_junc_nmos_sd_body      = (601.5)
+    pxti_junc_nmos_sd_body         = (2.342)
+    nom_chcj0_junc_nmos_sd_body    = (1.85581e-16)
+    nom_delr_chcj0_junc_nmos_sd_body = (1)
+    sig_delr_chcj0_junc_nmos_sd_body = (0.0333)
+    chphi_junc_nmos_sd_body        = (0.9)
+    chexm_junc_nmos_sd_body        = (0.7)
+    nom_chjs_junc_nmos_sd_body     = (5.39018e-21)
+    nom_delr_chjs_junc_nmos_sd_body = (1)
+    sig_delr_chjs_junc_nmos_sd_body = (0.0333)
+    chjnd_junc_nmos_sd_body        = (1.08317)
+    nom_acj0_junc_nmos_ll_sd_body  = (1.61e-15)
+    nom_delr_acj0_junc_nmos_ll_sd_body = (1)
+    sig_delr_acj0_junc_nmos_ll_sd_body = (0.0333)
+    aphi_junc_nmos_ll_sd_body      = (0.9)
+    pta_junc_nmos_ll_sd_body       = (1.288e-03)
+    aexm_junc_nmos_ll_sd_body      = (0.395)
+    nom_ajs_junc_nmos_ll_sd_body   = (8.0e-20)
+    nom_delr_ajs_junc_nmos_ll_sd_body = (1)
+    sig_delr_ajs_junc_nmos_ll_sd_body = (0.06)
+    ajnd_junc_nmos_ll_sd_body      = (1.01)
+    aeg_junc_nmos_ll_sd_body       = (1.188)
+    aalphaeg_junc_nmos_ll_sd_body  = (459.6e-06)
+    abetaeg_junc_nmos_ll_sd_body   = (601.5)
+    axti_junc_nmos_ll_sd_body      = (2.342)
+    nom_pcj0_junc_nmos_ll_sd_body  = (1.96e-16)
+    nom_delr_pcj0_junc_nmos_ll_sd_body = (1)
+    sig_delr_pcj0_junc_nmos_ll_sd_body = (0.0333)
+    ptp_junc_nmos_ll_sd_body       = (1.288e-03)
+    pphi_junc_nmos_ll_sd_body      = (0.9)
+    pexm_junc_nmos_ll_sd_body      = (0.245)
+    nom_pjs_junc_nmos_ll_sd_body   = (7.0e-20)
+    nom_delr_pjs_junc_nmos_ll_sd_body = (1)
+    sig_delr_pjs_junc_nmos_ll_sd_body = (0.06)
+    pjnd_junc_nmos_ll_sd_body      = (1.1)
+    peg_junc_nmos_ll_sd_body       = (1.188)
+    palphaeg_junc_nmos_ll_sd_body  = (459.6e-06)
+    pbetaeg_junc_nmos_ll_sd_body   = (601.5)
+    pxti_junc_nmos_ll_sd_body      = (2.342)
+    nom_chcj0_junc_nmos_ll_sd_body = (2.82e-16)
+    nom_delr_chcj0_junc_nmos_ll_sd_body = (1)
+    sig_delr_chcj0_junc_nmos_ll_sd_body = (0.0333)
+    chphi_junc_nmos_ll_sd_body     = (0.9)
+    chexm_junc_nmos_ll_sd_body     = (0.55)
+    nom_chjs_junc_nmos_ll_sd_body  = (1.0e-20)
+    nom_delr_chjs_junc_nmos_ll_sd_body = (1)
+    sig_delr_chjs_junc_nmos_ll_sd_body = (0.06)
+    chjnd_junc_nmos_ll_sd_body     = (1.08317)
+    nom_acj0_junc_nmos_ull_sd_body = (1.894417559626685e-15)
+    nom_delr_acj0_junc_nmos_ull_sd_body = (1)
+    sig_delr_acj0_junc_nmos_ull_sd_body = (0.0333)
+    aphi_junc_nmos_ull_sd_body     = (0.85)
+    pta_junc_nmos_ull_sd_body      = (1.288e-03)
+    aexm_junc_nmos_ull_sd_body     = (0.395)
+    nom_ajs_junc_nmos_ull_sd_body  = (8.0e-20)
+    nom_delr_ajs_junc_nmos_ull_sd_body = (1)
+    sig_delr_ajs_junc_nmos_ull_sd_body = (0.06)
+    ajnd_junc_nmos_ull_sd_body     = (1.01)
+    aeg_junc_nmos_ull_sd_body      = (1.188)
+    aalphaeg_junc_nmos_ull_sd_body = (459.6e-06)
+    abetaeg_junc_nmos_ull_sd_body  = (601.5)
+    axti_junc_nmos_ull_sd_body     = (2.342)
+    nom_pcj0_junc_nmos_ull_sd_body = (0.6416666666666667e-16)
+    nom_delr_pcj0_junc_nmos_ull_sd_body = (1)
+    sig_delr_pcj0_junc_nmos_ull_sd_body = (0.0333)
+    ptp_junc_nmos_ull_sd_body      = (1.288e-03)
+    pphi_junc_nmos_ull_sd_body     = (0.9)
+    pexm_junc_nmos_ull_sd_body     = (0.245)
+    nom_pjs_junc_nmos_ull_sd_body  = (7e-20)
+    nom_delr_pjs_junc_nmos_ull_sd_body = (1)
+    sig_delr_pjs_junc_nmos_ull_sd_body = (0.06)
+    pjnd_junc_nmos_ull_sd_body     = (1.1)
+    peg_junc_nmos_ull_sd_body      = (1.188)
+    palphaeg_junc_nmos_ull_sd_body = (459.6e-06)
+    pbetaeg_junc_nmos_ull_sd_body  = (601.5)
+    pxti_junc_nmos_ull_sd_body     = (2.342)
+    nom_chcj0_junc_nmos_ull_sd_body = (2.296e-16)
+    nom_delr_chcj0_junc_nmos_ull_sd_body = (1)
+    sig_delr_chcj0_junc_nmos_ull_sd_body = (0.0333)
+    chphi_junc_nmos_ull_sd_body    = (0.97)
+    chexm_junc_nmos_ull_sd_body    = (0.55)
+    nom_chjs_junc_nmos_ull_sd_body = (1.0e-20)
+    nom_delr_chjs_junc_nmos_ull_sd_body = (1)
+    sig_delr_chjs_junc_nmos_ull_sd_body = (0.06)
+    chjnd_junc_nmos_ull_sd_body    = (1.08317)
+    nom_acj0_junc_nmos_ana_sd_body = (2e-15/2)
+    nom_delr_acj0_junc_nmos_ana_sd_body = (1)
+    sig_delr_acj0_junc_nmos_ana_sd_body = (0.0333)
+    aphi_junc_nmos_ana_sd_body     = (0.7102)
+    pta_junc_nmos_ana_sd_body      = (2.0003e-03)
+    aexm_junc_nmos_ana_sd_body     = (0.3175)
+    nom_ajs_junc_nmos_ana_sd_body  = (1.1e-19)
+    nom_delr_ajs_junc_nmos_ana_sd_body = (1)
+    sig_delr_ajs_junc_nmos_ana_sd_body = (0.0333)
+    ajnd_junc_nmos_ana_sd_body     = (1.04)
+    aeg_junc_nmos_ana_sd_body      = (1.188)
+    aalphaeg_junc_nmos_ana_sd_body = (459.6e-06)
+    abetaeg_junc_nmos_ana_sd_body  = (601.5)
+    axti_junc_nmos_ana_sd_body     = (2.342)
+    nom_pcj0_junc_nmos_ana_sd_body = (2.23e-16/2)
+    nom_delr_pcj0_junc_nmos_ana_sd_body = (1)
+    sig_delr_pcj0_junc_nmos_ana_sd_body = (0.0333)
+    ptp_junc_nmos_ana_sd_body      = (2.6207e-03)
+    pphi_junc_nmos_ana_sd_body     = (0.3754)
+    pexm_junc_nmos_ana_sd_body     = (0.1861)
+    nom_pjs_junc_nmos_ana_sd_body  = (1.1e-19)
+    nom_delr_pjs_junc_nmos_ana_sd_body = (1)
+    sig_delr_pjs_junc_nmos_ana_sd_body = (0.0333)
+    pjnd_junc_nmos_ana_sd_body     = (1.04344)
+    peg_junc_nmos_ana_sd_body      = (1.188)
+    palphaeg_junc_nmos_ana_sd_body = (459.6e-06)
+    pbetaeg_junc_nmos_ana_sd_body  = (601.5)
+    pxti_junc_nmos_ana_sd_body     = (2.342)
+    nom_chcj0_junc_nmos_ana_sd_body = (5.3e-16/2)
+    nom_delr_chcj0_junc_nmos_ana_sd_body = (1)
+    sig_delr_chcj0_junc_nmos_ana_sd_body = (0.0333)
+    chphi_junc_nmos_ana_sd_body    = (0.7808)
+    chexm_junc_nmos_ana_sd_body    = (0.3752)
+    nom_chjs_junc_nmos_ana_sd_body = (5e-20)
+    nom_delr_chjs_junc_nmos_ana_sd_body = (1)
+    sig_delr_chjs_junc_nmos_ana_sd_body = (0.0333)
+    chjnd_junc_nmos_ana_sd_body    = (1.04344)
+    nom_acj0_junc_nsrampg_sd_body  = (1.29889e-15)
+    nom_delr_acj0_junc_nsrampg_sd_body = (1)
+    sig_delr_acj0_junc_nsrampg_sd_body = (0.0333)
+    aphi_junc_nsrampg_sd_body      = (0.9)
+    pta_junc_nsrampg_sd_body       = (1.288e-03)
+    aexm_junc_nsrampg_sd_body      = (0.43)
+    nom_ajs_junc_nsrampg_sd_body   = (6.71375e-20)
+    nom_delr_ajs_junc_nsrampg_sd_body = (1)
+    sig_delr_ajs_junc_nsrampg_sd_body = (0.0333)
+    ajnd_junc_nsrampg_sd_body      = (1.01749)
+    aeg_junc_nsrampg_sd_body       = (1.188)
+    aalphaeg_junc_nsrampg_sd_body  = (459.6e-06)
+    abetaeg_junc_nsrampg_sd_body   = (601.5)
+    axti_junc_nsrampg_sd_body      = (2.342)
+    nom_pcj0_junc_nsrampg_sd_body  = (1.04559e-16)
+    nom_delr_pcj0_junc_nsrampg_sd_body = (1)
+    sig_delr_pcj0_junc_nsrampg_sd_body = (0.0333)
+    ptp_junc_nsrampg_sd_body       = (1.288e-03)
+    pphi_junc_nsrampg_sd_body      = (0.9)
+    pexm_junc_nsrampg_sd_body      = (0.4)
+    nom_pjs_junc_nsrampg_sd_body   = (2.07546e-19)
+    nom_delr_pjs_junc_nsrampg_sd_body = (1)
+    sig_delr_pjs_junc_nsrampg_sd_body = (0.0333)
+    pjnd_junc_nsrampg_sd_body      = (1.1)
+    peg_junc_nsrampg_sd_body       = (1.188)
+    palphaeg_junc_nsrampg_sd_body  = (459.6e-06)
+    pbetaeg_junc_nsrampg_sd_body   = (601.5)
+    pxti_junc_nsrampg_sd_body      = (2.342)
+    nom_chcj0_junc_nsrampg_sd_body = (1.85581e-16)
+    nom_delr_chcj0_junc_nsrampg_sd_body = (1)
+    sig_delr_chcj0_junc_nsrampg_sd_body = (0.0333)
+    chphi_junc_nsrampg_sd_body     = (0.9)
+    chexm_junc_nsrampg_sd_body     = (0.7)
+    nom_chjs_junc_nsrampg_sd_body  = (5.39018e-21)
+    nom_delr_chjs_junc_nsrampg_sd_body = (1)
+    sig_delr_chjs_junc_nsrampg_sd_body = (0.0333)
+    chjnd_junc_nsrampg_sd_body     = (1.08317)
+    nom_acj0_junc_nsrampd_sd_body  = (1.29889e-15)
+    nom_delr_acj0_junc_nsrampd_sd_body = (1)
+    sig_delr_acj0_junc_nsrampd_sd_body = (0.0333)
+    aphi_junc_nsrampd_sd_body      = (0.9)
+    pta_junc_nsrampd_sd_body       = (1.288e-03)
+    aexm_junc_nsrampd_sd_body      = (0.43)
+    nom_ajs_junc_nsrampd_sd_body   = (6.71375e-20)
+    nom_delr_ajs_junc_nsrampd_sd_body = (1)
+    sig_delr_ajs_junc_nsrampd_sd_body = (0.0333)
+    ajnd_junc_nsrampd_sd_body      = (1.01749)
+    aeg_junc_nsrampd_sd_body       = (1.188)
+    aalphaeg_junc_nsrampd_sd_body  = (459.6e-06)
+    abetaeg_junc_nsrampd_sd_body   = (601.5)
+    axti_junc_nsrampd_sd_body      = (2.342)
+    nom_pcj0_junc_nsrampd_sd_body  = (1.04559e-16)
+    nom_delr_pcj0_junc_nsrampd_sd_body = (1)
+    sig_delr_pcj0_junc_nsrampd_sd_body = (0.0333)
+    ptp_junc_nsrampd_sd_body       = (1.288e-03)
+    pphi_junc_nsrampd_sd_body      = (0.9)
+    pexm_junc_nsrampd_sd_body      = (0.4)
+    nom_pjs_junc_nsrampd_sd_body   = (2.07546e-19)
+    nom_delr_pjs_junc_nsrampd_sd_body = (1)
+    sig_delr_pjs_junc_nsrampd_sd_body = (0.0333)
+    pjnd_junc_nsrampd_sd_body      = (1.1)
+    peg_junc_nsrampd_sd_body       = (1.188)
+    palphaeg_junc_nsrampd_sd_body  = (459.6e-06)
+    pbetaeg_junc_nsrampd_sd_body   = (601.5)
+    pxti_junc_nsrampd_sd_body      = (2.342)
+    nom_chcj0_junc_nsrampd_sd_body = (1.85581e-16)
+    nom_delr_chcj0_junc_nsrampd_sd_body = (1)
+    sig_delr_chcj0_junc_nsrampd_sd_body = (0.0333)
+    chphi_junc_nsrampd_sd_body     = (0.9)
+    chexm_junc_nsrampd_sd_body     = (0.7)
+    nom_chjs_junc_nsrampd_sd_body  = (5.39018e-21)
+    nom_delr_chjs_junc_nsrampd_sd_body = (1)
+    sig_delr_chjs_junc_nsrampd_sd_body = (0.0333)
+    chjnd_junc_nsrampd_sd_body     = (1.08317)
+    nom_acj0_junc_pmos_sd_body     = (1.38868e-15)
+    nom_delr_acj0_junc_pmos_sd_body = (1)
+    sig_delr_acj0_junc_pmos_sd_body = (0.0333)
+    aphi_junc_pmos_sd_body         = (0.9)
+    pta_junc_pmos_sd_body          = (1.288e-03)
+    aexm_junc_pmos_sd_body         = (0.4)
+    nom_ajs_junc_pmos_sd_body      = (4.38741e-19)
+    nom_delr_ajs_junc_pmos_sd_body = (1)
+    sig_delr_ajs_junc_pmos_sd_body = (0.0333)
+    ajnd_junc_pmos_sd_body         = (1.1)
+    aeg_junc_pmos_sd_body          = (1.188)
+    aalphaeg_junc_pmos_sd_body     = (459.6e-06)
+    abetaeg_junc_pmos_sd_body      = (601.5)
+    axti_junc_pmos_sd_body         = (2.342)
+    nom_pcj0_junc_pmos_sd_body     = (1.16667e-16)
+    nom_delr_pcj0_junc_pmos_sd_body = (1)
+    sig_delr_pcj0_junc_pmos_sd_body = (0.0333)
+    ptp_junc_pmos_sd_body          = (1.288e-03)
+    pphi_junc_pmos_sd_body         = (0.9)
+    pexm_junc_pmos_sd_body         = (0.5)
+    nom_pjs_junc_pmos_sd_body      = (1.58894e-20)
+    nom_delr_pjs_junc_pmos_sd_body = (1)
+    sig_delr_pjs_junc_pmos_sd_body = (0.0333)
+    pjnd_junc_pmos_sd_body         = (1.05486)
+    peg_junc_pmos_sd_body          = (1.188)
+    palphaeg_junc_pmos_sd_body     = (459.6e-06)
+    pbetaeg_junc_pmos_sd_body      = (601.5)
+    pxti_junc_pmos_sd_body         = (2.342)
+    nom_chcj0_junc_pmos_sd_body    = (3.16529e-16)
+    nom_delr_chcj0_junc_pmos_sd_body = (1)
+    sig_delr_chcj0_junc_pmos_sd_body = (0.0333)
+    chphi_junc_pmos_sd_body        = (0.9)
+    chexm_junc_pmos_sd_body        = (0.5)
+    nom_chjs_junc_pmos_sd_body     = (1.80014e-19)
+    nom_delr_chjs_junc_pmos_sd_body = (1)
+    sig_delr_chjs_junc_pmos_sd_body = (0.0333)
+    chjnd_junc_pmos_sd_body        = (1.1)
+    nom_acj0_junc_pmos_ll_sd_body  = (1.63e-15)
+    nom_delr_acj0_junc_pmos_ll_sd_body = (1)
+    sig_delr_acj0_junc_pmos_ll_sd_body = (0.0333)
+    aphi_junc_pmos_ll_sd_body      = (1.8)
+    pta_junc_pmos_ll_sd_body       = (1.288e-03)
+    aexm_junc_pmos_ll_sd_body      = (0.65)
+    nom_ajs_junc_pmos_ll_sd_body   = (7.0e-20)
+    nom_delr_ajs_junc_pmos_ll_sd_body = (1)
+    sig_delr_ajs_junc_pmos_ll_sd_body = (0.06)
+    ajnd_junc_pmos_ll_sd_body      = (1.0)
+    aeg_junc_pmos_ll_sd_body       = (1.188)
+    aalphaeg_junc_pmos_ll_sd_body  = (459.6e-06)
+    abetaeg_junc_pmos_ll_sd_body   = (601.5)
+    axti_junc_pmos_ll_sd_body      = (2.342)
+    nom_pcj0_junc_pmos_ll_sd_body  = (1.9e-16)
+    nom_delr_pcj0_junc_pmos_ll_sd_body = (1)
+    sig_delr_pcj0_junc_pmos_ll_sd_body = (0.0333)
+    ptp_junc_pmos_ll_sd_body       = (1.288e-03)
+    pphi_junc_pmos_ll_sd_body      = (1.3)
+    pexm_junc_pmos_ll_sd_body      = (0.4)
+    nom_pjs_junc_pmos_ll_sd_body   = (2.0e-20)
+    nom_delr_pjs_junc_pmos_ll_sd_body = (1)
+    sig_delr_pjs_junc_pmos_ll_sd_body = (0.06)
+    pjnd_junc_pmos_ll_sd_body      = (1.05486)
+    peg_junc_pmos_ll_sd_body       = (1.188)
+    palphaeg_junc_pmos_ll_sd_body  = (459.6e-06)
+    pbetaeg_junc_pmos_ll_sd_body   = (601.5)
+    pxti_junc_pmos_ll_sd_body      = (2.342)
+    nom_chcj0_junc_pmos_ll_sd_body = (3.25e-16)
+    nom_delr_chcj0_junc_pmos_ll_sd_body = (1)
+    sig_delr_chcj0_junc_pmos_ll_sd_body = (0.0333)
+    chphi_junc_pmos_ll_sd_body     = (1.7)
+    chexm_junc_pmos_ll_sd_body     = (0.73)
+    nom_chjs_junc_pmos_ll_sd_body  = (6.0e-21)
+    nom_delr_chjs_junc_pmos_ll_sd_body = (1)
+    sig_delr_chjs_junc_pmos_ll_sd_body = (0.06)
+    chjnd_junc_pmos_ll_sd_body     = (1.1)
+    nom_acj0_junc_pmos_ull_sd_body = (1.6626e-15)
+    nom_delr_acj0_junc_pmos_ull_sd_body = (1)
+    sig_delr_acj0_junc_pmos_ull_sd_body = (0.0333)
+    aphi_junc_pmos_ull_sd_body     = (1.0)
+    pta_junc_pmos_ull_sd_body      = (1.288e-03)
+    aexm_junc_pmos_ull_sd_body     = (0.45)
+    nom_ajs_junc_pmos_ull_sd_body  = (5.997e-20)
+    nom_delr_ajs_junc_pmos_ull_sd_body = (1)
+    sig_delr_ajs_junc_pmos_ull_sd_body = (0.06)
+    ajnd_junc_pmos_ull_sd_body     = (1.0)
+    aeg_junc_pmos_ull_sd_body      = (1.188)
+    aalphaeg_junc_pmos_ull_sd_body = (459.6e-06)
+    abetaeg_junc_pmos_ull_sd_body  = (601.5)
+    axti_junc_pmos_ull_sd_body     = (2.342)
+    nom_pcj0_junc_pmos_ull_sd_body = (0.66983e-16)
+    nom_delr_pcj0_junc_pmos_ull_sd_body = (1)
+    sig_delr_pcj0_junc_pmos_ull_sd_body = (0.0333)
+    ptp_junc_pmos_ull_sd_body      = (1.288e-03)
+    pphi_junc_pmos_ull_sd_body     = (0.7)
+    pexm_junc_pmos_ull_sd_body     = (0.2573)
+    nom_pjs_junc_pmos_ull_sd_body  = (3.498e-20)
+    nom_delr_pjs_junc_pmos_ull_sd_body = (1)
+    sig_delr_pjs_junc_pmos_ull_sd_body = (0.06)
+    pjnd_junc_pmos_ull_sd_body     = (1.05486)
+    peg_junc_pmos_ull_sd_body      = (1.188)
+    palphaeg_junc_pmos_ull_sd_body = (459.6e-06)
+    pbetaeg_junc_pmos_ull_sd_body  = (601.5)
+    pxti_junc_pmos_ull_sd_body     = (2.342)
+    nom_chcj0_junc_pmos_ull_sd_body = (3.5868e-16)
+    nom_delr_chcj0_junc_pmos_ull_sd_body = (1)
+    sig_delr_chcj0_junc_pmos_ull_sd_body = (0.0333)
+    chphi_junc_pmos_ull_sd_body    = (0.7)
+    chexm_junc_pmos_ull_sd_body    = (0.363)
+    nom_chjs_junc_pmos_ull_sd_body = (1.821e-20)
+    nom_delr_chjs_junc_pmos_ull_sd_body = (1)
+    sig_delr_chjs_junc_pmos_ull_sd_body = (0.06)
+    chjnd_junc_pmos_ull_sd_body    = (1.1)
+    nom_acj0_junc_pmos_ana_sd_body = (2.8e-15/2)
+    nom_delr_acj0_junc_pmos_ana_sd_body = (1)
+    sig_delr_acj0_junc_pmos_ana_sd_body = (0.0333)
+    aphi_junc_pmos_ana_sd_body     = (0.8778)
+    pta_junc_pmos_ana_sd_body      = (1.3618e-03)
+    aexm_junc_pmos_ana_sd_body     = (0.38)
+    nom_ajs_junc_pmos_ana_sd_body  = (6e-21)
+    nom_delr_ajs_junc_pmos_ana_sd_body = (1)
+    sig_delr_ajs_junc_pmos_ana_sd_body = (0.0333)
+    ajnd_junc_pmos_ana_sd_body     = (1.0)
+    aeg_junc_pmos_ana_sd_body      = (1.188)
+    aalphaeg_junc_pmos_ana_sd_body = (459.6e-06)
+    abetaeg_junc_pmos_ana_sd_body  = (601.5)
+    axti_junc_pmos_ana_sd_body     = (2.342)
+    nom_pcj0_junc_pmos_ana_sd_body = (5e-16*1.18/5)
+    nom_delr_pcj0_junc_pmos_ana_sd_body = (1)
+    sig_delr_pcj0_junc_pmos_ana_sd_body = (0.0333)
+    ptp_junc_pmos_ana_sd_body      = (2.6207e-03)
+    pphi_junc_pmos_ana_sd_body     = (0.8)
+    pexm_junc_pmos_ana_sd_body     = (0.3)
+    nom_pjs_junc_pmos_ana_sd_body  = (3e-20)
+    nom_delr_pjs_junc_pmos_ana_sd_body = (1)
+    sig_delr_pjs_junc_pmos_ana_sd_body = (0.0333)
+    pjnd_junc_pmos_ana_sd_body     = (1.03671)
+    peg_junc_pmos_ana_sd_body      = (1.188)
+    palphaeg_junc_pmos_ana_sd_body = (459.6e-06)
+    pbetaeg_junc_pmos_ana_sd_body  = (601.5)
+    pxti_junc_pmos_ana_sd_body     = (2.342)
+    nom_chcj0_junc_pmos_ana_sd_body = (4e-16*1.71/4)
+    nom_delr_chcj0_junc_pmos_ana_sd_body = (1)
+    sig_delr_chcj0_junc_pmos_ana_sd_body = (0.0333)
+    chphi_junc_pmos_ana_sd_body    = (0.8)
+    chexm_junc_pmos_ana_sd_body    = (0.32)
+    nom_chjs_junc_pmos_ana_sd_body = (4e-20)
+    nom_delr_chjs_junc_pmos_ana_sd_body = (1)
+    sig_delr_chjs_junc_pmos_ana_sd_body = (0.0333)
+    chjnd_junc_pmos_ana_sd_body    = (1.03671)
+    nom_acj0_junc_nmos3_zvt_d_body = (9.56285e-16)
+    nom_delr_acj0_junc_nmos3_zvt_d_body = (1)
+    sig_delr_acj0_junc_nmos3_zvt_d_body = (0.0333)
+    aphi_junc_nmos3_zvt_d_body     = (0.814784)
+    pta_junc_nmos3_zvt_d_body      = (1.5719e-03)
+    aexm_junc_nmos3_zvt_d_body     = (0.327712)
+    nom_ajs_junc_nmos3_zvt_d_body  = (3.69073e-19)
+    nom_delr_ajs_junc_nmos3_zvt_d_body = (1)
+    sig_delr_ajs_junc_nmos3_zvt_d_body = (0.0333)
+    ajnd_junc_nmos3_zvt_d_body     = (1.09946)
+    aeg_junc_nmos3_zvt_d_body      = (1.188)
+    aalphaeg_junc_nmos3_zvt_d_body = (459.6e-06)
+    abetaeg_junc_nmos3_zvt_d_body  = (601.5)
+    axti_junc_nmos3_zvt_d_body     = (2.342)
+    nom_pcj0_junc_nmos3_zvt_d_body = (1.02653e-16)
+    nom_delr_pcj0_junc_nmos3_zvt_d_body = (1)
+    sig_delr_pcj0_junc_nmos3_zvt_d_body = (0.0333)
+    ptp_junc_nmos3_zvt_d_body      = (2.3621e-03)
+    pphi_junc_nmos3_zvt_d_body     = (0.57761)
+    pexm_junc_nmos3_zvt_d_body     = (0.229697)
+    nom_pjs_junc_nmos3_zvt_d_body  = (4.41798e-19)
+    nom_delr_pjs_junc_nmos3_zvt_d_body = (1)
+    sig_delr_pjs_junc_nmos3_zvt_d_body = (0.0333)
+    pjnd_junc_nmos3_zvt_d_body     = (1.09946)
+    peg_junc_nmos3_zvt_d_body      = (1.188)
+    palphaeg_junc_nmos3_zvt_d_body = (459.6e-06)
+    pbetaeg_junc_nmos3_zvt_d_body  = (601.5)
+    pxti_junc_nmos3_zvt_d_body     = (2.342)
+    nom_chcj0_junc_nmos3_zvt_d_body = (1.51748e-16)
+    nom_delr_chcj0_junc_nmos3_zvt_d_body = (1)
+    sig_delr_chcj0_junc_nmos3_zvt_d_body = (0.0333)
+    chphi_junc_nmos3_zvt_d_body    = (0.882552)
+    chexm_junc_nmos3_zvt_d_body    = (0.5)
+    nom_chjs_junc_nmos3_zvt_d_body = (4.33744e-20)
+    nom_delr_chjs_junc_nmos3_zvt_d_body = (1)
+    sig_delr_chjs_junc_nmos3_zvt_d_body = (0.0333)
+    chjnd_junc_nmos3_zvt_d_body    = (1.09946)
+    nom_acj0_junc_nmos3_zvt_s_body = (9.29324e-16)
+    nom_delr_acj0_junc_nmos3_zvt_s_body = (1)
+    sig_delr_acj0_junc_nmos3_zvt_s_body = (0.0333)
+    aphi_junc_nmos3_zvt_s_body     = (0.79943)
+    pta_junc_nmos3_zvt_s_body      = (1.6231e-03)
+    aexm_junc_nmos3_zvt_s_body     = (0.307348)
+    nom_ajs_junc_nmos3_zvt_s_body  = (8.83803e-19)
+    nom_delr_ajs_junc_nmos3_zvt_s_body = (1)
+    sig_delr_ajs_junc_nmos3_zvt_s_body = (0.0333)
+    ajnd_junc_nmos3_zvt_s_body     = (1.14577)
+    aeg_junc_nmos3_zvt_s_body      = (1.188)
+    aalphaeg_junc_nmos3_zvt_s_body = (459.6e-06)
+    abetaeg_junc_nmos3_zvt_s_body  = (601.5)
+    axti_junc_nmos3_zvt_s_body     = (2.342)
+    nom_pcj0_junc_nmos3_zvt_s_body = (1.05282e-16)
+    nom_delr_pcj0_junc_nmos3_zvt_s_body = (1)
+    sig_delr_pcj0_junc_nmos3_zvt_s_body = (0.0333)
+    ptp_junc_nmos3_zvt_s_body      = (1.5778e-03)
+    pphi_junc_nmos3_zvt_s_body     = (0.813027)
+    pexm_junc_nmos3_zvt_s_body     = (0.275559)
+    nom_pjs_junc_nmos3_zvt_s_body  = (9.19746e-19)
+    nom_delr_pjs_junc_nmos3_zvt_s_body = (1)
+    sig_delr_pjs_junc_nmos3_zvt_s_body = (0.0333)
+    pjnd_junc_nmos3_zvt_s_body     = (1.14577)
+    peg_junc_nmos3_zvt_s_body      = (1.188)
+    palphaeg_junc_nmos3_zvt_s_body = (459.6e-06)
+    pbetaeg_junc_nmos3_zvt_s_body  = (601.5)
+    pxti_junc_nmos3_zvt_s_body     = (2.342)
+    nom_chcj0_junc_nmos3_zvt_s_body = (2.21658e-16)
+    nom_delr_chcj0_junc_nmos3_zvt_s_body = (1)
+    sig_delr_chcj0_junc_nmos3_zvt_s_body = (0.0333)
+    chphi_junc_nmos3_zvt_s_body    = (0.5)
+    chexm_junc_nmos3_zvt_s_body    = (0.5)
+    nom_chjs_junc_nmos3_zvt_s_body = (3.68379e-20)
+    nom_delr_chjs_junc_nmos3_zvt_s_body = (1)
+    sig_delr_chjs_junc_nmos3_zvt_s_body = (0.0333)
+    chjnd_junc_nmos3_zvt_s_body    = (1.14577)
+    nom_acj0_junc_psrampu_sd_body  = (1.38868e-15)
+    nom_delr_acj0_junc_psrampu_sd_body = (1)
+    sig_delr_acj0_junc_psrampu_sd_body = (0.0333)
+    aphi_junc_psrampu_sd_body      = (0.9)
+    pta_junc_psrampu_sd_body       = (1.288e-03)
+    aexm_junc_psrampu_sd_body      = (0.4)
+    nom_ajs_junc_psrampu_sd_body   = (4.38741e-19)
+    nom_delr_ajs_junc_psrampu_sd_body = (1)
+    sig_delr_ajs_junc_psrampu_sd_body = (0.0333)
+    ajnd_junc_psrampu_sd_body      = (1.1)
+    aeg_junc_psrampu_sd_body       = (1.188)
+    aalphaeg_junc_psrampu_sd_body  = (459.6e-06)
+    abetaeg_junc_psrampu_sd_body   = (601.5)
+    axti_junc_psrampu_sd_body      = (2.342)
+    nom_pcj0_junc_psrampu_sd_body  = (1.16667e-16)
+    nom_delr_pcj0_junc_psrampu_sd_body = (1)
+    sig_delr_pcj0_junc_psrampu_sd_body = (0.0333)
+    ptp_junc_psrampu_sd_body       = (1.288e-03)
+    pphi_junc_psrampu_sd_body      = (0.9)
+    pexm_junc_psrampu_sd_body      = (0.5)
+    nom_pjs_junc_psrampu_sd_body   = (1.58894e-20)
+    nom_delr_pjs_junc_psrampu_sd_body = (1)
+    sig_delr_pjs_junc_psrampu_sd_body = (0.0333)
+    pjnd_junc_psrampu_sd_body      = (1.05486)
+    peg_junc_psrampu_sd_body       = (1.188)
+    palphaeg_junc_psrampu_sd_body  = (459.6e-06)
+    pbetaeg_junc_psrampu_sd_body   = (601.5)
+    pxti_junc_psrampu_sd_body      = (2.342)
+    nom_chcj0_junc_psrampu_sd_body = (3.16529e-16)
+    nom_delr_chcj0_junc_psrampu_sd_body = (1)
+    sig_delr_chcj0_junc_psrampu_sd_body = (0.0333)
+    chphi_junc_psrampu_sd_body     = (0.9)
+    chexm_junc_psrampu_sd_body     = (0.5)
+    nom_chjs_junc_psrampu_sd_body  = (1.80014e-19)
+    nom_delr_chjs_junc_psrampu_sd_body = (1)
+    sig_delr_chjs_junc_psrampu_sd_body = (0.0333)
+    chjnd_junc_psrampu_sd_body     = (1.1)
+    nom_acj0_junc_nmos5_s_body     = (9.0e-16)
+    nom_delr_acj0_junc_nmos5_s_body = (1)
+    sig_delr_acj0_junc_nmos5_s_body = (0.0333)
+    aphi_junc_nmos5_s_body         = (0.9)
+    pta_junc_nmos5_s_body          = (1.288e-03)
+    aexm_junc_nmos5_s_body         = (0.36)
+    nom_ajs_junc_nmos5_s_body      = (1.5e-19)
+    nom_delr_ajs_junc_nmos5_s_body = (1)
+    sig_delr_ajs_junc_nmos5_s_body = (0.0333)
+    ajnd_junc_nmos5_s_body         = (1.1)
+    aeg_junc_nmos5_s_body          = (1.188)
+    aalphaeg_junc_nmos5_s_body     = (459.6e-06)
+    abetaeg_junc_nmos5_s_body      = (601.5)
+    axti_junc_nmos5_s_body         = (2.342)
+    nom_pcj0_junc_nmos5_s_body     = (5.0e-17)
+    nom_delr_pcj0_junc_nmos5_s_body = (1)
+    sig_delr_pcj0_junc_nmos5_s_body = (0.0333)
+    ptp_junc_nmos5_s_body          = (2.6207e-03)
+    pphi_junc_nmos5_s_body         = (0.9)
+    pexm_junc_nmos5_s_body         = (0.38)
+    nom_pjs_junc_nmos5_s_body      = (2.5e-19)
+    nom_delr_pjs_junc_nmos5_s_body = (1)
+    sig_delr_pjs_junc_nmos5_s_body = (0.0333)
+    pjnd_junc_nmos5_s_body         = (1.07648)
+    peg_junc_nmos5_s_body          = (1.188)
+    palphaeg_junc_nmos5_s_body     = (459.6e-06)
+    pbetaeg_junc_nmos5_s_body      = (601.5)
+    pxti_junc_nmos5_s_body         = (2.342)
+    nom_chcj0_junc_nmos5_s_body    = (2.2e-16)
+    nom_delr_chcj0_junc_nmos5_s_body = (1)
+    sig_delr_chcj0_junc_nmos5_s_body = (0.0333)
+    chphi_junc_nmos5_s_body        = (0.9)
+    chexm_junc_nmos5_s_body        = (0.28)
+    nom_chjs_junc_nmos5_s_body     = (1e-19)
+    nom_delr_chjs_junc_nmos5_s_body = (1)
+    sig_delr_chjs_junc_nmos5_s_body = (0.0333)
+    chjnd_junc_nmos5_s_body        = (1.07648)
+    nom_acj0_junc_nmos5_d_body     = (9e-16)
+    nom_delr_acj0_junc_nmos5_d_body = (1)
+    sig_delr_acj0_junc_nmos5_d_body = (0.0333)
+    aphi_junc_nmos5_d_body         = (0.9)
+    pta_junc_nmos5_d_body          = (1.4503e-03)
+    aexm_junc_nmos5_d_body         = (0.36)
+    nom_ajs_junc_nmos5_d_body      = (5e-20)
+    nom_delr_ajs_junc_nmos5_d_body = (1)
+    sig_delr_ajs_junc_nmos5_d_body = (0.0333)
+    ajnd_junc_nmos5_d_body         = (1.05)
+    aeg_junc_nmos5_d_body          = (1.188)
+    aalphaeg_junc_nmos5_d_body     = (459.6e-06)
+    abetaeg_junc_nmos5_d_body      = (601.5)
+    axti_junc_nmos5_d_body         = (2.342)
+    nom_pcj0_junc_nmos5_d_body     = (5e-17)
+    nom_delr_pcj0_junc_nmos5_d_body = (1)
+    sig_delr_pcj0_junc_nmos5_d_body = (0.0333)
+    ptp_junc_nmos5_d_body          = (2.6207e-03)
+    pphi_junc_nmos5_d_body         = (0.9)
+    pexm_junc_nmos5_d_body         = (0.38)
+    nom_pjs_junc_nmos5_d_body      = (2.50e-19)
+    nom_delr_pjs_junc_nmos5_d_body = (1)
+    sig_delr_pjs_junc_nmos5_d_body = (0.0333)
+    pjnd_junc_nmos5_d_body         = (1.1)
+    peg_junc_nmos5_d_body          = (1.188)
+    palphaeg_junc_nmos5_d_body     = (459.6e-06)
+    pbetaeg_junc_nmos5_d_body      = (601.5)
+    pxti_junc_nmos5_d_body         = (2.342)
+    nom_chcj0_junc_nmos5_d_body    = (4.8e-16)
+    nom_delr_chcj0_junc_nmos5_d_body = (1)
+    sig_delr_chcj0_junc_nmos5_d_body = (0.0333)
+    chphi_junc_nmos5_d_body        = (0.9)
+    chexm_junc_nmos5_d_body        = (0.42)
+    nom_chjs_junc_nmos5_d_body     = (8e-20)
+    nom_delr_chjs_junc_nmos5_d_body = (1)
+    sig_delr_chjs_junc_nmos5_d_body = (0.0333)
+    chjnd_junc_nmos5_d_body        = (1.1)
+    nom_acj0_junc_pmos5_sd_body    = (9.471e-16)
+    nom_delr_acj0_junc_pmos5_sd_body = (1)
+    sig_delr_acj0_junc_pmos5_sd_body = (0.0333)
+    aphi_junc_pmos5_sd_body        = (0.8906)
+    pta_junc_pmos5_sd_body         = (1.288e-03)
+    aexm_junc_pmos5_sd_body        = (0.4137)
+    nom_ajs_junc_pmos5_sd_body     = (4.445e-20)
+    nom_delr_ajs_junc_pmos5_sd_body = (1)
+    sig_delr_ajs_junc_pmos5_sd_body = (0.0333)
+    ajnd_junc_pmos5_sd_body        = (0.9985)
+    aeg_junc_pmos5_sd_body         = (1.188)
+    aalphaeg_junc_pmos5_sd_body    = (459.6e-06)
+    abetaeg_junc_pmos5_sd_body     = (601.5)
+    axti_junc_pmos5_sd_body        = (2.342)
+    nom_pcj0_junc_pmos5_sd_body    = (7.808e-17)
+    nom_delr_pcj0_junc_pmos5_sd_body = (1)
+    sig_delr_pcj0_junc_pmos5_sd_body = (0.0333)
+    ptp_junc_pmos5_sd_body         = (2.6207e-03)
+    pphi_junc_pmos5_sd_body        = (0.4322)
+    pexm_junc_pmos5_sd_body        = (0.1913)
+    nom_pjs_junc_pmos5_sd_body     = (2.642e-20)
+    nom_delr_pjs_junc_pmos5_sd_body = (1)
+    sig_delr_pjs_junc_pmos5_sd_body = (0.0333)
+    pjnd_junc_pmos5_sd_body        = (1.05956)
+    peg_junc_pmos5_sd_body         = (1.188)
+    palphaeg_junc_pmos5_sd_body    = (459.6e-06)
+    pbetaeg_junc_pmos5_sd_body     = (601.5)
+    pxti_junc_pmos5_sd_body        = (2.342)
+    nom_chcj0_junc_pmos5_sd_body   = (1.676e-16)
+    nom_delr_chcj0_junc_pmos5_sd_body = (1)
+    sig_delr_chcj0_junc_pmos5_sd_body = (0.0333)
+    chphi_junc_pmos5_sd_body       = (0.677)
+    chexm_junc_pmos5_sd_body       = (0.321)
+    nom_chjs_junc_pmos5_sd_body    = (1.219e-20)
+    nom_delr_chjs_junc_pmos5_sd_body = (1)
+    sig_delr_chjs_junc_pmos5_sd_body = (0.0333)
+    chjnd_junc_pmos5_sd_body       = (1.05956)
+    nom_acj0_junc_nmos10_d_body    = (5.42214e-16)
+    nom_delr_acj0_junc_nmos10_d_body = (1)
+    sig_delr_acj0_junc_nmos10_d_body = (0.0333)
+    aphi_junc_nmos10_d_body        = (0.656029)
+    pta_junc_nmos10_d_body         = (2.1008e-03)
+    aexm_junc_nmos10_d_body        = (0.5)
+    nom_ajs_junc_nmos10_d_body     = (2.59355e-19)
+    nom_delr_ajs_junc_nmos10_d_body = (1)
+    sig_delr_ajs_junc_nmos10_d_body = (0.0333)
+    ajnd_junc_nmos10_d_body        = (1.0999)
+    aeg_junc_nmos10_d_body         = (1.188)
+    aalphaeg_junc_nmos10_d_body    = (459.6e-06)
+    abetaeg_junc_nmos10_d_body     = (601.5)
+    axti_junc_nmos10_d_body        = (2.342)
+    nom_pcj0_junc_nmos10_d_body    = (5.80704e-17)
+    nom_delr_pcj0_junc_nmos10_d_body = (1)
+    sig_delr_pcj0_junc_nmos10_d_body = (0.0333)
+    ptp_junc_nmos10_d_body         = (2.6207e-03)
+    pphi_junc_nmos10_d_body        = (0.5)
+    pexm_junc_nmos10_d_body        = (0.5)
+    nom_pjs_junc_nmos10_d_body     = (7.56467e-20)
+    nom_delr_pjs_junc_nmos10_d_body = (1)
+    sig_delr_pjs_junc_nmos10_d_body = (0.0333)
+    pjnd_junc_nmos10_d_body        = (1.0999)
+    peg_junc_nmos10_d_body         = (1.188)
+    palphaeg_junc_nmos10_d_body    = (459.6e-06)
+    pbetaeg_junc_nmos10_d_body     = (601.5)
+    pxti_junc_nmos10_d_body        = (2.342)
+    nom_chcj0_junc_nmos10_d_body   = (1.06819e-17)
+    nom_delr_chcj0_junc_nmos10_d_body = (1)
+    sig_delr_chcj0_junc_nmos10_d_body = (0.0333)
+    chphi_junc_nmos10_d_body       = (0.9)
+    chexm_junc_nmos10_d_body       = (0.1)
+    nom_chjs_junc_nmos10_d_body    = (1.92903e-22)
+    nom_delr_chjs_junc_nmos10_d_body = (1)
+    sig_delr_chjs_junc_nmos10_d_body = (0.0333)
+    chjnd_junc_nmos10_d_body       = (1.0999)
+    nom_acj0_junc_nmos10_s_body    = (8.88415e-16)
+    nom_delr_acj0_junc_nmos10_s_body = (1)
+    sig_delr_acj0_junc_nmos10_s_body = (0.0333)
+    aphi_junc_nmos10_s_body        = (0.695419)
+    pta_junc_nmos10_s_body         = (1.9696e-03)
+    aexm_junc_nmos10_s_body        = (0.320052)
+    nom_ajs_junc_nmos10_s_body     = (2.98299e-19)
+    nom_delr_ajs_junc_nmos10_s_body = (1)
+    sig_delr_ajs_junc_nmos10_s_body = (0.0333)
+    ajnd_junc_nmos10_s_body        = (1.09898)
+    aeg_junc_nmos10_s_body         = (1.188)
+    aalphaeg_junc_nmos10_s_body    = (459.6e-06)
+    abetaeg_junc_nmos10_s_body     = (601.5)
+    axti_junc_nmos10_s_body        = (2.342)
+    nom_pcj0_junc_nmos10_s_body    = (8.94448e-17)
+    nom_delr_pcj0_junc_nmos10_s_body = (1)
+    sig_delr_pcj0_junc_nmos10_s_body = (0.0333)
+    ptp_junc_nmos10_s_body         = (1.4017e-03)
+    pphi_junc_nmos10_s_body        = (0.865883)
+    pexm_junc_nmos10_s_body        = (0.143222)
+    nom_pjs_junc_nmos10_s_body     = (5.70673e-19)
+    nom_delr_pjs_junc_nmos10_s_body = (1)
+    sig_delr_pjs_junc_nmos10_s_body = (0.0333)
+    pjnd_junc_nmos10_s_body        = (1.09898)
+    peg_junc_nmos10_s_body         = (1.188)
+    palphaeg_junc_nmos10_s_body    = (459.6e-06)
+    pbetaeg_junc_nmos10_s_body     = (601.5)
+    pxti_junc_nmos10_s_body        = (2.342)
+    nom_chcj0_junc_nmos10_s_body   = (1.8392e-16)
+    nom_delr_chcj0_junc_nmos10_s_body = (1)
+    sig_delr_chcj0_junc_nmos10_s_body = (0.0333)
+    chphi_junc_nmos10_s_body       = (0.833113)
+    chexm_junc_nmos10_s_body       = (0.446856)
+    nom_chjs_junc_nmos10_s_body    = (2.49998e-19)
+    nom_delr_chjs_junc_nmos10_s_body = (1)
+    sig_delr_chjs_junc_nmos10_s_body = (0.0333)
+    chjnd_junc_nmos10_s_body       = (1.09898)
+    nom_acj0_junc_pmos10_d_body    = (1.5565e-16)
+    nom_delr_acj0_junc_pmos10_d_body = (1)
+    sig_delr_acj0_junc_pmos10_d_body = (0.0333)
+    aphi_junc_pmos10_d_body        = (0.5)
+    pta_junc_pmos10_d_body         = (2.6207e-03)
+    aexm_junc_pmos10_d_body        = (0.3)
+    nom_ajs_junc_pmos10_d_body     = (1.64313e-19)
+    nom_delr_ajs_junc_pmos10_d_body = (1)
+    sig_delr_ajs_junc_pmos10_d_body = (0.0333)
+    ajnd_junc_pmos10_d_body        = (1.1)
+    aeg_junc_pmos10_d_body         = (1.188)
+    aalphaeg_junc_pmos10_d_body    = (459.6e-06)
+    abetaeg_junc_pmos10_d_body     = (601.5)
+    axti_junc_pmos10_d_body        = (2.342)
+    nom_pcj0_junc_pmos10_d_body    = (3.5276e-16)
+    nom_delr_pcj0_junc_pmos10_d_body = (1)
+    sig_delr_pcj0_junc_pmos10_d_body = (0.0333)
+    ptp_junc_pmos10_d_body         = (2.4541e-03)
+    pphi_junc_pmos10_d_body        = (0.55)
+    pexm_junc_pmos10_d_body        = (0.37397)
+    nom_pjs_junc_pmos10_d_body     = (5.42969e-20)
+    nom_delr_pjs_junc_pmos10_d_body = (1)
+    sig_delr_pjs_junc_pmos10_d_body = (0.0333)
+    pjnd_junc_pmos10_d_body        = (1.1)
+    peg_junc_pmos10_d_body         = (1.188)
+    palphaeg_junc_pmos10_d_body    = (459.6e-06)
+    pbetaeg_junc_pmos10_d_body     = (601.5)
+    pxti_junc_pmos10_d_body        = (2.342)
+    nom_chcj0_junc_pmos10_d_body   = (6.25377e-16)
+    nom_delr_chcj0_junc_pmos10_d_body = (1)
+    sig_delr_chcj0_junc_pmos10_d_body = (0.0333)
+    chphi_junc_pmos10_d_body       = (0.9)
+    chexm_junc_pmos10_d_body       = (0.489979)
+    nom_chjs_junc_pmos10_d_body    = (5.8053e-20)
+    nom_delr_chjs_junc_pmos10_d_body = (1)
+    sig_delr_chjs_junc_pmos10_d_body = (0.0333)
+    chjnd_junc_pmos10_d_body       = (1.1)
+    nom_acj0_junc_pmos10_s_body    = (9.52532e-16)
+    nom_delr_acj0_junc_pmos10_s_body = (1)
+    sig_delr_acj0_junc_pmos10_s_body = (0.0333)
+    aphi_junc_pmos10_s_body        = (0.834182)
+    pta_junc_pmos10_s_body         = (1.5073e-03)
+    aexm_junc_pmos10_s_body        = (0.406742)
+    nom_ajs_junc_pmos10_s_body     = (2.22401e-19)
+    nom_delr_ajs_junc_pmos10_s_body = (1)
+    sig_delr_ajs_junc_pmos10_s_body = (0.0333)
+    ajnd_junc_pmos10_s_body        = (1.1)
+    aeg_junc_pmos10_s_body         = (1.188)
+    aalphaeg_junc_pmos10_s_body    = (459.6e-06)
+    abetaeg_junc_pmos10_s_body     = (601.5)
+    axti_junc_pmos10_s_body        = (2.342)
+    nom_pcj0_junc_pmos10_s_body    = (6.25078e-17)
+    nom_delr_pcj0_junc_pmos10_s_body = (1)
+    sig_delr_pcj0_junc_pmos10_s_body = (0.0333)
+    ptp_junc_pmos10_s_body         = (2.6207e-03)
+    pphi_junc_pmos10_s_body        = (0.5)
+    pexm_junc_pmos10_s_body        = (0.3)
+    nom_pjs_junc_pmos10_s_body     = (1.5571e-19)
+    nom_delr_pjs_junc_pmos10_s_body = (1)
+    sig_delr_pjs_junc_pmos10_s_body = (0.0333)
+    pjnd_junc_pmos10_s_body        = (1.1)
+    peg_junc_pmos10_s_body         = (1.188)
+    palphaeg_junc_pmos10_s_body    = (459.6e-06)
+    pbetaeg_junc_pmos10_s_body     = (601.5)
+    pxti_junc_pmos10_s_body        = (2.342)
+    nom_chcj0_junc_pmos10_s_body   = (1.60562e-16)
+    nom_delr_chcj0_junc_pmos10_s_body = (1)
+    sig_delr_chcj0_junc_pmos10_s_body = (0.0333)
+    chphi_junc_pmos10_s_body       = (0.9)
+    chexm_junc_pmos10_s_body       = (0.377334)
+    nom_chjs_junc_pmos10_s_body    = (4.08446e-20)
+    nom_delr_chjs_junc_pmos10_s_body = (1)
+    sig_delr_chjs_junc_pmos10_s_body = (0.0333)
+    chjnd_junc_pmos10_s_body       = (1.1)
+    nom_acj0_junc_nmos45_d_body    = (1.433e-16)
+    nom_delr_acj0_junc_nmos45_d_body = (1)
+    sig_delr_acj0_junc_nmos45_d_body = (0.0333)
+    aphi_junc_nmos45_d_body        = (0.628102)
+    pta_junc_nmos45_d_body         = (2.1939e-03)
+    aexm_junc_nmos45_d_body        = (0.5)
+    nom_ajs_junc_nmos45_d_body     = (5.30592e-21)
+    nom_delr_ajs_junc_nmos45_d_body = (1)
+    sig_delr_ajs_junc_nmos45_d_body = (0.0333)
+    ajnd_junc_nmos45_d_body        = (1.1)
+    aeg_junc_nmos45_d_body         = (1.188)
+    aalphaeg_junc_nmos45_d_body    = (459.6e-06)
+    abetaeg_junc_nmos45_d_body     = (601.5)
+    axti_junc_nmos45_d_body        = (2.342)
+    nom_pcj0_junc_nmos45_d_body    = (1.05936e-17)
+    nom_delr_pcj0_junc_nmos45_d_body = (1)
+    sig_delr_pcj0_junc_nmos45_d_body = (0.0333)
+    ptp_junc_nmos45_d_body         = (2.6207e-03)
+    pphi_junc_nmos45_d_body        = (0.5)
+    pexm_junc_nmos45_d_body        = (0.5)
+    nom_pjs_junc_nmos45_d_body     = (2.21437e-19)
+    nom_delr_pjs_junc_nmos45_d_body = (1)
+    sig_delr_pjs_junc_nmos45_d_body = (0.0333)
+    pjnd_junc_nmos45_d_body        = (1.1)
+    peg_junc_nmos45_d_body         = (1.188)
+    palphaeg_junc_nmos45_d_body    = (459.6e-06)
+    pbetaeg_junc_nmos45_d_body     = (601.5)
+    pxti_junc_nmos45_d_body        = (2.342)
+    nom_chcj0_junc_nmos45_d_body   = (1.94044e-16)
+    nom_delr_chcj0_junc_nmos45_d_body = (1)
+    sig_delr_chcj0_junc_nmos45_d_body = (0.0333)
+    chphi_junc_nmos45_d_body       = (0.9)
+    chexm_junc_nmos45_d_body       = (0.275696)
+    nom_chjs_junc_nmos45_d_body    = (7.47652e-19)
+    nom_delr_chjs_junc_nmos45_d_body = (1)
+    sig_delr_chjs_junc_nmos45_d_body = (0.0333)
+    chjnd_junc_nmos45_d_body       = (1.1)
+    nom_acj0_junc_nmos45_s_body    = (8.78301e-16)
+    nom_delr_acj0_junc_nmos45_s_body = (1)
+    sig_delr_acj0_junc_nmos45_s_body = (0.0333)
+    aphi_junc_nmos45_s_body        = (0.730448)
+    pta_junc_nmos45_s_body         = (1.8529e-03)
+    aexm_junc_nmos45_s_body        = (0.326836)
+    nom_ajs_junc_nmos45_s_body     = (2.9127e-19)
+    nom_delr_ajs_junc_nmos45_s_body = (1)
+    sig_delr_ajs_junc_nmos45_s_body = (0.0333)
+    ajnd_junc_nmos45_s_body        = (1.09798)
+    aeg_junc_nmos45_s_body         = (1.188)
+    aalphaeg_junc_nmos45_s_body    = (459.6e-06)
+    abetaeg_junc_nmos45_s_body     = (601.5)
+    axti_junc_nmos45_s_body        = (2.342)
+    nom_pcj0_junc_nmos45_s_body    = (2.09466e-16)
+    nom_delr_pcj0_junc_nmos45_s_body = (1)
+    sig_delr_pcj0_junc_nmos45_s_body = (0.0333)
+    ptp_junc_nmos45_s_body         = (1.7475e-03)
+    pphi_junc_nmos45_s_body        = (0.7621)
+    pexm_junc_nmos45_s_body        = (0.196437)
+    nom_pjs_junc_nmos45_s_body     = (9.06107e-19)
+    nom_delr_pjs_junc_nmos45_s_body = (1)
+    sig_delr_pjs_junc_nmos45_s_body = (0.0333)
+    pjnd_junc_nmos45_s_body        = (1.09798)
+    peg_junc_nmos45_s_body         = (1.188)
+    palphaeg_junc_nmos45_s_body    = (459.6e-06)
+    pbetaeg_junc_nmos45_s_body     = (601.5)
+    pxti_junc_nmos45_s_body        = (2.342)
+    nom_chcj0_junc_nmos45_s_body   = (6.20259e-17)
+    nom_delr_chcj0_junc_nmos45_s_body = (1)
+    sig_delr_chcj0_junc_nmos45_s_body = (0.0333)
+    chphi_junc_nmos45_s_body       = (0.5)
+    chexm_junc_nmos45_s_body       = (0.5)
+    nom_chjs_junc_nmos45_s_body    = (6.14485e-20)
+    nom_delr_chjs_junc_nmos45_s_body = (1)
+    sig_delr_chjs_junc_nmos45_s_body = (0.0333)
+    chjnd_junc_nmos45_s_body       = (1.09798)
+    nom_acj0_junc_nmos45b_d_body   = (1.433e-16)
+    nom_delr_acj0_junc_nmos45b_d_body = (1)
+    sig_delr_acj0_junc_nmos45b_d_body = (0.0333)
+    aphi_junc_nmos45b_d_body       = (0.628102)
+    pta_junc_nmos45b_d_body        = (2.1939e-03)
+    aexm_junc_nmos45b_d_body       = (0.5)
+    nom_ajs_junc_nmos45b_d_body    = (5.30592e-21)
+    nom_delr_ajs_junc_nmos45b_d_body = (1)
+    sig_delr_ajs_junc_nmos45b_d_body = (0.0333)
+    ajnd_junc_nmos45b_d_body       = (1.1)
+    aeg_junc_nmos45b_d_body        = (1.188)
+    aalphaeg_junc_nmos45b_d_body   = (459.6e-06)
+    abetaeg_junc_nmos45b_d_body    = (601.5)
+    axti_junc_nmos45b_d_body       = (2.342)
+    nom_pcj0_junc_nmos45b_d_body   = (1.05936e-17)
+    nom_delr_pcj0_junc_nmos45b_d_body = (1)
+    sig_delr_pcj0_junc_nmos45b_d_body = (0.0333)
+    ptp_junc_nmos45b_d_body        = (2.6207e-03)
+    pphi_junc_nmos45b_d_body       = (0.5)
+    pexm_junc_nmos45b_d_body       = (0.5)
+    nom_pjs_junc_nmos45b_d_body    = (2.21437e-19)
+    nom_delr_pjs_junc_nmos45b_d_body = (1)
+    sig_delr_pjs_junc_nmos45b_d_body = (0.0333)
+    pjnd_junc_nmos45b_d_body       = (1.1)
+    peg_junc_nmos45b_d_body        = (1.188)
+    palphaeg_junc_nmos45b_d_body   = (459.6e-06)
+    pbetaeg_junc_nmos45b_d_body    = (601.5)
+    pxti_junc_nmos45b_d_body       = (2.342)
+    nom_chcj0_junc_nmos45b_d_body  = (1.94044e-16)
+    nom_delr_chcj0_junc_nmos45b_d_body = (1)
+    sig_delr_chcj0_junc_nmos45b_d_body = (0.0333)
+    chphi_junc_nmos45b_d_body      = (0.9)
+    chexm_junc_nmos45b_d_body      = (0.275696)
+    nom_chjs_junc_nmos45b_d_body   = (7.47652e-19)
+    nom_delr_chjs_junc_nmos45b_d_body = (1)
+    sig_delr_chjs_junc_nmos45b_d_body = (0.0333)
+    chjnd_junc_nmos45b_d_body      = (1.1)
+    nom_acj0_junc_nmos45b_s_body   = (8.78301e-16)
+    nom_delr_acj0_junc_nmos45b_s_body = (1)
+    sig_delr_acj0_junc_nmos45b_s_body = (0.0333)
+    aphi_junc_nmos45b_s_body       = (0.730448)
+    pta_junc_nmos45b_s_body        = (1.8529e-03)
+    aexm_junc_nmos45b_s_body       = (0.326836)
+    nom_ajs_junc_nmos45b_s_body    = (2.9127e-19)
+    nom_delr_ajs_junc_nmos45b_s_body = (1)
+    sig_delr_ajs_junc_nmos45b_s_body = (0.0333)
+    ajnd_junc_nmos45b_s_body       = (1.09798)
+    aeg_junc_nmos45b_s_body        = (1.188)
+    aalphaeg_junc_nmos45b_s_body   = (459.6e-06)
+    abetaeg_junc_nmos45b_s_body    = (601.5)
+    axti_junc_nmos45b_s_body       = (2.342)
+    nom_pcj0_junc_nmos45b_s_body   = (2.09466e-16)
+    nom_delr_pcj0_junc_nmos45b_s_body = (1)
+    sig_delr_pcj0_junc_nmos45b_s_body = (0.0333)
+    ptp_junc_nmos45b_s_body        = (1.7475e-03)
+    pphi_junc_nmos45b_s_body       = (0.7621)
+    pexm_junc_nmos45b_s_body       = (0.196437)
+    nom_pjs_junc_nmos45b_s_body    = (9.06107e-19)
+    nom_delr_pjs_junc_nmos45b_s_body = (1)
+    sig_delr_pjs_junc_nmos45b_s_body = (0.0333)
+    pjnd_junc_nmos45b_s_body       = (1.09798)
+    peg_junc_nmos45b_s_body        = (1.188)
+    palphaeg_junc_nmos45b_s_body   = (459.6e-06)
+    pbetaeg_junc_nmos45b_s_body    = (601.5)
+    pxti_junc_nmos45b_s_body       = (2.342)
+    nom_chcj0_junc_nmos45b_s_body  = (6.20259e-17)
+    nom_delr_chcj0_junc_nmos45b_s_body = (1)
+    sig_delr_chcj0_junc_nmos45b_s_body = (0.0333)
+    chphi_junc_nmos45b_s_body      = (0.5)
+    chexm_junc_nmos45b_s_body      = (0.5)
+    nom_chjs_junc_nmos45b_s_body   = (6.14485e-20)
+    nom_delr_chjs_junc_nmos45b_s_body = (1)
+    sig_delr_chjs_junc_nmos45b_s_body = (0.0333)
+    chjnd_junc_nmos45b_s_body      = (1.09798)
+    nom_acj0_junc_pmos45_d_body    = (1.38818e-16)
+    nom_delr_acj0_junc_pmos45_d_body = (1)
+    sig_delr_acj0_junc_pmos45_d_body = (0.0333)
+    aphi_junc_pmos45_d_body        = (0.9)
+    pta_junc_pmos45_d_body         = (1.288e-03)
+    aexm_junc_pmos45_d_body        = (0.5)
+    nom_ajs_junc_pmos45_d_body     = (1.72533e-19)
+    nom_delr_ajs_junc_pmos45_d_body = (1)
+    sig_delr_ajs_junc_pmos45_d_body = (0.0333)
+    ajnd_junc_pmos45_d_body        = (1.1)
+    aeg_junc_pmos45_d_body         = (1.188)
+    aalphaeg_junc_pmos45_d_body    = (459.6e-06)
+    abetaeg_junc_pmos45_d_body     = (601.5)
+    axti_junc_pmos45_d_body        = (2.342)
+    nom_pcj0_junc_pmos45_d_body    = (1.82008e-16)
+    nom_delr_pcj0_junc_pmos45_d_body = (1)
+    sig_delr_pcj0_junc_pmos45_d_body = (0.0333)
+    ptp_junc_pmos45_d_body         = (2.6207e-03)
+    pphi_junc_pmos45_d_body        = (0.5)
+    pexm_junc_pmos45_d_body        = (0.5)
+    nom_pjs_junc_pmos45_d_body     = (1e-23)
+    nom_delr_pjs_junc_pmos45_d_body = (1)
+    sig_delr_pjs_junc_pmos45_d_body = (0.0333)
+    pjnd_junc_pmos45_d_body        = (1.1)
+    peg_junc_pmos45_d_body         = (1.188)
+    palphaeg_junc_pmos45_d_body    = (459.6e-06)
+    pbetaeg_junc_pmos45_d_body     = (601.5)
+    pxti_junc_pmos45_d_body        = (2.342)
+    nom_chcj0_junc_pmos45_d_body   = (3.21264e-16)
+    nom_delr_chcj0_junc_pmos45_d_body = (1)
+    sig_delr_chcj0_junc_pmos45_d_body = (0.0333)
+    chphi_junc_pmos45_d_body       = (0.9)
+    chexm_junc_pmos45_d_body       = (0.5)
+    nom_chjs_junc_pmos45_d_body    = (1.40824e-19)
+    nom_delr_chjs_junc_pmos45_d_body = (1)
+    sig_delr_chjs_junc_pmos45_d_body = (0.0333)
+    chjnd_junc_pmos45_d_body       = (1.1)
+    nom_acj0_junc_pmos45_s_body    = (9.45152e-16)
+    nom_delr_acj0_junc_pmos45_s_body = (1)
+    sig_delr_acj0_junc_pmos45_s_body = (0.0333)
+    aphi_junc_pmos45_s_body        = (0.888607)
+    pta_junc_pmos45_s_body         = (1.326e-03)
+    aexm_junc_pmos45_s_body        = (0.411877)
+    nom_ajs_junc_pmos45_s_body     = (2.2927e-19)
+    nom_delr_ajs_junc_pmos45_s_body = (1)
+    sig_delr_ajs_junc_pmos45_s_body = (0.0333)
+    ajnd_junc_pmos45_s_body        = (1.1)
+    aeg_junc_pmos45_s_body         = (1.188)
+    aalphaeg_junc_pmos45_s_body    = (459.6e-06)
+    abetaeg_junc_pmos45_s_body     = (601.5)
+    axti_junc_pmos45_s_body        = (2.342)
+    nom_pcj0_junc_pmos45_s_body    = (1.46379e-16)
+    nom_delr_pcj0_junc_pmos45_s_body = (1)
+    sig_delr_pcj0_junc_pmos45_s_body = (0.0333)
+    ptp_junc_pmos45_s_body         = (1.288e-03)
+    pphi_junc_pmos45_s_body        = (0.9)
+    pexm_junc_pmos45_s_body        = (0.1)
+    nom_pjs_junc_pmos45_s_body     = (1.43558e-19)
+    nom_delr_pjs_junc_pmos45_s_body = (1)
+    sig_delr_pjs_junc_pmos45_s_body = (0.0333)
+    pjnd_junc_pmos45_s_body        = (1.1)
+    peg_junc_pmos45_s_body         = (1.188)
+    palphaeg_junc_pmos45_s_body    = (459.6e-06)
+    pbetaeg_junc_pmos45_s_body     = (601.5)
+    pxti_junc_pmos45_s_body        = (2.342)
+    nom_chcj0_junc_pmos45_s_body   = (1.47919e-16)
+    nom_delr_chcj0_junc_pmos45_s_body = (1)
+    sig_delr_chcj0_junc_pmos45_s_body = (0.0333)
+    chphi_junc_pmos45_s_body       = (0.532051)
+    chexm_junc_pmos45_s_body       = (0.299256)
+    nom_chjs_junc_pmos45_s_body    = (5.98856e-20)
+    nom_delr_chjs_junc_pmos45_s_body = (1)
+    sig_delr_chjs_junc_pmos45_s_body = (0.0333)
+    chjnd_junc_pmos45_s_body       = (1.1)
+    nom_acj0_junc_pmos45b_d_body   = (1.38818e-16)
+    nom_delr_acj0_junc_pmos45b_d_body = (1)
+    sig_delr_acj0_junc_pmos45b_d_body = (0.0333)
+    aphi_junc_pmos45b_d_body       = (0.9)
+    pta_junc_pmos45b_d_body        = (1.288e-03)
+    aexm_junc_pmos45b_d_body       = (0.5)
+    nom_ajs_junc_pmos45b_d_body    = (1.72533e-19)
+    nom_delr_ajs_junc_pmos45b_d_body = (1)
+    sig_delr_ajs_junc_pmos45b_d_body = (0.0333)
+    ajnd_junc_pmos45b_d_body       = (1.1)
+    aeg_junc_pmos45b_d_body        = (1.188)
+    aalphaeg_junc_pmos45b_d_body   = (459.6e-06)
+    abetaeg_junc_pmos45b_d_body    = (601.5)
+    axti_junc_pmos45b_d_body       = (2.342)
+    nom_pcj0_junc_pmos45b_d_body   = (1.82008e-16)
+    nom_delr_pcj0_junc_pmos45b_d_body = (1)
+    sig_delr_pcj0_junc_pmos45b_d_body = (0.0333)
+    ptp_junc_pmos45b_d_body        = (2.6207e-03)
+    pphi_junc_pmos45b_d_body       = (0.5)
+    pexm_junc_pmos45b_d_body       = (0.5)
+    nom_pjs_junc_pmos45b_d_body    = (1e-23)
+    nom_delr_pjs_junc_pmos45b_d_body = (1)
+    sig_delr_pjs_junc_pmos45b_d_body = (0.0333)
+    pjnd_junc_pmos45b_d_body       = (1.1)
+    peg_junc_pmos45b_d_body        = (1.188)
