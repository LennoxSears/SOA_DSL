        vary nsig_dela_k3_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_pu0_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_la0_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_vsat_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_pa0_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_la0_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_vsat_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_pa0_nmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_tox_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_rdsw_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_tox_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_rdsw_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_nmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dl_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vsat_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wags_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wwl_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_agidl_pmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_lw_pmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_prsh_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_prsh_pmos45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_prsh_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_prsh_pmoshs45b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_tox_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_tox_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_pmos90b_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_pmos90b_10hv_bsim3v3     dist=gauss std=1
    }
}


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = 0.0
+    nsig_delr_uch_pmos90b_sphv_10hv = 0.0
+    nsig_delr_res_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = 0.0
+    nsig_dela_mueo_pmos90b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = 0.0
+    nsig_delr_is_pmos90b_sphv_10hv = 0.0
+    nsig_delr_is2_pmos90b_sphv_10hv = 0.0
+    nsig_delr_ir_pmos90b_sphv_10hv = 0.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_res_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_tox_nmos10_sphv_10hv = 0.0
+    nsig_delr_uch_nmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos10_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos10_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos10_sphv_10hv = 0.0
+    nsig_delr_thesatl_nmos10_sphv_10hv = 0.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = 0.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos10_sphv_10hv = 0.0
+    nsig_delr_cj_nmos10_sphv_10hv = 0.0
+    nsig_delr_is_nmos10_sphv_10hv = 0.0
+    nsig_delr_is2_nmos10_sphv_10hv = 0.0
+    nsig_delr_ir_nmos10_sphv_10hv = 0.0
+    nsig_delr_tox_pmos45b_sphv_10hv = 0.0
+    nsig_delr_uch_pmos45b_sphv_10hv = 0.0
+    nsig_delr_res_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_pmos45b_sphv_10hv = 0.0
+    nsig_delr_cjs_pmos45b_sphv_10hv = 0.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtm_nmos45b_sphv_10hv = 0.0
+    nsig_delr_mobref_nmos45b_sphv_10hv = 0.0
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = 0.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_tox_pmos10_sphv_10hv = 0.0
+    nsig_delr_uch_pmos10_sphv_10hv = 0.0
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_dl_pmos10_sphv_10hv = 0.0
+    nsig_dela_dw_pmos10_sphv_10hv = 0.0
+    nsig_dela_dlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = 0.0
+    nsig_delr_cj_pmos10_sphv_10hv = 0.0
+    nsig_delr_is_pmos10_sphv_10hv = 0.0
+    nsig_delr_is2_pmos10_sphv_10hv = 0.0
+    nsig_delr_ir_pmos10_sphv_10hv = 0.0
+    nsig_delr_tox_nmos90b_sphv_10hv = 0.0
+    nsig_delr_uch_nmos90b_sphv_10hv = 0.0
+    nsig_delr_res_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = 0.0
+    nsig_dela_dw_nmos90b_sphv_10hv = 0.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_nmos90b_sphv_10hv = 0.0
+    nsig_delr_is_nmos90b_sphv_10hv = 0.0
+    nsig_delr_is2_nmos90b_sphv_10hv = 0.0
+    nsig_delr_ir_nmos90b_sphv_10hv = 0.0
+    nsig_delr_tox_nmos120_sphv_10hv = 0.0
+    nsig_delr_uch_nmos120_sphv_10hv = 0.0
+    nsig_delr_res_nmos120_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtlw_nmos120_sphv_10hv = 0.0
+    nsig_dela_dw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesato_nmos120_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscale_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalel_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalew_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = 0.0
+    nsig_dela_xw_nmos120_sphv_10hv = 0.0
+    nsig_dela_lvarw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = 0.0
+    nsig_delr_is_nmos120_sphv_10hv = 0.0
+    nsig_delr_is2_nmos120_sphv_10hv = 0.0
+    nsig_delr_ir_nmos120_sphv_10hv = 0.0


statistics {
    process {
        vary nsig_delr_tox_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_mueo_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalel_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalew_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalelw_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtm_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dl_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dlw_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjs_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjd_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsideal_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdideal_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsnonideal_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdnonideal_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsdideal_pmoshs45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_thesatl_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_thesatlw_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_lvaro_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtm_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dl_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dlw_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjs_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjd_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsideal_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdideal_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsnonideal_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdnonideal_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsdideal_pmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dl_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dlw_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtm_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_satl_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjs_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cjd_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsideal_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdideal_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jsnonideal_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_jdnonideal_nmos45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtlw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_dl_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_dlw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesato_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatl_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatlw_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalel_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscaleo_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pmos10_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesato_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_lvaro_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalel_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nmos90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtlw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesato_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_lvaro_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalel_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalew_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalelw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_lvarw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatl_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatlw_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nmos120_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nmos120_sphv_10hv dist=gauss std=1
        
    }
}

//***********************************************************
endsection mc_thick_mos_process_params
//***********************************************************

//***********************************************************
section bpln_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (-3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (2.68031)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (0.697053)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (0.437778)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (0.189309)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (-3.07906)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (1.13999)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (-0.650416)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (1.72207)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (0.895592)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (1.74589)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (-0.0523373)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-0.201308)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (-2.5)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (2.2685)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (-2.67489)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.0883759)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (0.893905)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (1.44936)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (-0.299843)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (0.186378)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (-0.175706)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (-0.217203)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (0.316758)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (-0.0629064)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (2.34105)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (-2.81693)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (0.508046)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (1.09833)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (0.287266)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.607233)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0.121117)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (-0.487189)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (-0.150956)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.0877664)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (0.648424)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (-0.137731)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (2.34105)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (-2.81693)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (0.508046)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (1.09833)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (0.287266)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.607233)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0.121117)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (-0.487189)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (-0.150956)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.0877664)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (0.648424)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (-0.137731)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0.6001568)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (2.20941)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (-2.2978)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (0.897718)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.977733)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (0.279809)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-5.34706)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (1.74442)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (-6)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0.231882)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0.6001568)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (2.20941)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (-2.2978)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (0.897718)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.977733)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (0.279809)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-5.34706)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (1.74442)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (-6)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0.231882)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (-2.05112)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (1.14585)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.640187)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (-0.1428)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (-1.07065)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (-0.186741)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (0.508717)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (0.894453)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (-2.37752)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.17376)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (-0.432524)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (-1.92192)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (1.23843)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (-1.7282)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (-0.67775)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (0.136426)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (0.98511)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0.458457)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (0.90877)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (-1.71923)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (1.30494)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (-0.473002)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (-0.898824)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (-0.424276)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.0453067)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (1.28444)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (0.514149)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (-0.111216)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (-2.21048)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (0.315682)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (-1.80148)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (1.48633)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (-0.811163)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (-0.82043)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (-0.349849)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (-0.0260309)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (12.9951)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (-0.0867154)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (-0.895939)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (-2.17337)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (0.67167)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (-1.71306)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (1.31024)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (-0.474836)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (-0.896897)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (-0.377743)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.128735)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (1.30792)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (-0.0935394)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (-2.23852)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0.67167)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (-1.71306)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (1.31024)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (-0.474836)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (-0.896897)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (-0.377743)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.128735)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (1.30792)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (-0.0935394)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (-2.23852)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (5.477)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (-2.105)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (0.2836)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (-1.919)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (-0.5312)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (-1.14)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (-0.03572)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (1.661)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0.1532)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (3.43)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (5.477)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (-2.105*1.1)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (0.2836*1.8)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (-1.919*0.9)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (-0.5312)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (-1.14)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (-0.03572*20)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (1.661*0.9)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0.1532*5)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (3.43)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = 1.3392857
+    nsig_delr_res_pmos90b_sphv_10hv = -3.64705882
+    nsig_dela_vfb_pmos90b_sphv_10hv = -2.0079
+    nsig_dela_vtw_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = 3.4021505
+    nsig_dela_mueo_pmos90b_sphv_10hv = 3.6
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = -0.816
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = 2.99898
+    nsig_delr_res_pmoshs45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = -2.011
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = 1.65
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = -1.1
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = 2.111
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos10_sphv_10hv = -3.0
+    nsig_delr_uch_nmos10_sphv_10hv = -1.75
+    nsig_dela_vfb_nmos10_sphv_10hv = 2.57
+    nsig_dela_vtl_nmos10_sphv_10hv = -0.22222222
+    nsig_dela_vtw_nmos10_sphv_10hv = -0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = -2.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = 1.5
+    nsig_dela_vdscale_nmos10_sphv_10hv = 0.25
+    nsig_dela_lvaro_nmos10_sphv_10hv = 1.5
+    nsig_delr_cj_nmos10_sphv_10hv = 3.0
+    nsig_delr_is_nmos10_sphv_10hv = -3.0
+    nsig_delr_is2_nmos10_sphv_10hv = -3.0
+    nsig_delr_ir_nmos10_sphv_10hv = -3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = 2.931
+    nsig_delr_res_pmos45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = -2.005
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = 2.15
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = -1.54545
+    nsig_dela_dlw_pmos45b_sphv_10hv = 1.8
+    nsig_delr_cjs_pmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = 2.334
+    nsig_dela_vtw_nmos45b_sphv_10hv = 1.0534
+    nsig_dela_vtl_nmos45b_sphv_10hv = 2.01617
+    nsig_dela_vtm_nmos45b_sphv_10hv = 1.10195
+    nsig_delr_mobref_nmos45b_sphv_10hv = -3.0
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = 1.5
+    nsig_delr_cjs_nmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_tox_pmos10_sphv_10hv = -3.0
+    nsig_delr_uch_pmos10_sphv_10hv = 0.96
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = -2.328
+    nsig_dela_vtl_pmos10_sphv_10hv = -2.565
+    nsig_dela_vtw_pmos10_sphv_10hv = 2.366
+    nsig_dela_vtlw_pmos10_sphv_10hv = 2.66
+    nsig_dela_dl_pmos10_sphv_10hv = -1.9
+    nsig_dela_dw_pmos10_sphv_10hv = 1.805
+    nsig_dela_dlw_pmos10_sphv_10hv = 0.527
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = -2.974
+    nsig_delr_cj_pmos10_sphv_10hv = -3.0
+    nsig_delr_is_pmos10_sphv_10hv = 3.0
+    nsig_delr_is2_pmos10_sphv_10hv = 3.0
+    nsig_delr_ir_pmos10_sphv_10hv = 3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = -1.7
+    nsig_delr_res_nmos90b_sphv_10hv = 1.5
+    nsig_dela_vfb_nmos90b_sphv_10hv = 2.8333333
+    nsig_dela_vtw_nmos90b_sphv_10hv = 4.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = -3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = 3.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = -2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = 1.8
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = -3.0
+    nsig_delr_cj_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_nmos120_sphv_10hv = -3.0
+    nsig_delr_uch_nmos120_sphv_10hv = -3.74
+    nsig_delr_res_nmos120_sphv_10hv = 1.33
+    nsig_dela_vfb_nmos120_sphv_10hv = 3.0
+    nsig_dela_vtw_nmos120_sphv_10hv = -3.36666666667
+    nsig_dela_vtl_nmos120_sphv_10hv = -3.02857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 1.86666666667
+    nsig_dela_dw_nmos120_sphv_10hv = -3.0
+    nsig_dela_thesato_nmos120_sphv_10hv = 1.104
+    nsig_dela_lvaro_nmos120_sphv_10hv = -3.0
+    nsig_dela_vdscale_nmos120_sphv_10hv = -0.966666666667
+    nsig_dela_vdscalel_nmos120_sphv_10hv = -0.4375
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -0.75
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = 1.62
+    nsig_dela_xw_nmos120_sphv_10hv = -0.714333333333
+    nsig_dela_lvarw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = 1.5
+    nsig_delr_is_nmos120_sphv_10hv = -1.5
+    nsig_delr_is2_nmos120_sphv_10hv = -1.5
+    nsig_delr_ir_nmos120_sphv_10hv = -1.5


//***********************************************************
endsection bpln_thick_mos_process_params
//***********************************************************

//***********************************************************
section bnlp_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (-3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (-2.04424)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (-1.57989)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (0.11537)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (-0.138234)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (1.37075)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (-1.75337)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (1.28923)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (-0.225125)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (-1.38678)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (-3.95237)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (0.803969)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-1.88573)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (-2.37528)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (1.09365)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.411964)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (4.28408)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (-2.05622)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (-0.346249)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (-0.00218096)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (1.14442)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (0.435824)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (-0.555343)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (0.642841)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (-2.35909)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (1.16321)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (-1.57185)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (-0.451929)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (-0.292768)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.495944)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0.815741)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (2.2441)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (0.219333)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.0608014)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (-3.00159)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (-1.39461)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (-2.35909)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (1.16321)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (-1.57185)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (-0.451929)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (-0.292768)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.495944)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0.815741)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (2.2441)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (0.219333)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.0608014)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (-3.00159)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (-1.39461)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (-0.279217)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (-2.40499)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (1.62783)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (-0.806101)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.83878)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (-0.455793)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-4.59913)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (-7.41483)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (-0.971681)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0.274579)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (-0.279217)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (-2.40499)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (1.62783)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (-0.806101)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.83878)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (-0.455793)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-4.59913)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (-7.41483)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (-0.971681)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0.274579)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (2.79904)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (-2.63761)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.273327)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (1.44441)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (0.752812)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0.380342)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (-0.675887)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (-0.487104)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (5.01541)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.342707)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (0.286973)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (2.19112)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (-1.77196)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (0.60019)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (-0.0511372)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (-0.369159)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (0.14318)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0.568243)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (1.08835)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (3.61768)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (-2.7096)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (-1.2791)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (0.594433)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (0.459312)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.346121)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (0.144618)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (-2.69747)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (3.51306)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (1.32622)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (3.01218)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (3.56642)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (-2.49006)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (-1.09451)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (0.640877)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (0.354525)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0.0501289)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (-3.28181)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (-1.25083)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (1.05573)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (1.27287)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (1.85332)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (3.64435)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (-2.74582)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (-1.28673)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0.59942)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0.227316)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.328807)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (0.0104592)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (3.59132)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (1.33054)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0.5332)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (3.64435)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (-2.74582)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0.8673)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0.59942)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0.227316)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.328807)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (0.0104592)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0.29132)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (1.33054)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (-1.492)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (2.163)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (-1.189)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (0.541)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (0.4027)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (0.2972)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (0.04845)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (-0.5276)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (-0.2702)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (-0.7203)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (-1.492)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (2.163)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (-1.189)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (0.541)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (0.4027)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (0.2972)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (0.04845*5)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (-0.5276)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (-0.2702)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (-0.7203)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = -2.2
+    nsig_delr_res_pmos90b_sphv_10hv = 2.0
+    nsig_dela_vfb_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vtw_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = -2.1075269
+    nsig_dela_mueo_pmos90b_sphv_10hv = -3.0
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = -6.6049
+    nsig_delr_res_pmoshs45b_sphv_10hv = 1.5
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = 2.953
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = -2.98
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = -1.3046
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 3.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = 1.5
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = -3.333
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_tox_nmos10_sphv_10hv = -3.0
+    nsig_delr_uch_nmos10_sphv_10hv = 1.5
+    nsig_dela_vfb_nmos10_sphv_10hv = -2.45
+    nsig_dela_vtl_nmos10_sphv_10hv = 1.05555556
+    nsig_dela_vtw_nmos10_sphv_10hv = 0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = 2.9
+    nsig_delr_thesatlw_nmos10_sphv_10hv = -3.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = -0.66
+    nsig_dela_lvaro_nmos10_sphv_10hv = -1.93
+    nsig_delr_cj_nmos10_sphv_10hv = -3.0
+    nsig_delr_is_nmos10_sphv_10hv = 3.0
+    nsig_delr_is2_nmos10_sphv_10hv = 3.0
+    nsig_delr_ir_nmos10_sphv_10hv = 3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = -6.453
+    nsig_delr_res_pmos45b_sphv_10hv = 1.5
+    nsig_dela_vfb_pmos45b_sphv_10hv = 2.95
+    nsig_dela_vtw_pmos45b_sphv_10hv = -2.98
+    nsig_dela_vtl_pmos45b_sphv_10hv = -1.43
+    nsig_dela_vtm_pmos45b_sphv_10hv = 3.1
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = 1.364
+    nsig_dela_dlw_pmos45b_sphv_10hv = -1.607
+    nsig_delr_cjs_pmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = -3.608
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 3.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = -2.6953
+    nsig_dela_vtw_nmos45b_sphv_10hv = -2.51333
+    nsig_dela_vtl_nmos45b_sphv_10hv = -0.8154
+    nsig_dela_vtm_nmos45b_sphv_10hv = -2.33977
+    nsig_delr_mobref_nmos45b_sphv_10hv = 0.83333
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = -3.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_tox_pmos10_sphv_10hv = -3.0
+    nsig_delr_uch_pmos10_sphv_10hv = -2.306
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = 2.915
+    nsig_dela_vtl_pmos10_sphv_10hv = 1.568
+    nsig_dela_vtw_pmos10_sphv_10hv = 0.697
+    nsig_dela_vtlw_pmos10_sphv_10hv = -1.33
+    nsig_dela_dl_pmos10_sphv_10hv = 1.026
+    nsig_dela_dw_pmos10_sphv_10hv = -1.818
+    nsig_dela_dlw_pmos10_sphv_10hv = -0.428
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = -0.191
+    nsig_delr_cj_pmos10_sphv_10hv = 3.0
+    nsig_delr_is_pmos10_sphv_10hv = -3.0
+    nsig_delr_is2_pmos10_sphv_10hv = -3.0
+    nsig_delr_ir_pmos10_sphv_10hv = -3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = 1.6
+    nsig_delr_res_nmos90b_sphv_10hv = -3.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = -2.4583333
+    nsig_dela_vtw_nmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = -4.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = 2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = -3.5
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = 2.6
+    nsig_delr_cj_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos120_sphv_10hv = -3.0
+    nsig_delr_uch_nmos120_sphv_10hv = 1.53
+    nsig_delr_res_nmos120_sphv_10hv = -3.0476
+    nsig_dela_vfb_nmos120_sphv_10hv = -1.78666666667
+    nsig_dela_vtw_nmos120_sphv_10hv = 0.8
+    nsig_dela_vtl_nmos120_sphv_10hv = 1.74857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 2.93333333333
+    nsig_dela_dw_nmos120_sphv_10hv = 2.30769230769
+    nsig_dela_thesato_nmos120_sphv_10hv = 0.88
+    nsig_dela_lvaro_nmos120_sphv_10hv = 1.515
+    nsig_dela_vdscale_nmos120_sphv_10hv = 0.9
+    nsig_dela_vdscalel_nmos120_sphv_10hv = 1.08125
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -1.05
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = -3.0
+    nsig_dela_xw_nmos120_sphv_10hv = 1.03
+    nsig_dela_lvarw_nmos120_sphv_10hv = 3.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = -3.0
+    nsig_delr_is_nmos120_sphv_10hv = 3.0
+    nsig_delr_is2_nmos120_sphv_10hv = 3.0
+    nsig_delr_ir_nmos120_sphv_10hv = 3.0


//***********************************************************
endsection bnlp_thick_mos_process_params
//***********************************************************

//***********************************************************
section bcs_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (-3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (-2.04424)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (-1.57989)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (0.11537)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (-0.138234)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (1.37075)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (-1.75337)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (1.28923)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (-0.225125)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (-1.38678)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (-3.95237)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (0.803969)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-1.88573)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (-2.37528)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (1.09365)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.411964)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (4.28408)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (-2.05622)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (-0.346249)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (-0.00218096)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (1.14442)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (0.435824)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (-0.555343)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (0.642841)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (-2.35909)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (1.16321)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (-1.57185)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (-0.451929)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (-0.292768)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.495944)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0.815741)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (2.2441)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (0.219333)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.0608014)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (-3.00159)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (-1.39461)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (-2.35909)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (1.16321)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (-1.57185)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (-0.451929)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (-0.292768)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.495944)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0.815741)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (2.2441)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (0.219333)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.0608014)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (-3.00159)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (-1.39461)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (-0.279217)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (-2.40499)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (1.62783)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (-0.806101)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.83878)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (-0.455793)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-4.59913)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (-7.41483)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (-0.971681)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0.274579)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (-0.279217)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (-2.40499)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (1.62783)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (-0.806101)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.83878)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (-0.455793)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-4.59913)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (-7.41483)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (-0.971681)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0.274579)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (-2.05112)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (1.14585)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.640187)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (-0.1428)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (-1.07065)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (-0.186741)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (0.508717)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (0.894453)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (-2.37752)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.17376)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (-0.432524)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (-1.92192)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (1.23843)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (-1.7282)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (-0.67775)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (0.136426)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (0.98511)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0.458457)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (0.90877)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (-1.71923)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (1.30494)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (-0.473002)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (-0.898824)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (-0.424276)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.0453067)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (1.28444)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (0.514149)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (-0.111216)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (-2.21048)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (0.315682)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (-1.80148)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (1.48633)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (-0.811163)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (-0.82043)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (-0.349849)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (-0.0260309)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (12.9951)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (-0.0867154)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (-0.895939)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (-2.17337)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (0.67167)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (-1.71306)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (1.31024)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (-0.474836)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (-0.896897)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (-0.377743)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.128735)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (1.30792)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (-0.0935394)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (-2.23852)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0.67167)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (-1.71306)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (1.31024)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (-0.474836)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (-0.896897)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (-0.377743)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.128735)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (1.30792)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (-0.0935394)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (-2.23852)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (5.477)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (-2.105)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (0.2836)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (-1.919)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (-0.5312)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (-1.14)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (-0.03572)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (1.661)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0.1532)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (3.43)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (-3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (5.477)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (-2.105*1.1)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (0.2836*1.8)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (-1.919*0.9)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (-0.5312)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (-1.14)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (-0.03572*20)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (1.661*0.9)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0.1532*5)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (3.43)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = 1.3392857
+    nsig_delr_res_pmos90b_sphv_10hv = -3.64705882
+    nsig_dela_vfb_pmos90b_sphv_10hv = -2.0079
+    nsig_dela_vtw_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = 3.4021505
+    nsig_dela_mueo_pmos90b_sphv_10hv = 3.6
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = -0.816
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = 2.99898
+    nsig_delr_res_pmoshs45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = -2.011
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = 1.65
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = -1.1
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = 2.111
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos10_sphv_10hv = -3.0
+    nsig_delr_uch_nmos10_sphv_10hv = 1.5
+    nsig_dela_vfb_nmos10_sphv_10hv = -2.45
+    nsig_dela_vtl_nmos10_sphv_10hv = 1.05555556
+    nsig_dela_vtw_nmos10_sphv_10hv = 0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = 2.9
+    nsig_delr_thesatlw_nmos10_sphv_10hv = -3.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = -0.66
+    nsig_dela_lvaro_nmos10_sphv_10hv = -1.93
+    nsig_delr_cj_nmos10_sphv_10hv = -3.0
+    nsig_delr_is_nmos10_sphv_10hv = 3.0
+    nsig_delr_is2_nmos10_sphv_10hv = 3.0
+    nsig_delr_ir_nmos10_sphv_10hv = 3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = -3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = 2.931
+    nsig_delr_res_pmos45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = -2.005
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = 2.15
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = -1.54545
+    nsig_dela_dlw_pmos45b_sphv_10hv = 1.8
+    nsig_delr_cjs_pmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 3.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = -2.6881
+    nsig_dela_vtw_nmos45b_sphv_10hv = -2.51328
+    nsig_dela_vtl_nmos45b_sphv_10hv = -0.8154
+    nsig_dela_vtm_nmos45b_sphv_10hv = -2.33977
+    nsig_delr_mobref_nmos45b_sphv_10hv = 0.83333
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = -3.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_tox_pmos10_sphv_10hv = -3.0
+    nsig_delr_uch_pmos10_sphv_10hv = 0.96
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = -2.328
+    nsig_dela_vtl_pmos10_sphv_10hv = -2.565
+    nsig_dela_vtw_pmos10_sphv_10hv = 2.366
+    nsig_dela_vtlw_pmos10_sphv_10hv = 2.66
+    nsig_dela_dl_pmos10_sphv_10hv = -1.9
+    nsig_dela_dw_pmos10_sphv_10hv = 1.805
+    nsig_dela_dlw_pmos10_sphv_10hv = 0.527
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = -2.974
+    nsig_delr_cj_pmos10_sphv_10hv = -3.0
+    nsig_delr_is_pmos10_sphv_10hv = 3.0
+    nsig_delr_is2_pmos10_sphv_10hv = 3.0
+    nsig_delr_ir_pmos10_sphv_10hv = 3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = -3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = 1.6
+    nsig_delr_res_nmos90b_sphv_10hv = -3.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = -2.4583333
+    nsig_dela_vtw_nmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = -4.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = 2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = -3.5
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = 2.6
+    nsig_delr_cj_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos120_sphv_10hv = -3.0
+    nsig_delr_uch_nmos120_sphv_10hv = 1.53
+    nsig_delr_res_nmos120_sphv_10hv = -3.0476
+    nsig_dela_vfb_nmos120_sphv_10hv = -1.78666666667
+    nsig_dela_vtw_nmos120_sphv_10hv = 0.8
+    nsig_dela_vtl_nmos120_sphv_10hv = 1.74857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 2.93333333333
+    nsig_dela_dw_nmos120_sphv_10hv = 2.30769230769
+    nsig_dela_thesato_nmos120_sphv_10hv = 0.88
+    nsig_dela_lvaro_nmos120_sphv_10hv = 1.515
+    nsig_dela_vdscale_nmos120_sphv_10hv = 0.9
+    nsig_dela_vdscalel_nmos120_sphv_10hv = 1.08125
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -1.05
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = -3.0
+    nsig_dela_xw_nmos120_sphv_10hv = 1.03
+    nsig_dela_lvarw_nmos120_sphv_10hv = 3.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = -3.0
+    nsig_delr_is_nmos120_sphv_10hv = 3.0
+    nsig_delr_is2_nmos120_sphv_10hv = 3.0
+    nsig_delr_ir_nmos120_sphv_10hv = 3.0


//***********************************************************
endsection bcs_thick_mos_process_params
//***********************************************************

//***********************************************************
section lo_res_process_params
//***********************************************************

parameters
+    nsig_delr_rs_poly_silicide     = (-2.832)
+    nsig_dela_dw_poly_silicide     = (3.0)
+    nsig_dela_dl_poly_silicide     = (3.0)
+    nsig_delr_rs_poly0_r3          = (-3.097)
+    nsig_dela_dw_poly0_r3          = (3.121)
+    nsig_dela_dl_poly0_r3          = (3.085)
+    nsig_dela_dlw_poly0_r3         = (-3.499)
+    nsig_dela_tc1_poly0_r3         = (3.0)
+    nsig_dela_tc2_poly0_r3         = (-3.0)
+    nsig_delr_rs_poly_r3           = (-2.9607)
+    nsig_dela_dw_poly_r3           = (1.76318)
+    nsig_dela_dl_poly_r3           = (-1.39144)
+    nsig_delr_rs_phv_nbl_r3        = (-2.85292)
+    nsig_dela_dw_phv_nbl_r3        = (1.2327)
+    nsig_dela_dl_phv_nbl_r3        = (-1.5308)
+    nsig_delr_rs_hvpw_nbl_r3       = (-2.75879)
+    nsig_dela_dw_hvpw_nbl_r3       = (2.23038)
+    nsig_dela_dl_hvpw_nbl_r3       = (-2.03314)
+    nsig_delr_rs_nwell_pepi        = (-2.54033)
+    nsig_dela_dw_nwell_pepi        = (1.44963)
+    nsig_dela_dl_nwell_pepi        = (-1.74287)
+    nsig_delr_rs_poly_1meg_r3      = (-3.00001)
+    nsig_delr_rs_m1                = (-2.99996)
+    nsig_dela_dw_m1                = (3.0)
+    nsig_dela_dl_m1                = (-3.0)
+    nsig_delr_rs_m2                = (-2.9993)
+    nsig_dela_dw_m2                = (3.0)
+    nsig_dela_dl_m2                = (-3.0)
+    nsig_delr_rs_m3                = (-2.999767)
+    nsig_dela_dw_m3                = (3.0)
+    nsig_dela_dl_m3                = (-3.0)
+    nsig_delr_rs_m4                = (-2.998587)
+    nsig_dela_dw_m4                = (3.0)
+    nsig_dela_dl_m4                = (-3.0)
+    nsig_delr_rs_alcap             = (-2.99999)
+    nsig_dela_dw_alcap             = (0.0)
+    nsig_dela_dl_alcap             = (0.0)
+    nsig_delr_rs_ulm               = (-2.993)
+    nsig_dela_dw_ulm               = (3.0)
+    nsig_dela_dl_ulm               = (-3.0)
+    nsig_on_antifuse_t             = (-2.0)
+    nsig_off_antifuse_t            = (-2.5)

//***********************************************************
endsection lo_res_process_params
//***********************************************************

//***********************************************************
section typ_res_process_params
//***********************************************************

parameters
+    nsig_delr_rs_poly_silicide     = (0)
+    nsig_dela_dw_poly_silicide     = (0)
+    nsig_dela_dl_poly_silicide     = (0)
+    nsig_delr_rs_poly0_r3          = (0)
+    nsig_dela_dw_poly0_r3          = (0)
+    nsig_dela_dl_poly0_r3          = (0)
+    nsig_dela_dlw_poly0_r3         = (0)
+    nsig_dela_tc1_poly0_r3         = (0)
+    nsig_dela_tc2_poly0_r3         = (0)
+    nsig_delr_rs_poly_r3           = (0)
+    nsig_dela_dw_poly_r3           = (0)
+    nsig_dela_dl_poly_r3           = (0)
+    nsig_delr_rs_phv_nbl_r3        = (0)
+    nsig_dela_dw_phv_nbl_r3        = (0)
+    nsig_dela_dl_phv_nbl_r3        = (0)
+    nsig_delr_rs_hvpw_nbl_r3       = (0)
+    nsig_dela_dw_hvpw_nbl_r3       = (0)
+    nsig_dela_dl_hvpw_nbl_r3       = (0)
+    nsig_delr_rs_nwell_pepi        = (0)
+    nsig_dela_dw_nwell_pepi        = (0)
+    nsig_dela_dl_nwell_pepi        = (0)
+    nsig_delr_rs_poly_1meg_r3      = (0)
+    nsig_delr_rs_m1                = (0)
+    nsig_dela_dw_m1                = (0)
+    nsig_dela_dl_m1                = (0)
+    nsig_delr_rs_m2                = (0)
+    nsig_dela_dw_m2                = (0)
+    nsig_dela_dl_m2                = (0)
+    nsig_delr_rs_m3                = (0)
+    nsig_dela_dw_m3                = (0)
+    nsig_dela_dl_m3                = (0)
+    nsig_delr_rs_m4                = (0)
+    nsig_dela_dw_m4                = (0)
+    nsig_dela_dl_m4                = (0)
+    nsig_delr_rs_alcap             = (0)
+    nsig_dela_dw_alcap             = (0)
+    nsig_dela_dl_alcap             = (0)
+    nsig_delr_rs_ulm               = (0)
+    nsig_dela_dw_ulm               = (0)
+    nsig_dela_dl_ulm               = (0)
+    nsig_on_antifuse_t             = (0)
+    nsig_off_antifuse_t            = (0)

//***********************************************************
endsection typ_res_process_params
//***********************************************************

//***********************************************************
section mc_res_process_params
//***********************************************************

parameters
+    nsig_delr_rs_poly_silicide     = (0)
+    nsig_dela_dw_poly_silicide     = (0)
+    nsig_dela_dl_poly_silicide     = (0)
+    nsig_delr_rs_poly0_r3          = (0)
+    nsig_dela_dw_poly0_r3          = (0)
+    nsig_dela_dl_poly0_r3          = (0)
+    nsig_dela_dlw_poly0_r3         = (0)
+    nsig_dela_tc1_poly0_r3         = (0)
+    nsig_dela_tc2_poly0_r3         = (0)
+    nsig_delr_rs_poly_r3           = (0)
+    nsig_dela_dw_poly_r3           = (0)
+    nsig_dela_dl_poly_r3           = (0)
+    nsig_delr_rs_phv_nbl_r3        = (0)
+    nsig_dela_dw_phv_nbl_r3        = (0)
+    nsig_dela_dl_phv_nbl_r3        = (0)
+    nsig_delr_rs_hvpw_nbl_r3       = (0)
+    nsig_dela_dw_hvpw_nbl_r3       = (0)
+    nsig_dela_dl_hvpw_nbl_r3       = (0)
+    nsig_delr_rs_nwell_pepi        = (0)
+    nsig_dela_dw_nwell_pepi        = (0)
+    nsig_dela_dl_nwell_pepi        = (0)
+    nsig_delr_rs_poly_1meg_r3      = (0)
+    nsig_delr_rs_m1                = (0)
+    nsig_dela_dw_m1                = (0)
+    nsig_dela_dl_m1                = (0)
+    nsig_delr_rs_m2                = (0)
+    nsig_dela_dw_m2                = (0)
+    nsig_dela_dl_m2                = (0)
+    nsig_delr_rs_m3                = (0)
+    nsig_dela_dw_m3                = (0)
+    nsig_dela_dl_m3                = (0)
+    nsig_delr_rs_m4                = (0)
+    nsig_dela_dw_m4                = (0)
+    nsig_dela_dl_m4                = (0)
+    nsig_delr_rs_alcap             = (0)
+    nsig_dela_dw_alcap             = (0)
+    nsig_dela_dl_alcap             = (0)
+    nsig_delr_rs_ulm               = (0)
+    nsig_dela_dw_ulm               = (0)
+    nsig_dela_dl_ulm               = (0)
+    nsig_on_antifuse_t             = (0)
+    nsig_off_antifuse_t            = (0)

statistics {
    process {
        vary nsig_delr_rs_poly_silicide     dist=gauss std=1
        vary nsig_dela_dw_poly_silicide     dist=gauss std=1
        vary nsig_dela_dl_poly_silicide     dist=gauss std=1
        vary nsig_delr_rs_poly0_r3     dist=gauss std=1
        vary nsig_dela_dw_poly0_r3     dist=gauss std=1
        vary nsig_dela_dl_poly0_r3     dist=gauss std=1
        vary nsig_dela_dlw_poly0_r3     dist=gauss std=1
        vary nsig_dela_tc1_poly0_r3     dist=gauss std=1
        vary nsig_dela_tc2_poly0_r3     dist=gauss std=1
        vary nsig_delr_rs_poly_r3     dist=gauss std=1
        vary nsig_dela_dw_poly_r3     dist=gauss std=1
        vary nsig_dela_dl_poly_r3     dist=gauss std=1
        vary nsig_delr_rs_phv_nbl_r3     dist=gauss std=1
        vary nsig_dela_dw_phv_nbl_r3     dist=gauss std=1
        vary nsig_dela_dl_phv_nbl_r3     dist=gauss std=1
        vary nsig_delr_rs_hvpw_nbl_r3     dist=gauss std=1
        vary nsig_dela_dw_hvpw_nbl_r3     dist=gauss std=1
        vary nsig_dela_dl_hvpw_nbl_r3     dist=gauss std=1
        vary nsig_delr_rs_nwell_pepi     dist=gauss std=1
        vary nsig_dela_dw_nwell_pepi     dist=gauss std=1
        vary nsig_dela_dl_nwell_pepi     dist=gauss std=1
        vary nsig_delr_rs_poly_1meg_r3     dist=gauss std=1
        vary nsig_delr_rs_m1     dist=gauss std=1
        vary nsig_dela_dw_m1     dist=gauss std=1
        vary nsig_dela_dl_m1     dist=gauss std=1
        vary nsig_delr_rs_m2     dist=gauss std=1
        vary nsig_dela_dw_m2     dist=gauss std=1
        vary nsig_dela_dl_m2     dist=gauss std=1
        vary nsig_delr_rs_m3     dist=gauss std=1
        vary nsig_dela_dw_m3     dist=gauss std=1
        vary nsig_dela_dl_m3     dist=gauss std=1
        vary nsig_delr_rs_m4     dist=gauss std=1
        vary nsig_dela_dw_m4     dist=gauss std=1
        vary nsig_dela_dl_m4     dist=gauss std=1
        vary nsig_delr_rs_alcap     dist=gauss std=1
        vary nsig_dela_dw_alcap     dist=gauss std=1
        vary nsig_dela_dl_alcap     dist=gauss std=1
        vary nsig_delr_rs_ulm     dist=gauss std=1
        vary nsig_dela_dw_ulm     dist=gauss std=1
        vary nsig_dela_dl_ulm     dist=gauss std=1
        vary nsig_on_antifuse_t     dist=gauss std=1
        vary nsig_off_antifuse_t     dist=gauss std=1
    }
}

//***********************************************************
endsection mc_res_process_params
//***********************************************************

//***********************************************************
section hi_res_process_params
//***********************************************************

parameters
+    nsig_delr_rs_poly_silicide     = (2.124)
+    nsig_dela_dw_poly_silicide     = (-3.0)
+    nsig_dela_dl_poly_silicide     = (-3.0)
+    nsig_delr_rs_poly0_r3          = (3.097)
+    nsig_dela_dw_poly0_r3          = (-2.135)
+    nsig_dela_dl_poly0_r3          = (-2.15)
+    nsig_dela_dlw_poly0_r3         = (2.397)
+    nsig_dela_tc1_poly0_r3         = (-3.0)
+    nsig_dela_tc2_poly0_r3         = (3.0)
+    nsig_delr_rs_poly_r3           = (2.96653)
+    nsig_dela_dw_poly_r3           = (-1.10026)
+    nsig_dela_dl_poly_r3           = (0.871801)
+    nsig_delr_rs_phv_nbl_r3        = (2.86461)
+    nsig_dela_dw_phv_nbl_r3        = (-1.00589)
+    nsig_dela_dl_phv_nbl_r3        = (1.2662)
+    nsig_delr_rs_hvpw_nbl_r3       = (2.77341)
+    nsig_dela_dw_hvpw_nbl_r3       = (-1.82363)
+    nsig_dela_dl_hvpw_nbl_r3       = (1.88051)
+    nsig_delr_rs_nwell_pepi        = (2.58402)
+    nsig_dela_dw_nwell_pepi        = (-1.17251)
+    nsig_dela_dl_nwell_pepi        = (1.45351)
+    nsig_delr_rs_poly_1meg_r3      = (3.00001)
+    nsig_delr_rs_m1                = (3.00006)
+    nsig_dela_dw_m1                = (-3.0)
+    nsig_dela_dl_m1                = (3.0)
+    nsig_delr_rs_m2                = (3.00081)
+    nsig_dela_dw_m2                = (-3.0)
+    nsig_dela_dl_m2                = (3.0)
+    nsig_delr_rs_m3                = (3.00125)
+    nsig_dela_dw_m3                = (-3.0)
+    nsig_dela_dl_m3                = (3.0)
+    nsig_delr_rs_m4                = (3.00142)
+    nsig_dela_dw_m4                = (-3.0)
+    nsig_dela_dl_m4                = (3.0)
+    nsig_delr_rs_alcap             = (2.99999)
+    nsig_dela_dw_alcap             = (0.0)
+    nsig_dela_dl_alcap             = (0.0)
+    nsig_delr_rs_ulm               = (3.0)
+    nsig_dela_dw_ulm               = (-3.0)
+    nsig_dela_dl_ulm               = (3.0)
+    nsig_on_antifuse_t             = (6.0)
+    nsig_off_antifuse_t            = (3.0)

//***********************************************************
endsection hi_res_process_params
//***********************************************************

//***********************************************************
section bcs_bjt_process_params
//***********************************************************

parameters
+    nsig_delr_psbe_npn_10hv_vbic   = (3.56914)
+    nsig_delr_psb_npn_10hv_vbic    = (0)
+    nsig_dela_dle_npn_10hv_vbic    = (0.435879)
+    nsig_delr_jbei_npn_10hv_vbic   = (-1.1797)
+    nsig_delr_jben_npn_10hv_vbic   = (-3.14523)
+    nsig_delr_x_col_npn_10hv_vbic  = (0)
+    nsig_delr_n_epi_npn_10hv_vbic  = (0)
+    nsig_delr_psbe_npn_b_10hv_vbic = (3.56914)
+    nsig_delr_psb_npn_b_10hv_vbic  = (0)
+    nsig_dela_dle_npn_b_10hv_vbic  = (2.4)
+    nsig_delr_jbei_npn_b_10hv_vbic = (-1.55)
+    nsig_delr_jben_npn_b_10hv_vbic = (-5)
+    nsig_delr_x_col_npn_b_10hv_vbic = (0)
+    nsig_delr_n_epi_npn_b_10hv_vbic = (0)
+    nsig_dela_dle_pnp_10hv_vbic    = (0.779259)
+    nsig_delr_psbe_pnp_10hv_vbic   = (2.93787)
+    nsig_delr_psb_pnp_10hv_vbic    = (0)
+    nsig_delr_jbei_pnp_10hv_vbic   = (-3.27743)
+    nsig_delr_jben_pnp_10hv_vbic   = (-1.19334)
+    nsig_delr_n_col_pnp_10hv_vbic  = (0)
+    nsig_delr_x_col_pnp_10hv_vbic  = (0)
+    nsig_dela_dle_pnp_iso_10hv_vbic = (0.77206)
+    nsig_delr_psbe_pnp_iso_10hv_vbic = (2.94139)
+    nsig_delr_psb_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jbei_pnp_iso_10hv_vbic = (-3.21654)
+    nsig_delr_jben_pnp_iso_10hv_vbic = (-1.34593)
+    nsig_delr_n_col_pnp_iso_10hv_vbic = (0)
+    nsig_delr_x_col_pnp_iso_10hv_vbic = (0)

//***********************************************************
endsection bcs_bjt_process_params
//***********************************************************

//***********************************************************
section typ_bjt_process_params
//***********************************************************

parameters
+    nsig_delr_psbe_npn_10hv_vbic   = (0)
+    nsig_delr_psb_npn_10hv_vbic    = (0)
+    nsig_dela_dle_npn_10hv_vbic    = (0)
+    nsig_delr_jbei_npn_10hv_vbic   = (0)
+    nsig_delr_jben_npn_10hv_vbic   = (0)
+    nsig_delr_x_col_npn_10hv_vbic  = (0)
+    nsig_delr_n_epi_npn_10hv_vbic  = (0)
+    nsig_delr_psbe_npn_b_10hv_vbic = (0)
+    nsig_delr_psb_npn_b_10hv_vbic  = (0)
+    nsig_dela_dle_npn_b_10hv_vbic  = (0)
+    nsig_delr_jbei_npn_b_10hv_vbic = (0)
+    nsig_delr_jben_npn_b_10hv_vbic = (0)
+    nsig_delr_x_col_npn_b_10hv_vbic = (0)
+    nsig_delr_n_epi_npn_b_10hv_vbic = (0)
+    nsig_dela_dle_pnp_10hv_vbic    = (0)
+    nsig_delr_psbe_pnp_10hv_vbic   = (0)
+    nsig_delr_psb_pnp_10hv_vbic    = (0)
+    nsig_delr_jbei_pnp_10hv_vbic   = (0)
+    nsig_delr_jben_pnp_10hv_vbic   = (0)
+    nsig_delr_n_col_pnp_10hv_vbic  = (0)
+    nsig_delr_x_col_pnp_10hv_vbic  = (0)
+    nsig_dela_dle_pnp_iso_10hv_vbic = (0)
+    nsig_delr_psbe_pnp_iso_10hv_vbic = (0)
+    nsig_delr_psb_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jbei_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jben_pnp_iso_10hv_vbic = (0)
+    nsig_delr_n_col_pnp_iso_10hv_vbic = (0)
+    nsig_delr_x_col_pnp_iso_10hv_vbic = (0)

//***********************************************************
endsection typ_bjt_process_params
//***********************************************************

//***********************************************************
section mc_bjt_process_params
//***********************************************************

parameters
+    nsig_delr_psbe_npn_10hv_vbic   = (0)
+    nsig_delr_psb_npn_10hv_vbic    = (0)
+    nsig_dela_dle_npn_10hv_vbic    = (0)
+    nsig_delr_jbei_npn_10hv_vbic   = (0)
+    nsig_delr_jben_npn_10hv_vbic   = (0)
+    nsig_delr_x_col_npn_10hv_vbic  = (0)
+    nsig_delr_n_epi_npn_10hv_vbic  = (0)
+    nsig_delr_psbe_npn_b_10hv_vbic = (0)
+    nsig_delr_psb_npn_b_10hv_vbic  = (0)
+    nsig_dela_dle_npn_b_10hv_vbic  = (0)
+    nsig_delr_jbei_npn_b_10hv_vbic = (0)
+    nsig_delr_jben_npn_b_10hv_vbic = (0)
+    nsig_delr_x_col_npn_b_10hv_vbic = (0)
+    nsig_delr_n_epi_npn_b_10hv_vbic = (0)
+    nsig_dela_dle_pnp_10hv_vbic    = (0)
+    nsig_delr_psbe_pnp_10hv_vbic   = (0)
+    nsig_delr_psb_pnp_10hv_vbic    = (0)
+    nsig_delr_jbei_pnp_10hv_vbic   = (0)
+    nsig_delr_jben_pnp_10hv_vbic   = (0)
+    nsig_delr_n_col_pnp_10hv_vbic  = (0)
+    nsig_delr_x_col_pnp_10hv_vbic  = (0)
+    nsig_dela_dle_pnp_iso_10hv_vbic = (0)
+    nsig_delr_psbe_pnp_iso_10hv_vbic = (0)
+    nsig_delr_psb_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jbei_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jben_pnp_iso_10hv_vbic = (0)
+    nsig_delr_n_col_pnp_iso_10hv_vbic = (0)
+    nsig_delr_x_col_pnp_iso_10hv_vbic = (0)

statistics {
    process {
        vary nsig_delr_psbe_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psb_npn_10hv_vbic     dist=gauss std=1
        vary nsig_dela_dle_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jbei_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jben_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_x_col_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_n_epi_npn_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psbe_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psb_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_dela_dle_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jbei_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jben_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_delr_x_col_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_delr_n_epi_npn_b_10hv_vbic     dist=gauss std=1
        vary nsig_dela_dle_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psbe_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psb_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jbei_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jben_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_n_col_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_delr_x_col_pnp_10hv_vbic     dist=gauss std=1
        vary nsig_dela_dle_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psbe_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_psb_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jbei_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_jben_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_n_col_pnp_iso_10hv_vbic     dist=gauss std=1
        vary nsig_delr_x_col_pnp_iso_10hv_vbic     dist=gauss std=1
    }
}

//***********************************************************
endsection mc_bjt_process_params
//***********************************************************

//***********************************************************
section wcs_bjt_process_params
//***********************************************************

parameters
+    nsig_delr_psbe_npn_10hv_vbic   = (-2.55192)
+    nsig_delr_psb_npn_10hv_vbic    = (0)
+    nsig_dela_dle_npn_10hv_vbic    = (-1.88316)
+    nsig_delr_jbei_npn_10hv_vbic   = (4.5901)
+    nsig_delr_jben_npn_10hv_vbic   = (2.39782)
+    nsig_delr_x_col_npn_10hv_vbic  = (0)
+    nsig_delr_n_epi_npn_10hv_vbic  = (0)
+    nsig_delr_psbe_npn_b_10hv_vbic = (-3.65)
+    nsig_delr_psb_npn_b_10hv_vbic  = (0)
+    nsig_dela_dle_npn_b_10hv_vbic  = (-3.52)
+    nsig_delr_jbei_npn_b_10hv_vbic = (6.5)
+    nsig_delr_jben_npn_b_10hv_vbic = (2)
+    nsig_delr_x_col_npn_b_10hv_vbic = (0)
+    nsig_delr_n_epi_npn_b_10hv_vbic = (0)
+    nsig_dela_dle_pnp_10hv_vbic    = (-1.07102)
+    nsig_delr_psbe_pnp_10hv_vbic   = (-2.86139)
+    nsig_delr_psb_pnp_10hv_vbic    = (0)
+    nsig_delr_jbei_pnp_10hv_vbic   = (3.01096)
+    nsig_delr_jben_pnp_10hv_vbic   = (2.02297)
+    nsig_delr_n_col_pnp_10hv_vbic  = (0)
+    nsig_delr_x_col_pnp_10hv_vbic  = (0)
+    nsig_dela_dle_pnp_iso_10hv_vbic = (-1.06999)
+    nsig_delr_psbe_pnp_iso_10hv_vbic = (-2.86096)
+    nsig_delr_psb_pnp_iso_10hv_vbic = (0)
+    nsig_delr_jbei_pnp_iso_10hv_vbic = (2.94956)
+    nsig_delr_jben_pnp_iso_10hv_vbic = (1.98474)
+    nsig_delr_n_col_pnp_iso_10hv_vbic = (0)
+    nsig_delr_x_col_pnp_iso_10hv_vbic = (0)

//***********************************************************
endsection wcs_bjt_process_params
//***********************************************************

//***********************************************************
section lo_capacitor_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_cdp_10hv         = (-3)
+    nsig_delr_cfr_cdp_10hv         = (-3)
+    nsig_delr_rs_poly0_r3_cdp_10hv = (-2.9058)
+    nsig_delr_cpp_cdpf_10hv        = (-3)
+    nsig_delr_cfr_cdpf_10hv        = (-3)
+    nsig_delr_cfrlv_cdpf_10hv      = (-3)
+    nsig_delr_rs_poly0_r3_cdpf_10hv = (-2.9058)
+    nsig_delr_cpp_cdpf_m1m2m3_10hv = (-3.0)
+    nsig_delr_cfr_cdpf_m1m2m3_10hv = (-3.0)
+    nsig_delr_cfrlv_cdpf_m1m2m3_10hv = (-2.9822)
+    nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv = (-2.9058)
+    nsig_delr_cglv_10hv_tox        = (3.0)
+    nsig_dela_cglv_10hv_vfb        = (3.0)
+    nsig_delr_cglv_10hv_ileak      = (-3.0)
+    nsig_delr_tox_cghv_10hv        = (3.0)
+    nsig_dela_vfb_cghv_10hv        = (3.0)
+    nsig_delr_tox_cghvf_10hv       = (3.0)
+    nsig_dela_vfb_cghvf_10hv       = (3.0)
+    nsig_delr_cfrlv_cghvf_10hv     = (-1.6753)
+    nsig_delr_tox_cghvf_m1m2m3_10hv = (3.2)
+    nsig_dela_vfb_cghvf_m1m2m3_10hv = (3.0)
+    nsig_delr_cfrlv_cghvf_m1m2m3_10hv = (-3.057)
+    nsig_delr_cfrlv_10hv           = (-3.0)
+    nsig_delr_cfrlv_m1m2m3_10hv    = (-3.0)
+    nsig_delr_cfr45_10hv           = (-3.0)
+    nsig_delr_cfr45_m1m2m3_10hv    = (-3.0)
+    nsig_delr_cfr90_10hv           = (-3.0)
+    nsig_delr_cfr90_m1m2m3_10hv    = (-3.0)
+    nsig_delr_cfr120_10hv          = (-3.0)
+    nsig_delr_cfr120_m1m2m3_10hv   = (-3.0)

//***********************************************************
endsection lo_capacitor_process_params
//***********************************************************

//***********************************************************
section typ_capacitor_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_cdp_10hv         = (0.0)
+    nsig_delr_cfr_cdp_10hv         = (0.0)
+    nsig_delr_rs_poly0_r3_cdp_10hv = (0)
+    nsig_delr_cpp_cdpf_10hv        = (0.0)
+    nsig_delr_cfr_cdpf_10hv        = (0.0)
+    nsig_delr_cfrlv_cdpf_10hv      = (0.0)
+    nsig_delr_rs_poly0_r3_cdpf_10hv = (0)
+    nsig_delr_cpp_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfr_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv = (0)
+    nsig_delr_cglv_10hv_tox        = (0.0)
+    nsig_dela_cglv_10hv_vfb        = (0.0)
+    nsig_delr_cglv_10hv_ileak      = (0.0)
+    nsig_delr_tox_cghv_10hv        = (0.0)
+    nsig_dela_vfb_cghv_10hv        = (0.0)
+    nsig_delr_tox_cghvf_10hv       = (0.0)
+    nsig_dela_vfb_cghvf_10hv       = (0.0)
+    nsig_delr_cfrlv_cghvf_10hv     = (0.0)
+    nsig_delr_tox_cghvf_m1m2m3_10hv = (0.0)
+    nsig_dela_vfb_cghvf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_cghvf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_10hv           = (0.0)
+    nsig_delr_cfrlv_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr45_10hv           = (0.0)
+    nsig_delr_cfr45_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr90_10hv           = (0.0)
+    nsig_delr_cfr90_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr120_10hv          = (0.0)
+    nsig_delr_cfr120_m1m2m3_10hv   = (0.0)

//***********************************************************
endsection typ_capacitor_process_params
//***********************************************************

//***********************************************************
section mc_capacitor_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_cdp_10hv         = (0.0)
+    nsig_delr_cfr_cdp_10hv         = (0.0)
+    nsig_delr_rs_poly0_r3_cdp_10hv = (0)
+    nsig_delr_cpp_cdpf_10hv        = (0.0)
+    nsig_delr_cfr_cdpf_10hv        = (0.0)
+    nsig_delr_cfrlv_cdpf_10hv      = (0.0)
+    nsig_delr_rs_poly0_r3_cdpf_10hv = (0)
+    nsig_delr_cpp_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfr_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_cdpf_m1m2m3_10hv = (0.0)
+    nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv = (0)
+    nsig_delr_cglv_10hv_tox        = (0.0)
+    nsig_dela_cglv_10hv_vfb        = (0.0)
+    nsig_delr_cglv_10hv_ileak      = (0.0)
+    nsig_delr_tox_cghv_10hv        = (0.0)
+    nsig_dela_vfb_cghv_10hv        = (0.0)
+    nsig_delr_tox_cghvf_10hv       = (0.0)
+    nsig_dela_vfb_cghvf_10hv       = (0.0)
+    nsig_delr_cfrlv_cghvf_10hv     = (0.0)
+    nsig_delr_tox_cghvf_m1m2m3_10hv = (0.0)
+    nsig_dela_vfb_cghvf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_cghvf_m1m2m3_10hv = (0.0)
+    nsig_delr_cfrlv_10hv           = (0.0)
+    nsig_delr_cfrlv_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr45_10hv           = (0.0)
+    nsig_delr_cfr45_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr90_10hv           = (0.0)
+    nsig_delr_cfr90_m1m2m3_10hv    = (0.0)
+    nsig_delr_cfr120_10hv          = (0.0)
+    nsig_delr_cfr120_m1m2m3_10hv   = (0.0)

statistics {
    process {
        vary nsig_delr_cpp_cdp_10hv     dist=gauss std=1
        vary nsig_delr_cfr_cdp_10hv     dist=gauss std=1
        vary nsig_delr_rs_poly0_r3_cdp_10hv     dist=gauss std=1
        vary nsig_delr_cpp_cdpf_10hv     dist=gauss std=1
        vary nsig_delr_cfr_cdpf_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_cdpf_10hv     dist=gauss std=1
        vary nsig_delr_rs_poly0_r3_cdpf_10hv     dist=gauss std=1
        vary nsig_delr_cpp_cdpf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfr_cdpf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_cdpf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cglv_10hv_tox     dist=gauss std=1
        vary nsig_dela_cglv_10hv_vfb     dist=gauss std=1
        vary nsig_delr_cglv_10hv_ileak     dist=gauss std=1
        vary nsig_delr_tox_cghv_10hv     dist=gauss std=1
        vary nsig_dela_vfb_cghv_10hv     dist=gauss std=1
        vary nsig_delr_tox_cghvf_10hv     dist=gauss std=1
        vary nsig_dela_vfb_cghvf_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_cghvf_10hv     dist=gauss std=1
        vary nsig_delr_tox_cghvf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_dela_vfb_cghvf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_cghvf_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_10hv     dist=gauss std=1
        vary nsig_delr_cfrlv_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfr45_10hv     dist=gauss std=1
        vary nsig_delr_cfr45_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfr90_10hv     dist=gauss std=1
        vary nsig_delr_cfr90_m1m2m3_10hv     dist=gauss std=1
        vary nsig_delr_cfr120_10hv     dist=gauss std=1
        vary nsig_delr_cfr120_m1m2m3_10hv     dist=gauss std=1
    }
}

//***********************************************************
endsection mc_capacitor_process_params
//***********************************************************

//***********************************************************
section hi_capacitor_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_cdp_10hv         = (3.0)
+    nsig_delr_cfr_cdp_10hv         = (3.0)
+    nsig_delr_rs_poly0_r3_cdp_10hv = (2.91083)
+    nsig_delr_cpp_cdpf_10hv        = (3.0)
+    nsig_delr_cfr_cdpf_10hv        = (3.0)
+    nsig_delr_cfrlv_cdpf_10hv      = (3.0)
+    nsig_delr_rs_poly0_r3_cdpf_10hv = (2.91083)
+    nsig_delr_cpp_cdpf_m1m2m3_10hv = (3.0)
+    nsig_delr_cfr_cdpf_m1m2m3_10hv = (3.0)
+    nsig_delr_cfrlv_cdpf_m1m2m3_10hv = (3.0253)
+    nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv = (2.91083)
+    nsig_delr_cglv_10hv_tox        = (-3.00763)
+    nsig_dela_cglv_10hv_vfb        = (-3.0)
+    nsig_delr_cglv_10hv_ileak      = (3.0)
+    nsig_delr_tox_cghv_10hv        = (-2.7)
+    nsig_dela_vfb_cghv_10hv        = (-3.0)
+    nsig_delr_tox_cghvf_10hv       = (-3.0)
+    nsig_dela_vfb_cghvf_10hv       = (-3.0)
+    nsig_delr_cfrlv_cghvf_10hv     = (1.4078)
+    nsig_delr_tox_cghvf_m1m2m3_10hv = (-2.92)
+    nsig_dela_vfb_cghvf_m1m2m3_10hv = (-3.0)
+    nsig_delr_cfrlv_cghvf_m1m2m3_10hv = (2.896)
+    nsig_delr_cfrlv_10hv           = (3.0)
+    nsig_delr_cfrlv_m1m2m3_10hv    = (3.0)
+    nsig_delr_cfr45_10hv           = (3.0)
+    nsig_delr_cfr45_m1m2m3_10hv    = (3.0)
+    nsig_delr_cfr90_10hv           = (3.0)
+    nsig_delr_cfr90_m1m2m3_10hv    = (3.0)
+    nsig_delr_cfr120_10hv          = (3.0)
+    nsig_delr_cfr120_m1m2m3_10hv   = (3.0)

//***********************************************************
endsection hi_capacitor_process_params
//***********************************************************

//***********************************************************
section lobv_lovf_drsf_zener_process_params
//***********************************************************

parameters
+    nsig_delr_isr_dz5_10hv         = (3)
+    nsig_dela_bv_dz5_10hv          = (-3)
+    nsig_delr_isr_dz5b_10hv        = (3)
+    nsig_dela_bv_dz5b_10hv         = (-3)
+    nsig_dela_bv_tc2_dz5b_10hv     = (-3)
+    nsig_delr_isr_drsf45_10hv      = (2.3207255)
+    nsig_delr_isf_drsf45_10hv      = (2.1421639)
+    nsig_delr_isr_drsf45b_10hv     = (1.845)
+    nsig_delr_isf_drsf45b_10hv     = (2.36)
+    nsig_dela_dw_isf_drsf45b_10hv  = (1.791)
+    nsig_delr_isr_drsf90_10hv      = (2.5739878)
+    nsig_delr_isf_drsf90_10hv      = (2.1783498)
+    nsig_delr_isr_drsf90b_10hv     = (2.549)
+    nsig_delr_isf_drsf90b_10hv     = (2.345)
+    nsig_dela_dw_isf_drsf90b_10hv  = (1.612)

//***********************************************************
endsection lobv_lovf_drsf_zener_process_params
section typ_drsf_zener_process_params
//***********************************************************

parameters
+    nsig_delr_isr_dz5_10hv         = (0)
+    nsig_dela_bv_dz5_10hv          = (0)
+    nsig_delr_isr_dz5b_10hv        = (0)
+    nsig_dela_bv_dz5b_10hv         = (0)
+    nsig_dela_bv_tc2_dz5b_10hv     = (0)
+    nsig_delr_isr_drsf45_10hv      = (0)
+    nsig_delr_isf_drsf45_10hv      = (0)
+    nsig_delr_isr_drsf45b_10hv     = (0)
+    nsig_delr_isf_drsf45b_10hv     = (0)
+    nsig_dela_dw_isf_drsf45b_10hv  = (0)
+    nsig_delr_isr_drsf90_10hv      = (0)
+    nsig_delr_isf_drsf90_10hv      = (0)
+    nsig_delr_isr_drsf90b_10hv     = (0)
+    nsig_delr_isf_drsf90b_10hv     = (0)
+    nsig_dela_dw_isf_drsf90b_10hv  = (0)

//***********************************************************
endsection typ_drsf_zener_process_params
//***********************************************************

//***********************************************************
section mc_drsf_zener_process_params
//***********************************************************

parameters
+    nsig_delr_isr_dz5_10hv         = (0)
+    nsig_dela_bv_dz5_10hv          = (0)
+    nsig_delr_isr_dz5b_10hv        = (0)
+    nsig_dela_bv_dz5b_10hv         = (0)
+    nsig_dela_bv_tc2_dz5b_10hv     = (0)
+    nsig_delr_isr_drsf45_10hv      = (0)
+    nsig_delr_isf_drsf45_10hv      = (0)
+    nsig_delr_isr_drsf45b_10hv     = (0)
+    nsig_delr_isf_drsf45b_10hv     = (0)
+    nsig_dela_dw_isf_drsf45b_10hv  = (0)
+    nsig_delr_isr_drsf90_10hv      = (0)
+    nsig_delr_isf_drsf90_10hv      = (0)
+    nsig_delr_isr_drsf90b_10hv     = (0)
+    nsig_delr_isf_drsf90b_10hv     = (0)
+    nsig_dela_dw_isf_drsf90b_10hv  = (0)

statistics {
    process {
        vary nsig_delr_isr_dz5_10hv     dist=gauss std=1
        vary nsig_dela_bv_dz5_10hv     dist=gauss std=1
        vary nsig_delr_isr_dz5b_10hv     dist=gauss std=1
        vary nsig_dela_bv_dz5b_10hv     dist=gauss std=1
        vary nsig_dela_bv_tc2_dz5b_10hv     dist=gauss std=1
        vary nsig_delr_isr_drsf45_10hv     dist=gauss std=1
        vary nsig_delr_isf_drsf45_10hv     dist=gauss std=1
        vary nsig_delr_isr_drsf45b_10hv     dist=gauss std=1
        vary nsig_delr_isf_drsf45b_10hv     dist=gauss std=1
        vary nsig_dela_dw_isf_drsf45b_10hv     dist=gauss std=1
        vary nsig_delr_isr_drsf90_10hv     dist=gauss std=1
        vary nsig_delr_isf_drsf90_10hv     dist=gauss std=1
        vary nsig_delr_isr_drsf90b_10hv     dist=gauss std=1
        vary nsig_delr_isf_drsf90b_10hv     dist=gauss std=1
        vary nsig_dela_dw_isf_drsf90b_10hv     dist=gauss std=1
    }
}

//***********************************************************
endsection mc_drsf_zener_process_params
//***********************************************************

//***********************************************************
section hibv_hivf_drsf_zener_process_params
//***********************************************************

parameters
+    nsig_delr_isr_dz5_10hv         = (-2.948)
+    nsig_dela_bv_dz5_10hv          = (3)
+    nsig_delr_isr_dz5b_10hv        = (-3)
+    nsig_dela_bv_dz5b_10hv         = (3)
+    nsig_dela_bv_tc2_dz5b_10hv     = (3)
+    nsig_delr_isr_drsf45_10hv      = (-3)
+    nsig_delr_isf_drsf45_10hv      = (-3)
+    nsig_delr_isr_drsf45b_10hv     = (-3)
+    nsig_delr_isf_drsf45b_10hv     = (-3)
+    nsig_dela_dw_isf_drsf45b_10hv  = (-3)
+    nsig_delr_isr_drsf90_10hv      = (-3)
+    nsig_delr_isf_drsf90_10hv      = (-3)
+    nsig_delr_isr_drsf90b_10hv     = (-3)
+    nsig_delr_isf_drsf90b_10hv     = (-3)
+    nsig_dela_dw_isf_drsf90b_10hv  = (-3)

//***********************************************************
endsection hibv_hivf_drsf_zener_process_params
section typ_powermos_process_params
//***********************************************************

parameters
+    nsig_delr_powermos_tox         = (0)
+    nsig_dela_nld65_10hv_vfb       = (0)
+    nsig_dela_nld65_10hv_vtw       = (0)
+    nsig_delr_nld65_10hv_res       = (0)
+    nsig_delr_nld65_10hv_uch       = (0)
+    nsig_dela_nld65_10hv_dwres     = (0)
+    nsig_dela_nld65b_10hv_vfb      = (0)
+    nsig_dela_nld65b_10hv_vtw      = (0)
+    nsig_delr_nld65b_10hv_res      = (0)
+    nsig_delr_nld65b_10hv_uch      = (0)
+    nsig_dela_nld65b_10hv_dwres    = (0)
+    nsig_dela_nld90_10hv_vfb       = (0)
+    nsig_dela_nld90_10hv_vtw       = (0)
+    nsig_delr_nld90_10hv_res       = (0)
+    nsig_delr_nld90_10hv_uch       = (0)
+    nsig_dela_nld90_10hv_dwmos     = (0)
+    nsig_dela_nld90_10hv_dwres     = (0)
+    nsig_dela_nld90b_10hv_vfb      = (0)
+    nsig_dela_nld90b_10hv_vtw      = (0)
+    nsig_delr_nld90b_10hv_res      = (0)
+    nsig_delr_nld90b_10hv_uch      = (0)
+    nsig_dela_nld90b_10hv_dwmos    = (0)
+    nsig_dela_nld90b_10hv_dwres    = (0)
+    nsig_dela_pld90_10hv_vfb       = (0)
+    nsig_dela_pld90_10hv_vtm       = (0)
+    nsig_delr_pld90_10hv_res       = (0)
+    nsig_delr_pld90_10hv_uch       = (0)
+    nsig_dela_pld90b_10hv_vfb      = (0)
+    nsig_dela_pld90b_10hv_vtm      = (0)
+    nsig_delr_pld90b_10hv_res      = (0)
+    nsig_delr_pld90b_10hv_uch      = (0)
+    nsig_dela_nld10_10hv_vfb       = (0)
+    nsig_delr_nld10_10hv_res       = (0)
+    nsig_delr_nld10_10hv_uch       = (0)
+    nsig_dela_nld10_10hv_dw        = (0)
+    nsig_dela_nld10_10hv_vtm       = (0)
+    nsig_dela_nld30_10hv_vfb       = (0)
+    nsig_dela_nld30_10hv_vtm       = (0)
+    nsig_delr_nld30_10hv_res       = (0)
+    nsig_delr_nld30_10hv_uch       = (0)
+    nsig_dela_nld30_10hv_dw        = (0)
+    nsig_dela_nld30_10hv_dr        = (0)
+    nsig_dela_nld30b_10hv_vfb      = (0)
+    nsig_dela_nld30b_10hv_vtm      = (0)
+    nsig_delr_nld30b_10hv_res      = (0)
+    nsig_delr_nld30b_10hv_uch      = (0)
+    nsig_dela_nld30b_10hv_dw       = (0)
+    nsig_dela_nld30b_10hv_dr       = (0)
+    nsig_dela_nld45_10hv_vfb       = (0)
+    nsig_dela_nld45_10hv_vtm       = (0)
+    nsig_delr_nld45_10hv_res       = (0)
+    nsig_delr_nld45_10hv_uch       = (0)
+    nsig_dela_nld45_10hv_dw        = (0)
+    nsig_dela_nld45_10hv_dr        = (0)
+    nsig_dela_nld45b_10hv_vfb      = (0)
+    nsig_dela_nld45b_10hv_vtm      = (0)
+    nsig_delr_nld45b_10hv_res      = (0)
+    nsig_delr_nld45b_10hv_uch      = (0)
+    nsig_dela_nld45b_10hv_dw       = (0)
+    nsig_dela_nld45b_10hv_dr       = (0)
+    nsig_dela_nld45_he_10hv_vfb    = (0)
+    nsig_dela_nld45_he_10hv_vtm    = (0)
+    nsig_delr_nld45_he_10hv_res    = (0)
+    nsig_delr_nld45_he_10hv_uch    = (0)
+    nsig_dela_nld45_he_10hv_dw     = (0)
+    nsig_dela_nld45_he_10hv_dr     = (0)
+    nsig_dela_nld45_he_10hv_a0     = (0)
+    nsig_dela_nld45_he_10hv_b0     = (0)
+    nsig_dela_nld45b_he_10hv_vfb   = (0)
+    nsig_dela_nld45b_he_10hv_vtm   = (0)
+    nsig_delr_nld45b_he_10hv_res   = (0)
+    nsig_delr_nld45b_he_10hv_uch   = (0)
+    nsig_dela_nld45b_he_10hv_dw    = (0)
+    nsig_dela_nld45b_he_10hv_dr    = (0)
+    nsig_dela_nld45b_he_10hv_a0    = (0)
+    nsig_dela_nld45b_he_10hv_b0    = (0)
+    nsig_dela_nld45_tlp_10hv_vfb   = (0)
+    nsig_dela_nld45_tlp_10hv_vtm   = (0)
+    nsig_delr_nld45_tlp_10hv_res   = (0)
+    nsig_delr_nld45_tlp_10hv_uch   = (0)
+    nsig_dela_nld45_tlp_10hv_dr    = (0)
+    nsig_dela_nld45_tlp_10hv_dw    = (0)
+    nsig_dela_nld45_tlp_10hv_a0    = (0)
+    nsig_dela_nld45_tlp_10hv_b0    = (0)
+    nsig_dela_nld45b_tlp_10hv_vfb  = (0)
+    nsig_dela_nld45b_tlp_10hv_vtm  = (0)
+    nsig_delr_nld45b_tlp_10hv_res  = (0)
+    nsig_delr_nld45b_tlp_10hv_uch  = (0)
+    nsig_dela_nld45b_tlp_10hv_dr   = (0)
+    nsig_dela_nld45b_tlp_10hv_dw   = (0)
+    nsig_dela_nld45b_tlp_10hv_a0   = (0)
+    nsig_dela_nld45b_tlp_10hv_b0   = (0)
+    nsig_dela_pld5_10hv_vfb        = (0)
+    nsig_dela_pld5_10hv_vtm        = (0)
+    nsig_delr_pld5_10hv_uch        = (0)
+    nsig_dela_pld5_10hv_dw         = (0)
+    nsig_dela_nld5_10hv_vfb        = (0)
+    nsig_delr_nld5_10hv_res        = (0)
+    nsig_delr_nld5_10hv_uch        = (0)
+    nsig_delr_nld5_10hv_vsat       = (0)
+    nsig_dela_nld5_10hv_dwmos      = (0)
+    nsig_dela_nld5_10hv_vtw        = (0)
+    nsig_dela_pld10_10hv_vfb       = (0)
+    nsig_delr_pld10_10hv_res       = (0)
+    nsig_delr_pld10_10hv_uch       = (0)
+    nsig_dela_pld10_10hv_vtw       = (0)
+    nsig_dela_pld10_10hv_dwres     = (0)
+    nsig_dela_pld10_10hv_dwmos     = (0)
+    nsig_dela_dw_pld10b_sphv_10hv  = (0)
+    nsig_dela_vfb_pld10b_sphv_10hv = (0)
+    nsig_dela_vtwl_pld10b_sphv_10hv = (0)
+    nsig_delr_mobref_pld10b_sphv_10hv = (0)
+    nsig_delr_rshl_pld10b_sphv_10hv = (0)
+    nsig_dela_pld30_10hv_vfb       = (0)
+    nsig_delr_pld30_10hv_res       = (0)
+    nsig_delr_pld30_10hv_uch       = (0)
+    nsig_dela_pld30_10hv_dwmos     = (0)
+    nsig_dela_pld30_10hv_dwres     = (0)
+    nsig_dela_pld30_10hv_vtw       = (0)
+    nsig_dela_pld30b_10hv_vfb      = (0)
+    nsig_delr_pld30b_10hv_res      = (0)
+    nsig_delr_pld30b_10hv_uch      = (0)
+    nsig_dela_pld30b_10hv_dwmos    = (0)
+    nsig_dela_pld30b_10hv_dwres    = (0)
+    nsig_dela_pld30b_10hv_vtw      = (0)
+    nsig_dela_pld45_10hv_vfb       = (0)
+    nsig_delr_pld45_10hv_res       = (0)
+    nsig_delr_pld45_10hv_uch       = (0)
+    nsig_dela_pld45_10hv_dwmos     = (0)
+    nsig_dela_pld45_10hv_dwres     = (0)
+    nsig_dela_pld45_10hv_vtw       = (0)
+    nsig_dela_pld45b_10hv_vfb      = (0)
+    nsig_delr_pld45b_10hv_res      = (0)
+    nsig_delr_pld45b_10hv_uch      = (0)
+    nsig_dela_pld45b_10hv_dwmos    = (0)
+    nsig_dela_pld45b_10hv_dwres    = (0)
+    nsig_dela_pld45b_10hv_vtw      = (0)
+    nsig_dela_nld5_lvt_10hv_vfb    = (0)
+    nsig_delr_nld5_lvt_10hv_res    = (0)
+    nsig_delr_nld5_lvt_10hv_uch    = (0)
+    nsig_dela_nld5_lvt_10hv_dwmos  = (0)
+    nsig_dela_nld5_lvt_10hv_vtw    = (0)
+    nsig_delr_nld5_lvt_10hv_vsat   = (0)
+    nsig_delr_nld5_lvt_10hv_ub     = (0)


parameters
+    nsig_delr_tox_nld45b_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_sphv_10hv = 0.0
+    nsig_delr_vdscale_nld45b_sphv_10hv = 0.0
+    nsig_delr_cj_nld45b_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld65_sphv_10hv = 0.0
+    nsig_dela_vtw_pld65_sphv_10hv = 0.0
+    nsig_delr_uch_pld65_sphv_10hv = 0.0
+    nsig_delr_res_pld65_sphv_10hv = 0.0
+    nsig_dela_dwox_pld65_sphv_10hv = 0.0
+    nsig_delr_cj_pld65_sphv_10hv = 0.0
+    nsig_delr_is_pld65_sphv_10hv = 0.0
+    nsig_delr_is2_pld65_sphv_10hv = 0.0
+    nsig_delr_ir_pld65_sphv_10hv = 0.0
+    nsig_dela_dw_nld90b_sphv_10hv = 0.0
+    nsig_dela_xw_nld90b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld90b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld90b_sphv_10hv = 0.0
+    nsig_delr_ids_nld90b_sphv_10hv = 0.0
+    nsig_delr_rshl_nld90b_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld90b_sphv_10hv = 0.0
+    nsig_delr_cj_nld90b_sphv_10hv = 0.0
+    nsig_delr_is_nld90b_sphv_10hv = 0.0
+    nsig_delr_is2_nld90b_sphv_10hv = 0.0
+    nsig_delr_ir_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = 0.0
+    nsig_delr_tox_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_vdscale_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_thesato_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_tlp_mosb_10hv = 0.0
+    nsig_delr_cj_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_tox_pld120_sphv_10hv = 0.0
+    nsig_delr_uch_pld120_sphv_10hv = 0.0
+    nsig_delr_res_pld120_sphv_10hv = 0.0
+    nsig_dela_vfb_pld120_sphv_10hv = 0.0
+    nsig_dela_vtw_pld120_sphv_10hv = 0.0
+    nsig_dela_vtl_pld120_sphv_10hv = 0.0
+    nsig_dela_mueo_pld120_sphv_10hv = 0.0
+    nsig_dela_dw_pld120_sphv_10hv = 0.0
+    nsig_dela_dwox_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscale_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pld120_sphv_10hv = 0.0
+    nsig_delr_cj_pld120_sphv_10hv = 0.0
+    nsig_delr_is_pld120_sphv_10hv = 0.0
+    nsig_delr_is2_pld120_sphv_10hv = 0.0
+    nsig_delr_ir_pld120_sphv_10hv = 0.0
+    nsig_delr_tox_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_thesato_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_cj_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_tox_nld30b_sphv_10hv = 0.0
+    nsig_dela_dw_nld30b_sphv_10hv = 0.0
+    nsig_dela_xw_nld30b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld30b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld30b_sphv_10hv = 0.0
+    nsig_delr_rshl_nld30b_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld30b_sphv_10hv = 0.0
+    nsig_delr_cj_nld30b_sphv_10hv = 0.0
+    nsig_delr_is_nld30b_sphv_10hv = 0.0
+    nsig_delr_is2_nld30b_sphv_10hv = 0.0
+    nsig_delr_ir_nld30b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld100_sphv_10hv = 0.0
+    nsig_dela_vtw_pld100_sphv_10hv = 0.0
+    nsig_delr_uch_pld100_sphv_10hv = 0.0
+    nsig_delr_res_pld100_sphv_10hv = 0.0
+    nsig_dela_dwox_pld100_sphv_10hv = 0.0
+    nsig_delr_cj_pld100_sphv_10hv = 0.0
+    nsig_delr_is_pld100_sphv_10hv = 0.0
+    nsig_delr_is2_pld100_sphv_10hv = 0.0
+    nsig_delr_ir_pld100_sphv_10hv = 0.0
+    nsig_dela_dw_pld100_sphv_10hv = 0.0
+    nsig_delr_thesat_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscale_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscalew_pld100_sphv_10hv = 0.0
+    nsig_delr_theacc2_pld100_sphv_10hv = 0.0
+    nsig_delr_tox_nld10_sphv_10hv = 0.0
+    nsig_dela_dw_nld10_sphv_10hv = 0.0
+    nsig_dela_xw_nld10_sphv_10hv = 0.0
+    nsig_dela_vfb_nld10_sphv_10hv = 0.0
+    nsig_delr_mobref_nld10_sphv_10hv = 0.0
+    nsig_delr_rshl_nld10_sphv_10hv = 0.0
+    nsig_delr_thesato_nld10_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld10_sphv_10hv = 0.0
+    nsig_delr_cj_nld10_sphv_10hv = 0.0
+    nsig_delr_is_nld10_sphv_10hv = 0.0
+    nsig_delr_is2_nld10_sphv_10hv = 0.0
+    nsig_delr_ir_nld10_sphv_10hv = 0.0
+    nsig_delr_tox_nld100_sphv_10hv = 0.0
+    nsig_dela_xw_nld100_sphv_10hv = 0.0
+    nsig_dela_vfb_nld100_sphv_10hv = 0.0
+    nsig_dela_vfbw_nld100_sphv_10hv = 0.0
+    nsig_dela_vdscale_nld100_sphv_10hv = 0.0
+    nsig_dela_vdscalew_nld100_sphv_10hv = 0.0
+    nsig_dela_thesatgo_nld100_sphv_10hv = 0.0
+    nsig_delr_rshl_nld100_sphv_10hv = 0.0
+    nsig_delr_cj_nld100_sphv_10hv = 0.0
+    nsig_delr_is_nld100_sphv_10hv = 0.0
+    nsig_delr_is2_nld100_sphv_10hv = 0.0
+    nsig_delr_ir_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_met_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_met_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = 0.0
+    nsig_dela_dw_pld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld45b_sphv_10hv = 0.0
+    nsig_delr_uch_pld45b_sphv_10hv = 0.0
+    nsig_delr_rshl_pld45b_sphv_10hv = 0.0
+    nsig_dela_vtwl_pld45b_sphv_10hv = 0.0
+    nsig_dela_nwxw_pld45b_sphv_10hv = 0.0
+    nsig_delr_cj_pld45b_sphv_10hv = 0.0
+    nsig_delr_is_pld45b_sphv_10hv = 0.0
+    nsig_delr_is2_pld45b_sphv_10hv = 0.0
+    nsig_delr_ir_pld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld90b_sphv_10hv = 0.0
+    nsig_dela_vtw_pld90b_sphv_10hv = 0.0
+    nsig_delr_uch_pld90b_sphv_10hv = 0.0
+    nsig_delr_res_pld90b_sphv_10hv = 0.0
+    nsig_dela_dwox_pld90b_sphv_10hv = 0.0
+    nsig_delr_cj_pld90b_sphv_10hv = 0.0
+    nsig_delr_is_pld90b_sphv_10hv = 0.0
+    nsig_delr_is2_pld90b_sphv_10hv = 0.0
+    nsig_delr_ir_pld90b_sphv_10hv = 0.0
+    nsig_delr_uch_nld65b_sphv_10hv = 0.0
+    nsig_delr_res_nld65b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld65b_sphv_10hv = 0.0
+    nsig_dela_vtw_nld65b_sphv_10hv = 0.0
+    nsig_dela_xw_nld65b_sphv_10hv = 0.0
+    nsig_dela_thesatw_nld65b_sphv_10hv = 0.0
+    nsig_delr_cj_nld65b_sphv_10hv = 0.0
+    nsig_delr_is_nld65b_sphv_10hv = 0.0
+    nsig_delr_is2_nld65b_sphv_10hv = 0.0
+    nsig_delr_ir_nld65b_sphv_10hv = 0.0
+    nsig_dela_vfbo_pld30b_sphv_10hv = 0.0
+    nsig_dela_vfbw_pld30b_sphv_10hv = 0.0
+    nsig_delr_rshldd_pld30b_sphv_10hv = 0.0
+    nsig_dela_nwxw_pld30b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pld30b_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pld30b_sphv_10hv = 0.0
+    nsig_delr_cj_pld30b_sphv_10hv = 0.0
+    nsig_delr_is_pld30b_sphv_10hv = 0.0
+    nsig_delr_is2_pld30b_sphv_10hv = 0.0
+    nsig_delr_ir_pld30b_sphv_10hv = 0.0

//***********************************************************
endsection typ_powermos_process_params
//***********************************************************

//***********************************************************
section mc_powermos_process_params
//***********************************************************

parameters
+    nsig_delr_powermos_tox         = (0)
+    nsig_dela_nld65_10hv_vfb       = (0)
+    nsig_dela_nld65_10hv_vtw       = (0)
+    nsig_delr_nld65_10hv_res       = (0)
+    nsig_delr_nld65_10hv_uch       = (0)
+    nsig_dela_nld65_10hv_dwres     = (0)
+    nsig_dela_nld65b_10hv_vfb      = (0)
+    nsig_dela_nld65b_10hv_vtw      = (0)
+    nsig_delr_nld65b_10hv_res      = (0)
+    nsig_delr_nld65b_10hv_uch      = (0)
+    nsig_dela_nld65b_10hv_dwres    = (0)
+    nsig_dela_nld90_10hv_vfb       = (0)
+    nsig_dela_nld90_10hv_vtw       = (0)
+    nsig_delr_nld90_10hv_res       = (0)
+    nsig_delr_nld90_10hv_uch       = (0)
+    nsig_dela_nld90_10hv_dwmos     = (0)
+    nsig_dela_nld90_10hv_dwres     = (0)
+    nsig_dela_nld90b_10hv_vfb      = (0)
+    nsig_dela_nld90b_10hv_vtw      = (0)
+    nsig_delr_nld90b_10hv_res      = (0)
+    nsig_delr_nld90b_10hv_uch      = (0)
+    nsig_dela_nld90b_10hv_dwmos    = (0)
+    nsig_dela_nld90b_10hv_dwres    = (0)
+    nsig_dela_pld90_10hv_vfb       = (0)
+    nsig_dela_pld90_10hv_vtm       = (0)
+    nsig_delr_pld90_10hv_res       = (0)
+    nsig_delr_pld90_10hv_uch       = (0)
+    nsig_dela_pld90b_10hv_vfb      = (0)
+    nsig_dela_pld90b_10hv_vtm      = (0)
+    nsig_delr_pld90b_10hv_res      = (0)
+    nsig_delr_pld90b_10hv_uch      = (0)
+    nsig_dela_nld10_10hv_vfb       = (0)
+    nsig_delr_nld10_10hv_res       = (0)
+    nsig_delr_nld10_10hv_uch       = (0)
+    nsig_dela_nld10_10hv_dw        = (0)
+    nsig_dela_nld10_10hv_vtm       = (0)
+    nsig_dela_nld30_10hv_vfb       = (0)
+    nsig_dela_nld30_10hv_vtm       = (0)
+    nsig_delr_nld30_10hv_res       = (0)
+    nsig_delr_nld30_10hv_uch       = (0)
+    nsig_dela_nld30_10hv_dw        = (0)
+    nsig_dela_nld30_10hv_dr        = (0)
+    nsig_dela_nld30b_10hv_vfb      = (0)
+    nsig_dela_nld30b_10hv_vtm      = (0)
+    nsig_delr_nld30b_10hv_res      = (0)
+    nsig_delr_nld30b_10hv_uch      = (0)
+    nsig_dela_nld30b_10hv_dw       = (0)
+    nsig_dela_nld30b_10hv_dr       = (0)
+    nsig_dela_nld45_10hv_vfb       = (0)
+    nsig_dela_nld45_10hv_vtm       = (0)
+    nsig_delr_nld45_10hv_res       = (0)
+    nsig_delr_nld45_10hv_uch       = (0)
+    nsig_dela_nld45_10hv_dw        = (0)
+    nsig_dela_nld45_10hv_dr        = (0)
+    nsig_dela_nld45b_10hv_vfb      = (0)
+    nsig_dela_nld45b_10hv_vtm      = (0)
+    nsig_delr_nld45b_10hv_res      = (0)
+    nsig_delr_nld45b_10hv_uch      = (0)
+    nsig_dela_nld45b_10hv_dw       = (0)
+    nsig_dela_nld45b_10hv_dr       = (0)
+    nsig_dela_nld45_he_10hv_vfb    = (0)
+    nsig_dela_nld45_he_10hv_vtm    = (0)
+    nsig_delr_nld45_he_10hv_res    = (0)
+    nsig_delr_nld45_he_10hv_uch    = (0)
+    nsig_dela_nld45_he_10hv_dw     = (0)
+    nsig_dela_nld45_he_10hv_dr     = (0)
+    nsig_dela_nld45_he_10hv_a0     = (0)
+    nsig_dela_nld45_he_10hv_b0     = (0)
+    nsig_dela_nld45b_he_10hv_vfb   = (0)
+    nsig_dela_nld45b_he_10hv_vtm   = (0)
+    nsig_delr_nld45b_he_10hv_res   = (0)
+    nsig_delr_nld45b_he_10hv_uch   = (0)
+    nsig_dela_nld45b_he_10hv_dw    = (0)
+    nsig_dela_nld45b_he_10hv_dr    = (0)
+    nsig_dela_nld45b_he_10hv_a0    = (0)
+    nsig_dela_nld45b_he_10hv_b0    = (0)
+    nsig_dela_nld45_tlp_10hv_vfb   = (0)
+    nsig_dela_nld45_tlp_10hv_vtm   = (0)
+    nsig_delr_nld45_tlp_10hv_res   = (0)
+    nsig_delr_nld45_tlp_10hv_uch   = (0)
+    nsig_dela_nld45_tlp_10hv_dr    = (0)
+    nsig_dela_nld45_tlp_10hv_dw    = (0)
+    nsig_dela_nld45_tlp_10hv_a0    = (0)
+    nsig_dela_nld45_tlp_10hv_b0    = (0)
+    nsig_dela_nld45b_tlp_10hv_vfb  = (0)
+    nsig_dela_nld45b_tlp_10hv_vtm  = (0)
+    nsig_delr_nld45b_tlp_10hv_res  = (0)
+    nsig_delr_nld45b_tlp_10hv_uch  = (0)
+    nsig_dela_nld45b_tlp_10hv_dr   = (0)
+    nsig_dela_nld45b_tlp_10hv_dw   = (0)
+    nsig_dela_nld45b_tlp_10hv_a0   = (0)
+    nsig_dela_nld45b_tlp_10hv_b0   = (0)
+    nsig_dela_pld5_10hv_vfb        = (0)
+    nsig_dela_pld5_10hv_vtm        = (0)
+    nsig_delr_pld5_10hv_uch        = (0)
+    nsig_dela_pld5_10hv_dw         = (0)
+    nsig_dela_nld5_10hv_vfb        = (0)
+    nsig_delr_nld5_10hv_res        = (0)
+    nsig_delr_nld5_10hv_uch        = (0)
+    nsig_delr_nld5_10hv_vsat       = (0)
+    nsig_dela_nld5_10hv_dwmos      = (0)
+    nsig_dela_nld5_10hv_vtw        = (0)
+    nsig_dela_pld10_10hv_vfb       = (0)
+    nsig_delr_pld10_10hv_res       = (0)
+    nsig_delr_pld10_10hv_uch       = (0)
+    nsig_dela_pld10_10hv_vtw       = (0)
+    nsig_dela_pld10_10hv_dwres     = (0)
+    nsig_dela_pld10_10hv_dwmos     = (0)
+    nsig_dela_dw_pld10b_sphv_10hv  = (0)
+    nsig_dela_vfb_pld10b_sphv_10hv = (0)
+    nsig_dela_vtwl_pld10b_sphv_10hv = (0)
+    nsig_delr_mobref_pld10b_sphv_10hv = (0)
+    nsig_delr_rshl_pld10b_sphv_10hv = (0)
+    nsig_dela_pld30_10hv_vfb       = (0)
+    nsig_delr_pld30_10hv_res       = (0)
+    nsig_delr_pld30_10hv_uch       = (0)
+    nsig_dela_pld30_10hv_dwmos     = (0)
+    nsig_dela_pld30_10hv_dwres     = (0)
+    nsig_dela_pld30_10hv_vtw       = (0)
+    nsig_dela_pld30b_10hv_vfb      = (0)
+    nsig_delr_pld30b_10hv_res      = (0)
+    nsig_delr_pld30b_10hv_uch      = (0)
+    nsig_dela_pld30b_10hv_dwmos    = (0)
+    nsig_dela_pld30b_10hv_dwres    = (0)
+    nsig_dela_pld30b_10hv_vtw      = (0)
+    nsig_dela_pld45_10hv_vfb       = (0)
+    nsig_delr_pld45_10hv_res       = (0)
+    nsig_delr_pld45_10hv_uch       = (0)
+    nsig_dela_pld45_10hv_dwmos     = (0)
+    nsig_dela_pld45_10hv_dwres     = (0)
+    nsig_dela_pld45_10hv_vtw       = (0)
+    nsig_dela_pld45b_10hv_vfb      = (0)
+    nsig_delr_pld45b_10hv_res      = (0)
+    nsig_delr_pld45b_10hv_uch      = (0)
+    nsig_dela_pld45b_10hv_dwmos    = (0)
+    nsig_dela_pld45b_10hv_dwres    = (0)
+    nsig_dela_pld45b_10hv_vtw      = (0)
+    nsig_dela_nld5_lvt_10hv_vfb    = (0)
+    nsig_delr_nld5_lvt_10hv_res    = (0)
+    nsig_delr_nld5_lvt_10hv_uch    = (0)
+    nsig_dela_nld5_lvt_10hv_dwmos  = (0)
+    nsig_dela_nld5_lvt_10hv_vtw    = (0)
+    nsig_delr_nld5_lvt_10hv_vsat   = (0)
+    nsig_delr_nld5_lvt_10hv_ub     = (0)

statistics {
    process {
        vary nsig_delr_powermos_tox     dist=gauss std=1
        vary nsig_dela_nld65_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld65_10hv_vtw     dist=gauss std=1
        vary nsig_delr_nld65_10hv_res     dist=gauss std=1
        vary nsig_delr_nld65_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld65_10hv_dwres     dist=gauss std=1
        vary nsig_dela_nld65b_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld65b_10hv_vtw     dist=gauss std=1
        vary nsig_delr_nld65b_10hv_res     dist=gauss std=1
        vary nsig_delr_nld65b_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld65b_10hv_dwres     dist=gauss std=1
        vary nsig_dela_nld90_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld90_10hv_vtw     dist=gauss std=1
        vary nsig_delr_nld90_10hv_res     dist=gauss std=1
        vary nsig_delr_nld90_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld90_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_nld90_10hv_dwres     dist=gauss std=1
        vary nsig_dela_nld90b_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld90b_10hv_vtw     dist=gauss std=1
        vary nsig_delr_nld90b_10hv_res     dist=gauss std=1
        vary nsig_delr_nld90b_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld90b_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_nld90b_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld90_10hv_vfb     dist=gauss std=1
        vary nsig_dela_pld90_10hv_vtm     dist=gauss std=1
        vary nsig_delr_pld90_10hv_res     dist=gauss std=1
        vary nsig_delr_pld90_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld90b_10hv_vfb     dist=gauss std=1
        vary nsig_dela_pld90b_10hv_vtm     dist=gauss std=1
        vary nsig_delr_pld90b_10hv_res     dist=gauss std=1
        vary nsig_delr_pld90b_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld10_10hv_vfb     dist=gauss std=1
        vary nsig_delr_nld10_10hv_res     dist=gauss std=1
        vary nsig_delr_nld10_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld10_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld10_10hv_vtm     dist=gauss std=1
        vary nsig_dela_nld30_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld30_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld30_10hv_res     dist=gauss std=1
        vary nsig_delr_nld30_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld30_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld30_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld30b_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld30b_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld30b_10hv_res     dist=gauss std=1
        vary nsig_delr_nld30b_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld30b_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld30b_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45b_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45b_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45b_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45b_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45b_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45b_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45_he_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45_he_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_a0     dist=gauss std=1
        vary nsig_dela_nld45_he_10hv_b0     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45b_he_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45b_he_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_a0     dist=gauss std=1
        vary nsig_dela_nld45b_he_10hv_b0     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45_tlp_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45_tlp_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_a0     dist=gauss std=1
        vary nsig_dela_nld45_tlp_10hv_b0     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_vfb     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_vtm     dist=gauss std=1
        vary nsig_delr_nld45b_tlp_10hv_res     dist=gauss std=1
        vary nsig_delr_nld45b_tlp_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_dr     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_a0     dist=gauss std=1
        vary nsig_dela_nld45b_tlp_10hv_b0     dist=gauss std=1
        vary nsig_dela_pld5_10hv_vfb     dist=gauss std=1
        vary nsig_dela_pld5_10hv_vtm     dist=gauss std=1
        vary nsig_delr_pld5_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld5_10hv_dw     dist=gauss std=1
        vary nsig_dela_nld5_10hv_vfb     dist=gauss std=1
        vary nsig_delr_nld5_10hv_res     dist=gauss std=1
        vary nsig_delr_nld5_10hv_uch     dist=gauss std=1
        vary nsig_delr_nld5_10hv_vsat     dist=gauss std=1
        vary nsig_dela_nld5_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_nld5_10hv_vtw     dist=gauss std=1
        vary nsig_dela_pld10_10hv_vfb     dist=gauss std=1
        vary nsig_delr_pld10_10hv_res     dist=gauss std=1
        vary nsig_delr_pld10_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld10_10hv_vtw     dist=gauss std=1
        vary nsig_dela_pld10_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld10_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_dw_pld10b_sphv_10hv     dist=gauss std=1
        vary nsig_dela_vfb_pld10b_sphv_10hv     dist=gauss std=1
        vary nsig_dela_vtwl_pld10b_sphv_10hv     dist=gauss std=1
        vary nsig_delr_mobref_pld10b_sphv_10hv     dist=gauss std=1
        vary nsig_delr_rshl_pld10b_sphv_10hv     dist=gauss std=1
        vary nsig_dela_pld30_10hv_vfb     dist=gauss std=1
        vary nsig_delr_pld30_10hv_res     dist=gauss std=1
        vary nsig_delr_pld30_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld30_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_pld30_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld30_10hv_vtw     dist=gauss std=1
        vary nsig_dela_pld30b_10hv_vfb     dist=gauss std=1
        vary nsig_delr_pld30b_10hv_res     dist=gauss std=1
        vary nsig_delr_pld30b_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld30b_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_pld30b_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld30b_10hv_vtw     dist=gauss std=1
        vary nsig_dela_pld45_10hv_vfb     dist=gauss std=1
        vary nsig_delr_pld45_10hv_res     dist=gauss std=1
        vary nsig_delr_pld45_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld45_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_pld45_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld45_10hv_vtw     dist=gauss std=1
        vary nsig_dela_pld45b_10hv_vfb     dist=gauss std=1
        vary nsig_delr_pld45b_10hv_res     dist=gauss std=1
        vary nsig_delr_pld45b_10hv_uch     dist=gauss std=1
        vary nsig_dela_pld45b_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_pld45b_10hv_dwres     dist=gauss std=1
        vary nsig_dela_pld45b_10hv_vtw     dist=gauss std=1
        vary nsig_dela_nld5_lvt_10hv_vfb     dist=gauss std=1
        vary nsig_delr_nld5_lvt_10hv_res     dist=gauss std=1
        vary nsig_delr_nld5_lvt_10hv_uch     dist=gauss std=1
        vary nsig_dela_nld5_lvt_10hv_dwmos     dist=gauss std=1
        vary nsig_dela_nld5_lvt_10hv_vtw     dist=gauss std=1
        vary nsig_delr_nld5_lvt_10hv_vsat     dist=gauss std=1
        vary nsig_delr_nld5_lvt_10hv_ub     dist=gauss std=1
    }
}


parameters
+    nsig_delr_tox_nld45b_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_sphv_10hv = 0.0
+    nsig_delr_vdscale_nld45b_sphv_10hv = 0.0
+    nsig_delr_cj_nld45b_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld65_sphv_10hv = 0.0
+    nsig_dela_vtw_pld65_sphv_10hv = 0.0
+    nsig_delr_uch_pld65_sphv_10hv = 0.0
+    nsig_delr_res_pld65_sphv_10hv = 0.0
+    nsig_dela_dwox_pld65_sphv_10hv = 0.0
+    nsig_delr_cj_pld65_sphv_10hv = 0.0
+    nsig_delr_is_pld65_sphv_10hv = 0.0
+    nsig_delr_is2_pld65_sphv_10hv = 0.0
+    nsig_delr_ir_pld65_sphv_10hv = 0.0
+    nsig_dela_dw_nld90b_sphv_10hv = 0.0
+    nsig_dela_xw_nld90b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld90b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld90b_sphv_10hv = 0.0
+    nsig_delr_ids_nld90b_sphv_10hv = 0.0
+    nsig_delr_rshl_nld90b_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld90b_sphv_10hv = 0.0
+    nsig_delr_cj_nld90b_sphv_10hv = 0.0
+    nsig_delr_is_nld90b_sphv_10hv = 0.0
+    nsig_delr_is2_nld90b_sphv_10hv = 0.0
+    nsig_delr_ir_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = 0.0
+    nsig_delr_tox_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_vdscale_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_thesato_nld45b_tlp_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_tlp_mosb_10hv = 0.0
+    nsig_delr_cj_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_tlp_sphv_10hv = 0.0
+    nsig_delr_tox_pld120_sphv_10hv = 0.0
+    nsig_delr_uch_pld120_sphv_10hv = 0.0
+    nsig_delr_res_pld120_sphv_10hv = 0.0
+    nsig_dela_vfb_pld120_sphv_10hv = 0.0
+    nsig_dela_vtw_pld120_sphv_10hv = 0.0
+    nsig_dela_vtl_pld120_sphv_10hv = 0.0
+    nsig_dela_mueo_pld120_sphv_10hv = 0.0
+    nsig_dela_dw_pld120_sphv_10hv = 0.0
+    nsig_dela_dwox_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscale_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pld120_sphv_10hv = 0.0
+    nsig_delr_cj_pld120_sphv_10hv = 0.0
+    nsig_delr_is_pld120_sphv_10hv = 0.0
+    nsig_delr_is2_pld120_sphv_10hv = 0.0
+    nsig_delr_ir_pld120_sphv_10hv = 0.0
+    nsig_delr_tox_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_xw_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_vfb_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_mobref_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_rsh_nld45b_he_sphv_10hv = 0.0
+    nsig_dela_vtw_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_thesato_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_cj_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_is_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_is2_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_ir_nld45b_he_sphv_10hv = 0.0
+    nsig_delr_tox_nld30b_sphv_10hv = 0.0
+    nsig_dela_dw_nld30b_sphv_10hv = 0.0
+    nsig_dela_xw_nld30b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld30b_sphv_10hv = 0.0
+    nsig_delr_mobref_nld30b_sphv_10hv = 0.0
+    nsig_delr_rshl_nld30b_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld30b_sphv_10hv = 0.0
+    nsig_delr_cj_nld30b_sphv_10hv = 0.0
+    nsig_delr_is_nld30b_sphv_10hv = 0.0
+    nsig_delr_is2_nld30b_sphv_10hv = 0.0
+    nsig_delr_ir_nld30b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld100_sphv_10hv = 0.0
+    nsig_dela_vtw_pld100_sphv_10hv = 0.0
+    nsig_delr_uch_pld100_sphv_10hv = 0.0
+    nsig_delr_res_pld100_sphv_10hv = 0.0
+    nsig_dela_dwox_pld100_sphv_10hv = 0.0
+    nsig_delr_cj_pld100_sphv_10hv = 0.0
+    nsig_delr_is_pld100_sphv_10hv = 0.0
+    nsig_delr_is2_pld100_sphv_10hv = 0.0
+    nsig_delr_ir_pld100_sphv_10hv = 0.0
+    nsig_dela_dw_pld100_sphv_10hv = 0.0
+    nsig_delr_thesat_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscale_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscalew_pld100_sphv_10hv = 0.0
+    nsig_delr_theacc2_pld100_sphv_10hv = 0.0
+    nsig_delr_tox_nld10_sphv_10hv = 0.0
+    nsig_dela_dw_nld10_sphv_10hv = 0.0
+    nsig_dela_xw_nld10_sphv_10hv = 0.0
+    nsig_dela_vfb_nld10_sphv_10hv = 0.0
+    nsig_delr_mobref_nld10_sphv_10hv = 0.0
+    nsig_delr_rshl_nld10_sphv_10hv = 0.0
+    nsig_delr_thesato_nld10_sphv_10hv = 0.0
+    nsig_dela_vtwl_nld10_sphv_10hv = 0.0
+    nsig_delr_cj_nld10_sphv_10hv = 0.0
+    nsig_delr_is_nld10_sphv_10hv = 0.0
+    nsig_delr_is2_nld10_sphv_10hv = 0.0
+    nsig_delr_ir_nld10_sphv_10hv = 0.0
+    nsig_delr_tox_nld100_sphv_10hv = 0.0
+    nsig_dela_xw_nld100_sphv_10hv = 0.0
+    nsig_dela_vfb_nld100_sphv_10hv = 0.0
+    nsig_dela_vfbw_nld100_sphv_10hv = 0.0
+    nsig_dela_vdscale_nld100_sphv_10hv = 0.0
+    nsig_dela_vdscalew_nld100_sphv_10hv = 0.0
+    nsig_dela_thesatgo_nld100_sphv_10hv = 0.0
+    nsig_delr_rshl_nld100_sphv_10hv = 0.0
+    nsig_delr_cj_nld100_sphv_10hv = 0.0
+    nsig_delr_is_nld100_sphv_10hv = 0.0
+    nsig_delr_is2_nld100_sphv_10hv = 0.0
+    nsig_delr_ir_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_met_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_met_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = 0.0
+    nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = 0.0
+    nsig_dela_dw_pld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld45b_sphv_10hv = 0.0
+    nsig_delr_uch_pld45b_sphv_10hv = 0.0
+    nsig_delr_rshl_pld45b_sphv_10hv = 0.0
+    nsig_dela_vtwl_pld45b_sphv_10hv = 0.0
+    nsig_dela_nwxw_pld45b_sphv_10hv = 0.0
+    nsig_delr_cj_pld45b_sphv_10hv = 0.0
+    nsig_delr_is_pld45b_sphv_10hv = 0.0
+    nsig_delr_is2_pld45b_sphv_10hv = 0.0
+    nsig_delr_ir_pld45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pld90b_sphv_10hv = 0.0
+    nsig_dela_vtw_pld90b_sphv_10hv = 0.0
+    nsig_delr_uch_pld90b_sphv_10hv = 0.0
+    nsig_delr_res_pld90b_sphv_10hv = 0.0
+    nsig_dela_dwox_pld90b_sphv_10hv = 0.0
+    nsig_delr_cj_pld90b_sphv_10hv = 0.0
+    nsig_delr_is_pld90b_sphv_10hv = 0.0
+    nsig_delr_is2_pld90b_sphv_10hv = 0.0
+    nsig_delr_ir_pld90b_sphv_10hv = 0.0
+    nsig_delr_uch_nld65b_sphv_10hv = 0.0
+    nsig_delr_res_nld65b_sphv_10hv = 0.0
+    nsig_dela_vfb_nld65b_sphv_10hv = 0.0
+    nsig_dela_vtw_nld65b_sphv_10hv = 0.0
+    nsig_dela_xw_nld65b_sphv_10hv = 0.0
+    nsig_dela_thesatw_nld65b_sphv_10hv = 0.0
+    nsig_delr_cj_nld65b_sphv_10hv = 0.0
+    nsig_delr_is_nld65b_sphv_10hv = 0.0
+    nsig_delr_is2_nld65b_sphv_10hv = 0.0
+    nsig_delr_ir_nld65b_sphv_10hv = 0.0
+    nsig_dela_vfbo_pld30b_sphv_10hv = 0.0
+    nsig_dela_vfbw_pld30b_sphv_10hv = 0.0
+    nsig_delr_rshldd_pld30b_sphv_10hv = 0.0
+    nsig_dela_nwxw_pld30b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pld30b_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pld30b_sphv_10hv = 0.0
+    nsig_delr_cj_pld30b_sphv_10hv = 0.0
+    nsig_delr_is_pld30b_sphv_10hv = 0.0
+    nsig_delr_is2_pld30b_sphv_10hv = 0.0
+    nsig_delr_ir_pld30b_sphv_10hv = 0.0

statistics {
    process {
        vary nsig_delr_tox_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rsh_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pld65_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pld65_sphv_10hv dist=gauss std=1
        vary nsig_dela_dwox_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld65_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld65_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ids_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtwl_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_rsh_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld45b_tlp_mosb_10hv dist=gauss std=1
        vary nsig_delr_cj_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtl_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_mueo_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_dwox_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalel_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalew_pld120_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalelw_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld120_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_rsh_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld45b_he_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtwl_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_dwox_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_thesat_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_vdscale_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_vdscalew_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_theacc2_pld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nld10_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_nld10_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_mobref_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_thesato_nld10_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtwl_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld10_sphv_10hv dist=gauss std=1
        vary nsig_delr_tox_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfbw_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalew_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatgo_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_s_ply_met_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_d_ply_met_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv dist=gauss std=1
        vary nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv dist=gauss std=1
        vary nsig_dela_dw_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshl_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtwl_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_nwxw_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld45b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_dela_dwox_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld90b_sphv_10hv dist=gauss std=1
        vary nsig_delr_uch_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_delr_res_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfb_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vtw_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_dela_xw_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_dela_thesatw_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_nld65b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfbo_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vfbw_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_rshldd_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_nwxw_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscale_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_dela_vdscalew_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_cj_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_is2_pld30b_sphv_10hv dist=gauss std=1
        vary nsig_delr_ir_pld30b_sphv_10hv dist=gauss std=1
    }
}

//***********************************************************
endsection mc_powermos_process_params
//***********************************************************

//***********************************************************
section wcs_powermos_process_params
//***********************************************************

parameters
+    nsig_delr_powermos_tox         = (3)
+    nsig_dela_nld65_10hv_vfb       = (2.42887)
+    nsig_dela_nld65_10hv_vtw       = (-0.995173)
+    nsig_delr_nld65_10hv_res       = (1.63926)
+    nsig_delr_nld65_10hv_uch       = (-1.70291)
+    nsig_dela_nld65_10hv_dwres     = (-0.269039)
+    nsig_dela_nld65b_10hv_vfb      = (2.42887)
+    nsig_dela_nld65b_10hv_vtw      = (-0.995173)
+    nsig_delr_nld65b_10hv_res      = (1.63926)
+    nsig_delr_nld65b_10hv_uch      = (-1.70291)
+    nsig_dela_nld65b_10hv_dwres    = (-0.269039)
+    nsig_dela_nld90_10hv_vfb       = (2.1208)
+    nsig_dela_nld90_10hv_vtw       = (-2.545)
+    nsig_delr_nld90_10hv_res       = (-0.47)
+    nsig_delr_nld90_10hv_uch       = (-4.32)
+    nsig_dela_nld90_10hv_dwmos     = (-0.85)
+    nsig_dela_nld90_10hv_dwres     = (-3)
+    nsig_dela_nld90b_10hv_vfb      = (2.1208)
+    nsig_dela_nld90b_10hv_vtw      = (-2.545)
+    nsig_delr_nld90b_10hv_res      = (-0.47)
+    nsig_delr_nld90b_10hv_uch      = (-4.32)
+    nsig_dela_nld90b_10hv_dwmos    = (-0.85)
+    nsig_dela_nld90b_10hv_dwres    = (-3)
+    nsig_dela_pld90_10hv_vfb       = (2.47088)
+    nsig_dela_pld90_10hv_vtm       = (0.997529)
+    nsig_delr_pld90_10hv_res       = (2.95375)
+    nsig_delr_pld90_10hv_uch       = (0.0278847)
+    nsig_dela_pld90b_10hv_vfb      = (2.219)
+    nsig_dela_pld90b_10hv_vtm      = (0.989562)
+    nsig_delr_pld90b_10hv_res      = (3.05228)
+    nsig_delr_pld90b_10hv_uch      = (-0.06096)
+    nsig_dela_nld10_10hv_vfb       = (2.64209)
+    nsig_delr_nld10_10hv_res       = (0)
+    nsig_delr_nld10_10hv_uch       = (-0.802489)
+    nsig_dela_nld10_10hv_dw        = (0.919832)
+    nsig_dela_nld10_10hv_vtm       = (-0.378303)
+    nsig_dela_nld30_10hv_vfb       = (2.51873)
+    nsig_dela_nld30_10hv_vtm       = (-0.877835)
+    nsig_delr_nld30_10hv_res       = (0)
+    nsig_delr_nld30_10hv_uch       = (-1.09065)
+    nsig_dela_nld30_10hv_dw        = (0.585028)
+    nsig_dela_nld30_10hv_dr        = (0)
+    nsig_dela_nld30b_10hv_vfb      = (2.51873)
+    nsig_dela_nld30b_10hv_vtm      = (-0.877835)
+    nsig_delr_nld30b_10hv_res      = (0)
+    nsig_delr_nld30b_10hv_uch      = (-1.09065)
+    nsig_dela_nld30b_10hv_dw       = (0.585028)
+    nsig_dela_nld30b_10hv_dr       = (0)
+    nsig_dela_nld45_10hv_vfb       = (2.68697)
+    nsig_dela_nld45_10hv_vtm       = (-0.428239)
+    nsig_delr_nld45_10hv_res       = (2.34508)
+    nsig_delr_nld45_10hv_uch       = (-0.373762)
+    nsig_dela_nld45_10hv_dw        = (-0.985639)
+    nsig_dela_nld45_10hv_dr        = (-0.335047)
+    nsig_dela_nld45b_10hv_vfb      = (2.68697)
+    nsig_dela_nld45b_10hv_vtm      = (-0.428239)
+    nsig_delr_nld45b_10hv_res      = (2.34508)
+    nsig_delr_nld45b_10hv_uch      = (-0.373762)
+    nsig_dela_nld45b_10hv_dw       = (-0.985639)
+    nsig_dela_nld45b_10hv_dr       = (-0.335047)
+    nsig_dela_nld45_he_10hv_vfb    = (2.59235)
+    nsig_dela_nld45_he_10hv_vtm    = (-0.836959)
+    nsig_delr_nld45_he_10hv_res    = (3.35791)
+    nsig_delr_nld45_he_10hv_uch    = (3.13072)
+    nsig_dela_nld45_he_10hv_dw     = (3)
+    nsig_dela_nld45_he_10hv_dr     = (-2.0232)
+    nsig_dela_nld45_he_10hv_a0     = (3.65267)
+    nsig_dela_nld45_he_10hv_b0     = (0.69151)
+    nsig_dela_nld45b_he_10hv_vfb   = (2.59235)
+    nsig_dela_nld45b_he_10hv_vtm   = (-0.836959)
+    nsig_delr_nld45b_he_10hv_res   = (3.35791)
+    nsig_delr_nld45b_he_10hv_uch   = (3.13072)
+    nsig_dela_nld45b_he_10hv_dw    = (3)
+    nsig_dela_nld45b_he_10hv_dr    = (-2.0232)
+    nsig_dela_nld45b_he_10hv_a0    = (3.65267)
+    nsig_dela_nld45b_he_10hv_b0    = (0.69151)
+    nsig_dela_nld45_tlp_10hv_vfb   = (2.14947)
+    nsig_dela_nld45_tlp_10hv_vtm   = (-0.894278)
+    nsig_delr_nld45_tlp_10hv_res   = (5.37374)
+    nsig_delr_nld45_tlp_10hv_uch   = (1.35073)
+    nsig_dela_nld45_tlp_10hv_dr    = (-1.09392)
+    nsig_dela_nld45_tlp_10hv_dw    = (3)
+    nsig_dela_nld45_tlp_10hv_a0    = (3.3772)
+    nsig_dela_nld45_tlp_10hv_b0    = (3.61657)
+    nsig_dela_nld45b_tlp_10hv_vfb  = (2.14947)
+    nsig_dela_nld45b_tlp_10hv_vtm  = (-0.894278)
+    nsig_delr_nld45b_tlp_10hv_res  = (5.37374)
+    nsig_delr_nld45b_tlp_10hv_uch  = (1.35073)
+    nsig_dela_nld45b_tlp_10hv_dr   = (-1.09392)
+    nsig_dela_nld45b_tlp_10hv_dw   = (3)
+    nsig_dela_nld45b_tlp_10hv_a0   = (3.3772)
+    nsig_dela_nld45b_tlp_10hv_b0   = (3.61657)
+    nsig_dela_pld5_10hv_vfb        = (2.41312)
+    nsig_dela_pld5_10hv_vtm        = (0.410529)
+    nsig_delr_pld5_10hv_uch        = (-1.69102)
+    nsig_dela_pld5_10hv_dw         = (-0.913495)
+    nsig_dela_nld5_10hv_vfb        = (2.5389)
+    nsig_delr_nld5_10hv_res        = (0)
+    nsig_delr_nld5_10hv_uch        = (-1.15492)
+    nsig_delr_nld5_10hv_vsat       = (-0.95811)
+    nsig_dela_nld5_10hv_dwmos      = (0.685519)
+    nsig_dela_nld5_10hv_vtw        = (-1.14984)
+    nsig_dela_pld10_10hv_vfb       = (2.74903)
+    nsig_delr_pld10_10hv_res       = (1.56)
+    nsig_delr_pld10_10hv_uch       = (-0.553808)
+    nsig_dela_pld10_10hv_vtw       = (-0.348708)
+    nsig_dela_pld10_10hv_dwres     = (-0.323)
+    nsig_dela_pld10_10hv_dwmos     = (1.56025)
+    nsig_dela_dw_pld10b_sphv_10hv  = (1.58382)
+    nsig_dela_vfb_pld10b_sphv_10hv = (2.99973)
+    nsig_dela_vtwl_pld10b_sphv_10hv = (4.48525)
+    nsig_delr_mobref_pld10b_sphv_10hv = (1.68936)
+    nsig_delr_rshl_pld10b_sphv_10hv = (2.70734)
+    nsig_dela_pld30_10hv_vfb       = (2.40316)
+    nsig_delr_pld30_10hv_res       = (2.35408)
+    nsig_delr_pld30_10hv_uch       = (-0.938002)
+    nsig_dela_pld30_10hv_dwmos     = (1.06596)
+    nsig_dela_pld30_10hv_dwres     = (0.369033)
+    nsig_dela_pld30_10hv_vtw       = (-0.443778)
+    nsig_dela_pld30b_10hv_vfb      = (2.176923)
+    nsig_delr_pld30b_10hv_res      = (2.933)
+    nsig_delr_pld30b_10hv_uch      = (-3.72)
+    nsig_dela_pld30b_10hv_dwmos    = (3.34)
+    nsig_dela_pld30b_10hv_dwres    = (3.6316)
+    nsig_dela_pld30b_10hv_vtw      = (-2.5)
+    nsig_dela_pld45_10hv_vfb       = (2.80087)
+    nsig_delr_pld45_10hv_res       = (2.70785)
+    nsig_delr_pld45_10hv_uch       = (-0.133154)
+    nsig_dela_pld45_10hv_dwmos     = (2.40056)
+    nsig_dela_pld45_10hv_dwres     = (0.0)
+    nsig_dela_pld45_10hv_vtw       = (-1.32806)
+    nsig_dela_pld45b_10hv_vfb      = (2.66638)
+    nsig_delr_pld45b_10hv_res      = (2.6)
+    nsig_delr_pld45b_10hv_uch      = (1.7)
+    nsig_dela_pld45b_10hv_dwmos    = (3.0)
+    nsig_dela_pld45b_10hv_dwres    = (3.0)
+    nsig_dela_pld45b_10hv_vtw      = (-0.200107)
+    nsig_dela_nld5_lvt_10hv_vfb    = (2.78919)
+    nsig_delr_nld5_lvt_10hv_res    = (4.00613)
+    nsig_delr_nld5_lvt_10hv_uch    = (-0.416862)
+    nsig_dela_nld5_lvt_10hv_dwmos  = (1.035292)
+    nsig_dela_nld5_lvt_10hv_vtw    = (2.586)
+    nsig_delr_nld5_lvt_10hv_vsat   = (0)
+    nsig_delr_nld5_lvt_10hv_ub     = (0)


parameters
+    nsig_delr_tox_nld45b_sphv_10hv = 3.0
+    nsig_dela_xw_nld45b_sphv_10hv = -2.635
+    nsig_dela_vfb_nld45b_sphv_10hv = 2.04121735337
+    nsig_delr_mobref_nld45b_sphv_10hv = 3.893
+    nsig_delr_rsh_nld45b_sphv_10hv = 3.677
+    nsig_dela_vtw_nld45b_sphv_10hv = -3.74851401668
+    nsig_delr_vdscale_nld45b_sphv_10hv = -4.46785627967
+    nsig_delr_cj_nld45b_sphv_10hv = 3.0
+    nsig_delr_is_nld45b_sphv_10hv = -3.0
+    nsig_delr_is2_nld45b_sphv_10hv = -3.0
+    nsig_delr_ir_nld45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pld65_sphv_10hv = 2.201
+    nsig_dela_vtw_pld65_sphv_10hv = -2.9
+    nsig_delr_uch_pld65_sphv_10hv = -2.565
+    nsig_delr_res_pld65_sphv_10hv = 2.538462
+    nsig_dela_dwox_pld65_sphv_10hv = -1.422571
+    nsig_delr_cj_pld65_sphv_10hv = 3.0
+    nsig_delr_is_pld65_sphv_10hv = -3.608
+    nsig_delr_is2_pld65_sphv_10hv = -3.0
+    nsig_delr_ir_pld65_sphv_10hv = -3.0
+    nsig_dela_dw_nld90b_sphv_10hv = 2.92144133334
+    nsig_dela_xw_nld90b_sphv_10hv = -3.02284725262
+    nsig_dela_vfb_nld90b_sphv_10hv = 2.99862202567
+    nsig_delr_mobref_nld90b_sphv_10hv = -3.0
+    nsig_delr_ids_nld90b_sphv_10hv = -3.0
+    nsig_delr_rshl_nld90b_sphv_10hv = 3.02251168512
+    nsig_dela_vtwl_nld90b_sphv_10hv = -2.97949255762
+    nsig_delr_cj_nld90b_sphv_10hv = 3.0
+    nsig_delr_is_nld90b_sphv_10hv = -3.608
+    nsig_delr_is2_nld90b_sphv_10hv = -3.0
+    nsig_delr_ir_nld90b_sphv_10hv = -3.0
+    nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv = 3.0
+    nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv = 3.0
+    nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = 3.0
+    nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = 3.0
+    nsig_delr_tox_nld45b_tlp_sphv_10hv = 3.0
+    nsig_dela_xw_nld45b_tlp_sphv_10hv = -2.771
+    nsig_dela_vfb_nld45b_tlp_sphv_10hv = 2.589
+    nsig_delr_mobref_nld45b_tlp_sphv_10hv = 1.5
+    nsig_delr_rsh_nld45b_tlp_sphv_10hv = 4.0
+    nsig_dela_vtw_nld45b_tlp_sphv_10hv = -3.808
+    nsig_delr_vdscale_nld45b_tlp_sphv_10hv = -4.3
+    nsig_delr_thesato_nld45b_tlp_sphv_10hv = -3.0
+    nsig_dela_vfb_nld45b_tlp_mosb_10hv = -3.5
+    nsig_delr_cj_nld45b_tlp_sphv_10hv = 3.0
+    nsig_delr_is_nld45b_tlp_sphv_10hv = -3.0
+    nsig_delr_is2_nld45b_tlp_sphv_10hv = -3.0
+    nsig_delr_ir_nld45b_tlp_sphv_10hv = -3.0
+    nsig_delr_tox_pld120_sphv_10hv = 3.0
+    nsig_delr_uch_pld120_sphv_10hv = -1.1
+    nsig_delr_res_pld120_sphv_10hv = 2.511
+    nsig_dela_vfb_pld120_sphv_10hv = 1.8
+    nsig_dela_vtw_pld120_sphv_10hv = -3.0
+    nsig_dela_vtl_pld120_sphv_10hv = -1.167
+    nsig_dela_mueo_pld120_sphv_10hv = 0.0
+    nsig_dela_dw_pld120_sphv_10hv = 0.0
+    nsig_dela_dwox_pld120_sphv_10hv = -3.376
+    nsig_dela_vdscale_pld120_sphv_10hv = 3.0
+    nsig_dela_vdscalel_pld120_sphv_10hv = -1.669
+    nsig_dela_vdscalew_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pld120_sphv_10hv = 0.0
+    nsig_delr_cj_pld120_sphv_10hv = 3.0
+    nsig_delr_is_pld120_sphv_10hv = -3.0
+    nsig_delr_is2_pld120_sphv_10hv = -3.0
+    nsig_delr_ir_pld120_sphv_10hv = -3.0
+    nsig_delr_tox_nld45b_he_sphv_10hv = 3.0
+    nsig_dela_xw_nld45b_he_sphv_10hv = -2.733
+    nsig_dela_vfb_nld45b_he_sphv_10hv = 2.88
+    nsig_delr_mobref_nld45b_he_sphv_10hv = -0.3215
+    nsig_delr_rsh_nld45b_he_sphv_10hv = 4.083
+    nsig_dela_vtw_nld45b_he_sphv_10hv = -4.574
+    nsig_delr_thesato_nld45b_he_sphv_10hv = 5.236
+    nsig_delr_cj_nld45b_he_sphv_10hv = 3.0
+    nsig_delr_is_nld45b_he_sphv_10hv = -3.0
+    nsig_delr_is2_nld45b_he_sphv_10hv = -3.0
+    nsig_delr_ir_nld45b_he_sphv_10hv = -3.0
+    nsig_delr_tox_nld30b_sphv_10hv = 3.0
+    nsig_dela_dw_nld30b_sphv_10hv = 0.0
+    nsig_dela_xw_nld30b_sphv_10hv = -3.0
+    nsig_dela_vfb_nld30b_sphv_10hv = 2.18
+    nsig_delr_mobref_nld30b_sphv_10hv = -2.2
+    nsig_delr_rshl_nld30b_sphv_10hv = 0.8
+    nsig_dela_vtwl_nld30b_sphv_10hv = -4.1
+    nsig_delr_cj_nld30b_sphv_10hv = 3.0
+    nsig_delr_is_nld30b_sphv_10hv = -3.0
+    nsig_delr_is2_nld30b_sphv_10hv = -3.0
+    nsig_delr_ir_nld30b_sphv_10hv = -3.0
+    nsig_dela_vfb_pld100_sphv_10hv = 2.07
+    nsig_dela_vtw_pld100_sphv_10hv = -1.125
+    nsig_delr_uch_pld100_sphv_10hv = -2.3
+    nsig_delr_res_pld100_sphv_10hv = 3.0693
+    nsig_dela_dwox_pld100_sphv_10hv = -3.4833
+    nsig_delr_cj_pld100_sphv_10hv = 3.0
+    nsig_delr_is_pld100_sphv_10hv = -3.608
+    nsig_delr_is2_pld100_sphv_10hv = -3.0
+    nsig_delr_ir_pld100_sphv_10hv = -3.0
+    nsig_dela_dw_pld100_sphv_10hv = 0.0
+    nsig_delr_thesat_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscale_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscalew_pld100_sphv_10hv = 0.0
+    nsig_delr_theacc2_pld100_sphv_10hv = 0.0
+    nsig_delr_tox_nld10_sphv_10hv = 3.0
+    nsig_dela_dw_nld10_sphv_10hv = 2.5
+    nsig_dela_xw_nld10_sphv_10hv = -0.8333
+    nsig_dela_vfb_nld10_sphv_10hv = 2.48
+    nsig_delr_mobref_nld10_sphv_10hv = -1.5
+    nsig_delr_rshl_nld10_sphv_10hv = 2.5
+    nsig_delr_thesato_nld10_sphv_10hv = 2.5
+    nsig_dela_vtwl_nld10_sphv_10hv = -2.436
+    nsig_delr_cj_nld10_sphv_10hv = 3.0
+    nsig_delr_is_nld10_sphv_10hv = -3.0
+    nsig_delr_is2_nld10_sphv_10hv = -3.0
+    nsig_delr_ir_nld10_sphv_10hv = -3.0
+    nsig_delr_tox_nld100_sphv_10hv = 3.0
+    nsig_dela_xw_nld100_sphv_10hv = -3.0
+    nsig_dela_vfb_nld100_sphv_10hv = 2.0
+    nsig_dela_vfbw_nld100_sphv_10hv = -3.04
+    nsig_dela_vdscale_nld100_sphv_10hv = 3.2
+    nsig_dela_vdscalew_nld100_sphv_10hv = 3.5
+    nsig_dela_thesatgo_nld100_sphv_10hv = 3.0
+    nsig_delr_rshl_nld100_sphv_10hv = 3.0
+    nsig_delr_cj_nld100_sphv_10hv = 3.0
+    nsig_delr_is_nld100_sphv_10hv = -3.608
+    nsig_delr_is2_nld100_sphv_10hv = -3.0
+    nsig_delr_ir_nld100_sphv_10hv = -3.0
+    nsig_delr_cfr_s_ply_met_nld100_sphv_10hv = 3.0
+    nsig_delr_cfr_d_ply_met_nld100_sphv_10hv = 3.0
+    nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = 3.0
+    nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = 3.0
+    nsig_dela_dw_pld45b_sphv_10hv = 3.08212
+    nsig_dela_vfb_pld45b_sphv_10hv = 2.60329
+    nsig_delr_uch_pld45b_sphv_10hv = 2.977221
+    nsig_delr_rshl_pld45b_sphv_10hv = 2.9001
+    nsig_dela_vtwl_pld45b_sphv_10hv = -2.7717
+    nsig_dela_nwxw_pld45b_sphv_10hv = -1.133742
+    nsig_delr_cj_pld45b_sphv_10hv = 3.0
+    nsig_delr_is_pld45b_sphv_10hv = -3.0
+    nsig_delr_is2_pld45b_sphv_10hv = -3.0
+    nsig_delr_ir_pld45b_sphv_10hv = -3.0
+    nsig_dela_vfb_pld90b_sphv_10hv = 1.92225005533
+    nsig_dela_vtw_pld90b_sphv_10hv = -3.0
+    nsig_delr_uch_pld90b_sphv_10hv = -0.543635864934
+    nsig_delr_res_pld90b_sphv_10hv = 3.01007273263
+    nsig_dela_dwox_pld90b_sphv_10hv = -1.8451988772
+    nsig_delr_cj_pld90b_sphv_10hv = 3.0
+    nsig_delr_is_pld90b_sphv_10hv = -3.608
+    nsig_delr_is2_pld90b_sphv_10hv = -3.0
+    nsig_delr_ir_pld90b_sphv_10hv = -3.0
+    nsig_delr_uch_nld65b_sphv_10hv = -3.0
+    nsig_delr_res_nld65b_sphv_10hv = 0.6
+    nsig_dela_vfb_nld65b_sphv_10hv = 2.871
+    nsig_dela_vtw_nld65b_sphv_10hv = -3.015
+    nsig_dela_xw_nld65b_sphv_10hv = 1.565
+    nsig_dela_thesatw_nld65b_sphv_10hv = 3.0
+    nsig_delr_cj_nld65b_sphv_10hv = 3.0
+    nsig_delr_is_nld65b_sphv_10hv = -3.0
+    nsig_delr_is2_nld65b_sphv_10hv = -3.0
+    nsig_delr_ir_nld65b_sphv_10hv = -3.0
+    nsig_dela_vfbo_pld30b_sphv_10hv = 2.066
+    nsig_dela_vfbw_pld30b_sphv_10hv = -2.7
+    nsig_delr_rshldd_pld30b_sphv_10hv = 2.715
+    nsig_dela_nwxw_pld30b_sphv_10hv = -2.7
+    nsig_dela_vdscale_pld30b_sphv_10hv = -1.694444
+    nsig_dela_vdscalew_pld30b_sphv_10hv = 0.0
+    nsig_delr_cj_pld30b_sphv_10hv = 3.0
+    nsig_delr_is_pld30b_sphv_10hv = -3.608
+    nsig_delr_is2_pld30b_sphv_10hv = -3.0
+    nsig_delr_ir_pld30b_sphv_10hv = -3.0

//***********************************************************
endsection wcs_powermos_process_params
//***********************************************************

//***********************************************************
section bcs_powermos_process_params
//***********************************************************

parameters
+    nsig_delr_powermos_tox         = (-3)
+    nsig_dela_nld65_10hv_vfb       = (-2.503)
+    nsig_dela_nld65_10hv_vtw       = (1.02661)
+    nsig_delr_nld65_10hv_res       = (-2.41829)
+    nsig_delr_nld65_10hv_uch       = (-0.702791)
+    nsig_dela_nld65_10hv_dwres     = (5.57802)
+    nsig_dela_nld65b_10hv_vfb      = (-2.503)
+    nsig_dela_nld65b_10hv_vtw      = (1.02661)
+    nsig_delr_nld65b_10hv_res      = (-2.41829)
+    nsig_delr_nld65b_10hv_uch      = (-0.702791)
+    nsig_dela_nld65b_10hv_dwres    = (5.57802)
+    nsig_dela_nld90_10hv_vfb       = (-2.2538)
+    nsig_dela_nld90_10hv_vtw       = (4.23)
+    nsig_delr_nld90_10hv_res       = (-3.58)
+    nsig_delr_nld90_10hv_uch       = (-2.075)
+    nsig_dela_nld90_10hv_dwmos     = (5.95)
+    nsig_dela_nld90_10hv_dwres     = (3)
+    nsig_dela_nld90b_10hv_vfb      = (-2.2538)
+    nsig_dela_nld90b_10hv_vtw      = (4.23)
+    nsig_delr_nld90b_10hv_res      = (-3.58)
+    nsig_delr_nld90b_10hv_uch      = (-2.075)
+    nsig_dela_nld90b_10hv_dwmos    = (5.95)
+    nsig_dela_nld90b_10hv_dwres    = (3)
+    nsig_dela_pld90_10hv_vfb       = (-2.55608)
+    nsig_dela_pld90_10hv_vtm       = (-0.941822)
+    nsig_delr_pld90_10hv_res       = (-3.04783)
+    nsig_delr_pld90_10hv_uch       = (-0.569241)
+    nsig_dela_pld90b_10hv_vfb      = (-2.20818)
+    nsig_dela_pld90b_10hv_vtm      = (-1.15876)
+    nsig_delr_pld90b_10hv_res      = (-3.06868)
+    nsig_delr_pld90b_10hv_uch      = (-0.329111)
+    nsig_dela_nld10_10hv_vfb       = (-2.35189)
+    nsig_delr_nld10_10hv_res       = (0)
+    nsig_delr_nld10_10hv_uch       = (0.86838)
+    nsig_dela_nld10_10hv_dw        = (-0.622818)
+    nsig_dela_nld10_10hv_vtm       = (0.480593)
+    nsig_dela_nld30_10hv_vfb       = (-2.31086)
+    nsig_dela_nld30_10hv_vtm       = (0.962098)
+    nsig_delr_nld30_10hv_res       = (0)
+    nsig_delr_nld30_10hv_uch       = (0.900285)
+    nsig_dela_nld30_10hv_dw        = (-0.119906)
+    nsig_dela_nld30_10hv_dr        = (0)
+    nsig_dela_nld30b_10hv_vfb      = (-2.31086)
+    nsig_dela_nld30b_10hv_vtm      = (0.962098)
+    nsig_delr_nld30b_10hv_res      = (0)
+    nsig_delr_nld30b_10hv_uch      = (0.900285)
+    nsig_dela_nld30b_10hv_dw       = (-0.119906)
+    nsig_dela_nld30b_10hv_dr       = (0)
+    nsig_dela_nld45_10hv_vfb       = (-2.64427)
+    nsig_dela_nld45_10hv_vtm       = (0.698606)
+    nsig_delr_nld45_10hv_res       = (-2.50653)
+    nsig_delr_nld45_10hv_uch       = (0.149169)
+    nsig_dela_nld45_10hv_dw        = (0.286407)
+    nsig_dela_nld45_10hv_dr        = (4.44653)
+    nsig_dela_nld45b_10hv_vfb      = (-2.64427)
+    nsig_dela_nld45b_10hv_vtm      = (0.698606)
+    nsig_delr_nld45b_10hv_res      = (-2.50653)
+    nsig_delr_nld45b_10hv_uch      = (0.149169)
+    nsig_dela_nld45b_10hv_dw       = (0.286407)
+    nsig_dela_nld45b_10hv_dr       = (4.44653)
+    nsig_dela_nld45_he_10hv_vfb    = (-2.68376)
+    nsig_dela_nld45_he_10hv_vtm    = (0.967454)
+    nsig_delr_nld45_he_10hv_res    = (-1.71475)
+    nsig_delr_nld45_he_10hv_uch    = (0.376732)
+    nsig_dela_nld45_he_10hv_dw     = (-3)
+    nsig_dela_nld45_he_10hv_dr     = (1.000406667)
+    nsig_dela_nld45_he_10hv_a0     = (-0.160097)
+    nsig_dela_nld45_he_10hv_b0     = (0.0741165)
+    nsig_dela_nld45b_he_10hv_vfb   = (-2.68376)
+    nsig_dela_nld45b_he_10hv_vtm   = (0.967454)
+    nsig_delr_nld45b_he_10hv_res   = (-1.71475)
+    nsig_delr_nld45b_he_10hv_uch   = (0.376732)
+    nsig_dela_nld45b_he_10hv_dw    = (-3)
+    nsig_dela_nld45b_he_10hv_dr    = (1.000406667)
+    nsig_dela_nld45b_he_10hv_a0    = (-0.160097)
+    nsig_dela_nld45b_he_10hv_b0    = (0.0741165)
+    nsig_dela_nld45_tlp_10hv_vfb   = (-2.43531)
+    nsig_dela_nld45_tlp_10hv_vtm   = (1.30396)
+    nsig_delr_nld45_tlp_10hv_res   = (-2.08334)
+    nsig_delr_nld45_tlp_10hv_uch   = (1.13024)
+    nsig_dela_nld45_tlp_10hv_dr    = (1.82558)
+    nsig_dela_nld45_tlp_10hv_dw    = (-3)
+    nsig_dela_nld45_tlp_10hv_a0    = (1.16786)
+    nsig_dela_nld45_tlp_10hv_b0    = (1.146)
+    nsig_dela_nld45b_tlp_10hv_vfb  = (-2.43531)
+    nsig_dela_nld45b_tlp_10hv_vtm  = (1.30396)
+    nsig_delr_nld45b_tlp_10hv_res  = (-2.08334)
+    nsig_delr_nld45b_tlp_10hv_uch  = (1.13024)
+    nsig_dela_nld45b_tlp_10hv_dr   = (1.82558)
+    nsig_dela_nld45b_tlp_10hv_dw   = (-3)
+    nsig_dela_nld45b_tlp_10hv_a0   = (1.16786)
+    nsig_dela_nld45b_tlp_10hv_b0   = (1.146)
+    nsig_dela_pld5_10hv_vfb        = (-1.79791)
+    nsig_dela_pld5_10hv_vtm        = (-1.5299)
+    nsig_delr_pld5_10hv_uch        = (2.39203)
+    nsig_dela_pld5_10hv_dw         = (0.0471789)
+    nsig_dela_nld5_10hv_vfb        = (-2.50833)
+    nsig_delr_nld5_10hv_res        = (0)
+    nsig_delr_nld5_10hv_uch        = (2.82881)
+    nsig_delr_nld5_10hv_vsat       = (-0.79576)
+    nsig_dela_nld5_10hv_dwmos      = (-1.29756)
+    nsig_dela_nld5_10hv_vtw        = (1.18919)
+    nsig_dela_pld10_10hv_vfb       = (-2.78759)
+    nsig_delr_pld10_10hv_res       = (-2.125)
+    nsig_delr_pld10_10hv_uch       = (-1.98118)
+    nsig_dela_pld10_10hv_vtw       = (0.456194)
+    nsig_dela_pld10_10hv_dwres     = (6.12)
+    nsig_dela_pld10_10hv_dwmos     = (5.5)
+    nsig_dela_dw_pld10b_sphv_10hv  = (0.868317)
+    nsig_dela_vfb_pld10b_sphv_10hv = (-2.99922)
+    nsig_dela_vtwl_pld10b_sphv_10hv = (0.113052)
+    nsig_delr_mobref_pld10b_sphv_10hv = (-1.0367)
+    nsig_delr_rshl_pld10b_sphv_10hv = (-2.7151)
+    nsig_dela_pld30_10hv_vfb       = (-2.4408)
+    nsig_delr_pld30_10hv_res       = (-2.60527)
+    nsig_delr_pld30_10hv_uch       = (0.605154)
+    nsig_dela_pld30_10hv_dwmos     = (-0.947679)
+    nsig_dela_pld30_10hv_dwres     = (0.117798)
+    nsig_dela_pld30_10hv_vtw       = (0.222473)
+    nsig_dela_pld30b_10hv_vfb      = (-2.466923)
+    nsig_delr_pld30b_10hv_res      = (-3.203)
+    nsig_delr_pld30b_10hv_uch      = (2.20)
+    nsig_dela_pld30b_10hv_dwmos    = (-2.73)
+    nsig_dela_pld30b_10hv_dwres    = (-2.3)
+    nsig_dela_pld30b_10hv_vtw      = (1.4975)
+    nsig_dela_pld45_10hv_vfb       = (-2.8923)
+    nsig_delr_pld45_10hv_res       = (-2.99343)
+    nsig_delr_pld45_10hv_uch       = (-3.55062)
+    nsig_dela_pld45_10hv_dwmos     = (0.100411)
+    nsig_dela_pld45_10hv_dwres     = (0.0)
+    nsig_dela_pld45_10hv_vtw       = (1.82366)
+    nsig_dela_pld45b_10hv_vfb      = (-2.87316)
+    nsig_delr_pld45b_10hv_res      = (-2.8)
+    nsig_delr_pld45b_10hv_uch      = (-3.5)
+    nsig_dela_pld45b_10hv_dwmos    = (0.344936)
+    nsig_dela_pld45b_10hv_dwres    = (0.423546)
+    nsig_dela_pld45b_10hv_vtw      = (0.695975)
+    nsig_dela_nld5_lvt_10hv_vfb    = (-2.53329)
+    nsig_delr_nld5_lvt_10hv_res    = (-2.37441)
+    nsig_delr_nld5_lvt_10hv_uch    = (3.48034)
+    nsig_dela_nld5_lvt_10hv_dwmos  = (-2.93214)
+    nsig_dela_nld5_lvt_10hv_vtw    = (-2.734551)
+    nsig_delr_nld5_lvt_10hv_vsat   = (0)
+    nsig_delr_nld5_lvt_10hv_ub     = (0)


parameters
+    nsig_delr_tox_nld45b_sphv_10hv = -3.0
+    nsig_dela_xw_nld45b_sphv_10hv = 4.021
+    nsig_dela_vfb_nld45b_sphv_10hv = -2.11522169663
+    nsig_delr_mobref_nld45b_sphv_10hv = 0.1544
+    nsig_delr_rsh_nld45b_sphv_10hv = -3.437
+    nsig_dela_vtw_nld45b_sphv_10hv = 2.4784263337
+    nsig_delr_vdscale_nld45b_sphv_10hv = -1.588
+    nsig_delr_cj_nld45b_sphv_10hv = -3.0
+    nsig_delr_is_nld45b_sphv_10hv = 3.0
+    nsig_delr_is2_nld45b_sphv_10hv = 3.0
+    nsig_delr_ir_nld45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pld65_sphv_10hv = -2.339
+    nsig_dela_vtw_pld65_sphv_10hv = 1.907
+    nsig_delr_uch_pld65_sphv_10hv = 1.573
+    nsig_delr_res_pld65_sphv_10hv = -2.714769
+    nsig_dela_dwox_pld65_sphv_10hv = 2.142857
+    nsig_delr_cj_pld65_sphv_10hv = -3.0
+    nsig_delr_is_pld65_sphv_10hv = 3.0
+    nsig_delr_is2_pld65_sphv_10hv = 3.0
+    nsig_delr_ir_pld65_sphv_10hv = 3.0
+    nsig_dela_dw_nld90b_sphv_10hv = -6.00735412058
+    nsig_dela_xw_nld90b_sphv_10hv = 3.43786682386
+    nsig_dela_vfb_nld90b_sphv_10hv = -3.0052408551
+    nsig_delr_mobref_nld90b_sphv_10hv = 3.0
+    nsig_delr_ids_nld90b_sphv_10hv = 3.0
+    nsig_delr_rshl_nld90b_sphv_10hv = -3.22668920861
+    nsig_dela_vtwl_nld90b_sphv_10hv = 2.47353175951
+    nsig_delr_cj_nld90b_sphv_10hv = -3.0
+    nsig_delr_is_nld90b_sphv_10hv = 3.0
+    nsig_delr_is2_nld90b_sphv_10hv = 3.0
+    nsig_delr_ir_nld90b_sphv_10hv = 3.0
+    nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv = -3.0
+    nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv = -3.0
+    nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = -3.0
+    nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = -3.0
+    nsig_delr_tox_nld45b_tlp_sphv_10hv = -3.0
+    nsig_dela_xw_nld45b_tlp_sphv_10hv = 3.0
+    nsig_dela_vfb_nld45b_tlp_sphv_10hv = -2.757
+    nsig_delr_mobref_nld45b_tlp_sphv_10hv = 3.0
+    nsig_delr_rsh_nld45b_tlp_sphv_10hv = -1.5
+    nsig_dela_vtw_nld45b_tlp_sphv_10hv = 2.6916551842
+    nsig_delr_vdscale_nld45b_tlp_sphv_10hv = -3.5
+    nsig_delr_thesato_nld45b_tlp_sphv_10hv = 3.6
+    nsig_dela_vfb_nld45b_tlp_mosb_10hv = 2.5
+    nsig_delr_cj_nld45b_tlp_sphv_10hv = -3.0
+    nsig_delr_is_nld45b_tlp_sphv_10hv = 3.0
+    nsig_delr_is2_nld45b_tlp_sphv_10hv = 3.0
+    nsig_delr_ir_nld45b_tlp_sphv_10hv = 3.0
+    nsig_delr_tox_pld120_sphv_10hv = -3.0
+    nsig_delr_uch_pld120_sphv_10hv = 1.3
+    nsig_delr_res_pld120_sphv_10hv = -2.875
+    nsig_dela_vfb_pld120_sphv_10hv = -1.95
+    nsig_dela_vtw_pld120_sphv_10hv = 3.0
+    nsig_dela_vtl_pld120_sphv_10hv = 1.167
+    nsig_dela_mueo_pld120_sphv_10hv = 0.0
+    nsig_dela_dw_pld120_sphv_10hv = 0.0
+    nsig_dela_dwox_pld120_sphv_10hv = 3.0
+    nsig_dela_vdscale_pld120_sphv_10hv = -3.0
+    nsig_dela_vdscalel_pld120_sphv_10hv = 0.885
+    nsig_dela_vdscalew_pld120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pld120_sphv_10hv = 0.0
+    nsig_delr_cj_pld120_sphv_10hv = -3.0
+    nsig_delr_is_pld120_sphv_10hv = 3.0
+    nsig_delr_is2_pld120_sphv_10hv = 3.0
+    nsig_delr_ir_pld120_sphv_10hv = 3.0
+    nsig_delr_tox_nld45b_he_sphv_10hv = -3.0
+    nsig_dela_xw_nld45b_he_sphv_10hv = 3.2
+    nsig_dela_vfb_nld45b_he_sphv_10hv = -2.85842511315
+    nsig_delr_mobref_nld45b_he_sphv_10hv = 2.8
+    nsig_delr_rsh_nld45b_he_sphv_10hv = -2.0
+    nsig_dela_vtw_nld45b_he_sphv_10hv = 2.45657910998
+    nsig_delr_thesato_nld45b_he_sphv_10hv = 2.56664174108
+    nsig_delr_cj_nld45b_he_sphv_10hv = -3.0
+    nsig_delr_is_nld45b_he_sphv_10hv = 3.0
+    nsig_delr_is2_nld45b_he_sphv_10hv = 3.0
+    nsig_delr_ir_nld45b_he_sphv_10hv = 3.0
+    nsig_delr_tox_nld30b_sphv_10hv = -3.0
+    nsig_dela_dw_nld30b_sphv_10hv = 0.0
+    nsig_dela_xw_nld30b_sphv_10hv = 3.0
+    nsig_dela_vfb_nld30b_sphv_10hv = -2.2
+    nsig_delr_mobref_nld30b_sphv_10hv = 1.35
+    nsig_delr_rshl_nld30b_sphv_10hv = -2.9
+    nsig_dela_vtwl_nld30b_sphv_10hv = 3.1
+    nsig_delr_cj_nld30b_sphv_10hv = -3.0
+    nsig_delr_is_nld30b_sphv_10hv = 3.0
+    nsig_delr_is2_nld30b_sphv_10hv = 3.0
+    nsig_delr_ir_nld30b_sphv_10hv = 3.0
+    nsig_dela_vfb_pld100_sphv_10hv = -2.205
+    nsig_dela_vtw_pld100_sphv_10hv = 3.6
+    nsig_delr_uch_pld100_sphv_10hv = 1.0
+    nsig_delr_res_pld100_sphv_10hv = -3.1283
+    nsig_dela_dwox_pld100_sphv_10hv = 1.8333
+    nsig_delr_cj_pld100_sphv_10hv = -3.0
+    nsig_delr_is_pld100_sphv_10hv = 3.0
+    nsig_delr_is2_pld100_sphv_10hv = 3.0
+    nsig_delr_ir_pld100_sphv_10hv = 3.0
+    nsig_dela_dw_pld100_sphv_10hv = 0.0
+    nsig_delr_thesat_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscale_pld100_sphv_10hv = 0.0
+    nsig_delr_vdscalew_pld100_sphv_10hv = 0.0
+    nsig_delr_theacc2_pld100_sphv_10hv = 0.0
+    nsig_delr_tox_nld10_sphv_10hv = -3.0
+    nsig_dela_dw_nld10_sphv_10hv = -1.0
+    nsig_dela_xw_nld10_sphv_10hv = 2.5
+    nsig_dela_vfb_nld10_sphv_10hv = -2.4675
+    nsig_delr_mobref_nld10_sphv_10hv = 2.5
+    nsig_delr_rshl_nld10_sphv_10hv = 0.0
+    nsig_delr_thesato_nld10_sphv_10hv = 0.5556
+    nsig_dela_vtwl_nld10_sphv_10hv = 1.761
+    nsig_delr_cj_nld10_sphv_10hv = -3.0
+    nsig_delr_is_nld10_sphv_10hv = 3.0
+    nsig_delr_is2_nld10_sphv_10hv = 3.0
+    nsig_delr_ir_nld10_sphv_10hv = 3.0
+    nsig_delr_tox_nld100_sphv_10hv = -3.0
+    nsig_dela_xw_nld100_sphv_10hv = 4.2
+    nsig_dela_vfb_nld100_sphv_10hv = -2.0
+    nsig_dela_vfbw_nld100_sphv_10hv = 2.55
+    nsig_dela_vdscale_nld100_sphv_10hv = -3.2
+    nsig_dela_vdscalew_nld100_sphv_10hv = -2.8
+    nsig_dela_thesatgo_nld100_sphv_10hv = -3.0
+    nsig_delr_rshl_nld100_sphv_10hv = -3.0
+    nsig_delr_cj_nld100_sphv_10hv = -3.0
+    nsig_delr_is_nld100_sphv_10hv = 3.0
+    nsig_delr_is2_nld100_sphv_10hv = 3.0
+    nsig_delr_ir_nld100_sphv_10hv = 3.0
+    nsig_delr_cfr_s_ply_met_nld100_sphv_10hv = -3.0
+    nsig_delr_cfr_d_ply_met_nld100_sphv_10hv = -3.0
+    nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = -3.0
+    nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = -3.0
+    nsig_dela_dw_pld45b_sphv_10hv = 1.01018
+    nsig_dela_vfb_pld45b_sphv_10hv = -2.62526
+    nsig_delr_uch_pld45b_sphv_10hv = -1.549806
+    nsig_delr_rshl_pld45b_sphv_10hv = -2.9085
+    nsig_dela_vtwl_pld45b_sphv_10hv = 1.358695
+    nsig_dela_nwxw_pld45b_sphv_10hv = 3.1764
+    nsig_delr_cj_pld45b_sphv_10hv = -3.0
+    nsig_delr_is_pld45b_sphv_10hv = 3.0
+    nsig_delr_is2_pld45b_sphv_10hv = 3.0
+    nsig_delr_ir_pld45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pld90b_sphv_10hv = -1.9541806841
+    nsig_dela_vtw_pld90b_sphv_10hv = 2.83461497634
+    nsig_delr_uch_pld90b_sphv_10hv = 0.12928447286
+    nsig_delr_res_pld90b_sphv_10hv = -3.04725343214
+    nsig_dela_dwox_pld90b_sphv_10hv = 3.0
+    nsig_delr_cj_pld90b_sphv_10hv = -3.0
+    nsig_delr_is_pld90b_sphv_10hv = 3.0
+    nsig_delr_is2_pld90b_sphv_10hv = 3.0
+    nsig_delr_ir_pld90b_sphv_10hv = 3.0
+    nsig_delr_uch_nld65b_sphv_10hv = -0.4307
+    nsig_delr_res_nld65b_sphv_10hv = -3.0
+    nsig_dela_vfb_nld65b_sphv_10hv = -3.001
+    nsig_dela_vtw_nld65b_sphv_10hv = 1.822
+    nsig_dela_xw_nld65b_sphv_10hv = 3.0
+    nsig_dela_thesatw_nld65b_sphv_10hv = 0.75
+    nsig_delr_cj_nld65b_sphv_10hv = -3.0
+    nsig_delr_is_nld65b_sphv_10hv = 3.0
+    nsig_delr_is2_nld65b_sphv_10hv = 3.0
+    nsig_delr_ir_nld65b_sphv_10hv = 3.0
+    nsig_dela_vfbo_pld30b_sphv_10hv = -2.243
+    nsig_dela_vfbw_pld30b_sphv_10hv = 2.8
+    nsig_delr_rshldd_pld30b_sphv_10hv = -2.842
+    nsig_dela_nwxw_pld30b_sphv_10hv = 3.9
+    nsig_dela_vdscale_pld30b_sphv_10hv = 1.5
+    nsig_dela_vdscalew_pld30b_sphv_10hv = -0.8
+    nsig_delr_cj_pld30b_sphv_10hv = -3.0
+    nsig_delr_is_pld30b_sphv_10hv = 3.0
+    nsig_delr_is2_pld30b_sphv_10hv = 3.0
+    nsig_delr_ir_pld30b_sphv_10hv = 3.0

//***********************************************************
endsection bcs_powermos_process_params
//***********************************************************

//***********************************************************
section lo_para_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_alcap_m4         = (-3.0)
+    nsig_delr_cfr_alcap_m4         = (-3.0)
+    nsig_delr_cpp_alcap_m3         = (-3.0)
+    nsig_delr_cfr_alcap_m3         = (-3.0)
+    nsig_delr_cpp_alcap_m2         = (-3.0)
+    nsig_delr_cfr_alcap_m2         = (-3.0)
+    nsig_delr_cpp_alcap_m1         = (-3.0)
+    nsig_delr_cfr_alcap_m1         = (-3.0)
+    nsig_delr_cpp_alcap_ply        = (-3.0)
+    nsig_delr_cfr_alcap_ply        = (-3.0)
+    nsig_delr_cpp_alcap_sd         = (-3.0)
+    nsig_delr_cfr_alcap_sd         = (-3.0)
+    nsig_delr_cpp_alcap_fld        = (-3.0)
+    nsig_delr_cfr_alcap_fld        = (-3.0)
+    nsig_delr_cpp_m4_m3            = (-3.0)
+    nsig_delr_cfr_m4_m3            = (-3.0)
+    nsig_delr_cpp_m4_m2            = (-3.0)
+    nsig_delr_cfr_m4_m2            = (-3.0)
+    nsig_delr_cpp_m4_m1            = (-3.0)
+    nsig_delr_cfr_m4_m1            = (-3.0)
+    nsig_delr_cpp_m4_ply           = (-3.0)
+    nsig_delr_cfr_m4_ply           = (-3.0)
+    nsig_delr_cpp_m4_sd            = (-3.0)
+    nsig_delr_cfr_m4_sd            = (-3.0)
+    nsig_delr_cpp_m4_fld           = (-3.0)
+    nsig_delr_cfr_m4_fld           = (-3.0)
+    nsig_delr_cpp_m3_m2            = (-3.0)
+    nsig_delr_cfr_m3_m2            = (-3.0)
+    nsig_delr_cpp_m3_m1            = (-3.0)
+    nsig_delr_cfr_m3_m1            = (-3.0)
+    nsig_delr_cpp_m3_ply           = (-3.0)
+    nsig_delr_cfr_m3_ply           = (-3.0)
+    nsig_delr_cpp_m3_sd            = (-3.0)
+    nsig_delr_cfr_m3_sd            = (-3.0)
+    nsig_delr_cpp_m3_fld           = (-3.0)
+    nsig_delr_cfr_m3_fld           = (-3.0)
+    nsig_delr_cpp_m2_m1            = (-3.0)
+    nsig_delr_cfr_m2_m1            = (-3.0)
+    nsig_delr_cpp_m2_ply           = (-3.0)
+    nsig_delr_cfr_m2_ply           = (-3.0)
+    nsig_delr_cpp_m2_sd            = (-3.0)
+    nsig_delr_cfr_m2_sd            = (-3.0)
+    nsig_delr_cpp_m2_fld           = (-3.0)
+    nsig_delr_cfr_m2_fld           = (-3.0)
+    nsig_delr_cpp_m1_ply           = (-3.0)
+    nsig_delr_cfr_m1_ply           = (-3.0)
+    nsig_delr_cpp_m1_sd            = (-3.0)
+    nsig_delr_cfr_m1_sd            = (-3.0)
+    nsig_delr_cpp_m1_fld           = (-3.0)
+    nsig_delr_cfr_m1_fld           = (-3.0)
+    nsig_delr_cpp_ply_ply0         = (-3.0)
+    nsig_delr_cfr_ply_ply0         = (-3.0)
+    nsig_delr_cpp_ply_sd           = (-3.0)
+    nsig_delr_cfr_ply_sd           = (-3.0)
+    nsig_delr_cpp_ply_fld          = (-3.0)
+    nsig_delr_cfr_ply_fld          = (-3.0)
+    nsig_delr_cpp_ply_sdt          = (-3.0)
+    nsig_delr_cfr_ply_sdt          = (-3.0)
+    nsig_delr_cpp_ply0_fld         = (-3.0)
+    nsig_delr_cfr_ply0_fld_cdp     = (-3.0)
+    nsig_delr_cpp_ply0_fld_cdp     = (-3.0)
+    nsig_delr_cfr_ply0_fld         = (-3.0)
+    nsig_delr_cfr_nld90_s_ply_m1ct = (-2.4)
+    nsig_delr_cfr_pmoshs45b_s_ply_met = (-2.5)
+    nsig_delr_cfr_pld5_s_ply_m1ct  = (-2.9)
+    nsig_delr_cfr_nsrampd_s_ply_met = (-2.5)
+    nsig_delr_cfr_psrampu_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld45b_tlp_d_ply_met = (-2.8)
+    nsig_delr_cfr_pmos_ll_s_ply_met = (-2.5)
+    nsig_delr_cfr_nmos_ull_s_ply_met = (-2.5)
+    nsig_delr_cfr_pmos_ana_s_ply_met = (-2.4)
+    nsig_delr_cfr_pld45_d_ply_met  = (-2.8)
+    nsig_delr_cfr_nld65_d_ply_met  = (-3.0)
+    nsig_delr_cfr_pmos45b_d_ply_met = (-3.0)
+    nsig_delr_cfr_pmos_d_ply_m1ct  = (-3.0)
+    nsig_delr_cfr_nld65b_s_ply_met = (-2.4)
+    nsig_delr_cfr_pmos90b_d_ply_met = (-3.0)
+    nsig_delr_cfr_nmos3_zvt_d_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pmoshs45_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nmos_ull_d_ply_ct = (-3.0)
+    nsig_delr_cfr_pld10_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pld30b_d_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nmos90b_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld45b_d_ply_met = (-2.7)
+    nsig_delr_cfr_pmos45_d_ply_met = (-3.0)
+    nsig_delr_cfr_pld45_s_ply_met  = (-2.6)
+    nsig_delr_cfr_nld45b_he_d_ply_met = (-2.7)
+    nsig_delr_cfr_nld90b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pld30_s_ply_met  = (-2.6)
+    nsig_delr_cfr_nmos_ull_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld90_d_ply_met  = (-3.0)
+    nsig_delr_cfr_pmos_s_ply_met   = (-2.5)
+    nsig_delr_cfr_nld45_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pmos_ll_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nsrampg_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nsrampd_d_ply_met = (-2.5)
+    nsig_delr_cfr_pmos45b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos_ull_d_ply_met = (-2.5)
+    nsig_delr_cfr_nld10_s_ply_met  = (-2.5)
+    nsig_delr_cfr_psrampu_d_ply_met = (-2.5)
+    nsig_delr_cfr_pld45b_s_ply_met = (-2.6)
+    nsig_delr_cfr_nsrampg_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld90b_d_ply_met = (-3.0)
+    nsig_delr_cfr_pmos_ll_d_ply_met = (-2.5)
+    nsig_delr_cfr_pld45b_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pmoshs45b_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pmos_ull_s_ply_ct_end = (-3.0)
+    nsig_delr_cfr_nld10_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nmos5_s_ply_met  = (-2.5)
+    nsig_delr_cfr_nld30b_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nld5_s_ply_m1ct  = (-2.6)
+    nsig_delr_cfr_pmos45_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos45b_d_ply_met = (-3.0)
+    nsig_delr_cfr_pld90b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld45b_he_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nmos10_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld45b_tlp_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pmos_ull_s_ply_ct = (-3.0)
+    nsig_delr_cfr_nld45_he_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nld45_tlp_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nmos_ull_s_ply_met_end = (-2.5)
+    nsig_delr_cfr_nsrampd_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_psrampu_s_ply_met = (-2.5)
+    nsig_delr_cfr_nmos90_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos_ull_d_ply_met = (-2.5)
+    nsig_delr_cfr_pld5_d_ply_m1ct  = (-2.9)
+    nsig_delr_cfr_nld30_d_ply_met  = (-2.6)
+    nsig_delr_cfr_pmos_ana_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld45b_s_ply_met = (-2.3)
+    nsig_delr_cfr_pmoshs45b_d_ply_met = (-3.0)
+    nsig_delr_cfr_nld65_s_ply_m1ct = (-2.7)
+    nsig_delr_cfr_nld90_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos_d_ply_met   = (-2.5)
+    nsig_delr_cfr_nld5_lvt_s_ply_met = (-2.3)
+    nsig_delr_cfr_nmos_ll_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos10_d_ply_met = (-2.9)
+    nsig_delr_cfr_nmos_s_ply_m1ct  = (-3.0)
+    nsig_delr_cfr_nmos5_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld10_d_ply_met  = (-2.5)
+    nsig_delr_cfr_pmos90b_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld45b_tlp_s_ply_met = (-2.3)
+    nsig_delr_cfr_pld10_d_ply_m1ct = (-2.4)
+    nsig_delr_cfr_nmos90_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nmos_ana_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos90_s_ply_met = (-2.5)
+    nsig_delr_cfr_nmos3_zvt_d_ply_met = (-2.8)
+    nsig_delr_cfr_pmos5_d_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pmos_ull_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos_ana_d_ply_met = (-2.4)
+    nsig_delr_cfr_nmos90b_s_ply_met = (-2.6)
+    nsig_delr_cfr_nmos45_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld45b_he_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nsrampg_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld45_d_ply_met  = (-2.7)
+    nsig_delr_cfr_nmos_ll_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos_ull_d_ply_met_end = (-2.5)
+    nsig_delr_cfr_nld45b_tlp_d_ply_m1ct = (-2.7)
+    nsig_delr_cfr_nmos90_s_ply_met = (-2.6)
+    nsig_delr_cfr_nmos_ana_d_ply_met = (-2.4)
+    nsig_delr_cfr_pld10_d_ply_met  = (-2.3)
+    nsig_delr_cfr_nld5_d_ply_m1ct  = (-2.6)
+    nsig_delr_cfr_nmos_s_ply_met   = (-2.5)
+    nsig_delr_cfr_pmos_ull_s_ply_met_end = (-2.5)
+    nsig_delr_cfr_pmos90_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld65b_s_ply_m1ct = (-2.7)
+    nsig_delr_cfr_nld30b_d_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nmos_ana_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld65b_d_ply_met = (-3.0)
+    nsig_delr_cfr_nmos_ll_d_ply_met = (-2.5)
+    nsig_delr_cfr_pld10_s_ply_met  = (-2.6)
+    nsig_delr_cfr_nmos10_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nmos_ull_s_ply_ct = (-3.0)
+    nsig_delr_cfr_pmos90b_s_ply_met = (-2.5)
+    nsig_delr_cfr_pld5_s_ply_met   = (-2.4)
+    nsig_delr_cfr_pmos_ull_d_ply_ct_end = (-3.0)
+    nsig_delr_cfr_pmos45b_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld90b_s_ply_met = (-2.4)
+    nsig_delr_cfr_pmos45b_s_ply_met = (-2.5)
+    nsig_delr_cfr_pmoshs45b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pld90_d_ply_met  = (-3.0)
+    nsig_delr_cfr_pmos_ll_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos5_s_ply_met  = (-2.5)
+    nsig_delr_cfr_pld90_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nld90_s_ply_met  = (-2.4)
+    nsig_delr_cfr_pmos_ull_s_ply_met = (-2.5)
+    nsig_delr_cfr_pmos10_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld65_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld45b_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pmos90_d_ply_met = (-3.0)
+    nsig_delr_cfr_nld10_d_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pld5_d_ply_met   = (-2.4)
+    nsig_delr_cfr_pmos5_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld30b_d_ply_met = (-2.6)
+    nsig_delr_cfr_nmos_ll_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld90b_s_ply_m1ct = (-2.4)
+    nsig_delr_cfr_pld45_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nld65b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nsrampg_d_ply_met = (-2.5)
+    nsig_delr_cfr_nmos90b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld5_lvt_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_pmos10_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld5_d_ply_met   = (-2.3)
+    nsig_delr_cfr_nld30b_s_ply_met = (-2.3)
+    nsig_delr_cfr_nld65_s_ply_met  = (-2.4)
+    nsig_delr_cfr_nld45_he_d_ply_met = (-2.7)
+    nsig_delr_cfr_pld30_s_ply_m1ct = (-2.6)
+    nsig_delr_cfr_pld90_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos90b_d_ply_met = (-3.0)
+    nsig_delr_cfr_pmos45_s_ply_met = (-2.5)
+    nsig_delr_cfr_pmoshs45_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos_ull_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos5_d_ply_met  = (-2.5)
+    nsig_delr_cfr_pld45_d_ply_m1ct = (-2.7)
+    nsig_delr_cfr_nmos45b_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld45_tlp_d_ply_met = (-2.8)
+    nsig_delr_cfr_nmos_ull_d_ply_met_end = (-2.5)
+    nsig_delr_cfr_nmos45b_d_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld45_tlp_d_ply_m1ct = (-2.7)
+    nsig_delr_cfr_pld90_s_ply_met  = (-2.5)
+    nsig_delr_cfr_nld30_d_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nmos5_d_ply_met  = (-2.5)
+    nsig_delr_cfr_nmos3_zvt_s_ply_met = (-2.9)
+    nsig_delr_cfr_nmos_d_ply_met   = (-2.5)
+    nsig_delr_cfr_pld30b_d_ply_met = (-2.6)
+    nsig_delr_cfr_nld30_s_ply_met  = (-2.3)
+    nsig_delr_cfr_pmoshs45_d_ply_met = (-3.0)
+    nsig_delr_cfr_nmos5_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pmos10_d_ply_met = (-2.5)
+    nsig_delr_cfr_pld30b_s_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nmos45_s_ply_met = (-2.5)
+    nsig_delr_cfr_pmoshs45_s_ply_met = (-2.5)
+    nsig_delr_cfr_nld5_lvt_s_ply_m1ct = (-2.6)
+    nsig_delr_cfr_pld90b_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pld90b_s_ply_met = (-2.5)
+    nsig_delr_cfr_nmos45_d_ply_met = (-3.0)
+    nsig_delr_cfr_nld5_s_ply_met   = (-2.3)
+    nsig_delr_cfr_pld30_d_ply_met  = (-2.6)
+    nsig_delr_cfr_pmos_s_ply_m1ct  = (-3.0)
+    nsig_delr_cfr_pmos90b_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nld5_lvt_d_ply_met = (-2.3)
+    nsig_delr_cfr_nmos10_d_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pmos10_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nld30_s_ply_m1ct = (-2.5)
+    nsig_delr_cfr_pmos_ull_d_ply_ct = (-3.0)
+    nsig_delr_cfr_nld45_tlp_s_ply_met = (-2.3)
+    nsig_delr_cfr_nmos45_d_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nmos_ull_s_ply_ct_end = (-3.0)
+    nsig_delr_cfr_pmos45_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pmos_ana_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pld30b_s_ply_met = (-2.6)
+    nsig_delr_cfr_pld90b_d_ply_met = (-3.0)
+    nsig_delr_cfr_pld45b_d_ply_m1ct = (-2.7)
+    nsig_delr_cfr_nld45b_he_s_ply_met = (-2.3)
+    nsig_delr_cfr_nld45_s_ply_met  = (-2.3)
+    nsig_delr_cfr_nmos_d_ply_m1ct  = (-3.0)
+    nsig_delr_cfr_pmos_ull_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_pld45b_d_ply_met = (-2.8)
+    nsig_delr_cfr_pmos90_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_pld30_d_ply_m1ct = (-2.5)
+    nsig_delr_cfr_nld45_he_s_ply_met = (-2.3)
+    nsig_delr_cfr_nmos3_zvt_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nsrampd_d_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos90_d_ply_met = (-3.0)
+    nsig_delr_cfr_nmos_ana_s_ply_met = (-2.4)
+    nsig_delr_cfr_psrampu_s_ply_m1ct = (-3.0)
+    nsig_delr_cfr_nmos45b_s_ply_m1ct = (-2.9)
+    nsig_delr_cfr_nld45_he_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nld45b_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nld45_d_ply_m1ct = (-2.6)
+    nsig_delr_cfr_nmos_ull_d_ply_ct_end = (-3.0)
+    nsig_delr_acj0_junc_psd_nw     = (-3.0)
+    nsig_delr_ajs_junc_psd_nw      = (-3.0)
+    nsig_delr_pcj0_junc_psd_nw     = (-3.0)
+    nsig_delr_pjs_junc_psd_nw      = (-3.0)
+    nsig_delr_acj0_junc_nsd_pw     = (-3.0)
+    nsig_delr_ajs_junc_nsd_pw      = (-3.0)
+    nsig_delr_pcj0_junc_nsd_pw     = (-3.0)
+    nsig_delr_pjs_junc_nsd_pw      = (-3.0)
+    nsig_delr_acj0_junc_psd_nhv    = (-3.0)
+    nsig_delr_ajs_junc_psd_nhv     = (-3.0)
+    nsig_delr_pcj0_junc_psd_nhv    = (-3.0)
+    nsig_delr_pjs_junc_psd_nhv     = (-3.0)
+    nsig_delr_acj0_junc_nsd_phv    = (-3.0)
+    nsig_delr_ajs_junc_nsd_phv     = (-3.0)
+    nsig_delr_pcj0_junc_nsd_phv    = (-3.0)
+    nsig_delr_pjs_junc_nsd_phv     = (-3.0)
+    nsig_delr_acj0_junc_pepi_nbl   = (-3.0)
+    nsig_delr_ajs_junc_pepi_nbl    = (-3.0)
+    nsig_delr_pcj0_junc_pepi_nbl   = (-3.0)
+    nsig_delr_pjs_junc_pepi_nbl    = (-3.0)
+    nsig_delr_acj0_junc_nw_pepi    = (-3.0)
+    nsig_delr_ajs_junc_nw_pepi     = (-3.0)
+    nsig_delr_pcj0_junc_nw_pepi    = (-3.0)
+    nsig_delr_pjs_junc_nw_pepi     = (-3.0)
+    nsig_delr_acj0_junc_nw_pepi_tr = (-3.0)
+    nsig_delr_ajs_junc_nw_pepi_tr  = (-3.0)
+    nsig_delr_pcj0_junc_nw_pepi_tr = (-3.0)
+    nsig_delr_pjs_junc_nw_pepi_tr  = (-3.0)
+    nsig_delr_acj0_junc_nhv_pepi_tr = (-3.0)
+    nsig_delr_ajs_junc_nhv_pepi_tr = (-3.0)
+    nsig_delr_pcj0_junc_nhv_pepi_tr = (-3.0)
+    nsig_delr_pjs_junc_nhv_pepi_tr = (-3.0)
+    nsig_delr_acj0_junc_nbl_pepi_tr = (-3.0)
+    nsig_delr_ajs_junc_nbl_pepi_tr = (-3.0)
+    nsig_delr_pcj0_junc_nbl_pepi_tr = (-3.0)
+    nsig_delr_pjs_junc_nbl_pepi_tr = (-3.0)
+    nsig_delr_acj0_junc_nmos_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nmos_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nmos_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nmos_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nmos_ll_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nmos_ull_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nmos_ana_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nsrampg_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_ajs_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_pjs_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_chjs_junc_nsrampd_sd_body = (-3.0)
+    nsig_delr_acj0_junc_pmos_sd_body = (-3.0)
+    nsig_delr_ajs_junc_pmos_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos_sd_body = (-3.0)
+    nsig_delr_pjs_junc_pmos_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos_sd_body = (-3.0)
+    nsig_delr_chjs_junc_pmos_sd_body = (-3.0)
+    nsig_delr_acj0_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_ajs_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_pjs_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_chjs_junc_pmos_ll_sd_body = (-3.0)
+    nsig_delr_acj0_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_ajs_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_pjs_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_chjs_junc_pmos_ull_sd_body = (-3.0)
+    nsig_delr_acj0_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_ajs_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_pjs_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_chjs_junc_pmos_ana_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos3_zvt_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos3_zvt_s_body = (-3.0)
+    nsig_delr_acj0_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_ajs_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_pjs_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_chjs_junc_psrampu_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos5_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos5_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos5_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos5_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos5_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos5_s_body = (-3.0)
+    nsig_delr_acj0_junc_nmos5_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos5_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos5_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos5_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos5_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos5_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_ajs_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_pjs_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_chjs_junc_pmos5_sd_body = (-3.0)
+    nsig_delr_acj0_junc_nmos10_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos10_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos10_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos10_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos10_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos10_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos10_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos10_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos10_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos10_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos10_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos10_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmos10_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmos10_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos10_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmos10_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos10_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmos10_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos10_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmos10_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos10_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmos10_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos10_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmos10_s_body = (-3.0)
+    nsig_delr_acj0_junc_nmos45_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos45_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos45_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos45_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos45_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos45_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos45_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos45_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos45_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos45_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos45_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos45_s_body = (-3.0)
+    nsig_delr_acj0_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos45b_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos45b_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmos45_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmos45_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos45_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmos45_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos45_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmos45_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos45_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmos45_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos45_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmos45_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos45_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmos45_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmos45b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmos45b_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmoshs45_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmoshs45_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmoshs45b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmoshs45b_s_body = (-3.0)
+    nsig_delr_acj0_junc_nmos90_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos90_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos90_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos90_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos90_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos90_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos90_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos90_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos90_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos90_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos90_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos90_s_body = (-3.0)
+    nsig_delr_acj0_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nmos90b_d_body = (-3.0)
+    nsig_delr_acj0_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_ajs_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_pcj0_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_pjs_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_chcj0_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_chjs_junc_nmos90b_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmos90_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmos90_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos90_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmos90_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos90_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmos90_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pmos90b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pmos90_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmos90_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos90_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmos90_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos90_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmos90_s_body = (-3.0)
+    nsig_delr_acj0_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_ajs_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_pcj0_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_pjs_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_chcj0_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_chjs_junc_pmos90b_s_body = (-3.0)
+    nsig_delr_acj0_junc_nld5_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld5_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld5_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld5_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld5_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld5_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld5_lvt_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld10_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld10_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld10_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld10_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld10_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld10_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld30_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld30_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld30_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld30_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld30_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld30_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld30b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld30b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld30b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld30b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld30b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld30b_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45b_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45_he_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45b_he_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45_tlp_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld45b_tlp_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld65_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld65_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld65_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld65_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld65_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld65_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld65b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld65b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld65b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld65b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld65b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld65b_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld90_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld90_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld90_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld90_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld90_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld90_d_body = (-3.0)
+    nsig_delr_acj0_junc_nld90b_d_body = (-3.0)
+    nsig_delr_ajs_junc_nld90b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_nld90b_d_body = (-3.0)
+    nsig_delr_pjs_junc_nld90b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_nld90b_d_body = (-3.0)
+    nsig_delr_chjs_junc_nld90b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld5_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld5_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld5_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld5_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld5_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld5_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld10_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld10_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld10_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld10_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld10_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld10_d_body = (-3.0)
+    nsig_delr_cj0_junc_pld10b_d_body = (-3.0)
+    nsig_delr_js_junc_pld10b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld30_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld30_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld30_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld30_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld30_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld30_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld30b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld30b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld30b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld30b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld30b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld30b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld45_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld45_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld45_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld45_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld45_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld45_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld45b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld45b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld45b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld45b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld45b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld45b_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld90_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld90_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld90_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld90_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld90_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld90_d_body = (-3.0)
+    nsig_delr_acj0_junc_pld90b_d_body = (-3.0)
+    nsig_delr_ajs_junc_pld90b_d_body = (-3.0)
+    nsig_delr_pcj0_junc_pld90b_d_body = (-3.0)
+    nsig_delr_pjs_junc_pld90b_d_body = (-3.0)
+    nsig_delr_chcj0_junc_pld90b_d_body = (-3.0)
+    nsig_delr_chjs_junc_pld90b_d_body = (-3.0)
+    nsig_delr_tox_box              = (-3.0)


parameters
+    nsig_delr_is_dpldd_junc_10hv = -3.0
+    nsig_delr_ir_dpldd_junc_10hv = -3.0
+    nsig_dela_bv_dpldd_junc_10hv = -3.0
+    nsig_delr_cj_dpldd_junc_10hv = -3.0

//***********************************************************
endsection lo_para_process_params
//***********************************************************

//***********************************************************
section typ_para_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_alcap_m4         = (0.0)
+    nsig_delr_cfr_alcap_m4         = (0.0)
+    nsig_delr_cpp_alcap_m3         = (0.0)
+    nsig_delr_cfr_alcap_m3         = (0.0)
+    nsig_delr_cpp_alcap_m2         = (0.0)
+    nsig_delr_cfr_alcap_m2         = (0.0)
+    nsig_delr_cpp_alcap_m1         = (0.0)
+    nsig_delr_cfr_alcap_m1         = (0.0)
+    nsig_delr_cpp_alcap_ply        = (0.0)
+    nsig_delr_cfr_alcap_ply        = (0.0)
+    nsig_delr_cpp_alcap_sd         = (0.0)
+    nsig_delr_cfr_alcap_sd         = (0.0)
+    nsig_delr_cpp_alcap_fld        = (0.0)
+    nsig_delr_cfr_alcap_fld        = (0.0)
+    nsig_delr_cpp_m4_m3            = (0.0)
+    nsig_delr_cfr_m4_m3            = (0.0)
+    nsig_delr_cpp_m4_m2            = (0.0)
+    nsig_delr_cfr_m4_m2            = (0.0)
+    nsig_delr_cpp_m4_m1            = (0.0)
+    nsig_delr_cfr_m4_m1            = (0.0)
+    nsig_delr_cpp_m4_ply           = (0.0)
+    nsig_delr_cfr_m4_ply           = (0.0)
+    nsig_delr_cpp_m4_sd            = (0.0)
+    nsig_delr_cfr_m4_sd            = (0.0)
+    nsig_delr_cpp_m4_fld           = (0.0)
+    nsig_delr_cfr_m4_fld           = (0.0)
+    nsig_delr_cpp_m3_m2            = (0.0)
+    nsig_delr_cfr_m3_m2            = (0.0)
+    nsig_delr_cpp_m3_m1            = (0.0)
+    nsig_delr_cfr_m3_m1            = (0.0)
+    nsig_delr_cpp_m3_ply           = (0.0)
+    nsig_delr_cfr_m3_ply           = (0.0)
+    nsig_delr_cpp_m3_sd            = (0.0)
+    nsig_delr_cfr_m3_sd            = (0.0)
+    nsig_delr_cpp_m3_fld           = (0.0)
+    nsig_delr_cfr_m3_fld           = (0.0)
+    nsig_delr_cpp_m2_m1            = (0.0)
+    nsig_delr_cfr_m2_m1            = (0.0)
+    nsig_delr_cpp_m2_ply           = (0.0)
+    nsig_delr_cfr_m2_ply           = (0.0)
+    nsig_delr_cpp_m2_sd            = (0.0)
+    nsig_delr_cfr_m2_sd            = (0.0)
+    nsig_delr_cpp_m2_fld           = (0.0)
+    nsig_delr_cfr_m2_fld           = (0.0)
+    nsig_delr_cpp_m1_ply           = (0.0)
+    nsig_delr_cfr_m1_ply           = (0.0)
+    nsig_delr_cpp_m1_sd            = (0.0)
+    nsig_delr_cfr_m1_sd            = (0.0)
+    nsig_delr_cpp_m1_fld           = (0.0)
+    nsig_delr_cfr_m1_fld           = (0.0)
+    nsig_delr_cpp_ply_ply0         = (0.0)
+    nsig_delr_cfr_ply_ply0         = (0.0)
+    nsig_delr_cpp_ply_sd           = (0.0)
+    nsig_delr_cfr_ply_sd           = (0.0)
+    nsig_delr_cpp_ply_fld          = (0.0)
+    nsig_delr_cfr_ply_fld          = (0.0)
+    nsig_delr_cpp_ply_sdt          = (0.0)
+    nsig_delr_cfr_ply_sdt          = (0.0)
+    nsig_delr_cpp_ply0_fld         = (0.0)
+    nsig_delr_cfr_ply0_fld_cdp     = (0.0)
+    nsig_delr_cpp_ply0_fld_cdp     = (0.0)
+    nsig_delr_cfr_ply0_fld         = (0.0)
+    nsig_delr_cfr_nld90_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45b_s_ply_met = (0)
+    nsig_delr_cfr_pld5_s_ply_m1ct  = (0)
+    nsig_delr_cfr_nsrampd_s_ply_met = (0)
+    nsig_delr_cfr_psrampu_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_tlp_d_ply_met = (0)
+    nsig_delr_cfr_pmos_ll_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_met = (0)
+    nsig_delr_cfr_pmos_ana_s_ply_met = (0)
+    nsig_delr_cfr_pld45_d_ply_met  = (0)
+    nsig_delr_cfr_nld65_d_ply_met  = (0)
+    nsig_delr_cfr_pmos45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nld65b_s_ply_met = (0)
+    nsig_delr_cfr_pmos90b_d_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_ct = (0)
+    nsig_delr_cfr_pld10_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos45_d_ply_met = (0)
+    nsig_delr_cfr_pld45_s_ply_met  = (0)
+    nsig_delr_cfr_nld45b_he_d_ply_met = (0)
+    nsig_delr_cfr_nld90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld30_s_ply_met  = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_s_ply_met   = (0)
+    nsig_delr_cfr_nld45_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ll_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampd_d_ply_met = (0)
+    nsig_delr_cfr_pmos45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_met = (0)
+    nsig_delr_cfr_nld10_s_ply_met  = (0)
+    nsig_delr_cfr_psrampu_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_s_ply_met = (0)
+    nsig_delr_cfr_nsrampg_s_ply_met = (0)
+    nsig_delr_cfr_nld90b_d_ply_met = (0)
+    nsig_delr_cfr_pmos_ll_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_ct_end = (0)
+    nsig_delr_cfr_nld10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos5_s_ply_met  = (0)
+    nsig_delr_cfr_nld30b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_s_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_d_ply_met = (0)
+    nsig_delr_cfr_pld90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos10_s_ply_met = (0)
+    nsig_delr_cfr_nld45b_tlp_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_ct = (0)
+    nsig_delr_cfr_nld45_he_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_tlp_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_met_end = (0)
+    nsig_delr_cfr_nsrampd_s_ply_m1ct = (0)
+    nsig_delr_cfr_psrampu_s_ply_met = (0)
+    nsig_delr_cfr_nmos90_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_met = (0)
+    nsig_delr_cfr_pld5_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nld30_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_ana_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45b_d_ply_met = (0)
+    nsig_delr_cfr_nld65_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_d_ply_met   = (0)
+    nsig_delr_cfr_nld5_lvt_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos10_d_ply_met = (0)
+    nsig_delr_cfr_nmos_s_ply_m1ct  = (0)
+    nsig_delr_cfr_nmos5_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld10_d_ply_met  = (0)
+    nsig_delr_cfr_pmos90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_tlp_s_ply_met = (0)
+    nsig_delr_cfr_pld10_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ana_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos90_s_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_d_ply_met = (0)
+    nsig_delr_cfr_pmos5_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ana_d_ply_met = (0)
+    nsig_delr_cfr_nmos90b_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_d_ply_met  = (0)
+    nsig_delr_cfr_nmos_ll_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_met_end = (0)
+    nsig_delr_cfr_nld45b_tlp_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ana_d_ply_met = (0)
+    nsig_delr_cfr_pld10_d_ply_met  = (0)
+    nsig_delr_cfr_nld5_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nmos_s_ply_met   = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_met_end = (0)
+    nsig_delr_cfr_pmos90_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld30b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ana_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_d_ply_met = (0)
+    nsig_delr_cfr_pld10_s_ply_met  = (0)
+    nsig_delr_cfr_nmos10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_ct = (0)
+    nsig_delr_cfr_pmos90b_s_ply_met = (0)
+    nsig_delr_cfr_pld5_s_ply_met   = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_ct_end = (0)
+    nsig_delr_cfr_pmos45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90b_s_ply_met = (0)
+    nsig_delr_cfr_pmos45b_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_ll_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos5_s_ply_met  = (0)
+    nsig_delr_cfr_pld90_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_s_ply_met  = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_met = (0)
+    nsig_delr_cfr_pmos10_s_ply_met = (0)
+    nsig_delr_cfr_nld65_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos90_d_ply_met = (0)
+    nsig_delr_cfr_nld10_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld5_d_ply_met   = (0)
+    nsig_delr_cfr_pmos5_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld30b_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_s_ply_met = (0)
+    nsig_delr_cfr_nld90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_d_ply_met = (0)
+    nsig_delr_cfr_nmos90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_lvt_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_d_ply_met   = (0)
+    nsig_delr_cfr_nld30b_s_ply_met = (0)
+    nsig_delr_cfr_nld65_s_ply_met  = (0)
+    nsig_delr_cfr_nld45_he_d_ply_met = (0)
+    nsig_delr_cfr_pld30_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90b_d_ply_met = (0)
+    nsig_delr_cfr_pmos45_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos5_d_ply_met  = (0)
+    nsig_delr_cfr_pld45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_s_ply_met = (0)
+    nsig_delr_cfr_nld45_tlp_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_met_end = (0)
+    nsig_delr_cfr_nmos45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_tlp_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_s_ply_met  = (0)
+    nsig_delr_cfr_nld30_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos5_d_ply_met  = (0)
+    nsig_delr_cfr_nmos3_zvt_s_ply_met = (0)
+    nsig_delr_cfr_nmos_d_ply_met   = (0)
+    nsig_delr_cfr_pld30b_d_ply_met = (0)
+    nsig_delr_cfr_nld30_s_ply_met  = (0)
+    nsig_delr_cfr_pmoshs45_d_ply_met = (0)
+    nsig_delr_cfr_nmos5_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_d_ply_met = (0)
+    nsig_delr_cfr_pld30b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45_s_ply_met = (0)
+    nsig_delr_cfr_nld5_lvt_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90b_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_d_ply_met = (0)
+    nsig_delr_cfr_nld5_s_ply_met   = (0)
+    nsig_delr_cfr_pld30_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_s_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_lvt_d_ply_met = (0)
+    nsig_delr_cfr_nmos10_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld30_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_ct = (0)
+    nsig_delr_cfr_nld45_tlp_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_ct_end = (0)
+    nsig_delr_cfr_pmos45_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ana_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30b_s_ply_met = (0)
+    nsig_delr_cfr_pld90b_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_s_ply_met = (0)
+    nsig_delr_cfr_nld45_s_ply_met  = (0)
+    nsig_delr_cfr_nmos_d_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos90_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_he_s_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampd_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ana_s_ply_met = (0)
+    nsig_delr_cfr_psrampu_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_he_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_ct_end = (0)
+    nsig_delr_acj0_junc_psd_nw     = (0.0)
+    nsig_delr_ajs_junc_psd_nw      = (0.0)
+    nsig_delr_pcj0_junc_psd_nw     = (0.0)
+    nsig_delr_pjs_junc_psd_nw      = (0.0)
+    nsig_delr_acj0_junc_nsd_pw     = (0.0)
+    nsig_delr_ajs_junc_nsd_pw      = (0.0)
+    nsig_delr_pcj0_junc_nsd_pw     = (0.0)
+    nsig_delr_pjs_junc_nsd_pw      = (0.0)
+    nsig_delr_acj0_junc_psd_nhv    = (0.0)
+    nsig_delr_ajs_junc_psd_nhv     = (0.0)
+    nsig_delr_pcj0_junc_psd_nhv    = (0.0)
+    nsig_delr_pjs_junc_psd_nhv     = (0.0)
+    nsig_delr_acj0_junc_nsd_phv    = (0.0)
+    nsig_delr_ajs_junc_nsd_phv     = (0.0)
+    nsig_delr_pcj0_junc_nsd_phv    = (0.0)
+    nsig_delr_pjs_junc_nsd_phv     = (0.0)
+    nsig_delr_acj0_junc_pepi_nbl   = (0.0)
+    nsig_delr_ajs_junc_pepi_nbl    = (0.0)
+    nsig_delr_pcj0_junc_pepi_nbl   = (0.0)
+    nsig_delr_pjs_junc_pepi_nbl    = (0.0)
+    nsig_delr_acj0_junc_nw_pepi    = (0.0)
+    nsig_delr_ajs_junc_nw_pepi     = (0.0)
+    nsig_delr_pcj0_junc_nw_pepi    = (0.0)
+    nsig_delr_pjs_junc_nw_pepi     = (0.0)
+    nsig_delr_acj0_junc_nw_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nw_pepi_tr  = (0.0)
+    nsig_delr_pcj0_junc_nw_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nw_pepi_tr  = (0.0)
+    nsig_delr_acj0_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_pcj0_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_acj0_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_pcj0_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_acj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_acj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_ajs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_pjs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_chjs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_acj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_ajs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_pjs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_chjs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_acj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_ajs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_pcj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_pjs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_chcj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_chjs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos5_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos5_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos5_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos5_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos5_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos5_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos10_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos10_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos10_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos10_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos10_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos10_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos10_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos10_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos10_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos10_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos10_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos10_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos45_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos45_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos45_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos45_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos45_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos45_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos45_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos45_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos45_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos45_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos90_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos90_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos90_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos90_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos90_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos90_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos90_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos90_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos90_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos90_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos90_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos90_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_acj0_junc_nld5_d_body = (0.0)
+    nsig_delr_ajs_junc_nld5_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld5_d_body = (0.0)
+    nsig_delr_pjs_junc_nld5_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld5_d_body = (0.0)
+    nsig_delr_chjs_junc_nld5_d_body = (0.0)
+    nsig_delr_acj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_ajs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_pjs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_chjs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_acj0_junc_nld10_d_body = (0.0)
+    nsig_delr_ajs_junc_nld10_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld10_d_body = (0.0)
+    nsig_delr_pjs_junc_nld10_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld10_d_body = (0.0)
+    nsig_delr_chjs_junc_nld10_d_body = (0.0)
+    nsig_delr_acj0_junc_nld30_d_body = (0.0)
+    nsig_delr_ajs_junc_nld30_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld30_d_body = (0.0)
+    nsig_delr_pjs_junc_nld30_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld30_d_body = (0.0)
+    nsig_delr_chjs_junc_nld30_d_body = (0.0)
+    nsig_delr_acj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld30b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld30b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld30b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_acj0_junc_nld65_d_body = (0.0)
+    nsig_delr_ajs_junc_nld65_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld65_d_body = (0.0)
+    nsig_delr_pjs_junc_nld65_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld65_d_body = (0.0)
+    nsig_delr_chjs_junc_nld65_d_body = (0.0)
+    nsig_delr_acj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld65b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld65b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld65b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld90_d_body = (0.0)
+    nsig_delr_ajs_junc_nld90_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld90_d_body = (0.0)
+    nsig_delr_pjs_junc_nld90_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld90_d_body = (0.0)
+    nsig_delr_chjs_junc_nld90_d_body = (0.0)
+    nsig_delr_acj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld90b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld5_d_body = (0.0)
+    nsig_delr_ajs_junc_pld5_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld5_d_body = (0.0)
+    nsig_delr_pjs_junc_pld5_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld5_d_body = (0.0)
+    nsig_delr_chjs_junc_pld5_d_body = (0.0)
+    nsig_delr_acj0_junc_pld10_d_body = (0.0)
+    nsig_delr_ajs_junc_pld10_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld10_d_body = (0.0)
+    nsig_delr_pjs_junc_pld10_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld10_d_body = (0.0)
+    nsig_delr_chjs_junc_pld10_d_body = (0.0)
+    nsig_delr_cj0_junc_pld10b_d_body = (0.0)
+    nsig_delr_js_junc_pld10b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld30_d_body = (0.0)
+    nsig_delr_ajs_junc_pld30_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld30_d_body = (0.0)
+    nsig_delr_pjs_junc_pld30_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld30_d_body = (0.0)
+    nsig_delr_chjs_junc_pld30_d_body = (0.0)
+    nsig_delr_acj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld30b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld30b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld30b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld45_d_body = (0.0)
+    nsig_delr_ajs_junc_pld45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld45_d_body = (0.0)
+    nsig_delr_pjs_junc_pld45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld45_d_body = (0.0)
+    nsig_delr_chjs_junc_pld45_d_body = (0.0)
+    nsig_delr_acj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld90_d_body = (0.0)
+    nsig_delr_ajs_junc_pld90_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld90_d_body = (0.0)
+    nsig_delr_pjs_junc_pld90_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld90_d_body = (0.0)
+    nsig_delr_chjs_junc_pld90_d_body = (0.0)
+    nsig_delr_acj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld90b_d_body = (0.0)
+    nsig_delr_tox_box              = (0)


parameters
+    nsig_delr_is_dpldd_junc_10hv = 0.0
+    nsig_delr_ir_dpldd_junc_10hv = 0.0
+    nsig_dela_bv_dpldd_junc_10hv = 0.0
+    nsig_delr_cj_dpldd_junc_10hv = 0.0

//***********************************************************
endsection typ_para_process_params
//***********************************************************

//***********************************************************
section mc_para_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_alcap_m4         = (0.0)
+    nsig_delr_cfr_alcap_m4         = (0.0)
+    nsig_delr_cpp_alcap_m3         = (0.0)
+    nsig_delr_cfr_alcap_m3         = (0.0)
+    nsig_delr_cpp_alcap_m2         = (0.0)
+    nsig_delr_cfr_alcap_m2         = (0.0)
+    nsig_delr_cpp_alcap_m1         = (0.0)
+    nsig_delr_cfr_alcap_m1         = (0.0)
+    nsig_delr_cpp_alcap_ply        = (0.0)
+    nsig_delr_cfr_alcap_ply        = (0.0)
+    nsig_delr_cpp_alcap_sd         = (0.0)
+    nsig_delr_cfr_alcap_sd         = (0.0)
+    nsig_delr_cpp_alcap_fld        = (0.0)
+    nsig_delr_cfr_alcap_fld        = (0.0)
+    nsig_delr_cpp_m4_m3            = (0.0)
+    nsig_delr_cfr_m4_m3            = (0.0)
+    nsig_delr_cpp_m4_m2            = (0.0)
+    nsig_delr_cfr_m4_m2            = (0.0)
+    nsig_delr_cpp_m4_m1            = (0.0)
+    nsig_delr_cfr_m4_m1            = (0.0)
+    nsig_delr_cpp_m4_ply           = (0.0)
+    nsig_delr_cfr_m4_ply           = (0.0)
+    nsig_delr_cpp_m4_sd            = (0.0)
+    nsig_delr_cfr_m4_sd            = (0.0)
+    nsig_delr_cpp_m4_fld           = (0.0)
+    nsig_delr_cfr_m4_fld           = (0.0)
+    nsig_delr_cpp_m3_m2            = (0.0)
+    nsig_delr_cfr_m3_m2            = (0.0)
+    nsig_delr_cpp_m3_m1            = (0.0)
+    nsig_delr_cfr_m3_m1            = (0.0)
+    nsig_delr_cpp_m3_ply           = (0.0)
+    nsig_delr_cfr_m3_ply           = (0.0)
+    nsig_delr_cpp_m3_sd            = (0.0)
+    nsig_delr_cfr_m3_sd            = (0.0)
+    nsig_delr_cpp_m3_fld           = (0.0)
+    nsig_delr_cfr_m3_fld           = (0.0)
+    nsig_delr_cpp_m2_m1            = (0.0)
+    nsig_delr_cfr_m2_m1            = (0.0)
+    nsig_delr_cpp_m2_ply           = (0.0)
+    nsig_delr_cfr_m2_ply           = (0.0)
+    nsig_delr_cpp_m2_sd            = (0.0)
+    nsig_delr_cfr_m2_sd            = (0.0)
+    nsig_delr_cpp_m2_fld           = (0.0)
+    nsig_delr_cfr_m2_fld           = (0.0)
+    nsig_delr_cpp_m1_ply           = (0.0)
+    nsig_delr_cfr_m1_ply           = (0.0)
+    nsig_delr_cpp_m1_sd            = (0.0)
+    nsig_delr_cfr_m1_sd            = (0.0)
+    nsig_delr_cpp_m1_fld           = (0.0)
+    nsig_delr_cfr_m1_fld           = (0.0)
+    nsig_delr_cpp_ply_ply0         = (0.0)
+    nsig_delr_cfr_ply_ply0         = (0.0)
+    nsig_delr_cpp_ply_sd           = (0.0)
+    nsig_delr_cfr_ply_sd           = (0.0)
+    nsig_delr_cpp_ply_fld          = (0.0)
+    nsig_delr_cfr_ply_fld          = (0.0)
+    nsig_delr_cpp_ply_sdt          = (0.0)
+    nsig_delr_cfr_ply_sdt          = (0.0)
+    nsig_delr_cpp_ply0_fld         = (0.0)
+    nsig_delr_cfr_ply0_fld_cdp     = (0.0)
+    nsig_delr_cpp_ply0_fld_cdp     = (0.0)
+    nsig_delr_cfr_ply0_fld         = (0.0)
+    nsig_delr_cfr_nld90_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45b_s_ply_met = (0)
+    nsig_delr_cfr_pld5_s_ply_m1ct  = (0)
+    nsig_delr_cfr_nsrampd_s_ply_met = (0)
+    nsig_delr_cfr_psrampu_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_tlp_d_ply_met = (0)
+    nsig_delr_cfr_pmos_ll_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_met = (0)
+    nsig_delr_cfr_pmos_ana_s_ply_met = (0)
+    nsig_delr_cfr_pld45_d_ply_met  = (0)
+    nsig_delr_cfr_nld65_d_ply_met  = (0)
+    nsig_delr_cfr_pmos45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nld65b_s_ply_met = (0)
+    nsig_delr_cfr_pmos90b_d_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_ct = (0)
+    nsig_delr_cfr_pld10_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos45_d_ply_met = (0)
+    nsig_delr_cfr_pld45_s_ply_met  = (0)
+    nsig_delr_cfr_nld45b_he_d_ply_met = (0)
+    nsig_delr_cfr_nld90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld30_s_ply_met  = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_s_ply_met   = (0)
+    nsig_delr_cfr_nld45_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ll_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampd_d_ply_met = (0)
+    nsig_delr_cfr_pmos45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_met = (0)
+    nsig_delr_cfr_nld10_s_ply_met  = (0)
+    nsig_delr_cfr_psrampu_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_s_ply_met = (0)
+    nsig_delr_cfr_nsrampg_s_ply_met = (0)
+    nsig_delr_cfr_nld90b_d_ply_met = (0)
+    nsig_delr_cfr_pmos_ll_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmoshs45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_ct_end = (0)
+    nsig_delr_cfr_nld10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos5_s_ply_met  = (0)
+    nsig_delr_cfr_nld30b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_s_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_d_ply_met = (0)
+    nsig_delr_cfr_pld90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos10_s_ply_met = (0)
+    nsig_delr_cfr_nld45b_tlp_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_ct = (0)
+    nsig_delr_cfr_nld45_he_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_tlp_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_met_end = (0)
+    nsig_delr_cfr_nsrampd_s_ply_m1ct = (0)
+    nsig_delr_cfr_psrampu_s_ply_met = (0)
+    nsig_delr_cfr_nmos90_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_met = (0)
+    nsig_delr_cfr_pld5_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nld30_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_ana_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45b_d_ply_met = (0)
+    nsig_delr_cfr_nld65_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_d_ply_met   = (0)
+    nsig_delr_cfr_nld5_lvt_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos10_d_ply_met = (0)
+    nsig_delr_cfr_nmos_s_ply_m1ct  = (0)
+    nsig_delr_cfr_nmos5_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld10_d_ply_met  = (0)
+    nsig_delr_cfr_pmos90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_tlp_s_ply_met = (0)
+    nsig_delr_cfr_pld10_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ana_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos90_s_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_d_ply_met = (0)
+    nsig_delr_cfr_pmos5_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ana_d_ply_met = (0)
+    nsig_delr_cfr_nmos90b_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_d_ply_met  = (0)
+    nsig_delr_cfr_nmos_ll_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_met_end = (0)
+    nsig_delr_cfr_nld45b_tlp_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_s_ply_met = (0)
+    nsig_delr_cfr_nmos_ana_d_ply_met = (0)
+    nsig_delr_cfr_pld10_d_ply_met  = (0)
+    nsig_delr_cfr_nld5_d_ply_m1ct  = (0)
+    nsig_delr_cfr_nmos_s_ply_met   = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_met_end = (0)
+    nsig_delr_cfr_pmos90_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld30b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ana_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_d_ply_met = (0)
+    nsig_delr_cfr_pld10_s_ply_met  = (0)
+    nsig_delr_cfr_nmos10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_ct = (0)
+    nsig_delr_cfr_pmos90b_s_ply_met = (0)
+    nsig_delr_cfr_pld5_s_ply_met   = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_ct_end = (0)
+    nsig_delr_cfr_pmos45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90b_s_ply_met = (0)
+    nsig_delr_cfr_pmos45b_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_ll_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos5_s_ply_met  = (0)
+    nsig_delr_cfr_pld90_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld90_s_ply_met  = (0)
+    nsig_delr_cfr_pmos_ull_s_ply_met = (0)
+    nsig_delr_cfr_pmos10_s_ply_met = (0)
+    nsig_delr_cfr_nld65_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos90_d_ply_met = (0)
+    nsig_delr_cfr_nld10_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld5_d_ply_met   = (0)
+    nsig_delr_cfr_pmos5_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld30b_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ll_s_ply_met = (0)
+    nsig_delr_cfr_nld90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld45_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld65b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampg_d_ply_met = (0)
+    nsig_delr_cfr_nmos90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_lvt_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_d_ply_met   = (0)
+    nsig_delr_cfr_nld30b_s_ply_met = (0)
+    nsig_delr_cfr_nld65_s_ply_met  = (0)
+    nsig_delr_cfr_nld45_he_d_ply_met = (0)
+    nsig_delr_cfr_pld30_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90b_d_ply_met = (0)
+    nsig_delr_cfr_pmos45_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos5_d_ply_met  = (0)
+    nsig_delr_cfr_pld45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_s_ply_met = (0)
+    nsig_delr_cfr_nld45_tlp_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_met_end = (0)
+    nsig_delr_cfr_nmos45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_tlp_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld90_s_ply_met  = (0)
+    nsig_delr_cfr_nld30_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos5_d_ply_met  = (0)
+    nsig_delr_cfr_nmos3_zvt_s_ply_met = (0)
+    nsig_delr_cfr_nmos_d_ply_met   = (0)
+    nsig_delr_cfr_pld30b_d_ply_met = (0)
+    nsig_delr_cfr_nld30_s_ply_met  = (0)
+    nsig_delr_cfr_pmoshs45_d_ply_met = (0)
+    nsig_delr_cfr_nmos5_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_d_ply_met = (0)
+    nsig_delr_cfr_pld30b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45_s_ply_met = (0)
+    nsig_delr_cfr_pmoshs45_s_ply_met = (0)
+    nsig_delr_cfr_nld5_lvt_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90b_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld90b_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_d_ply_met = (0)
+    nsig_delr_cfr_nld5_s_ply_met   = (0)
+    nsig_delr_cfr_pld30_d_ply_met  = (0)
+    nsig_delr_cfr_pmos_s_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos90b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld5_lvt_d_ply_met = (0)
+    nsig_delr_cfr_nmos10_d_ply_m1ct = (0)
+    nsig_delr_cfr_pmos10_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld30_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_ct = (0)
+    nsig_delr_cfr_nld45_tlp_s_ply_met = (0)
+    nsig_delr_cfr_nmos45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_s_ply_ct_end = (0)
+    nsig_delr_cfr_pmos45_s_ply_m1ct = (0)
+    nsig_delr_cfr_pmos_ana_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30b_s_ply_met = (0)
+    nsig_delr_cfr_pld90b_d_ply_met = (0)
+    nsig_delr_cfr_pld45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_he_s_ply_met = (0)
+    nsig_delr_cfr_nld45_s_ply_met  = (0)
+    nsig_delr_cfr_nmos_d_ply_m1ct  = (0)
+    nsig_delr_cfr_pmos_ull_d_ply_m1ct = (0)
+    nsig_delr_cfr_pld45b_d_ply_met = (0)
+    nsig_delr_cfr_pmos90_s_ply_m1ct = (0)
+    nsig_delr_cfr_pld30_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_he_s_ply_met = (0)
+    nsig_delr_cfr_nmos3_zvt_s_ply_m1ct = (0)
+    nsig_delr_cfr_nsrampd_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos90_d_ply_met = (0)
+    nsig_delr_cfr_nmos_ana_s_ply_met = (0)
+    nsig_delr_cfr_psrampu_s_ply_m1ct = (0)
+    nsig_delr_cfr_nmos45b_s_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_he_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45b_d_ply_m1ct = (0)
+    nsig_delr_cfr_nld45_d_ply_m1ct = (0)
+    nsig_delr_cfr_nmos_ull_d_ply_ct_end = (0)
+    nsig_delr_acj0_junc_psd_nw     = (0.0)
+    nsig_delr_ajs_junc_psd_nw      = (0.0)
+    nsig_delr_pcj0_junc_psd_nw     = (0.0)
+    nsig_delr_pjs_junc_psd_nw      = (0.0)
+    nsig_delr_acj0_junc_nsd_pw     = (0.0)
+    nsig_delr_ajs_junc_nsd_pw      = (0.0)
+    nsig_delr_pcj0_junc_nsd_pw     = (0.0)
+    nsig_delr_pjs_junc_nsd_pw      = (0.0)
+    nsig_delr_acj0_junc_psd_nhv    = (0.0)
+    nsig_delr_ajs_junc_psd_nhv     = (0.0)
+    nsig_delr_pcj0_junc_psd_nhv    = (0.0)
+    nsig_delr_pjs_junc_psd_nhv     = (0.0)
+    nsig_delr_acj0_junc_nsd_phv    = (0.0)
+    nsig_delr_ajs_junc_nsd_phv     = (0.0)
+    nsig_delr_pcj0_junc_nsd_phv    = (0.0)
+    nsig_delr_pjs_junc_nsd_phv     = (0.0)
+    nsig_delr_acj0_junc_pepi_nbl   = (0.0)
+    nsig_delr_ajs_junc_pepi_nbl    = (0.0)
+    nsig_delr_pcj0_junc_pepi_nbl   = (0.0)
+    nsig_delr_pjs_junc_pepi_nbl    = (0.0)
+    nsig_delr_acj0_junc_nw_pepi    = (0.0)
+    nsig_delr_ajs_junc_nw_pepi     = (0.0)
+    nsig_delr_pcj0_junc_nw_pepi    = (0.0)
+    nsig_delr_pjs_junc_nw_pepi     = (0.0)
+    nsig_delr_acj0_junc_nw_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nw_pepi_tr  = (0.0)
+    nsig_delr_pcj0_junc_nw_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nw_pepi_tr  = (0.0)
+    nsig_delr_acj0_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_pcj0_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nhv_pepi_tr = (0.0)
+    nsig_delr_acj0_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_ajs_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_pcj0_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_pjs_junc_nbl_pepi_tr = (0.0)
+    nsig_delr_acj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ll_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ull_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_ajs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_pjs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_chjs_junc_nmos_ana_sd_body = (0.0)
+    nsig_delr_acj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_ajs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_pjs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_chjs_junc_nsrampg_sd_body = (0.0)
+    nsig_delr_acj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_ajs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_pcj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_pjs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_chcj0_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_chjs_junc_nsrampd_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ll_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ull_sd_body = (0.0)
+    nsig_delr_acj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos_ana_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos3_zvt_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos3_zvt_s_body = (0.0)
+    nsig_delr_acj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_ajs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_pcj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_pjs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_chcj0_junc_psrampu_sd_body = (0.0)
+    nsig_delr_chjs_junc_psrampu_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos5_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos5_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos5_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos5_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos5_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos5_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos5_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos5_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_ajs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_pcj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_pjs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_chcj0_junc_pmos5_sd_body = (0.0)
+    nsig_delr_chjs_junc_pmos5_sd_body = (0.0)
+    nsig_delr_acj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos10_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos10_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos10_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos10_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos10_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos10_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos10_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos10_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos10_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos10_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos10_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos10_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos10_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos10_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos10_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos10_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos45_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos45_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos45_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos45_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos45_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos45_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45b_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos45b_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos45b_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos45b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos45_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos45_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos45_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos45_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos45b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos45b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45_d_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45_s_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmoshs45b_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos90_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos90_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos90_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos90_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos90_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos90_s_body = (0.0)
+    nsig_delr_acj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_ajs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_pjs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90b_d_body = (0.0)
+    nsig_delr_chjs_junc_nmos90b_d_body = (0.0)
+    nsig_delr_acj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_ajs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_pcj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_pjs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_chcj0_junc_nmos90b_s_body = (0.0)
+    nsig_delr_chjs_junc_nmos90b_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos90_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos90_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos90_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_ajs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_pjs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90b_d_body = (0.0)
+    nsig_delr_chjs_junc_pmos90b_d_body = (0.0)
+    nsig_delr_acj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos90_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos90_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos90_s_body = (0.0)
+    nsig_delr_acj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_ajs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_pcj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_pjs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_chcj0_junc_pmos90b_s_body = (0.0)
+    nsig_delr_chjs_junc_pmos90b_s_body = (0.0)
+    nsig_delr_acj0_junc_nld5_d_body = (0.0)
+    nsig_delr_ajs_junc_nld5_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld5_d_body = (0.0)
+    nsig_delr_pjs_junc_nld5_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld5_d_body = (0.0)
+    nsig_delr_chjs_junc_nld5_d_body = (0.0)
+    nsig_delr_acj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_ajs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_pjs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_chjs_junc_nld5_lvt_d_body = (0.0)
+    nsig_delr_acj0_junc_nld10_d_body = (0.0)
+    nsig_delr_ajs_junc_nld10_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld10_d_body = (0.0)
+    nsig_delr_pjs_junc_nld10_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld10_d_body = (0.0)
+    nsig_delr_chjs_junc_nld10_d_body = (0.0)
+    nsig_delr_acj0_junc_nld30_d_body = (0.0)
+    nsig_delr_ajs_junc_nld30_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld30_d_body = (0.0)
+    nsig_delr_pjs_junc_nld30_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld30_d_body = (0.0)
+    nsig_delr_chjs_junc_nld30_d_body = (0.0)
+    nsig_delr_acj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld30b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld30b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld30b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld30b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_he_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_he_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_he_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45_tlp_d_body = (0.0)
+    nsig_delr_acj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_ajs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_pjs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_chjs_junc_nld45b_tlp_d_body = (0.0)
+    nsig_delr_acj0_junc_nld65_d_body = (0.0)
+    nsig_delr_ajs_junc_nld65_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld65_d_body = (0.0)
+    nsig_delr_pjs_junc_nld65_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld65_d_body = (0.0)
+    nsig_delr_chjs_junc_nld65_d_body = (0.0)
+    nsig_delr_acj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld65b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld65b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld65b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld65b_d_body = (0.0)
+    nsig_delr_acj0_junc_nld90_d_body = (0.0)
+    nsig_delr_ajs_junc_nld90_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld90_d_body = (0.0)
+    nsig_delr_pjs_junc_nld90_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld90_d_body = (0.0)
+    nsig_delr_chjs_junc_nld90_d_body = (0.0)
+    nsig_delr_acj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_ajs_junc_nld90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_pjs_junc_nld90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_nld90b_d_body = (0.0)
+    nsig_delr_chjs_junc_nld90b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld5_d_body = (0.0)
+    nsig_delr_ajs_junc_pld5_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld5_d_body = (0.0)
+    nsig_delr_pjs_junc_pld5_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld5_d_body = (0.0)
+    nsig_delr_chjs_junc_pld5_d_body = (0.0)
+    nsig_delr_acj0_junc_pld10_d_body = (0.0)
+    nsig_delr_ajs_junc_pld10_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld10_d_body = (0.0)
+    nsig_delr_pjs_junc_pld10_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld10_d_body = (0.0)
+    nsig_delr_chjs_junc_pld10_d_body = (0.0)
+    nsig_delr_cj0_junc_pld10b_d_body = (0.0)
+    nsig_delr_js_junc_pld10b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld30_d_body = (0.0)
+    nsig_delr_ajs_junc_pld30_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld30_d_body = (0.0)
+    nsig_delr_pjs_junc_pld30_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld30_d_body = (0.0)
+    nsig_delr_chjs_junc_pld30_d_body = (0.0)
+    nsig_delr_acj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld30b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld30b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld30b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld30b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld45_d_body = (0.0)
+    nsig_delr_ajs_junc_pld45_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld45_d_body = (0.0)
+    nsig_delr_pjs_junc_pld45_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld45_d_body = (0.0)
+    nsig_delr_chjs_junc_pld45_d_body = (0.0)
+    nsig_delr_acj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld45b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld45b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld45b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld45b_d_body = (0.0)
+    nsig_delr_acj0_junc_pld90_d_body = (0.0)
+    nsig_delr_ajs_junc_pld90_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld90_d_body = (0.0)
+    nsig_delr_pjs_junc_pld90_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld90_d_body = (0.0)
+    nsig_delr_chjs_junc_pld90_d_body = (0.0)
+    nsig_delr_acj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_ajs_junc_pld90b_d_body = (0.0)
+    nsig_delr_pcj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_pjs_junc_pld90b_d_body = (0.0)
+    nsig_delr_chcj0_junc_pld90b_d_body = (0.0)
+    nsig_delr_chjs_junc_pld90b_d_body = (0.0)
+    nsig_delr_tox_box              = (0)

statistics {
    process {
        vary nsig_delr_cpp_alcap_m4     dist=gauss std=1
        vary nsig_delr_cfr_alcap_m4     dist=gauss std=1
        vary nsig_delr_cpp_alcap_m3     dist=gauss std=1
        vary nsig_delr_cfr_alcap_m3     dist=gauss std=1
        vary nsig_delr_cpp_alcap_m2     dist=gauss std=1
        vary nsig_delr_cfr_alcap_m2     dist=gauss std=1
        vary nsig_delr_cpp_alcap_m1     dist=gauss std=1
        vary nsig_delr_cfr_alcap_m1     dist=gauss std=1
        vary nsig_delr_cpp_alcap_ply     dist=gauss std=1
        vary nsig_delr_cfr_alcap_ply     dist=gauss std=1
        vary nsig_delr_cpp_alcap_sd     dist=gauss std=1
        vary nsig_delr_cfr_alcap_sd     dist=gauss std=1
        vary nsig_delr_cpp_alcap_fld     dist=gauss std=1
        vary nsig_delr_cfr_alcap_fld     dist=gauss std=1
        vary nsig_delr_cpp_m4_m3     dist=gauss std=1
        vary nsig_delr_cfr_m4_m3     dist=gauss std=1
        vary nsig_delr_cpp_m4_m2     dist=gauss std=1
        vary nsig_delr_cfr_m4_m2     dist=gauss std=1
        vary nsig_delr_cpp_m4_m1     dist=gauss std=1
        vary nsig_delr_cfr_m4_m1     dist=gauss std=1
        vary nsig_delr_cpp_m4_ply     dist=gauss std=1
        vary nsig_delr_cfr_m4_ply     dist=gauss std=1
        vary nsig_delr_cpp_m4_sd     dist=gauss std=1
        vary nsig_delr_cfr_m4_sd     dist=gauss std=1
        vary nsig_delr_cpp_m4_fld     dist=gauss std=1
        vary nsig_delr_cfr_m4_fld     dist=gauss std=1
        vary nsig_delr_cpp_m3_m2     dist=gauss std=1
        vary nsig_delr_cfr_m3_m2     dist=gauss std=1
        vary nsig_delr_cpp_m3_m1     dist=gauss std=1
        vary nsig_delr_cfr_m3_m1     dist=gauss std=1
        vary nsig_delr_cpp_m3_ply     dist=gauss std=1
        vary nsig_delr_cfr_m3_ply     dist=gauss std=1
        vary nsig_delr_cpp_m3_sd     dist=gauss std=1
        vary nsig_delr_cfr_m3_sd     dist=gauss std=1
        vary nsig_delr_cpp_m3_fld     dist=gauss std=1
        vary nsig_delr_cfr_m3_fld     dist=gauss std=1
        vary nsig_delr_cpp_m2_m1     dist=gauss std=1
        vary nsig_delr_cfr_m2_m1     dist=gauss std=1
        vary nsig_delr_cpp_m2_ply     dist=gauss std=1
        vary nsig_delr_cfr_m2_ply     dist=gauss std=1
        vary nsig_delr_cpp_m2_sd     dist=gauss std=1
        vary nsig_delr_cfr_m2_sd     dist=gauss std=1
        vary nsig_delr_cpp_m2_fld     dist=gauss std=1
        vary nsig_delr_cfr_m2_fld     dist=gauss std=1
        vary nsig_delr_cpp_m1_ply     dist=gauss std=1
        vary nsig_delr_cfr_m1_ply     dist=gauss std=1
        vary nsig_delr_cpp_m1_sd     dist=gauss std=1
        vary nsig_delr_cfr_m1_sd     dist=gauss std=1
        vary nsig_delr_cpp_m1_fld     dist=gauss std=1
        vary nsig_delr_cfr_m1_fld     dist=gauss std=1
        vary nsig_delr_cpp_ply_ply0     dist=gauss std=1
        vary nsig_delr_cfr_ply_ply0     dist=gauss std=1
        vary nsig_delr_cpp_ply_sd     dist=gauss std=1
        vary nsig_delr_cfr_ply_sd     dist=gauss std=1
        vary nsig_delr_cpp_ply_fld     dist=gauss std=1
        vary nsig_delr_cfr_ply_fld     dist=gauss std=1
        vary nsig_delr_cpp_ply_sdt     dist=gauss std=1
        vary nsig_delr_cfr_ply_sdt     dist=gauss std=1
        vary nsig_delr_cpp_ply0_fld     dist=gauss std=1
        vary nsig_delr_cfr_ply0_fld_cdp     dist=gauss std=1
        vary nsig_delr_cpp_ply0_fld_cdp     dist=gauss std=1
        vary nsig_delr_cfr_ply0_fld     dist=gauss std=1
        vary nsig_delr_cfr_nld90_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld5_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampd_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_psrampu_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_tlp_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ll_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ana_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld65_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos45b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld65b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos90b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos3_zvt_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_d_ply_ct     dist=gauss std=1
        vary nsig_delr_cfr_pld10_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld30b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos90b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos45_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_he_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld90b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld30_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld90_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ll_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampg_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampd_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos45b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld10_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_psrampu_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nsrampg_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld90b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ll_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_s_ply_ct_end     dist=gauss std=1
        vary nsig_delr_cfr_nld10_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos5_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld30b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld5_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos45_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos45b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld90b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_he_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos10_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_tlp_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_s_ply_ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_he_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_tlp_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_s_ply_met_end     dist=gauss std=1
        vary nsig_delr_cfr_nsrampd_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_psrampu_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos90_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld5_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld30_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ana_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld65_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld90_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld5_lvt_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ll_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos10_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos5_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld10_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos90b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_tlp_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld10_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos90_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ana_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos90_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos3_zvt_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos5_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ana_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos90b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos45_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_he_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampg_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ll_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_d_ply_met_end     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_tlp_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos90_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ana_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld10_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld5_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_s_ply_met_end     dist=gauss std=1
        vary nsig_delr_cfr_pmos90_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld65b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld30b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ana_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld65b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ll_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld10_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos10_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_s_ply_ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos90b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld5_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_d_ply_ct_end     dist=gauss std=1
        vary nsig_delr_cfr_pmos45b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld90b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos45b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld90_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ll_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos5_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld90_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld90_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos10_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld65_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos90_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld10_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld5_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos5_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld30b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ll_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld90b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld45_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld65b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampg_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos90b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld5_lvt_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos10_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld5_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld30b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld65_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45_he_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld30_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld90_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos90b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos45_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos5_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos45b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45_tlp_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_d_ply_met_end     dist=gauss std=1
        vary nsig_delr_cfr_nmos45b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_tlp_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld90_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld30_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos5_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos3_zvt_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld30b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld30_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos5_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos10_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld30b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos45_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmoshs45_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld5_lvt_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld90b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld90b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos45_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld5_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld30_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos90b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld5_lvt_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos10_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos10_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld30_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_d_ply_ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_tlp_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos45_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_s_ply_ct_end     dist=gauss std=1
        vary nsig_delr_cfr_pmos45_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ana_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld30b_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld90b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pld45b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_he_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nld45_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pmos_ull_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld45b_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_pmos90_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_pld30_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_he_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos3_zvt_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nsrampd_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos90_d_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ana_s_ply_met     dist=gauss std=1
        vary nsig_delr_cfr_psrampu_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos45b_s_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_he_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45b_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nld45_d_ply_m1ct     dist=gauss std=1
        vary nsig_delr_cfr_nmos_ull_d_ply_ct_end     dist=gauss std=1
        vary nsig_delr_acj0_junc_psd_nw     dist=gauss std=1
        vary nsig_delr_ajs_junc_psd_nw     dist=gauss std=1
        vary nsig_delr_pcj0_junc_psd_nw     dist=gauss std=1
        vary nsig_delr_pjs_junc_psd_nw     dist=gauss std=1
        vary nsig_delr_acj0_junc_nsd_pw     dist=gauss std=1
        vary nsig_delr_ajs_junc_nsd_pw     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nsd_pw     dist=gauss std=1
        vary nsig_delr_pjs_junc_nsd_pw     dist=gauss std=1
        vary nsig_delr_acj0_junc_psd_nhv     dist=gauss std=1
        vary nsig_delr_ajs_junc_psd_nhv     dist=gauss std=1
        vary nsig_delr_pcj0_junc_psd_nhv     dist=gauss std=1
        vary nsig_delr_pjs_junc_psd_nhv     dist=gauss std=1
        vary nsig_delr_acj0_junc_nsd_phv     dist=gauss std=1
        vary nsig_delr_ajs_junc_nsd_phv     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nsd_phv     dist=gauss std=1
        vary nsig_delr_pjs_junc_nsd_phv     dist=gauss std=1
        vary nsig_delr_acj0_junc_pepi_nbl     dist=gauss std=1
        vary nsig_delr_ajs_junc_pepi_nbl     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pepi_nbl     dist=gauss std=1
        vary nsig_delr_pjs_junc_pepi_nbl     dist=gauss std=1
        vary nsig_delr_acj0_junc_nw_pepi     dist=gauss std=1
        vary nsig_delr_ajs_junc_nw_pepi     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nw_pepi     dist=gauss std=1
        vary nsig_delr_pjs_junc_nw_pepi     dist=gauss std=1
        vary nsig_delr_acj0_junc_nw_pepi_tr     dist=gauss std=1
        vary nsig_delr_ajs_junc_nw_pepi_tr     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nw_pepi_tr     dist=gauss std=1
        vary nsig_delr_pjs_junc_nw_pepi_tr     dist=gauss std=1
        vary nsig_delr_acj0_junc_nhv_pepi_tr     dist=gauss std=1
        vary nsig_delr_ajs_junc_nhv_pepi_tr     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nhv_pepi_tr     dist=gauss std=1
        vary nsig_delr_pjs_junc_nhv_pepi_tr     dist=gauss std=1
        vary nsig_delr_acj0_junc_nbl_pepi_tr     dist=gauss std=1
        vary nsig_delr_ajs_junc_nbl_pepi_tr     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nbl_pepi_tr     dist=gauss std=1
        vary nsig_delr_pjs_junc_nbl_pepi_tr     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nsrampg_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nsrampd_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos_ll_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos_ull_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos_ana_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos3_zvt_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos3_zvt_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_psrampu_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos5_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos5_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos5_sd_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos10_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos10_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos10_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos10_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos45_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos45_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos45b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos45b_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos45_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos45_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos45b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos45b_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmoshs45_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmoshs45_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmoshs45b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmoshs45b_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos90_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos90_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos90b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nmos90b_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos90_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos90b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos90_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pmos90b_s_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld5_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld5_lvt_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld10_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld30_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld30b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45_he_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45b_he_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45_tlp_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld45b_tlp_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld65_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld65b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld90_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_nld90b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld5_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld10_d_body     dist=gauss std=1
        vary nsig_delr_cj0_junc_pld10b_d_body     dist=gauss std=1
        vary nsig_delr_js_junc_pld10b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld30_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld30b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld45_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld45b_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld90_d_body     dist=gauss std=1
        vary nsig_delr_acj0_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_ajs_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_pcj0_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_pjs_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_chcj0_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_chjs_junc_pld90b_d_body     dist=gauss std=1
        vary nsig_delr_tox_box     dist=gauss std=1
    }
}


parameters
+    nsig_delr_is_dpldd_junc_10hv = 0.0
+    nsig_delr_ir_dpldd_junc_10hv = 0.0
+    nsig_dela_bv_dpldd_junc_10hv = 0.0
+    nsig_delr_cj_dpldd_junc_10hv = 0.0

statistics {
    process {
        vary nsig_delr_is_dpldd_junc_10hv dist=gauss std=1
        vary nsig_delr_ir_dpldd_junc_10hv dist=gauss std=1
        vary nsig_dela_bv_dpldd_junc_10hv dist=gauss std=1
        vary nsig_delr_cj_dpldd_junc_10hv dist=gauss std=1
    }
}

//***********************************************************
endsection mc_para_process_params
//***********************************************************

//***********************************************************
section hi_para_process_params
//***********************************************************

parameters
+    nsig_delr_cpp_alcap_m4         = (3.0)
+    nsig_delr_cfr_alcap_m4         = (3.0)
+    nsig_delr_cpp_alcap_m3         = (3.0)
+    nsig_delr_cfr_alcap_m3         = (3.0)
+    nsig_delr_cpp_alcap_m2         = (3.0)
+    nsig_delr_cfr_alcap_m2         = (3.0)
+    nsig_delr_cpp_alcap_m1         = (3.0)
+    nsig_delr_cfr_alcap_m1         = (3.0)
+    nsig_delr_cpp_alcap_ply        = (3.0)
+    nsig_delr_cfr_alcap_ply        = (3.0)
+    nsig_delr_cpp_alcap_sd         = (3.0)
+    nsig_delr_cfr_alcap_sd         = (3.0)
+    nsig_delr_cpp_alcap_fld        = (3.0)
+    nsig_delr_cfr_alcap_fld        = (3.0)
+    nsig_delr_cpp_m4_m3            = (3.0)
+    nsig_delr_cfr_m4_m3            = (3.0)
+    nsig_delr_cpp_m4_m2            = (3.0)
+    nsig_delr_cfr_m4_m2            = (3.0)
+    nsig_delr_cpp_m4_m1            = (3.0)
+    nsig_delr_cfr_m4_m1            = (3.0)
+    nsig_delr_cpp_m4_ply           = (3.0)
+    nsig_delr_cfr_m4_ply           = (3.0)
+    nsig_delr_cpp_m4_sd            = (3.0)
+    nsig_delr_cfr_m4_sd            = (3.0)
+    nsig_delr_cpp_m4_fld           = (3.0)
+    nsig_delr_cfr_m4_fld           = (3.0)
+    nsig_delr_cpp_m3_m2            = (3.0)
+    nsig_delr_cfr_m3_m2            = (3.0)
+    nsig_delr_cpp_m3_m1            = (3.0)
+    nsig_delr_cfr_m3_m1            = (3.0)
+    nsig_delr_cpp_m3_ply           = (3.0)
+    nsig_delr_cfr_m3_ply           = (3.0)
+    nsig_delr_cpp_m3_sd            = (3.0)
+    nsig_delr_cfr_m3_sd            = (3.0)
+    nsig_delr_cpp_m3_fld           = (3.0)
+    nsig_delr_cfr_m3_fld           = (3.0)
+    nsig_delr_cpp_m2_m1            = (3.0)
+    nsig_delr_cfr_m2_m1            = (3.0)
+    nsig_delr_cpp_m2_ply           = (3.0)
+    nsig_delr_cfr_m2_ply           = (3.0)
+    nsig_delr_cpp_m2_sd            = (3.0)
+    nsig_delr_cfr_m2_sd            = (3.0)
+    nsig_delr_cpp_m2_fld           = (3.0)
+    nsig_delr_cfr_m2_fld           = (3.0)
+    nsig_delr_cpp_m1_ply           = (3.0)
+    nsig_delr_cfr_m1_ply           = (3.0)
+    nsig_delr_cpp_m1_sd            = (3.0)
+    nsig_delr_cfr_m1_sd            = (3.0)
+    nsig_delr_cpp_m1_fld           = (3.0)
+    nsig_delr_cfr_m1_fld           = (3.0)
+    nsig_delr_cpp_ply_ply0         = (3.0)
+    nsig_delr_cfr_ply_ply0         = (3.0)
+    nsig_delr_cpp_ply_sd           = (3.0)
+    nsig_delr_cfr_ply_sd           = (3.0)
+    nsig_delr_cpp_ply_fld          = (3.0)
+    nsig_delr_cfr_ply_fld          = (3.0)
+    nsig_delr_cpp_ply_sdt          = (3.0)
+    nsig_delr_cfr_ply_sdt          = (3.0)
+    nsig_delr_cpp_ply0_fld         = (3.0)
+    nsig_delr_cfr_ply0_fld_cdp     = (3.0)
+    nsig_delr_cpp_ply0_fld_cdp     = (3.0)
+    nsig_delr_cfr_ply0_fld         = (3.0)
+    nsig_delr_cfr_nld90_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmoshs45b_s_ply_met = (3)
+    nsig_delr_cfr_pld5_s_ply_m1ct  = (3)
+    nsig_delr_cfr_nsrampd_s_ply_met = (3)
+    nsig_delr_cfr_psrampu_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_tlp_d_ply_met = (3)
+    nsig_delr_cfr_pmos_ll_s_ply_met = (3)
+    nsig_delr_cfr_nmos_ull_s_ply_met = (3)
+    nsig_delr_cfr_pmos_ana_s_ply_met = (3)
+    nsig_delr_cfr_pld45_d_ply_met  = (3)
+    nsig_delr_cfr_nld65_d_ply_met  = (3)
+    nsig_delr_cfr_pmos45b_d_ply_met = (3)
+    nsig_delr_cfr_pmos_d_ply_m1ct  = (3)
+    nsig_delr_cfr_nld65b_s_ply_met = (3)
+    nsig_delr_cfr_pmos90b_d_ply_met = (3)
+    nsig_delr_cfr_nmos3_zvt_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmoshs45_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_d_ply_ct = (3)
+    nsig_delr_cfr_pld10_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld30b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos90b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_d_ply_met = (3)
+    nsig_delr_cfr_pmos45_d_ply_met = (3)
+    nsig_delr_cfr_pld45_s_ply_met  = (3)
+    nsig_delr_cfr_nld45b_he_d_ply_met = (3)
+    nsig_delr_cfr_nld90b_d_ply_m1ct = (3)
+    nsig_delr_cfr_pld30_s_ply_met  = (3)
+    nsig_delr_cfr_nmos_ull_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld90_d_ply_met  = (3)
+    nsig_delr_cfr_pmos_s_ply_met   = (3)
+    nsig_delr_cfr_nld45_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ll_s_ply_m1ct = (3)
+    nsig_delr_cfr_nsrampg_s_ply_m1ct = (3)
+    nsig_delr_cfr_nsrampd_d_ply_met = (3)
+    nsig_delr_cfr_pmos45b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_d_ply_met = (3)
+    nsig_delr_cfr_nld10_s_ply_met  = (3)
+    nsig_delr_cfr_psrampu_d_ply_met = (3)
+    nsig_delr_cfr_pld45b_s_ply_met = (3)
+    nsig_delr_cfr_nsrampg_s_ply_met = (3)
+    nsig_delr_cfr_nld90b_d_ply_met = (3)
+    nsig_delr_cfr_pmos_ll_d_ply_met = (3)
+    nsig_delr_cfr_pld45b_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmoshs45b_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_s_ply_ct_end = (3)
+    nsig_delr_cfr_nld10_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos5_s_ply_met  = (3)
+    nsig_delr_cfr_nld30b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld5_s_ply_m1ct  = (3)
+    nsig_delr_cfr_pmos45_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos45b_d_ply_met = (3)
+    nsig_delr_cfr_pld90b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_he_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos10_s_ply_met = (3)
+    nsig_delr_cfr_nld45b_tlp_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_s_ply_ct = (3)
+    nsig_delr_cfr_nld45_he_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_tlp_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_s_ply_met_end = (3)
+    nsig_delr_cfr_nsrampd_s_ply_m1ct = (3)
+    nsig_delr_cfr_psrampu_s_ply_met = (3)
+    nsig_delr_cfr_nmos90_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_d_ply_met = (3)
+    nsig_delr_cfr_pld5_d_ply_m1ct  = (3)
+    nsig_delr_cfr_nld30_d_ply_met  = (3)
+    nsig_delr_cfr_pmos_ana_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_s_ply_met = (3)
+    nsig_delr_cfr_pmoshs45b_d_ply_met = (3)
+    nsig_delr_cfr_nld65_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld90_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_d_ply_met   = (3)
+    nsig_delr_cfr_nld5_lvt_s_ply_met = (3)
+    nsig_delr_cfr_nmos_ll_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos10_d_ply_met = (3)
+    nsig_delr_cfr_nmos_s_ply_m1ct  = (3)
+    nsig_delr_cfr_nmos5_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld10_d_ply_met  = (3)
+    nsig_delr_cfr_pmos90b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_tlp_s_ply_met = (3)
+    nsig_delr_cfr_pld10_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos90_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ana_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos90_s_ply_met = (3)
+    nsig_delr_cfr_nmos3_zvt_d_ply_met = (3)
+    nsig_delr_cfr_pmos5_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ana_d_ply_met = (3)
+    nsig_delr_cfr_nmos90b_s_ply_met = (3)
+    nsig_delr_cfr_nmos45_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_he_s_ply_m1ct = (3)
+    nsig_delr_cfr_nsrampg_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_d_ply_met  = (3)
+    nsig_delr_cfr_nmos_ll_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_d_ply_met_end = (3)
+    nsig_delr_cfr_nld45b_tlp_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos90_s_ply_met = (3)
+    nsig_delr_cfr_nmos_ana_d_ply_met = (3)
+    nsig_delr_cfr_pld10_d_ply_met  = (3)
+    nsig_delr_cfr_nld5_d_ply_m1ct  = (3)
+    nsig_delr_cfr_nmos_s_ply_met   = (3)
+    nsig_delr_cfr_pmos_ull_s_ply_met_end = (3)
+    nsig_delr_cfr_pmos90_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld65b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld30b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ana_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld65b_d_ply_met = (3)
+    nsig_delr_cfr_nmos_ll_d_ply_met = (3)
+    nsig_delr_cfr_pld10_s_ply_met  = (3)
+    nsig_delr_cfr_nmos10_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_s_ply_ct = (3)
+    nsig_delr_cfr_pmos90b_s_ply_met = (3)
+    nsig_delr_cfr_pld5_s_ply_met   = (3)
+    nsig_delr_cfr_pmos_ull_d_ply_ct_end = (3)
+    nsig_delr_cfr_pmos45b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld90b_s_ply_met = (3)
+    nsig_delr_cfr_pmos45b_s_ply_met = (3)
+    nsig_delr_cfr_pmoshs45b_d_ply_m1ct = (3)
+    nsig_delr_cfr_pld90_d_ply_met  = (3)
+    nsig_delr_cfr_pmos_ll_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos5_s_ply_met  = (3)
+    nsig_delr_cfr_pld90_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld90_s_ply_met  = (3)
+    nsig_delr_cfr_pmos_ull_s_ply_met = (3)
+    nsig_delr_cfr_pmos10_s_ply_met = (3)
+    nsig_delr_cfr_nld65_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos90_d_ply_met = (3)
+    nsig_delr_cfr_nld10_d_ply_m1ct = (3)
+    nsig_delr_cfr_pld5_d_ply_met   = (3)
+    nsig_delr_cfr_pmos5_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld30b_d_ply_met = (3)
+    nsig_delr_cfr_nmos_ll_s_ply_met = (3)
+    nsig_delr_cfr_nld90b_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld45_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld65b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nsrampg_d_ply_met = (3)
+    nsig_delr_cfr_nmos90b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld5_lvt_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos10_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld5_d_ply_met   = (3)
+    nsig_delr_cfr_nld30b_s_ply_met = (3)
+    nsig_delr_cfr_nld65_s_ply_met  = (3)
+    nsig_delr_cfr_nld45_he_d_ply_met = (3)
+    nsig_delr_cfr_pld30_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld90_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos90b_d_ply_met = (3)
+    nsig_delr_cfr_pmos45_s_ply_met = (3)
+    nsig_delr_cfr_pmoshs45_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos5_d_ply_met  = (3)
+    nsig_delr_cfr_pld45_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos45b_s_ply_met = (3)
+    nsig_delr_cfr_nld45_tlp_d_ply_met = (3)
+    nsig_delr_cfr_nmos_ull_d_ply_met_end = (3)
+    nsig_delr_cfr_nmos45b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_tlp_d_ply_m1ct = (3)
+    nsig_delr_cfr_pld90_s_ply_met  = (3)
+    nsig_delr_cfr_nld30_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos5_d_ply_met  = (3)
+    nsig_delr_cfr_nmos3_zvt_s_ply_met = (3)
+    nsig_delr_cfr_nmos_d_ply_met   = (3)
+    nsig_delr_cfr_pld30b_d_ply_met = (3)
+    nsig_delr_cfr_nld30_s_ply_met  = (3)
+    nsig_delr_cfr_pmoshs45_d_ply_met = (3)
+    nsig_delr_cfr_nmos5_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos10_d_ply_met = (3)
+    nsig_delr_cfr_pld30b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos45_s_ply_met = (3)
+    nsig_delr_cfr_pmoshs45_s_ply_met = (3)
+    nsig_delr_cfr_nld5_lvt_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld90b_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld90b_s_ply_met = (3)
+    nsig_delr_cfr_nmos45_d_ply_met = (3)
+    nsig_delr_cfr_nld5_s_ply_met   = (3)
+    nsig_delr_cfr_pld30_d_ply_met  = (3)
+    nsig_delr_cfr_pmos_s_ply_m1ct  = (3)
+    nsig_delr_cfr_pmos90b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld5_lvt_d_ply_met = (3)
+    nsig_delr_cfr_nmos10_d_ply_m1ct = (3)
+    nsig_delr_cfr_pmos10_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld30_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ull_d_ply_ct = (3)
+    nsig_delr_cfr_nld45_tlp_s_ply_met = (3)
+    nsig_delr_cfr_nmos45_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_s_ply_ct_end = (3)
+    nsig_delr_cfr_pmos45_s_ply_m1ct = (3)
+    nsig_delr_cfr_pmos_ana_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld30b_s_ply_met = (3)
+    nsig_delr_cfr_pld90b_d_ply_met = (3)
+    nsig_delr_cfr_pld45b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_he_s_ply_met = (3)
+    nsig_delr_cfr_nld45_s_ply_met  = (3)
+    nsig_delr_cfr_nmos_d_ply_m1ct  = (3)
+    nsig_delr_cfr_pmos_ull_d_ply_m1ct = (3)
+    nsig_delr_cfr_pld45b_d_ply_met = (3)
+    nsig_delr_cfr_pmos90_s_ply_m1ct = (3)
+    nsig_delr_cfr_pld30_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_he_s_ply_met = (3)
+    nsig_delr_cfr_nmos3_zvt_s_ply_m1ct = (3)
+    nsig_delr_cfr_nsrampd_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos90_d_ply_met = (3)
+    nsig_delr_cfr_nmos_ana_s_ply_met = (3)
+    nsig_delr_cfr_psrampu_s_ply_m1ct = (3)
+    nsig_delr_cfr_nmos45b_s_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_he_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45b_d_ply_m1ct = (3)
+    nsig_delr_cfr_nld45_d_ply_m1ct = (3)
+    nsig_delr_cfr_nmos_ull_d_ply_ct_end = (3)
+    nsig_delr_acj0_junc_psd_nw     = (3.0)
+    nsig_delr_ajs_junc_psd_nw      = (3.0)
+    nsig_delr_pcj0_junc_psd_nw     = (3.0)
+    nsig_delr_pjs_junc_psd_nw      = (3.0)
+    nsig_delr_acj0_junc_nsd_pw     = (3.0)
+    nsig_delr_ajs_junc_nsd_pw      = (3.0)
+    nsig_delr_pcj0_junc_nsd_pw     = (3.0)
+    nsig_delr_pjs_junc_nsd_pw      = (3.0)
+    nsig_delr_acj0_junc_psd_nhv    = (3.0)
+    nsig_delr_ajs_junc_psd_nhv     = (3.0)
+    nsig_delr_pcj0_junc_psd_nhv    = (3.0)
+    nsig_delr_pjs_junc_psd_nhv     = (3.0)
+    nsig_delr_acj0_junc_nsd_phv    = (3.0)
+    nsig_delr_ajs_junc_nsd_phv     = (3.0)
+    nsig_delr_pcj0_junc_nsd_phv    = (3.0)
+    nsig_delr_pjs_junc_nsd_phv     = (3.0)
+    nsig_delr_acj0_junc_pepi_nbl   = (3.0)
+    nsig_delr_ajs_junc_pepi_nbl    = (3.0)
+    nsig_delr_pcj0_junc_pepi_nbl   = (3.0)
+    nsig_delr_pjs_junc_pepi_nbl    = (3.0)
+    nsig_delr_acj0_junc_nw_pepi    = (3.0)
+    nsig_delr_ajs_junc_nw_pepi     = (3.0)
+    nsig_delr_pcj0_junc_nw_pepi    = (3.0)
+    nsig_delr_pjs_junc_nw_pepi     = (3.0)
+    nsig_delr_acj0_junc_nw_pepi_tr = (3.0)
+    nsig_delr_ajs_junc_nw_pepi_tr  = (3.0)
+    nsig_delr_pcj0_junc_nw_pepi_tr = (3.0)
+    nsig_delr_pjs_junc_nw_pepi_tr  = (3.0)
+    nsig_delr_acj0_junc_nhv_pepi_tr = (3.0)
+    nsig_delr_ajs_junc_nhv_pepi_tr = (3.0)
+    nsig_delr_pcj0_junc_nhv_pepi_tr = (3.0)
+    nsig_delr_pjs_junc_nhv_pepi_tr = (3.0)
+    nsig_delr_acj0_junc_nbl_pepi_tr = (3.0)
+    nsig_delr_ajs_junc_nbl_pepi_tr = (3.0)
+    nsig_delr_pcj0_junc_nbl_pepi_tr = (3.0)
+    nsig_delr_pjs_junc_nbl_pepi_tr = (3.0)
+    nsig_delr_acj0_junc_nmos_sd_body = (3.0)
+    nsig_delr_ajs_junc_nmos_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nmos_sd_body = (3.0)
+    nsig_delr_pjs_junc_nmos_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nmos_sd_body = (3.0)
+    nsig_delr_chjs_junc_nmos_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_ajs_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_pjs_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_chjs_junc_nmos_ll_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_ajs_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_pjs_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_chjs_junc_nmos_ull_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_ajs_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_pjs_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_chjs_junc_nmos_ana_sd_body = (3.0)
+    nsig_delr_acj0_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_ajs_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_pjs_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_chjs_junc_nsrampg_sd_body = (3.0)
+    nsig_delr_acj0_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_ajs_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_pcj0_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_pjs_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_chcj0_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_chjs_junc_nsrampd_sd_body = (3.0)
+    nsig_delr_acj0_junc_pmos_sd_body = (3.0)
+    nsig_delr_ajs_junc_pmos_sd_body = (3.0)
+    nsig_delr_pcj0_junc_pmos_sd_body = (3.0)
+    nsig_delr_pjs_junc_pmos_sd_body = (3.0)
+    nsig_delr_chcj0_junc_pmos_sd_body = (3.0)
+    nsig_delr_chjs_junc_pmos_sd_body = (3.0)
+    nsig_delr_acj0_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_ajs_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_pcj0_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_pjs_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_chcj0_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_chjs_junc_pmos_ll_sd_body = (3.0)
+    nsig_delr_acj0_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_ajs_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_pcj0_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_pjs_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_chcj0_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_chjs_junc_pmos_ull_sd_body = (3.0)
+    nsig_delr_acj0_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_ajs_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_pcj0_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_pjs_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_chcj0_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_chjs_junc_pmos_ana_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos3_zvt_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos3_zvt_s_body = (3.0)
+    nsig_delr_acj0_junc_psrampu_sd_body = (3.0)
+    nsig_delr_ajs_junc_psrampu_sd_body = (3.0)
+    nsig_delr_pcj0_junc_psrampu_sd_body = (3.0)
+    nsig_delr_pjs_junc_psrampu_sd_body = (3.0)
+    nsig_delr_chcj0_junc_psrampu_sd_body = (3.0)
+    nsig_delr_chjs_junc_psrampu_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos5_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos5_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos5_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos5_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos5_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos5_s_body = (3.0)
+    nsig_delr_acj0_junc_nmos5_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos5_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos5_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos5_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos5_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos5_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos5_sd_body = (3.0)
+    nsig_delr_ajs_junc_pmos5_sd_body = (3.0)
+    nsig_delr_pcj0_junc_pmos5_sd_body = (3.0)
+    nsig_delr_pjs_junc_pmos5_sd_body = (3.0)
+    nsig_delr_chcj0_junc_pmos5_sd_body = (3.0)
+    nsig_delr_chjs_junc_pmos5_sd_body = (3.0)
+    nsig_delr_acj0_junc_nmos10_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos10_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos10_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos10_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos10_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos10_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos10_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos10_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos10_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos10_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos10_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos10_s_body = (3.0)
+    nsig_delr_acj0_junc_pmos10_d_body = (3.0)
+    nsig_delr_ajs_junc_pmos10_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmos10_d_body = (3.0)
+    nsig_delr_pjs_junc_pmos10_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmos10_d_body = (3.0)
+    nsig_delr_chjs_junc_pmos10_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos10_s_body = (3.0)
+    nsig_delr_ajs_junc_pmos10_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmos10_s_body = (3.0)
+    nsig_delr_pjs_junc_pmos10_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmos10_s_body = (3.0)
+    nsig_delr_chjs_junc_pmos10_s_body = (3.0)
+    nsig_delr_acj0_junc_nmos45_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos45_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos45_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos45_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos45_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos45_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos45_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos45_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos45_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos45_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos45_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos45_s_body = (3.0)
+    nsig_delr_acj0_junc_nmos45b_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos45b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos45b_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos45b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos45b_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos45b_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos45b_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos45b_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos45b_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos45b_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos45b_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos45b_s_body = (3.0)
+    nsig_delr_acj0_junc_pmos45_d_body = (3.0)
+    nsig_delr_ajs_junc_pmos45_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmos45_d_body = (3.0)
+    nsig_delr_pjs_junc_pmos45_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmos45_d_body = (3.0)
+    nsig_delr_chjs_junc_pmos45_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos45_s_body = (3.0)
+    nsig_delr_ajs_junc_pmos45_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmos45_s_body = (3.0)
+    nsig_delr_pjs_junc_pmos45_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmos45_s_body = (3.0)
+    nsig_delr_chjs_junc_pmos45_s_body = (3.0)
+    nsig_delr_acj0_junc_pmos45b_d_body = (3.0)
+    nsig_delr_ajs_junc_pmos45b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmos45b_d_body = (3.0)
+    nsig_delr_pjs_junc_pmos45b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmos45b_d_body = (3.0)
+    nsig_delr_chjs_junc_pmos45b_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos45b_s_body = (3.0)
+    nsig_delr_ajs_junc_pmos45b_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmos45b_s_body = (3.0)
+    nsig_delr_pjs_junc_pmos45b_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmos45b_s_body = (3.0)
+    nsig_delr_chjs_junc_pmos45b_s_body = (3.0)
+    nsig_delr_acj0_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_ajs_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_pjs_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_chjs_junc_pmoshs45_d_body = (3.0)
+    nsig_delr_acj0_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_ajs_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_pjs_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_chjs_junc_pmoshs45_s_body = (3.0)
+    nsig_delr_acj0_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_ajs_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_pjs_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_chjs_junc_pmoshs45b_d_body = (3.0)
+    nsig_delr_acj0_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_ajs_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_pjs_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_chjs_junc_pmoshs45b_s_body = (3.0)
+    nsig_delr_acj0_junc_nmos90_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos90_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos90_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos90_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos90_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos90_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos90_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos90_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos90_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos90_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos90_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos90_s_body = (3.0)
+    nsig_delr_acj0_junc_nmos90b_d_body = (3.0)
+    nsig_delr_ajs_junc_nmos90b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nmos90b_d_body = (3.0)
+    nsig_delr_pjs_junc_nmos90b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nmos90b_d_body = (3.0)
+    nsig_delr_chjs_junc_nmos90b_d_body = (3.0)
+    nsig_delr_acj0_junc_nmos90b_s_body = (3.0)
+    nsig_delr_ajs_junc_nmos90b_s_body = (3.0)
+    nsig_delr_pcj0_junc_nmos90b_s_body = (3.0)
+    nsig_delr_pjs_junc_nmos90b_s_body = (3.0)
+    nsig_delr_chcj0_junc_nmos90b_s_body = (3.0)
+    nsig_delr_chjs_junc_nmos90b_s_body = (3.0)
+    nsig_delr_acj0_junc_pmos90_d_body = (3.0)
+    nsig_delr_ajs_junc_pmos90_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmos90_d_body = (3.0)
+    nsig_delr_pjs_junc_pmos90_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmos90_d_body = (3.0)
+    nsig_delr_chjs_junc_pmos90_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos90b_d_body = (3.0)
+    nsig_delr_ajs_junc_pmos90b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pmos90b_d_body = (3.0)
+    nsig_delr_pjs_junc_pmos90b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pmos90b_d_body = (3.0)
+    nsig_delr_chjs_junc_pmos90b_d_body = (3.0)
+    nsig_delr_acj0_junc_pmos90_s_body = (3.0)
+    nsig_delr_ajs_junc_pmos90_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmos90_s_body = (3.0)
+    nsig_delr_pjs_junc_pmos90_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmos90_s_body = (3.0)
+    nsig_delr_chjs_junc_pmos90_s_body = (3.0)
+    nsig_delr_acj0_junc_pmos90b_s_body = (3.0)
+    nsig_delr_ajs_junc_pmos90b_s_body = (3.0)
+    nsig_delr_pcj0_junc_pmos90b_s_body = (3.0)
+    nsig_delr_pjs_junc_pmos90b_s_body = (3.0)
+    nsig_delr_chcj0_junc_pmos90b_s_body = (3.0)
+    nsig_delr_chjs_junc_pmos90b_s_body = (3.0)
+    nsig_delr_acj0_junc_nld5_d_body = (3.0)
+    nsig_delr_ajs_junc_nld5_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld5_d_body = (3.0)
+    nsig_delr_pjs_junc_nld5_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld5_d_body = (3.0)
+    nsig_delr_chjs_junc_nld5_d_body = (3.0)
+    nsig_delr_acj0_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_ajs_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_pjs_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_chjs_junc_nld5_lvt_d_body = (3.0)
+    nsig_delr_acj0_junc_nld10_d_body = (3.0)
+    nsig_delr_ajs_junc_nld10_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld10_d_body = (3.0)
+    nsig_delr_pjs_junc_nld10_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld10_d_body = (3.0)
+    nsig_delr_chjs_junc_nld10_d_body = (3.0)
+    nsig_delr_acj0_junc_nld30_d_body = (3.0)
+    nsig_delr_ajs_junc_nld30_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld30_d_body = (3.0)
+    nsig_delr_pjs_junc_nld30_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld30_d_body = (3.0)
+    nsig_delr_chjs_junc_nld30_d_body = (3.0)
+    nsig_delr_acj0_junc_nld30b_d_body = (3.0)
+    nsig_delr_ajs_junc_nld30b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld30b_d_body = (3.0)
+    nsig_delr_pjs_junc_nld30b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld30b_d_body = (3.0)
+    nsig_delr_chjs_junc_nld30b_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45b_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45b_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45b_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45b_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45_he_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45_he_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45_he_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45_he_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45_he_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45_he_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45b_he_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45_tlp_d_body = (3.0)
+    nsig_delr_acj0_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_ajs_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_pjs_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_chjs_junc_nld45b_tlp_d_body = (3.0)
+    nsig_delr_acj0_junc_nld65_d_body = (3.0)
+    nsig_delr_ajs_junc_nld65_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld65_d_body = (3.0)
+    nsig_delr_pjs_junc_nld65_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld65_d_body = (3.0)
+    nsig_delr_chjs_junc_nld65_d_body = (3.0)
+    nsig_delr_acj0_junc_nld65b_d_body = (3.0)
+    nsig_delr_ajs_junc_nld65b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld65b_d_body = (3.0)
+    nsig_delr_pjs_junc_nld65b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld65b_d_body = (3.0)
+    nsig_delr_chjs_junc_nld65b_d_body = (3.0)
+    nsig_delr_acj0_junc_nld90_d_body = (3.0)
+    nsig_delr_ajs_junc_nld90_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld90_d_body = (3.0)
+    nsig_delr_pjs_junc_nld90_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld90_d_body = (3.0)
+    nsig_delr_chjs_junc_nld90_d_body = (3.0)
+    nsig_delr_acj0_junc_nld90b_d_body = (3.0)
+    nsig_delr_ajs_junc_nld90b_d_body = (3.0)
+    nsig_delr_pcj0_junc_nld90b_d_body = (3.0)
+    nsig_delr_pjs_junc_nld90b_d_body = (3.0)
+    nsig_delr_chcj0_junc_nld90b_d_body = (3.0)
+    nsig_delr_chjs_junc_nld90b_d_body = (3.0)
+    nsig_delr_acj0_junc_pld5_d_body = (3.0)
+    nsig_delr_ajs_junc_pld5_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld5_d_body = (3.0)
+    nsig_delr_pjs_junc_pld5_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld5_d_body = (3.0)
+    nsig_delr_chjs_junc_pld5_d_body = (3.0)
+    nsig_delr_acj0_junc_pld10_d_body = (3.0)
+    nsig_delr_ajs_junc_pld10_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld10_d_body = (3.0)
+    nsig_delr_pjs_junc_pld10_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld10_d_body = (3.0)
+    nsig_delr_chjs_junc_pld10_d_body = (3.0)
+    nsig_delr_cj0_junc_pld10b_d_body = (3.0)
+    nsig_delr_js_junc_pld10b_d_body = (3.0)
+    nsig_delr_acj0_junc_pld30_d_body = (3.0)
+    nsig_delr_ajs_junc_pld30_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld30_d_body = (3.0)
+    nsig_delr_pjs_junc_pld30_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld30_d_body = (3.0)
+    nsig_delr_chjs_junc_pld30_d_body = (3.0)
+    nsig_delr_acj0_junc_pld30b_d_body = (3.0)
+    nsig_delr_ajs_junc_pld30b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld30b_d_body = (3.0)
+    nsig_delr_pjs_junc_pld30b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld30b_d_body = (3.0)
+    nsig_delr_chjs_junc_pld30b_d_body = (3.0)
+    nsig_delr_acj0_junc_pld45_d_body = (3.0)
+    nsig_delr_ajs_junc_pld45_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld45_d_body = (3.0)
+    nsig_delr_pjs_junc_pld45_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld45_d_body = (3.0)
+    nsig_delr_chjs_junc_pld45_d_body = (3.0)
+    nsig_delr_acj0_junc_pld45b_d_body = (3.0)
+    nsig_delr_ajs_junc_pld45b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld45b_d_body = (3.0)
+    nsig_delr_pjs_junc_pld45b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld45b_d_body = (3.0)
+    nsig_delr_chjs_junc_pld45b_d_body = (3.0)
+    nsig_delr_acj0_junc_pld90_d_body = (3.0)
+    nsig_delr_ajs_junc_pld90_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld90_d_body = (3.0)
+    nsig_delr_pjs_junc_pld90_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld90_d_body = (3.0)
+    nsig_delr_chjs_junc_pld90_d_body = (3.0)
+    nsig_delr_acj0_junc_pld90b_d_body = (3.0)
+    nsig_delr_ajs_junc_pld90b_d_body = (3.0)
+    nsig_delr_pcj0_junc_pld90b_d_body = (3.0)
+    nsig_delr_pjs_junc_pld90b_d_body = (3.0)
+    nsig_delr_chcj0_junc_pld90b_d_body = (3.0)
+    nsig_delr_chjs_junc_pld90b_d_body = (3.0)
+    nsig_delr_tox_box              = (3.0)


parameters
+    nsig_delr_is_dpldd_junc_10hv = 3.0
+    nsig_delr_ir_dpldd_junc_10hv = 3.0
+    nsig_dela_bv_dpldd_junc_10hv = 3.0
+    nsig_delr_cj_dpldd_junc_10hv = 3.0

//***********************************************************
endsection hi_para_process_params
//***********************************************************

//***********************************************************
section powermos
ahdl_include "./veriloga/powermos_vlaver6p7_forspectre.va"

ahdl_include "./veriloga/generalmacrosanddefines_forspectre.va"

ahdl_include "./veriloga/powerdiodev7p3_forspectre.va"

//***********************************************************

subckt nld65_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld65_10hv_gox       = tmp_nsmm_delr_nld65_10hv_gox
+    nsmm_dela_nld65_10hv_vfb       = tmp_nsmm_dela_nld65_10hv_vfb
+    nsmm_delr_nld65_10hv_nsub      = tmp_nsmm_delr_nld65_10hv_nsub
+    nsmm_dela_nld65_10hv_vtl       = tmp_nsmm_dela_nld65_10hv_vtl
+    nsmm_dela_nld65_10hv_dwox      = tmp_nsmm_dela_nld65_10hv_dwox
+    nsmm_delr_nld65_10hv_ubref     = tmp_nsmm_delr_nld65_10hv_ubref
+    nsmm_delr_nld65_10hv_rsh       = tmp_nsmm_delr_nld65_10hv_rsh
+    nsmm_dela_nld65_10hv_vtw       = tmp_nsmm_dela_nld65_10hv_vtw
+    l                              = (0.55)
+    delr_nld65_10hv_tox            = (nom_delr_nld65_10hv_tox*(1+sig_delr_nld65_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld65_10hv_gox*smm_delr_nld65_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld65_10hv_uch            = (nom_delr_nld65_10hv_uch*(1+sig_delr_nld65_10hv_uch*nsig_delr_nld65_10hv_uch+nsmm_delr_nld65_10hv_ubref*smm_delr_nld65_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld65_10hv_res            = (nom_delr_nld65_10hv_res*(1+sig_delr_nld65_10hv_res*nsig_delr_nld65_10hv_res+nsmm_delr_nld65_10hv_rsh*smm_delr_nld65_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld65_10hv_vfb            = (nom_dela_nld65_10hv_vfb+(sig_dela_nld65_10hv_vfb*nsig_dela_nld65_10hv_vfb)+nsmm_dela_nld65_10hv_vfb*smm_dela_nld65_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld65_10hv_vtl*smm_dela_nld65_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld65_10hv_vtw*smm_dela_nld65_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld65_10hv_dwres          = (nom_dela_nld65_10hv_dwres+(sig_dela_nld65_10hv_dwres*nsig_dela_nld65_10hv_dwres))
+    dela_nld65_10hv_dwmos          = (0+(nsmm_dela_nld65_10hv_dwox*smm_dela_nld65_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld65_10hv_vtw            = (nom_dela_nld65_10hv_vtw+(sig_dela_nld65_10hv_vtw*nsig_dela_nld65_10hv_vtw))
+    delr_nld65_10hv_nsub           = (1+nsmm_delr_nld65_10hv_nsub*smm_delr_nld65_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.008*1e-10*delr_nld65_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.6)
+    lacc_drawn                     = (0.6)
+    lchtcad                        = (0.480)
+    lacc                           = (0.6)
+    lch                            = (0.480)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (3.095)
+    wdel                           = (0.855)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (1.25)
+    xiso                           = (1.275)
+    yiso                           = (6.21)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.07)
+    lfrs                           = (0.0087)
+    lfrd                           = (0)
+    dw_mos                         = (0+dela_nld65_10hv_dwmos)
+    dw_res                         = (1.00803+(2.48254)/(w**1.24553)+dela_nld65_10hv_dwres)
+    lcheff                         = (0.480)
+    numbernplus                    = (int_round((w-0.09*(1-fem))/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = (w+dw_res*(1-fem))
+    xncom                          = (ld+lacc_drawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (125.1430026/(w+1.3))
+    rsd_t                          = (rsd*(1+0.001*(temp-27)))
+    xsub                           = (2*xiso+(lcell*ng)+0.36*(ng/2-1))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (1.345)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.155)*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*0.855)*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*0.855)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*5.1)*ng)
+    lfring_d                       = (((w+2*0.855)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (5.1)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*0.855+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.53*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.205)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*5.375)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*aplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    aphi_tnom                      = (aphi_junc_nld65_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld65_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld65_d_body)
+    pphi_tnom                      = (pphi_junc_nld65_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld65_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld65_d_body)
+    chphi_tnom                     = (chphi_junc_nld65_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld65_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld65_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.008*1e-10*delr_nld65_10hv_tox)
+ nch      = (1.45e17*delr_nld65_10hv_nsub)
+ nsub     = (9.85e16*delr_nld65_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-8.76544e-08)*(1-fem))
+ ww       = ((-5.7339e-13)*(1-fem))
+ wwl      = ((2.9527e-19)*(1-fem))
+ dwg      = ((0.0e-08)*(1-fem))
+ ags      = (0.279788*(1+(0.0271316)*(temp-27)+(-0.000130487)*(temp-27)*(temp-27))+((-0.5501)/w))
+ vfb      = (-0.7649808+dela_nld65_10hv_vfb)
+ a0       = (0.738133)
+ a1       = (0)
+ a2       = (1)
+ u0       = (371.758*delr_nld65_10hv_uch)
+ ua       = (0.6028e-10)
+ ub       = (9.4933e-19)
+ vsat     = (225000*(1+((-1e-2/w)*(temp-27))+((5.4975e-5/w)*(temp-27)*(temp-27))))
+ drout    = (0.056)
+ pclm     = (0.000022839)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.053)
+ rdsw     = (442.094)
+ prwg     = (0.266609)
+ prt      = (283.504)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0+dela_nld65_10hv_vtw)*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((0)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0218002)
+ nfactor  = (1.6)
+ beta0    = (78.5152)
+ kt1      = (-0.551641)
+ ua1      = (1e-11)
+ ub1      = (-8.88725e-19)
+ uc1      = (-5.6e-11)
+ ute      = (-1.795)
+ dlc      = (0)
+ dwc      = (-5.25e-7)
+ wwc      = (-5.95e-13)
+ voffcv   = (-0.359)
+ acde     = (0.6)
+ moin     = (25)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld65_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld65_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld65_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld65_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd_t) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(6.03173e+16+(-9.67569e+15/w))
+ vfb=(0.0374+dela_nld65_10hv_vfb)
+ f3=(8.71483)
+ phidel=(-0.127364)
+ em=(2.01697+(0.00949415/w))
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.00020935)
+ nd=(6.70781e+19)
+ u_init=(0.0541878/delr_nld65_10hv_res)
+ vsat=((74140.6+(-(0.78591)*(74140.6)/(w+(0.78591))))*(1+(-0.000681952+(0.00478615/w))*(temp-27)+(-8.77295e-07+(4.65986e-06/w))*(temp-27)*(temp-27)))
+ fneff=(0.0224756)
+ alphafneff=(0.301259+(-(-0.0589361)*(0.301259)/(w+(-0.0589361))))
+ alphexp=(1.90746+(1-fem)*((1.90746)*(0.773504)/w))
+ vfbtexp=(0.0167997)
+ udriftexpa=(-0.00483123+(0.00356246/w)*(1-fem))
+ udriftexpb=(8.95009e-06+(-1.58883e-05/w)*(1-fem))
+ betavds=(0.7032)
+ betaexp=(0.53036)
+ vfb0=(-5)
adsd_a (s intdx) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(ajs_junc_nld65_d_body*0.1)
+ n=(ajnd_junc_nld65_d_body*1.22)
+ rs=(0.0)
+ cj0=((acj0_junc_nld65_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld65_d_body)
+ tau=(30e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld65_d_body)
+ betaeg=(abetaeg_junc_nld65_d_body)
+ eg=(aeg_junc_nld65_d_body)
+ bv=(84+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(30.0e-5)
+ xti=(12)
adsd_p (s intdx) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(pjs_junc_nld65_d_body/sDOTmult*w*10)
+ n=(pjnd_junc_nld65_d_body*1.03)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld65_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld65_d_body)
+ tau=(30e-9)
+ trr=(1e-9)
+ alphaeg=(palphaeg_junc_nld65_d_body)
+ betaeg=(pbetaeg_junc_nld65_d_body)
+ eg=(peg_junc_nld65_d_body)
+ bv=(84+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(7.20e-07*w)
+ xti=(20)
adsd_pch (s intdx) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld65_d_body/sDOTmult*1.3)
+ n=(chjnd_junc_nld65_d_body)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld65_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld65_d_body)
+ tau=(20e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld65_d_body)
+ betaeg=(abetaeg_junc_nld65_d_body)
+ eg=(aeg_junc_nld65_d_body)
+ bv=(84+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(maxa(1e-8,(6.25e-08)*(1+0.048*(temp-27)),1e-14))
+ xti=(4.5)

include "./smos10hv_ade_dfrt.scs" section=nld65_10hv_dfrt
ends

subckt nld90_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld90_10hv_gox       = tmp_nsmm_delr_nld90_10hv_gox
+    nsmm_dela_nld90_10hv_vfb       = tmp_nsmm_dela_nld90_10hv_vfb
+    nsmm_delr_nld90_10hv_nsub      = tmp_nsmm_delr_nld90_10hv_nsub
+    nsmm_dela_nld90_10hv_vtl       = tmp_nsmm_dela_nld90_10hv_vtl
+    nsmm_delr_nld90_10hv_ubref     = tmp_nsmm_delr_nld90_10hv_ubref
+    nsmm_delr_nld90_10hv_rsh       = tmp_nsmm_delr_nld90_10hv_rsh
+    nsmm_dela_nld90_10hv_vtw       = tmp_nsmm_dela_nld90_10hv_vtw
+    l                              = (0.65)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    delr_nld90_10hv_tox            = (nom_delr_nld90_10hv_tox*(1+sig_delr_nld90_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld90_10hv_gox*smm_delr_nld90_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld90_10hv_uch            = (nom_delr_nld90_10hv_uch*(1+sig_delr_nld90_10hv_uch*nsig_delr_nld90_10hv_uch+nsmm_delr_nld90_10hv_ubref*smm_delr_nld90_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld90_10hv_res            = (nom_delr_nld90_10hv_res*(1+sig_delr_nld90_10hv_res*nsig_delr_nld90_10hv_res+nsmm_delr_nld90_10hv_rsh*smm_delr_nld90_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld90_10hv_vfb            = (nom_dela_nld90_10hv_vfb+(sig_dela_nld90_10hv_vfb*nsig_dela_nld90_10hv_vfb)+nsmm_dela_nld90_10hv_vfb*smm_dela_nld90_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld90_10hv_vtl*smm_dela_nld90_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld90_10hv_vtw*smm_dela_nld90_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld90_10hv_dwmos          = (nom_dela_nld90_10hv_dwmos+(sig_dela_nld90_10hv_dwmos*nsig_dela_nld90_10hv_dwmos))
+    dela_nld90_10hv_dwres          = (nom_dela_nld90_10hv_dwres+(sig_dela_nld90_10hv_dwres*nsig_dela_nld90_10hv_dwres))
+    dela_nld90_10hv_vtw            = (nom_dela_nld90_10hv_vtw+(sig_dela_nld90_10hv_vtw*nsig_dela_nld90_10hv_vtw))
+    delr_nld90_10hv_nsub           = (1+nsmm_delr_nld90_10hv_nsub*smm_delr_nld90_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.008*1e-10*delr_nld90_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.65)
+    laccdrawn                      = (0.6)
+    lacc_drawn                     = (0.6)
+    lchtcad                        = (0.582)
+    lacc                           = (0.601)
+    wdel                           = (1.545)
+    lch                            = (0.582)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (5.555)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (2.7)
+    xiso                           = (1.275)
+    yiso                           = (9.46)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.067)
+    lfrs                           = (0.0125)
+    lfrd                           = (0)
+    dw_mos                         = (0)
+    dw_res                         = ((2.59217+(9.8)/(w))+dela_nld90_10hv_dwres)
+    lcheff                         = (0.582)
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+dw_res*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+lacc_drawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = ((2*wdel+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (137.52/(w+1.9))
+    rsd_t                          = (rsd*(1+0.002*(temp-27)))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (2.355)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.12)*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*1.545)*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*1.545)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*8.35)*ng)
+    lfring_d                       = (((w+2*1.545)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (8.35)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*1.545+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.74*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.17)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*8.625)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*(aplyfld_d/(lflap*ng))/(lflap*3*ng))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    aphi_tnom                      = (aphi_junc_nld90_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld90_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld90_d_body)
+    pphi_tnom                      = (pphi_junc_nld90_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld90_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld90_d_body)
+    chphi_tnom                     = (chphi_junc_nld90_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld90_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld90_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.008*1e-10*delr_nld90_10hv_tox)
+ nch      = (1.50e17*delr_nld90_10hv_nsub)
+ nsub     = (3.61e16*delr_nld90_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-4.72781e-08*(0.6)-0.5e-06*dela_nld90_10hv_dwmos)*(1-fem))
+ ww       = ((2.06059e-14)*(1-fem))
+ wwl      = ((3.211e-21)*(1-fem))
+ dwg      = ((0.0e-08)*(1-fem))
+ ags      = ((0.2414*(1+(0.0318767)*(temp-27)+(-0.0001521)*(temp-27)*(temp-27))+((0.295295*(1+-0.0252791*(temp-27)+0.000203955*(temp-27)*(temp-27)))/w)))
+ vfb      = (-1.03799+(0.00067)+dela_nld90_10hv_vfb+dela_vth_relimo)
+ a0       = (0.28552823*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = ((361.809)*(1.003)*delr_nld90_10hv_uch*delr_u0_relimo)
+ ua       = (1e-15)
+ ub       = (3.032e-18)
+ vsat     = (1.15e+06)
+ drout    = (0.56)
+ pclm     = (0.13)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.0375)
+ rdsw     = (336.821*delr_rdsw_relimo)
+ prwg     = (0.566612*(1+(0.00457161*(1+(1-fem)*(1.07917/w)))*(temp-27)))
+ prt      = (400*(1+(0.0145945/w)*(1-fem)*(temp-27)+(-3.16206e-05/w)*(1-fem)*(temp-27)*(temp-27)))
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.641388+dela_nld90_10hv_vtw)*(1-fem))
+ dvt1w    = (361087)
+ k3       = ((1.52237-1.04+0.5955152)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0079265)
+ nfactor  = (1.86)
+ beta0    = (80.932)
+ kt1      = (-0.60491)
+ ua1      = (2.38202e-09)
+ ub1      = (-8.54066e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.55)
+ dlc      = (0)
+ dwc      = (-19.72781e-08)
+ wwc      = (0)
+ voffcv   = (-0.425)
+ acde     = (0.495)
+ moin     = (5)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld90_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld90_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld90_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld90_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd_t) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ num=(1)
+ tox=(tox)
+ nb=(6.31017e+16+(-2.03684e+16/w))
+ vfb=(0.05309971+dela_nld90_10hv_vfb)
+ f3=(6.59418)
+ phidel=(-0.146921)
+ em=(2.0255+(0/w))
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ num=(ng)
+ xj=(0.00122159)
+ nd=(4.8599e+19)
+ u_init=((0.00963978*(1.009)/delr_nld90_10hv_res)/delr_rdsw_relimo)
+ vsat=((17335.1+(-(1.72876)*(17335.1)/(w+(1.72876))))*(1+(-0.00157666)*(temp-27)))
+ fneff=(0.0966508)
+ alphafneff=(0.156196+(1-fem)*(-(-1.85139)*(-0.02)/(w+(-1.85139))))
+ alphexp=(1.97831+(1-fem)*((1.97831)*(0.836054)/w))
+ vfbtexp=(0)
+ udriftexpa=(-0.00556295+(0.000207998/w)*(1-fem))
+ udriftexpb=(1.20546e-05)
+ betavds=(0.59)
+ betaexp=(0.4)
+ vfb0=(0)
adsd_a (s intdx) powerdiode
+ areafactor=(ancom)
+ num=(1)
+ is=(ajs_junc_nld90_d_body)
+ n=(ajnd_junc_nld90_d_body*1.2)
+ rs=(0.0)
+ cj0=((acj0_junc_nld90_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_nld90_d_body)
+ tau=(58e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld90_d_body)
+ betaeg=(abetaeg_junc_nld90_d_body)
+ eg=(aeg_junc_nld90_d_body)
+ bv=(115+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(4.5e-6)
+ xti=(16)
adsd_p (s intdx) powerdiode
+ areafactor=(pncom)
+ num=(1)
+ is=(pjs_junc_nld90_d_body/sDOTmult*w*30)
+ n=(pjnd_junc_nld90_d_body*1.1)
+ rs=(0.0)
+ cj0=((pcj0_junc_nld90_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_nld90_d_body)
+ tau=(58e-9)
+ trr=(1e-9)
+ alphaeg=(palphaeg_junc_nld90_d_body)
+ betaeg=(pbetaeg_junc_nld90_d_body)
+ eg=(peg_junc_nld90_d_body)
+ bv=(115+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(1.2e-6*w)
+ xti=(8)
adsd_pch (s intdx) powerdiode
+ areafactor=(chncom)
+ num=(1)
+ is=(chjs_junc_nld90_d_body/sDOTmult*3)
+ n=(chjnd_junc_nld90_d_body*1.02)
+ rs=(0.0)
+ cj0=((chcj0_junc_nld90_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_nld90_d_body)
+ tau=(58e-9)
+ trr=(1e-9)
+ alphaeg=(aalphaeg_junc_nld90_d_body)
+ betaeg=(abetaeg_junc_nld90_d_body)
+ eg=(aeg_junc_nld90_d_body)
+ bv=(115+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(maxa(5e-8,(4e-7)*(1+0.05*(temp-27)),4e-13))
+ xti=(4.7)

include "./smos10hv_ade_dfrt.scs" section=nld90_10hv_dfrt
ends

subckt pld90_10hv (d g s sub)

parameters
+    w                              = 5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld90_10hv_gox       = tmp_nsmm_delr_pld90_10hv_gox
+    nsmm_dela_pld90_10hv_vfb       = tmp_nsmm_dela_pld90_10hv_vfb
+    nsmm_delr_pld90_10hv_nsub      = tmp_nsmm_delr_pld90_10hv_nsub
+    nsmm_dela_pld90_10hv_vtl       = tmp_nsmm_dela_pld90_10hv_vtl
+    nsmm_delr_pld90_10hv_ubref     = tmp_nsmm_delr_pld90_10hv_ubref
+    nsmm_delr_pld90_10hv_rsh       = tmp_nsmm_delr_pld90_10hv_rsh
+    nsmm_dela_pld90_10hv_vtw       = tmp_nsmm_dela_pld90_10hv_vtw
+    l                              = (0.5)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld90_vthratio          = 1.0
+    presto_pld90_betaratio         = 1
+    delr_pld90_10hv_tox            = (nom_delr_pld90_10hv_tox*(1+sig_delr_pld90_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld90_10hv_gox*smm_delr_pld90_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld90_10hv_uch            = (nom_delr_pld90_10hv_uch*(1+sig_delr_pld90_10hv_uch*nsig_delr_pld90_10hv_uch+nsmm_delr_pld90_10hv_ubref*smm_delr_pld90_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld90_10hv_res            = (nom_delr_pld90_10hv_res*(1+sig_delr_pld90_10hv_res*nsig_delr_pld90_10hv_res+nsmm_delr_pld90_10hv_rsh*smm_delr_pld90_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld90_10hv_vfb            = (nom_dela_pld90_10hv_vfb+(sig_dela_pld90_10hv_vfb*nsig_dela_pld90_10hv_vfb)+nsmm_dela_pld90_10hv_vfb*smm_dela_pld90_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld90_10hv_vtl*smm_dela_pld90_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld90_10hv_vtw*smm_dela_pld90_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld90_10hv_vtm            = (nom_dela_pld90_10hv_vtm+(sig_dela_pld90_10hv_vtm*nsig_dela_pld90_10hv_vtm))
+    delr_pld90_10hv_nsub           = (1+nsmm_delr_pld90_10hv_nsub*smm_delr_pld90_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.032*1e-10*delr_pld90_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.5)
+    lch                            = (0.913)
+    lacc_drawn                     = (0.55)
+    lacc                           = (0.078)
+    ld                             = (7.01)
+    lsc_ply                        = (0.495)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (2.65)
+    xiso                           = (3.165)
+    yiso                           = (13.4)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.021)
+    lfrd                           = (0.0157677+(2.64757)/(w**(2.2912)))
+    dw_mos                         = (0.141168)
+    dw_res                         = (0.611467)
+    lcheff                         = (0.913)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(0.865274/(w**0.092297)))*(1-fem))
+    nhvradius                      = (1.46)
+    xnhvhole                       = (ld+lacc_drawn)
+    ynhvhole                       = (w+2*(9.9-nhvradius))
+    apepid                         = (((7.01+0.55)*(w+2*8.44)+2*1.46*(7.01+0.55-1.46)+0.5*pi4models*1.46*1.46)*ng)
+    ppepid                         = (((2*8.44)+2*(7.01+0.55-1.46)+pi4models*1.46)*ng)
+    chpepid                        = (w*ng)
+    rsda                           = (378/(w+2.295))
+    rsdp                           = (513/(w+1.5))
+    rsdch                          = (131670/(w+0))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    xplyplushole                   = (7.01)
+    yplyplushole                   = (w+2*(9+0.35))
+    apolyplushole                  = ((xplyplushole*yplyplushole)*ng)
+    xplyholein                     = (3.86)
+    yplyholein                     = (w+2*4.8)
+    apolyholein                    = ((xplyholein*yplyholein)*ng)
+    xplyholeout                    = (0.5)
+    yplyholeout                    = (w+2*3.2)
+    apolyholeout                   = ((xplyholeout*yplyholeout)*ng)
+    aplyfld_d                      = (apolyplushole-apolyholein-apolyholeout)
+    pplyfld_in_d                   = ((yplyholein+xplyholein*2)*ng)
+    xply                           = (lch+lacc+ld+lovlap)
+    yply                           = (w+2*10.9)
+    aply_s                         = (ng*xply*yply-apolyplushole)
+    aplyfld_s                      = (aply_s-(lch+lacc+lovlap)*w*ng)
+    pplyfld_s                      = ((yply+2*xply)*ng)
+    pm1fld_s                       = (14.34*ng)
+    area_accum                     = (w*lacc*ng)
+    lfring_s                       = ((w)*ng)
+    lfring_d                       = ((w)*ng)
+    number_ct_s                    = (int_round((w-0.25*2)/(0.18+0.18))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.1*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w)-lfr_ct_ply_d)
+    aphi_tnom                      = (aphi_junc_pld90_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_pld90_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_pld90_d_body)
+    pphi_tnom                      = (pphi_junc_pld90_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_pld90_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_pld90_d_body)
+    chphi_tnom                     = (chphi_junc_pld90_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_pld90_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/pphi)
+    chexm                          = (chexm_junc_pld90_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.032*1e-10*delr_pld90_10hv_tox)
+ nch      = (8.82e16*delr_pld90_10hv_nsub)
+ nsub     = (1.47e17*delr_pld90_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((22e-8)*(1-fem))
+ ww       = ((2.5e-13)*(1-fem))
+ wwl      = ((0)*(1-fem))
+ dwg      = ((7.6e-08)*(1-fem))
+ ags      = ((0.65)*(1+0.0128548*(temp-27)+-5.3512e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.644188+dela_pld90_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld90_vthratio)
+ a0       = (0.874*delr_a0_relimo)
+ u0       = (163.167*delr_pld90_10hv_uch*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld90_betaratio))
+ ua       = (1.25516e-11)
+ ub       = (8.01052e-20)
+ vsat     = (0.29e+06)
+ drout    = (55.6)
+ pclm     = (0.055)
+ pvag     = (0)
+ pdiblc1  = (0.000039)
+ pdiblc2  = (0.00086)
+ delta    = (0.0317479)
+ rdsw     = ((4136.24+(-7788.25/w)*(1-fem))*delr_rdsw_relimo)
+ prwg     = (0.920767*(1+(-9.8901e-05+(1-fem)*(-4.16797e-06/w))*(temp-27)))
+ prt      = (8251.2+(1-fem)*(-9423.39/w))
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.00048)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.0411441)*(1-fem))
+ dvt1w    = (2.18207)
+ k3       = ((0+dela_pld90_10hv_vtm)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (2.4)
+ alpha0   = (0e-8)
+ alpha1   = (0.00)
+ nfactor  = (1.35)
+ beta0    = (50)
+ kt1      = (-0.488519)
+ ua1      = (1.980738e-09)
+ ub1      = (-8.61e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.5)
+ dlc      = (0)
+ dwc      = (1e-7)
+ wwc      = (-13.5e-13)
+ at       = (33000)
+ voff     = (-0.08)
+ acde     = (0.7)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgs_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+(cfr_ply_fld*(pplyfld_in_d))*sDOTmult)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+(cfr_ply_fld*pplyfld_s)*sDOTmult)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_pld90_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_pld90_s_ply_m1ct*sDOTmult+cfr_m1_fld*pm1fld_s*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_pld90_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_pld90_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*10.675)/((lch+lacc+lovlap+lflap)*3*ng)))
rxa (intdxa d) resistor r=(rsda) m=(ng)
rxp (intdxp d) resistor r=(rsdp) m=(ng)
rxch (intdxch d) resistor r=(rsdch) m=(ng)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
acapmos1 (intd intg s) accumcap
+ aream=(area_accum*sDOTmult2*1e-12)
+ kind=(-1)
+ num=(1)
+ tox=(tox)
+ nb=(9.5064e+16+(1.26285e+18/(w**(7.58236))))
+ vfb=(-0.200423+dela_pld90_10hv_vfb)
+ f3=(1)
+ phidel=(0)
+ em=(2.0)
ares (d intd intg) drifty
+ wm=(w_res*sDOTmult*1e-6)
+ lm=(1*sDOTmult*1e-6)
+ kind=(-1)
+ num=(ng)
+ xj=(5.5198e-05)
+ nd=(4.0196e+19)
+ u_init=(0.00455431/delr_pld90_10hv_res)
+ vsat=((37819.7+(1-fem)*(-22625.3/w))*(1+(0.00184983)*(temp-27)+(1.14929e-05)*(temp-27)*(temp-27)))
+ fneff=(1.28409)
+ alphafneff=(2.079192)
+ alphexp=(1.21109)
+ vfbtexp=(0)
+ udriftexpa=(-0.00477638+(0.00222722/w)*(1-fem))
+ udriftexpb=(1.007094e-05+(-5.80477e-06/w)*(1-fem))
+ betavds=(0.00828791)
+ betaexp=(1.45)
+ vfb0=(-5)
adsd_a (intdxa s) powerdiode
+ areafactor=(apepid)
+ num=(1)
+ is=(ajs_junc_pld90_d_body*0.001)
+ n=(ajnd_junc_pld90_d_body*1.2)
+ rs=(0.0)
+ cj0=((acj0_junc_pld90_d_body)*(aphi_tf**aexm))
+ vj=(aphi)
+ em=(aexm_junc_pld90_d_body)
+ tau=(40e-9)
+ trr=(10e-9)
+ alphaeg=(aalphaeg_junc_pld90_d_body)
+ betaeg=(abetaeg_junc_pld90_d_body)
+ eg=(aeg_junc_pld90_d_body)
+ bv=(112+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(6e-5)
+ xti=(15)
adsd_p (intdxp s) powerdiode
+ areafactor=(ppepid)
+ num=(1)
+ is=(pjs_junc_pld90_d_body/sDOTmult*4*(w))
+ n=(pjnd_junc_pld90_d_body*0.95)
+ rs=(0.0)
+ cj0=((pcj0_junc_pld90_d_body/sDOTmult)*(pphi_tf**pexm))
+ vj=(pphi)
+ em=(pexm_junc_pld90_d_body)
+ tau=(40e-9)
+ trr=(10e-9)
+ alphaeg=(palphaeg_junc_pld90_d_body)
+ betaeg=(pbetaeg_junc_pld90_d_body)
+ eg=(peg_junc_pld90_d_body)
+ bv=(112+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(6e-7*w)
+ xti=(17)
adsd_ch (intdxch s) powerdiode
+ areafactor=(chpepid)
+ num=(1)
+ is=(chjs_junc_pld90_d_body/sDOTmult*0.2)
+ n=(chjnd_junc_pld90_d_body*0.9)
+ rs=(0.0)
+ cj0=((chcj0_junc_pld90_d_body/sDOTmult)*(chphi_tf**chexm))
+ vj=(chphi)
+ em=(chexm_junc_pld90_d_body)
+ tau=(40e-9)
+ trr=(10e-9)
+ alphaeg=(aalphaeg_junc_pld90_d_body)
+ betaeg=(abetaeg_junc_pld90_d_body)
+ eg=(aeg_junc_pld90_d_body)
+ bv=(112+bvdss_shift)
+ ibv=(1e-5)
+ fc=(0.9)
+ tnom=(27)
+ ik=(maxa(1e-8,(1e-7*(1+0.013*(temp-27))),0))
+ xti=(axti_junc_pld90_d_body-0.97)

include "./smos10hv_ade_dfrt.scs" section=pld90_10hv_dfrt
ends

subckt nld45_tlp_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_tlp_10hv_gox   = tmp_nsmm_delr_nld45_tlp_10hv_gox
+    nsmm_dela_nld45_tlp_10hv_vfb   = tmp_nsmm_dela_nld45_tlp_10hv_vfb
+    nsmm_delr_nld45_tlp_10hv_nsub  = tmp_nsmm_delr_nld45_tlp_10hv_nsub
+    nsmm_dela_nld45_tlp_10hv_vtl   = tmp_nsmm_dela_nld45_tlp_10hv_vtl
+    nsmm_delr_nld45_tlp_10hv_ubref = tmp_nsmm_delr_nld45_tlp_10hv_ubref
+    nsmm_delr_nld45_tlp_10hv_rsh   = tmp_nsmm_delr_nld45_tlp_10hv_rsh
+    nsmm_dela_nld45_tlp_10hv_vtw   = tmp_nsmm_dela_nld45_tlp_10hv_vtw
+    l                              = (0.55)
+    delr_nld45_tlp_10hv_tox        = (nom_delr_nld45_tlp_10hv_tox*(1+sig_delr_nld45_tlp_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_tlp_10hv_gox*smm_delr_nld45_tlp_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_tlp_10hv_uch        = (nom_delr_nld45_tlp_10hv_uch*(1+sig_delr_nld45_tlp_10hv_uch*nsig_delr_nld45_tlp_10hv_uch+nsmm_delr_nld45_tlp_10hv_ubref*smm_delr_nld45_tlp_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_tlp_10hv_res        = (nom_delr_nld45_tlp_10hv_res*(1+sig_delr_nld45_tlp_10hv_res*nsig_delr_nld45_tlp_10hv_res+nsmm_delr_nld45_tlp_10hv_rsh*smm_delr_nld45_tlp_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_tlp_10hv_vfb        = (nom_dela_nld45_tlp_10hv_vfb+(sig_dela_nld45_tlp_10hv_vfb*nsig_dela_nld45_tlp_10hv_vfb)+nsmm_dela_nld45_tlp_10hv_vfb*smm_dela_nld45_tlp_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_tlp_10hv_vtl*smm_dela_nld45_tlp_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_tlp_10hv_vtw*smm_dela_nld45_tlp_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld45_tlp_10hv_dr         = (nom_dela_nld45_tlp_10hv_dr+(sig_dela_nld45_tlp_10hv_dr*nsig_dela_nld45_tlp_10hv_dr))
+    dela_nld45_tlp_10hv_dw         = (nom_dela_nld45_tlp_10hv_dw+(sig_dela_nld45_tlp_10hv_dw*nsig_dela_nld45_tlp_10hv_dw))
+    dela_nld45_tlp_10hv_vtm        = (nom_dela_nld45_tlp_10hv_vtm+(sig_dela_nld45_tlp_10hv_vtm*nsig_dela_nld45_tlp_10hv_vtm))
+    delr_nld45_tlp_10hv_nsub       = (1+nsmm_delr_nld45_tlp_10hv_nsub*smm_delr_nld45_tlp_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_tlp_10hv_a0         = (nom_dela_nld45_tlp_10hv_a0+(sig_dela_nld45_tlp_10hv_a0*nsig_dela_nld45_tlp_10hv_a0))
+    dela_nld45_tlp_10hv_b0         = (nom_dela_nld45_tlp_10hv_b0+(sig_dela_nld45_tlp_10hv_b0*nsig_dela_nld45_tlp_10hv_b0))
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_tlp_vthratio      = 1.0
+    presto_nld45_tlp_ronratio      = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (131.47*1e-10*delr_nld45_tlp_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.499)
+    lacc                           = (0.539)
+    lch                            = (0.499)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (2.395)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (1.05)
+    xiso                           = (1.275)
+    yiso                           = (5.11)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.058)
+    lfrs                           = (0)
+    lfrd                           = (0.015)
+    dw_mos                         = (0)
+    dw_res                         = (1.0484026+(1.4)/(w**0.65)+dela_nld45_tlp_10hv_dr)
+    lcheff                         = (0.499)
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+dw_res*(1-fem))/delr_rdsw_relimo)
+    wdel                           = (0.505)
+    xncom                          = (ld+laccdrawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (134.0258302/(w+1.4))
+    rsd_t                          = (rsd*(1+0.0022*(temp-27)))
+    xsub                           = (2*xiso+(lcell*ng)+(0.36*(ng/2-1)))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*(-0.095))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*(0.505))*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*0.505)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*4.0)*ng)
+    lfring_d                       = (((w+2*0.505)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (4.0)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*0.505+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.53*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.555)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*4.5)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*aplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    aphi_tnom                      = (aphi_junc_nld45_tlp_d_body)
+    aphi_temp                      = (aphi_tnom-pta_junc_nld45_tlp_d_body*(temp-tnom))
+    aphi                           = (maxmodels(0.1,aphi_temp))
+    aphi_tf                        = (aphi_tnom/aphi)
+    aexm                           = (aexm_junc_nld45_tlp_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_tlp_d_body)
+    pphi_temp                      = (pphi_tnom-ptp_junc_nld45_tlp_d_body*(temp-tnom))
+    pphi                           = (maxmodels(0.1,pphi_temp))
+    pphi_tf                        = (pphi_tnom/pphi)
+    pexm                           = (pexm_junc_nld45_tlp_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_tlp_d_body)
+    chphi_temp                     = (chphi_tnom-pta_junc_nld45_tlp_d_body*(temp-tnom))
+    chphi                          = (maxmodels(0.1,chphi_temp))
+    chphi_tf                       = (chphi_tnom/chphi)
+    chexm                          = (chexm_junc_nld45_tlp_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (131.47*1e-10*delr_nld45_tlp_10hv_tox)
+ nch      = (1.45e17*delr_nld45_tlp_10hv_nsub)
+ nsub     = (5.72451e+16*delr_nld45_tlp_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-2.06054e-08+0.5e-6*(dela_nld45_tlp_10hv_dw))*(1-fem))
+ ww       = ((0e-14)*(1-fem))
+ wln      = ((0))
+ wwn      = ((1))
+ dwg      = ((-1e-07)*(1-fem))
+ ags      = ((0.74)*(1+(0.00469908)*(temp-27)+(-3.6975e-05)*(temp-27)*(temp-27))+((-0.49)/w))
+ vfb      = (-0.747293+dela_nld45_tlp_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_tlp_vthratio)
+ a0       = (0.297102*delr_a0_relimo+dela_nld45_tlp_10hv_a0)
+ b0       = (6.051896e-07+1e-6*(dela_nld45_tlp_10hv_b0))
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (393.636*delr_nld45_tlp_10hv_uch*delr_u0_relimo)
+ ua       = (1e-21)
+ ub       = (1.002644e-20)
+ vsat     = ((176593+(11.95e4)/w)*(1+((0.011/w)*(temp-27))+((57e-6/w)*(temp-27)*(temp-27))))
+ drout    = (0.056)
+ pclm     = (0.000022839)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.053)
+ rdsw     = (223.042*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45_tlp_ronratio))
+ wr       = (1)
+ prwg     = (0.45064)
+ prt      = (490.142)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.082649+dela_nld45_tlp_10hv_vtm)*(1-fem))
+ dvt1w    = (13888.2)
+ k3       = ((0.149961+dela_nld45_tlp_10hv_vtm)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0471407)
+ nfactor  = (2.06)
+ voff     = (-0.135)
+ beta0    = (95.6293)
+ kt1      = (-0.529075)
+ ua1      = (2.26711e-09)
+ ub1      = (-7.61e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.3)
+ dlc      = (0)
+ dwc      = (-43e-8)
+ wwc      = (0)
+ voffcv   = (-0.5)
+ acde     = (0.6)
+ moin     = (25)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgd_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_tlp_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_tlp_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_tlp_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_tlp_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd_t) m=(ng)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
