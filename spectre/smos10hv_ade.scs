+    palphaeg_junc_pmos45b_d_body   = (459.6e-06)
+    pbetaeg_junc_pmos45b_d_body    = (601.5)
+    pxti_junc_pmos45b_d_body       = (2.342)
+    nom_chcj0_junc_pmos45b_d_body  = (3.21264e-16)
+    nom_delr_chcj0_junc_pmos45b_d_body = (1)
+    sig_delr_chcj0_junc_pmos45b_d_body = (0.0333)
+    chphi_junc_pmos45b_d_body      = (0.9)
+    chexm_junc_pmos45b_d_body      = (0.5)
+    nom_chjs_junc_pmos45b_d_body   = (1.40824e-19)
+    nom_delr_chjs_junc_pmos45b_d_body = (1)
+    sig_delr_chjs_junc_pmos45b_d_body = (0.0333)
+    chjnd_junc_pmos45b_d_body      = (1.1)
+    nom_acj0_junc_pmos45b_s_body   = (9.45152e-16)
+    nom_delr_acj0_junc_pmos45b_s_body = (1)
+    sig_delr_acj0_junc_pmos45b_s_body = (0.0333)
+    aphi_junc_pmos45b_s_body       = (0.888607)
+    pta_junc_pmos45b_s_body        = (1.326e-03)
+    aexm_junc_pmos45b_s_body       = (0.411877)
+    nom_ajs_junc_pmos45b_s_body    = (2.2927e-19)
+    nom_delr_ajs_junc_pmos45b_s_body = (1)
+    sig_delr_ajs_junc_pmos45b_s_body = (0.0333)
+    ajnd_junc_pmos45b_s_body       = (1.1)
+    aeg_junc_pmos45b_s_body        = (1.188)
+    aalphaeg_junc_pmos45b_s_body   = (459.6e-06)
+    abetaeg_junc_pmos45b_s_body    = (601.5)
+    axti_junc_pmos45b_s_body       = (2.342)
+    nom_pcj0_junc_pmos45b_s_body   = (1.46379e-16)
+    nom_delr_pcj0_junc_pmos45b_s_body = (1)
+    sig_delr_pcj0_junc_pmos45b_s_body = (0.0333)
+    ptp_junc_pmos45b_s_body        = (1.288e-03)
+    pphi_junc_pmos45b_s_body       = (0.9)
+    pexm_junc_pmos45b_s_body       = (0.1)
+    nom_pjs_junc_pmos45b_s_body    = (1.43558e-19)
+    nom_delr_pjs_junc_pmos45b_s_body = (1)
+    sig_delr_pjs_junc_pmos45b_s_body = (0.0333)
+    pjnd_junc_pmos45b_s_body       = (1.1)
+    peg_junc_pmos45b_s_body        = (1.188)
+    palphaeg_junc_pmos45b_s_body   = (459.6e-06)
+    pbetaeg_junc_pmos45b_s_body    = (601.5)
+    pxti_junc_pmos45b_s_body       = (2.342)
+    nom_chcj0_junc_pmos45b_s_body  = (1.47919e-16)
+    nom_delr_chcj0_junc_pmos45b_s_body = (1)
+    sig_delr_chcj0_junc_pmos45b_s_body = (0.0333)
+    chphi_junc_pmos45b_s_body      = (0.532051)
+    chexm_junc_pmos45b_s_body      = (0.299256)
+    nom_chjs_junc_pmos45b_s_body   = (5.98856e-20)
+    nom_delr_chjs_junc_pmos45b_s_body = (1)
+    sig_delr_chjs_junc_pmos45b_s_body = (0.0333)
+    chjnd_junc_pmos45b_s_body      = (1.1)
+    nom_acj0_junc_pmoshs45_d_body  = (1.33818e-16)
+    nom_delr_acj0_junc_pmoshs45_d_body = (1)
+    sig_delr_acj0_junc_pmoshs45_d_body = (0.0333)
+    aphi_junc_pmoshs45_d_body      = (0.9)
+    pta_junc_pmoshs45_d_body       = (1.288e-03)
+    aexm_junc_pmoshs45_d_body      = (0.5)
+    nom_ajs_junc_pmoshs45_d_body   = (2.04477e-19)
+    nom_delr_ajs_junc_pmoshs45_d_body = (1)
+    sig_delr_ajs_junc_pmoshs45_d_body = (0.0333)
+    ajnd_junc_pmoshs45_d_body      = (1.1)
+    aeg_junc_pmoshs45_d_body       = (1.188)
+    aalphaeg_junc_pmoshs45_d_body  = (459.6e-06)
+    abetaeg_junc_pmoshs45_d_body   = (601.5)
+    axti_junc_pmoshs45_d_body      = (2.342)
+    nom_pcj0_junc_pmoshs45_d_body  = (1.55176e-17)
+    nom_delr_pcj0_junc_pmoshs45_d_body = (1)
+    sig_delr_pcj0_junc_pmoshs45_d_body = (0.0333)
+    ptp_junc_pmoshs45_d_body       = (2.6207e-03)
+    pphi_junc_pmoshs45_d_body      = (0.5)
+    pexm_junc_pmoshs45_d_body      = (0.5)
+    nom_pjs_junc_pmoshs45_d_body   = (1e-23)
+    nom_delr_pjs_junc_pmoshs45_d_body = (1)
+    sig_delr_pjs_junc_pmoshs45_d_body = (0.0333)
+    pjnd_junc_pmoshs45_d_body      = (1.1)
+    peg_junc_pmoshs45_d_body       = (1.188)
+    palphaeg_junc_pmoshs45_d_body  = (459.6e-06)
+    pbetaeg_junc_pmoshs45_d_body   = (601.5)
+    pxti_junc_pmoshs45_d_body      = (2.342)
+    nom_chcj0_junc_pmoshs45_d_body = (2.71264e-16)
+    nom_delr_chcj0_junc_pmoshs45_d_body = (1)
+    sig_delr_chcj0_junc_pmoshs45_d_body = (0.0333)
+    chphi_junc_pmoshs45_d_body     = (0.9)
+    chexm_junc_pmoshs45_d_body     = (0.5)
+    nom_chjs_junc_pmoshs45_d_body  = (1.44646e-19)
+    nom_delr_chjs_junc_pmoshs45_d_body = (1)
+    sig_delr_chjs_junc_pmoshs45_d_body = (0.0333)
+    chjnd_junc_pmoshs45_d_body     = (1.1)
+    nom_acj0_junc_pmoshs45_s_body  = (9.57014e-16)
+    nom_delr_acj0_junc_pmoshs45_s_body = (1)
+    sig_delr_acj0_junc_pmoshs45_s_body = (0.0333)
+    aphi_junc_pmoshs45_s_body      = (0.752983)
+    pta_junc_pmoshs45_s_body       = (1.7778e-03)
+    aexm_junc_pmoshs45_s_body      = (0.377038)
+    nom_ajs_junc_pmoshs45_s_body   = (2.31855e-19)
+    nom_delr_ajs_junc_pmoshs45_s_body = (1)
+    sig_delr_ajs_junc_pmoshs45_s_body = (0.0333)
+    ajnd_junc_pmoshs45_s_body      = (1.1)
+    aeg_junc_pmoshs45_s_body       = (1.188)
+    aalphaeg_junc_pmoshs45_s_body  = (459.6e-06)
+    abetaeg_junc_pmoshs45_s_body   = (601.5)
+    axti_junc_pmoshs45_s_body      = (2.342)
+    nom_pcj0_junc_pmoshs45_s_body  = (1.39469e-16)
+    nom_delr_pcj0_junc_pmoshs45_s_body = (1)
+    sig_delr_pcj0_junc_pmoshs45_s_body = (0.0333)
+    ptp_junc_pmoshs45_s_body       = (1.905e-03)
+    pphi_junc_pmoshs45_s_body      = (0.714805)
+    pexm_junc_pmoshs45_s_body      = (0.294351)
+    nom_pjs_junc_pmoshs45_s_body   = (2.05163e-19)
+    nom_delr_pjs_junc_pmoshs45_s_body = (1)
+    sig_delr_pjs_junc_pmoshs45_s_body = (0.0333)
+    pjnd_junc_pmoshs45_s_body      = (1.1)
+    peg_junc_pmoshs45_s_body       = (1.188)
+    palphaeg_junc_pmoshs45_s_body  = (459.6e-06)
+    pbetaeg_junc_pmoshs45_s_body   = (601.5)
+    pxti_junc_pmoshs45_s_body      = (2.342)
+    nom_chcj0_junc_pmoshs45_s_body = (1.40003e-16)
+    nom_delr_chcj0_junc_pmoshs45_s_body = (1)
+    sig_delr_chcj0_junc_pmoshs45_s_body = (0.0333)
+    chphi_junc_pmoshs45_s_body     = (0.9)
+    chexm_junc_pmoshs45_s_body     = (0.1)
+    nom_chjs_junc_pmoshs45_s_body  = (1e-23)
+    nom_delr_chjs_junc_pmoshs45_s_body = (1)
+    sig_delr_chjs_junc_pmoshs45_s_body = (0.0333)
+    chjnd_junc_pmoshs45_s_body     = (1.01443)
+    nom_acj0_junc_pmoshs45b_d_body = (1.33818e-16)
+    nom_delr_acj0_junc_pmoshs45b_d_body = (1)
+    sig_delr_acj0_junc_pmoshs45b_d_body = (0.0333)
+    aphi_junc_pmoshs45b_d_body     = (0.9)
+    pta_junc_pmoshs45b_d_body      = (1.288e-03)
+    aexm_junc_pmoshs45b_d_body     = (0.5)
+    nom_ajs_junc_pmoshs45b_d_body  = (2.04477e-19)
+    nom_delr_ajs_junc_pmoshs45b_d_body = (1)
+    sig_delr_ajs_junc_pmoshs45b_d_body = (0.0333)
+    ajnd_junc_pmoshs45b_d_body     = (1.1)
+    aeg_junc_pmoshs45b_d_body      = (1.188)
+    aalphaeg_junc_pmoshs45b_d_body = (459.6e-06)
+    abetaeg_junc_pmoshs45b_d_body  = (601.5)
+    axti_junc_pmoshs45b_d_body     = (2.342)
+    nom_pcj0_junc_pmoshs45b_d_body = (1.55176e-17)
+    nom_delr_pcj0_junc_pmoshs45b_d_body = (1)
+    sig_delr_pcj0_junc_pmoshs45b_d_body = (0.0333)
+    ptp_junc_pmoshs45b_d_body      = (2.6207e-03)
+    pphi_junc_pmoshs45b_d_body     = (0.5)
+    pexm_junc_pmoshs45b_d_body     = (0.5)
+    nom_pjs_junc_pmoshs45b_d_body  = (1e-23)
+    nom_delr_pjs_junc_pmoshs45b_d_body = (1)
+    sig_delr_pjs_junc_pmoshs45b_d_body = (0.0333)
+    pjnd_junc_pmoshs45b_d_body     = (1.1)
+    peg_junc_pmoshs45b_d_body      = (1.188)
+    palphaeg_junc_pmoshs45b_d_body = (459.6e-06)
+    pbetaeg_junc_pmoshs45b_d_body  = (601.5)
+    pxti_junc_pmoshs45b_d_body     = (2.342)
+    nom_chcj0_junc_pmoshs45b_d_body = (2.71264e-16)
+    nom_delr_chcj0_junc_pmoshs45b_d_body = (1)
+    sig_delr_chcj0_junc_pmoshs45b_d_body = (0.0333)
+    chphi_junc_pmoshs45b_d_body    = (0.9)
+    chexm_junc_pmoshs45b_d_body    = (0.5)
+    nom_chjs_junc_pmoshs45b_d_body = (1.44646e-19)
+    nom_delr_chjs_junc_pmoshs45b_d_body = (1)
+    sig_delr_chjs_junc_pmoshs45b_d_body = (0.0333)
+    chjnd_junc_pmoshs45b_d_body    = (1.1)
+    nom_acj0_junc_pmoshs45b_s_body = (9.57014e-16)
+    nom_delr_acj0_junc_pmoshs45b_s_body = (1)
+    sig_delr_acj0_junc_pmoshs45b_s_body = (0.0333)
+    aphi_junc_pmoshs45b_s_body     = (0.752983)
+    pta_junc_pmoshs45b_s_body      = (1.7778e-03)
+    aexm_junc_pmoshs45b_s_body     = (0.377038)
+    nom_ajs_junc_pmoshs45b_s_body  = (2.31855e-19)
+    nom_delr_ajs_junc_pmoshs45b_s_body = (1)
+    sig_delr_ajs_junc_pmoshs45b_s_body = (0.0333)
+    ajnd_junc_pmoshs45b_s_body     = (1.1)
+    aeg_junc_pmoshs45b_s_body      = (1.188)
+    aalphaeg_junc_pmoshs45b_s_body = (459.6e-06)
+    abetaeg_junc_pmoshs45b_s_body  = (601.5)
+    axti_junc_pmoshs45b_s_body     = (2.342)
+    nom_pcj0_junc_pmoshs45b_s_body = (1.39469e-16)
+    nom_delr_pcj0_junc_pmoshs45b_s_body = (1)
+    sig_delr_pcj0_junc_pmoshs45b_s_body = (0.0333)
+    ptp_junc_pmoshs45b_s_body      = (1.905e-03)
+    pphi_junc_pmoshs45b_s_body     = (0.714805)
+    pexm_junc_pmoshs45b_s_body     = (0.294351)
+    nom_pjs_junc_pmoshs45b_s_body  = (2.05163e-19)
+    nom_delr_pjs_junc_pmoshs45b_s_body = (1)
+    sig_delr_pjs_junc_pmoshs45b_s_body = (0.0333)
+    pjnd_junc_pmoshs45b_s_body     = (1.1)
+    peg_junc_pmoshs45b_s_body      = (1.188)
+    palphaeg_junc_pmoshs45b_s_body = (459.6e-06)
+    pbetaeg_junc_pmoshs45b_s_body  = (601.5)
+    pxti_junc_pmoshs45b_s_body     = (2.342)
+    nom_chcj0_junc_pmoshs45b_s_body = (1.40003e-16)
+    nom_delr_chcj0_junc_pmoshs45b_s_body = (1)
+    sig_delr_chcj0_junc_pmoshs45b_s_body = (0.0333)
+    chphi_junc_pmoshs45b_s_body    = (0.9)
+    chexm_junc_pmoshs45b_s_body    = (0.1)
+    nom_chjs_junc_pmoshs45b_s_body = (1e-23)
+    nom_delr_chjs_junc_pmoshs45b_s_body = (1)
+    sig_delr_chjs_junc_pmoshs45b_s_body = (0.0333)
+    chjnd_junc_pmoshs45b_s_body    = (1.01443)
+    nom_acj0_junc_nmos90_d_body    = (1.45615e-16)
+    nom_delr_acj0_junc_nmos90_d_body = (1)
+    sig_delr_acj0_junc_nmos90_d_body = (0.0333)
+    aphi_junc_nmos90_d_body        = (0.680675)
+    pta_junc_nmos90_d_body         = (2.0187e-03)
+    aexm_junc_nmos90_d_body        = (0.460499)
+    nom_ajs_junc_nmos90_d_body     = (6.60385e-20)
+    nom_delr_ajs_junc_nmos90_d_body = (1)
+    sig_delr_ajs_junc_nmos90_d_body = (0.0333)
+    ajnd_junc_nmos90_d_body        = (1.1)
+    aeg_junc_nmos90_d_body         = (1.188)
+    aalphaeg_junc_nmos90_d_body    = (459.6e-06)
+    abetaeg_junc_nmos90_d_body     = (601.5)
+    axti_junc_nmos90_d_body        = (2.342)
+    nom_pcj0_junc_nmos90_d_body    = (4.05624e-19)
+    nom_delr_pcj0_junc_nmos90_d_body = (1)
+    sig_delr_pcj0_junc_nmos90_d_body = (0.0333)
+    ptp_junc_nmos90_d_body         = (2.5204e-03)
+    pphi_junc_nmos90_d_body        = (0.530108)
+    pexm_junc_nmos90_d_body        = (0.5)
+    nom_pjs_junc_nmos90_d_body     = (3.45389e-20)
+    nom_delr_pjs_junc_nmos90_d_body = (1)
+    sig_delr_pjs_junc_nmos90_d_body = (0.0333)
+    pjnd_junc_nmos90_d_body        = (1.1)
+    peg_junc_nmos90_d_body         = (1.188)
+    palphaeg_junc_nmos90_d_body    = (459.6e-06)
+    pbetaeg_junc_nmos90_d_body     = (601.5)
+    pxti_junc_nmos90_d_body        = (2.342)
+    nom_chcj0_junc_nmos90_d_body   = (1.20141e-16)
+    nom_delr_chcj0_junc_nmos90_d_body = (1)
+    sig_delr_chcj0_junc_nmos90_d_body = (0.0333)
+    chphi_junc_nmos90_d_body       = (0.9)
+    chexm_junc_nmos90_d_body       = (0.301797)
+    nom_chjs_junc_nmos90_d_body    = (3.44433e-19)
+    nom_delr_chjs_junc_nmos90_d_body = (1)
+    sig_delr_chjs_junc_nmos90_d_body = (0.0333)
+    chjnd_junc_nmos90_d_body       = (1.1)
+    nom_acj0_junc_nmos90_s_body    = (8.97025e-16)
+    nom_delr_acj0_junc_nmos90_s_body = (1)
+    sig_delr_acj0_junc_nmos90_s_body = (0.0333)
+    aphi_junc_nmos90_s_body        = (0.703068)
+    pta_junc_nmos90_s_body         = (1.9441e-03)
+    aexm_junc_nmos90_s_body        = (0.309542)
+    nom_ajs_junc_nmos90_s_body     = (1.90124e-19)
+    nom_delr_ajs_junc_nmos90_s_body = (1)
+    sig_delr_ajs_junc_nmos90_s_body = (0.0333)
+    ajnd_junc_nmos90_s_body        = (1.06764)
+    aeg_junc_nmos90_s_body         = (1.188)
+    aalphaeg_junc_nmos90_s_body    = (459.6e-06)
+    abetaeg_junc_nmos90_s_body     = (601.5)
+    axti_junc_nmos90_s_body        = (2.342)
+    nom_pcj0_junc_nmos90_s_body    = (8.59117e-17)
+    nom_delr_pcj0_junc_nmos90_s_body = (1)
+    sig_delr_pcj0_junc_nmos90_s_body = (0.0333)
+    ptp_junc_nmos90_s_body         = (2.6207e-03)
+    pphi_junc_nmos90_s_body        = (0.5)
+    pexm_junc_nmos90_s_body        = (0.5)
+    nom_pjs_junc_nmos90_s_body     = (2.96691e-19)
+    nom_delr_pjs_junc_nmos90_s_body = (1)
+    sig_delr_pjs_junc_nmos90_s_body = (0.0333)
+    pjnd_junc_nmos90_s_body        = (1.06764)
+    peg_junc_nmos90_s_body         = (1.188)
+    palphaeg_junc_nmos90_s_body    = (459.6e-06)
+    pbetaeg_junc_nmos90_s_body     = (601.5)
+    pxti_junc_nmos90_s_body        = (2.342)
+    nom_chcj0_junc_nmos90_s_body   = (1.63315e-16)
+    nom_delr_chcj0_junc_nmos90_s_body = (1)
+    sig_delr_chcj0_junc_nmos90_s_body = (0.0333)
+    chphi_junc_nmos90_s_body       = (0.9)
+    chexm_junc_nmos90_s_body       = (0.193272)
+    nom_chjs_junc_nmos90_s_body    = (5.57098e-19)
+    nom_delr_chjs_junc_nmos90_s_body = (1)
+    sig_delr_chjs_junc_nmos90_s_body = (0.0333)
+    chjnd_junc_nmos90_s_body       = (1.06764)
+    nom_acj0_junc_nmos90b_d_body   = (1.45615e-16)
+    nom_delr_acj0_junc_nmos90b_d_body = (1)
+    sig_delr_acj0_junc_nmos90b_d_body = (0.0333)
+    aphi_junc_nmos90b_d_body       = (0.680675)
+    pta_junc_nmos90b_d_body        = (2.0187e-03)
+    aexm_junc_nmos90b_d_body       = (0.460499)
+    nom_ajs_junc_nmos90b_d_body    = (6.60385e-20)
+    nom_delr_ajs_junc_nmos90b_d_body = (1)
+    sig_delr_ajs_junc_nmos90b_d_body = (0.0333)
+    ajnd_junc_nmos90b_d_body       = (1.1)
+    aeg_junc_nmos90b_d_body        = (1.188)
+    aalphaeg_junc_nmos90b_d_body   = (459.6e-06)
+    abetaeg_junc_nmos90b_d_body    = (601.5)
+    axti_junc_nmos90b_d_body       = (2.342)
+    nom_pcj0_junc_nmos90b_d_body   = (4.05624e-19)
+    nom_delr_pcj0_junc_nmos90b_d_body = (1)
+    sig_delr_pcj0_junc_nmos90b_d_body = (0.0333)
+    ptp_junc_nmos90b_d_body        = (2.5204e-03)
+    pphi_junc_nmos90b_d_body       = (0.530108)
+    pexm_junc_nmos90b_d_body       = (0.5)
+    nom_pjs_junc_nmos90b_d_body    = (3.45389e-20)
+    nom_delr_pjs_junc_nmos90b_d_body = (1)
+    sig_delr_pjs_junc_nmos90b_d_body = (0.0333)
+    pjnd_junc_nmos90b_d_body       = (1.1)
+    peg_junc_nmos90b_d_body        = (1.188)
+    palphaeg_junc_nmos90b_d_body   = (459.6e-06)
+    pbetaeg_junc_nmos90b_d_body    = (601.5)
+    pxti_junc_nmos90b_d_body       = (2.342)
+    nom_chcj0_junc_nmos90b_d_body  = (1.20141e-16)
+    nom_delr_chcj0_junc_nmos90b_d_body = (1)
+    sig_delr_chcj0_junc_nmos90b_d_body = (0.0333)
+    chphi_junc_nmos90b_d_body      = (0.9)
+    chexm_junc_nmos90b_d_body      = (0.301797)
+    nom_chjs_junc_nmos90b_d_body   = (3.44433e-19)
+    nom_delr_chjs_junc_nmos90b_d_body = (1)
+    sig_delr_chjs_junc_nmos90b_d_body = (0.0333)
+    chjnd_junc_nmos90b_d_body      = (1.1)
+    nom_acj0_junc_nmos90b_s_body   = (8.97025e-16)
+    nom_delr_acj0_junc_nmos90b_s_body = (1)
+    sig_delr_acj0_junc_nmos90b_s_body = (0.0333)
+    aphi_junc_nmos90b_s_body       = (0.703068)
+    pta_junc_nmos90b_s_body        = (1.9441e-03)
+    aexm_junc_nmos90b_s_body       = (0.309542)
+    nom_ajs_junc_nmos90b_s_body    = (1.90124e-19)
+    nom_delr_ajs_junc_nmos90b_s_body = (1)
+    sig_delr_ajs_junc_nmos90b_s_body = (0.0333)
+    ajnd_junc_nmos90b_s_body       = (1.06764)
+    aeg_junc_nmos90b_s_body        = (1.188)
+    aalphaeg_junc_nmos90b_s_body   = (459.6e-06)
+    abetaeg_junc_nmos90b_s_body    = (601.5)
+    axti_junc_nmos90b_s_body       = (2.342)
+    nom_pcj0_junc_nmos90b_s_body   = (8.59117e-17)
+    nom_delr_pcj0_junc_nmos90b_s_body = (1)
+    sig_delr_pcj0_junc_nmos90b_s_body = (0.0333)
+    ptp_junc_nmos90b_s_body        = (2.6207e-03)
+    pphi_junc_nmos90b_s_body       = (0.5)
+    pexm_junc_nmos90b_s_body       = (0.5)
+    nom_pjs_junc_nmos90b_s_body    = (2.96691e-19)
+    nom_delr_pjs_junc_nmos90b_s_body = (1)
+    sig_delr_pjs_junc_nmos90b_s_body = (0.0333)
+    pjnd_junc_nmos90b_s_body       = (1.06764)
+    peg_junc_nmos90b_s_body        = (1.188)
+    palphaeg_junc_nmos90b_s_body   = (459.6e-06)
+    pbetaeg_junc_nmos90b_s_body    = (601.5)
+    pxti_junc_nmos90b_s_body       = (2.342)
+    nom_chcj0_junc_nmos90b_s_body  = (1.63315e-16)
+    nom_delr_chcj0_junc_nmos90b_s_body = (1)
+    sig_delr_chcj0_junc_nmos90b_s_body = (0.0333)
+    chphi_junc_nmos90b_s_body      = (0.9)
+    chexm_junc_nmos90b_s_body      = (0.193272)
+    nom_chjs_junc_nmos90b_s_body   = (5.57098e-19)
+    nom_delr_chjs_junc_nmos90b_s_body = (1)
+    sig_delr_chjs_junc_nmos90b_s_body = (0.0333)
+    chjnd_junc_nmos90b_s_body      = (1.06764)
+    nom_acj0_junc_pmos90_d_body    = (1.25174e-16)
+    nom_delr_acj0_junc_pmos90_d_body = (1)
+    sig_delr_acj0_junc_pmos90_d_body = (0.0333)
+    aphi_junc_pmos90_d_body        = (0.594383)
+    pta_junc_pmos90_d_body         = (2.3062e-03)
+    aexm_junc_pmos90_d_body        = (0.435249)
+    nom_ajs_junc_pmos90_d_body     = (1.58368e-19)
+    nom_delr_ajs_junc_pmos90_d_body = (1)
+    sig_delr_ajs_junc_pmos90_d_body = (0.0333)
+    ajnd_junc_pmos90_d_body        = (1.1)
+    aeg_junc_pmos90_d_body         = (1.188)
+    aalphaeg_junc_pmos90_d_body    = (459.6e-06)
+    abetaeg_junc_pmos90_d_body     = (601.5)
+    axti_junc_pmos90_d_body        = (2.342)
+    nom_pcj0_junc_pmos90_d_body    = (2.59412e-16)
+    nom_delr_pcj0_junc_pmos90_d_body = (1)
+    sig_delr_pcj0_junc_pmos90_d_body = (0.0333)
+    ptp_junc_pmos90_d_body         = (2.6207e-03)
+    pphi_junc_pmos90_d_body        = (0.5)
+    pexm_junc_pmos90_d_body        = (0.387779)
+    nom_pjs_junc_pmos90_d_body     = (1e-23)
+    nom_delr_pjs_junc_pmos90_d_body = (1)
+    sig_delr_pjs_junc_pmos90_d_body = (0.0333)
+    pjnd_junc_pmos90_d_body        = (1.1)
+    peg_junc_pmos90_d_body         = (1.188)
+    palphaeg_junc_pmos90_d_body    = (459.6e-06)
+    pbetaeg_junc_pmos90_d_body     = (601.5)
+    pxti_junc_pmos90_d_body        = (2.342)
+    nom_chcj0_junc_pmos90_d_body   = (2.62826e-16)
+    nom_delr_chcj0_junc_pmos90_d_body = (1)
+    sig_delr_chcj0_junc_pmos90_d_body = (0.0333)
+    chphi_junc_pmos90_d_body       = (0.9)
+    chexm_junc_pmos90_d_body       = (0.315152)
+    nom_chjs_junc_pmos90_d_body    = (1.70526e-19)
+    nom_delr_chjs_junc_pmos90_d_body = (1)
+    sig_delr_chjs_junc_pmos90_d_body = (0.0333)
+    chjnd_junc_pmos90_d_body       = (1.1)
+    nom_acj0_junc_pmos90b_d_body   = (1.25174e-16)
+    nom_delr_acj0_junc_pmos90b_d_body = (1)
+    sig_delr_acj0_junc_pmos90b_d_body = (0.0333)
+    aphi_junc_pmos90b_d_body       = (0.594383)
+    pta_junc_pmos90b_d_body        = (2.3062e-03)
+    aexm_junc_pmos90b_d_body       = (0.435249)
+    nom_ajs_junc_pmos90b_d_body    = (1.58368e-19)
+    nom_delr_ajs_junc_pmos90b_d_body = (1)
+    sig_delr_ajs_junc_pmos90b_d_body = (0.0333)
+    ajnd_junc_pmos90b_d_body       = (1.1)
+    aeg_junc_pmos90b_d_body        = (1.188)
+    aalphaeg_junc_pmos90b_d_body   = (459.6e-06)
+    abetaeg_junc_pmos90b_d_body    = (601.5)
+    axti_junc_pmos90b_d_body       = (2.342)
+    nom_pcj0_junc_pmos90b_d_body   = (2.59412e-16)
+    nom_delr_pcj0_junc_pmos90b_d_body = (1)
+    sig_delr_pcj0_junc_pmos90b_d_body = (0.0333)
+    ptp_junc_pmos90b_d_body        = (2.6207e-03)
+    pphi_junc_pmos90b_d_body       = (0.5)
+    pexm_junc_pmos90b_d_body       = (0.387779)
+    nom_pjs_junc_pmos90b_d_body    = (1e-23)
+    nom_delr_pjs_junc_pmos90b_d_body = (1)
+    sig_delr_pjs_junc_pmos90b_d_body = (0.0333)
+    pjnd_junc_pmos90b_d_body       = (1.1)
+    peg_junc_pmos90b_d_body        = (1.188)
+    palphaeg_junc_pmos90b_d_body   = (459.6e-06)
+    pbetaeg_junc_pmos90b_d_body    = (601.5)
+    pxti_junc_pmos90b_d_body       = (2.342)
+    nom_chcj0_junc_pmos90b_d_body  = (2.62826e-16)
+    nom_delr_chcj0_junc_pmos90b_d_body = (1)
+    sig_delr_chcj0_junc_pmos90b_d_body = (0.0333)
+    chphi_junc_pmos90b_d_body      = (0.9)
+    chexm_junc_pmos90b_d_body      = (0.315152)
+    nom_chjs_junc_pmos90b_d_body   = (1.70526e-19)
+    nom_delr_chjs_junc_pmos90b_d_body = (1)
+    sig_delr_chjs_junc_pmos90b_d_body = (0.0333)
+    chjnd_junc_pmos90b_d_body      = (1.1)
+    nom_acj0_junc_pmos90_s_body    = (9.64096e-16)
+    nom_delr_acj0_junc_pmos90_s_body = (1)
+    sig_delr_acj0_junc_pmos90_s_body = (0.0333)
+    aphi_junc_pmos90_s_body        = (0.7)
+    pta_junc_pmos90_s_body         = (1.9543e-03)
+    aexm_junc_pmos90_s_body        = (0.4)
+    nom_ajs_junc_pmos90_s_body     = (7.0341e-20)
+    nom_delr_ajs_junc_pmos90_s_body = (1)
+    sig_delr_ajs_junc_pmos90_s_body = (0.0333)
+    ajnd_junc_pmos90_s_body        = (1.02)
+    aeg_junc_pmos90_s_body         = (1.188)
+    aalphaeg_junc_pmos90_s_body    = (459.6e-06)
+    abetaeg_junc_pmos90_s_body     = (601.5)
+    axti_junc_pmos90_s_body        = (2.342)
+    nom_pcj0_junc_pmos90_s_body    = (3.2655e-16)
+    nom_delr_pcj0_junc_pmos90_s_body = (1)
+    sig_delr_pcj0_junc_pmos90_s_body = (0.0333)
+    ptp_junc_pmos90_s_body         = (1.288e-03)
+    pphi_junc_pmos90_s_body        = (0.9)
+    pexm_junc_pmos90_s_body        = (0.1)
+    nom_pjs_junc_pmos90_s_body     = (1.83451e-19)
+    nom_delr_pjs_junc_pmos90_s_body = (1)
+    sig_delr_pjs_junc_pmos90_s_body = (0.0333)
+    pjnd_junc_pmos90_s_body        = (1.1)
+    peg_junc_pmos90_s_body         = (1.188)
+    palphaeg_junc_pmos90_s_body    = (459.6e-06)
+    pbetaeg_junc_pmos90_s_body     = (601.5)
+    pxti_junc_pmos90_s_body        = (2.342)
+    nom_chcj0_junc_pmos90_s_body   = (1.65026e-16)
+    nom_delr_chcj0_junc_pmos90_s_body = (1)
+    sig_delr_chcj0_junc_pmos90_s_body = (0.0333)
+    chphi_junc_pmos90_s_body       = (0.9)
+    chexm_junc_pmos90_s_body       = (0.5)
+    nom_chjs_junc_pmos90_s_body    = (1e-23)
+    nom_delr_chjs_junc_pmos90_s_body = (1)
+    sig_delr_chjs_junc_pmos90_s_body = (0.0333)
+    chjnd_junc_pmos90_s_body       = (1.1)
+    nom_acj0_junc_pmos90b_s_body   = (9.64096e-16)
+    nom_delr_acj0_junc_pmos90b_s_body = (1)
+    sig_delr_acj0_junc_pmos90b_s_body = (0.0333)
+    aphi_junc_pmos90b_s_body       = (0.7)
+    pta_junc_pmos90b_s_body        = (1.9543e-03)
+    aexm_junc_pmos90b_s_body       = (0.4)
+    nom_ajs_junc_pmos90b_s_body    = (7.0341e-20)
+    nom_delr_ajs_junc_pmos90b_s_body = (1)
+    sig_delr_ajs_junc_pmos90b_s_body = (0.0333)
+    ajnd_junc_pmos90b_s_body       = (1.02)
+    aeg_junc_pmos90b_s_body        = (1.188)
+    aalphaeg_junc_pmos90b_s_body   = (459.6e-06)
+    abetaeg_junc_pmos90b_s_body    = (601.5)
+    axti_junc_pmos90b_s_body       = (2.342)
+    nom_pcj0_junc_pmos90b_s_body   = (3.2655e-16)
+    nom_delr_pcj0_junc_pmos90b_s_body = (1)
+    sig_delr_pcj0_junc_pmos90b_s_body = (0.0333)
+    ptp_junc_pmos90b_s_body        = (1.288e-03)
+    pphi_junc_pmos90b_s_body       = (0.9)
+    pexm_junc_pmos90b_s_body       = (0.1)
+    nom_pjs_junc_pmos90b_s_body    = (1.83451e-19)
+    nom_delr_pjs_junc_pmos90b_s_body = (1)
+    sig_delr_pjs_junc_pmos90b_s_body = (0.0333)
+    pjnd_junc_pmos90b_s_body       = (1.1)
+    peg_junc_pmos90b_s_body        = (1.188)
+    palphaeg_junc_pmos90b_s_body   = (459.6e-06)
+    pbetaeg_junc_pmos90b_s_body    = (601.5)
+    pxti_junc_pmos90b_s_body       = (2.342)
+    nom_chcj0_junc_pmos90b_s_body  = (1.65026e-16)
+    nom_delr_chcj0_junc_pmos90b_s_body = (1)
+    sig_delr_chcj0_junc_pmos90b_s_body = (0.0333)
+    chphi_junc_pmos90b_s_body      = (0.9)
+    chexm_junc_pmos90b_s_body      = (0.5)
+    nom_chjs_junc_pmos90b_s_body   = (1e-23)
+    nom_delr_chjs_junc_pmos90b_s_body = (1)
+    sig_delr_chjs_junc_pmos90b_s_body = (0.0333)
+    chjnd_junc_pmos90b_s_body      = (1.1)
+    nom_acj0_junc_nld5_d_body      = (1.45728e-15)
+    nom_delr_acj0_junc_nld5_d_body = (1)
+    sig_delr_acj0_junc_nld5_d_body = (0.0333)
+    aphi_junc_nld5_d_body          = (0.5)
+    pta_junc_nld5_d_body           = (2.6207e-03)
+    aexm_junc_nld5_d_body          = (0.213799)
+    nom_ajs_junc_nld5_d_body       = (1.0e-23)
+    nom_delr_ajs_junc_nld5_d_body  = (1)
+    sig_delr_ajs_junc_nld5_d_body  = (0.0333)
+    ajnd_junc_nld5_d_body          = (1.0317)
+    aeg_junc_nld5_d_body           = (0.833654)
+    aalphaeg_junc_nld5_d_body      = (0.001)
+    abetaeg_junc_nld5_d_body       = (641.885)
+    axti_junc_nld5_d_body          = (4.5)
+    nom_pcj0_junc_nld5_d_body      = (1e-17)
+    nom_delr_pcj0_junc_nld5_d_body = (1)
+    sig_delr_pcj0_junc_nld5_d_body = (0.0333)
+    ptp_junc_nld5_d_body           = (2.6207e-03)
+    pphi_junc_nld5_d_body          = (0.5)
+    pexm_junc_nld5_d_body          = (0.1)
+    nom_pjs_junc_nld5_d_body       = (1.00e-23)
+    nom_delr_pjs_junc_nld5_d_body  = (1)
+    sig_delr_pjs_junc_nld5_d_body  = (0.0333)
+    pjnd_junc_nld5_d_body          = (1.0317)
+    peg_junc_nld5_d_body           = (0.833654)
+    palphaeg_junc_nld5_d_body      = (0.001)
+    pbetaeg_junc_nld5_d_body       = (641.885)
+    pxti_junc_nld5_d_body          = (4.5)
+    nom_chcj0_junc_nld5_d_body     = (0)
+    nom_delr_chcj0_junc_nld5_d_body = (1)
+    sig_delr_chcj0_junc_nld5_d_body = (0.0333)
+    chphi_junc_nld5_d_body         = (0.7)
+    chexm_junc_nld5_d_body         = (0.3)
+    nom_chjs_junc_nld5_d_body      = (8.5299e-18)
+    nom_delr_chjs_junc_nld5_d_body = (1)
+    sig_delr_chjs_junc_nld5_d_body = (0.0333)
+    chjnd_junc_nld5_d_body         = (1.0317)
+    nom_acj0_junc_nld5_lvt_d_body  = (1.45728e-15)
+    nom_delr_acj0_junc_nld5_lvt_d_body = (1)
+    sig_delr_acj0_junc_nld5_lvt_d_body = (0.0333)
+    aphi_junc_nld5_lvt_d_body      = (0.5)
+    pta_junc_nld5_lvt_d_body       = (2.6207e-03)
+    aexm_junc_nld5_lvt_d_body      = (0.213799)
+    nom_ajs_junc_nld5_lvt_d_body   = (1.0e-23)
+    nom_delr_ajs_junc_nld5_lvt_d_body = (1)
+    sig_delr_ajs_junc_nld5_lvt_d_body = (0.0333)
+    ajnd_junc_nld5_lvt_d_body      = (1.0317)
+    aeg_junc_nld5_lvt_d_body       = (0.833654)
+    aalphaeg_junc_nld5_lvt_d_body  = (0.001)
+    abetaeg_junc_nld5_lvt_d_body   = (641.885)
+    axti_junc_nld5_lvt_d_body      = (4.5)
+    nom_pcj0_junc_nld5_lvt_d_body  = (1e-17)
+    nom_delr_pcj0_junc_nld5_lvt_d_body = (1)
+    sig_delr_pcj0_junc_nld5_lvt_d_body = (0.0333)
+    ptp_junc_nld5_lvt_d_body       = (2.6207e-03)
+    pphi_junc_nld5_lvt_d_body      = (0.5)
+    pexm_junc_nld5_lvt_d_body      = (0.1)
+    nom_pjs_junc_nld5_lvt_d_body   = (1.00e-23)
+    nom_delr_pjs_junc_nld5_lvt_d_body = (1)
+    sig_delr_pjs_junc_nld5_lvt_d_body = (0.0333)
+    pjnd_junc_nld5_lvt_d_body      = (1.0317)
+    peg_junc_nld5_lvt_d_body       = (0.833654)
+    palphaeg_junc_nld5_lvt_d_body  = (0.001)
+    pbetaeg_junc_nld5_lvt_d_body   = (641.885)
+    pxti_junc_nld5_lvt_d_body      = (4.5)
+    nom_chcj0_junc_nld5_lvt_d_body = (0)
+    nom_delr_chcj0_junc_nld5_lvt_d_body = (1)
+    sig_delr_chcj0_junc_nld5_lvt_d_body = (0.0333)
+    chphi_junc_nld5_lvt_d_body     = (0.7)
+    chexm_junc_nld5_lvt_d_body     = (0.3)
+    nom_chjs_junc_nld5_lvt_d_body  = (8.5299e-18)
+    nom_delr_chjs_junc_nld5_lvt_d_body = (1)
+    sig_delr_chjs_junc_nld5_lvt_d_body = (0.0333)
+    chjnd_junc_nld5_lvt_d_body     = (1.0317)
+    nom_acj0_junc_nld10_d_body     = (7.53324e-16)
+    nom_delr_acj0_junc_nld10_d_body = (1)
+    sig_delr_acj0_junc_nld10_d_body = (0.0333)
+    aphi_junc_nld10_d_body         = (0.676343)
+    pta_junc_nld10_d_body          = (2.0332e-03)
+    aexm_junc_nld10_d_body         = (0.415)
+    nom_ajs_junc_nld10_d_body      = (8.26267e-17)
+    nom_delr_ajs_junc_nld10_d_body = (1)
+    sig_delr_ajs_junc_nld10_d_body = (0.0333)
+    ajnd_junc_nld10_d_body         = (0.9928)
+    aeg_junc_nld10_d_body          = (0.56874)
+    aalphaeg_junc_nld10_d_body     = (0.001)
+    abetaeg_junc_nld10_d_body      = (731.379)
+    axti_junc_nld10_d_body         = (5.0)
+    nom_pcj0_junc_nld10_d_body     = (1.38556e-16)
+    nom_delr_pcj0_junc_nld10_d_body = (1)
+    sig_delr_pcj0_junc_nld10_d_body = (0.0333)
+    ptp_junc_nld10_d_body          = (1.288e-03)
+    pphi_junc_nld10_d_body         = (0.9)
+    pexm_junc_nld10_d_body         = (0.37022)
+    nom_pjs_junc_nld10_d_body      = (1.00e-23)
+    nom_delr_pjs_junc_nld10_d_body = (1)
+    sig_delr_pjs_junc_nld10_d_body = (0.0333)
+    pjnd_junc_nld10_d_body         = (0.9928)
+    peg_junc_nld10_d_body          = (0.56874)
+    palphaeg_junc_nld10_d_body     = (0.001)
+    pbetaeg_junc_nld10_d_body      = (731.379)
+    pxti_junc_nld10_d_body         = (5.0)
+    nom_chcj0_junc_nld10_d_body    = (1e-20)
+    nom_delr_chcj0_junc_nld10_d_body = (1)
+    sig_delr_chcj0_junc_nld10_d_body = (0.0333)
+    chphi_junc_nld10_d_body        = (0.5)
+    chexm_junc_nld10_d_body        = (0.5)
+    nom_chjs_junc_nld10_d_body     = (4.28914e-16)
+    nom_delr_chjs_junc_nld10_d_body = (1)
+    sig_delr_chjs_junc_nld10_d_body = (0.0333)
+    chjnd_junc_nld10_d_body        = (0.9928)
+    nom_acj0_junc_nld30_d_body     = (2.37307e-16)
+    nom_delr_acj0_junc_nld30_d_body = (1)
+    sig_delr_acj0_junc_nld30_d_body = (0.0333)
+    aphi_junc_nld30_d_body         = (0.569774)
+    pta_junc_nld30_d_body          = (2.3882e-03)
+    aexm_junc_nld30_d_body         = (0.309938)
+    nom_ajs_junc_nld30_d_body      = (3.19869e-20)
+    nom_delr_ajs_junc_nld30_d_body = (1)
+    sig_delr_ajs_junc_nld30_d_body = (0.0333)
+    ajnd_junc_nld30_d_body         = (1.0016)
+    aeg_junc_nld30_d_body          = (0.600268)
+    aalphaeg_junc_nld30_d_body     = (0.001)
+    abetaeg_junc_nld30_d_body      = (653.859)
+    axti_junc_nld30_d_body         = (4)
+    nom_pcj0_junc_nld30_d_body     = (1.21911e-16)
+    nom_delr_pcj0_junc_nld30_d_body = (1)
+    sig_delr_pcj0_junc_nld30_d_body = (0.0333)
+    ptp_junc_nld30_d_body          = (1.517e-03)
+    pphi_junc_nld30_d_body         = (0.831271)
+    pexm_junc_nld30_d_body         = (0.407526)
+    nom_pjs_junc_nld30_d_body      = (1.00e-23)
+    nom_delr_pjs_junc_nld30_d_body = (1)
+    sig_delr_pjs_junc_nld30_d_body = (0.0333)
+    pjnd_junc_nld30_d_body         = (1.0016)
+    peg_junc_nld30_d_body          = (0.600268)
+    palphaeg_junc_nld30_d_body     = (0.001)
+    pbetaeg_junc_nld30_d_body      = (653.859)
+    pxti_junc_nld30_d_body         = (4)
+    nom_chcj0_junc_nld30_d_body    = (2.30224e-16)
+    nom_delr_chcj0_junc_nld30_d_body = (1)
+    sig_delr_chcj0_junc_nld30_d_body = (0.0333)
+    chphi_junc_nld30_d_body        = (0.5)
+    chexm_junc_nld30_d_body        = (0.5)
+    nom_chjs_junc_nld30_d_body     = (5.80625e-16)
+    nom_delr_chjs_junc_nld30_d_body = (1)
+    sig_delr_chjs_junc_nld30_d_body = (0.0333)
+    chjnd_junc_nld30_d_body        = (1.0016)
+    nom_acj0_junc_nld30b_d_body    = (2.37307e-16)
+    nom_delr_acj0_junc_nld30b_d_body = (1)
+    sig_delr_acj0_junc_nld30b_d_body = (0.0333)
+    aphi_junc_nld30b_d_body        = (0.569774)
+    pta_junc_nld30b_d_body         = (2.3882e-03)
+    aexm_junc_nld30b_d_body        = (0.309938)
+    nom_ajs_junc_nld30b_d_body     = (3.19869e-20)
+    nom_delr_ajs_junc_nld30b_d_body = (1)
+    sig_delr_ajs_junc_nld30b_d_body = (0.0333)
+    ajnd_junc_nld30b_d_body        = (1.0016)
+    aeg_junc_nld30b_d_body         = (0.600268)
+    aalphaeg_junc_nld30b_d_body    = (0.001)
+    abetaeg_junc_nld30b_d_body     = (653.859)
+    axti_junc_nld30b_d_body        = (4)
+    nom_pcj0_junc_nld30b_d_body    = (1.21911e-16)
+    nom_delr_pcj0_junc_nld30b_d_body = (1)
+    sig_delr_pcj0_junc_nld30b_d_body = (0.0333)
+    ptp_junc_nld30b_d_body         = (1.517e-03)
+    pphi_junc_nld30b_d_body        = (0.831271)
+    pexm_junc_nld30b_d_body        = (0.407526)
+    nom_pjs_junc_nld30b_d_body     = (1.00e-23)
+    nom_delr_pjs_junc_nld30b_d_body = (1)
+    sig_delr_pjs_junc_nld30b_d_body = (0.0333)
+    pjnd_junc_nld30b_d_body        = (1.0016)
+    peg_junc_nld30b_d_body         = (0.600268)
+    palphaeg_junc_nld30b_d_body    = (0.001)
+    pbetaeg_junc_nld30b_d_body     = (653.859)
+    pxti_junc_nld30b_d_body        = (4)
+    nom_chcj0_junc_nld30b_d_body   = (2.30224e-16)
+    nom_delr_chcj0_junc_nld30b_d_body = (1)
+    sig_delr_chcj0_junc_nld30b_d_body = (0.0333)
+    chphi_junc_nld30b_d_body       = (0.5)
+    chexm_junc_nld30b_d_body       = (0.5)
+    nom_chjs_junc_nld30b_d_body    = (5.80625e-16)
+    nom_delr_chjs_junc_nld30b_d_body = (1)
+    sig_delr_chjs_junc_nld30b_d_body = (0.0333)
+    chjnd_junc_nld30b_d_body       = (1.0016)
+    nom_acj0_junc_nld45_d_body     = (1.78716e-16)
+    nom_delr_acj0_junc_nld45_d_body = (1)
+    sig_delr_acj0_junc_nld45_d_body = (0.0333)
+    aphi_junc_nld45_d_body         = (0.5)
+    pta_junc_nld45_d_body          = (2.6207e-03)
+    aexm_junc_nld45_d_body         = (0.384848)
+    nom_ajs_junc_nld45_d_body      = (5e-20)
+    nom_delr_ajs_junc_nld45_d_body = (1)
+    sig_delr_ajs_junc_nld45_d_body = (0.0333)
+    ajnd_junc_nld45_d_body         = (1.0171)
+    aeg_junc_nld45_d_body          = (0.599485)
+    aalphaeg_junc_nld45_d_body     = (0.001)
+    abetaeg_junc_nld45_d_body      = (900)
+    axti_junc_nld45_d_body         = (4.9377)
+    nom_pcj0_junc_nld45_d_body     = (3.34603e-16)
+    nom_delr_pcj0_junc_nld45_d_body = (1)
+    sig_delr_pcj0_junc_nld45_d_body = (0.0333)
+    ptp_junc_nld45_d_body          = (2.4288e-03)
+    pphi_junc_nld45_d_body         = (0.557591)
+    pexm_junc_nld45_d_body         = (0.437613)
+    nom_pjs_junc_nld45_d_body      = (7.17e-30)
+    nom_delr_pjs_junc_nld45_d_body = (1)
+    sig_delr_pjs_junc_nld45_d_body = (0.0333)
+    pjnd_junc_nld45_d_body         = (1.0171)
+    peg_junc_nld45_d_body          = (0.599485)
+    palphaeg_junc_nld45_d_body     = (0.001)
+    pbetaeg_junc_nld45_d_body      = (900)
+    pxti_junc_nld45_d_body         = (4.9377)
+    nom_chcj0_junc_nld45_d_body    = (3.24096e-16)
+    nom_delr_chcj0_junc_nld45_d_body = (1)
+    sig_delr_chcj0_junc_nld45_d_body = (0.0333)
+    chphi_junc_nld45_d_body        = (0.532449)
+    chexm_junc_nld45_d_body        = (0.328937)
+    nom_chjs_junc_nld45_d_body     = (5.224e-16)
+    nom_delr_chjs_junc_nld45_d_body = (1)
+    sig_delr_chjs_junc_nld45_d_body = (0.0333)
+    chjnd_junc_nld45_d_body        = (1.0171)
+    nom_acj0_junc_nld45b_d_body    = (1.78716e-16)
+    nom_delr_acj0_junc_nld45b_d_body = (1)
+    sig_delr_acj0_junc_nld45b_d_body = (0.0333)
+    aphi_junc_nld45b_d_body        = (0.5)
+    pta_junc_nld45b_d_body         = (2.6207e-03)
+    aexm_junc_nld45b_d_body        = (0.384848)
+    nom_ajs_junc_nld45b_d_body     = (5e-20)
+    nom_delr_ajs_junc_nld45b_d_body = (1)
+    sig_delr_ajs_junc_nld45b_d_body = (0.0333)
+    ajnd_junc_nld45b_d_body        = (1.0171)
+    aeg_junc_nld45b_d_body         = (0.599485)
+    aalphaeg_junc_nld45b_d_body    = (0.001)
+    abetaeg_junc_nld45b_d_body     = (900)
+    axti_junc_nld45b_d_body        = (4.9377)
+    nom_pcj0_junc_nld45b_d_body    = (3.34603e-16)
+    nom_delr_pcj0_junc_nld45b_d_body = (1)
+    sig_delr_pcj0_junc_nld45b_d_body = (0.0333)
+    ptp_junc_nld45b_d_body         = (2.4288e-03)
+    pphi_junc_nld45b_d_body        = (0.557591)
+    pexm_junc_nld45b_d_body        = (0.437613)
+    nom_pjs_junc_nld45b_d_body     = (7.17e-30)
+    nom_delr_pjs_junc_nld45b_d_body = (1)
+    sig_delr_pjs_junc_nld45b_d_body = (0.0333)
+    pjnd_junc_nld45b_d_body        = (1.0171)
+    peg_junc_nld45b_d_body         = (0.599485)
+    palphaeg_junc_nld45b_d_body    = (0.001)
+    pbetaeg_junc_nld45b_d_body     = (900)
+    pxti_junc_nld45b_d_body        = (4.9377)
+    nom_chcj0_junc_nld45b_d_body   = (3.24096e-16)
+    nom_delr_chcj0_junc_nld45b_d_body = (1)
+    sig_delr_chcj0_junc_nld45b_d_body = (0.0333)
+    chphi_junc_nld45b_d_body       = (0.532449)
+    chexm_junc_nld45b_d_body       = (0.328937)
+    nom_chjs_junc_nld45b_d_body    = (5.224e-16)
+    nom_delr_chjs_junc_nld45b_d_body = (1)
+    sig_delr_chjs_junc_nld45b_d_body = (0.0333)
+    chjnd_junc_nld45b_d_body       = (1.0171)
+    nom_acj0_junc_nld45_he_d_body  = (3.14635e-16)
+    nom_delr_acj0_junc_nld45_he_d_body = (1)
+    sig_delr_acj0_junc_nld45_he_d_body = (0.0333)
+    aphi_junc_nld45_he_d_body      = (0.5)
+    pta_junc_nld45_he_d_body       = (2.6207e-03)
+    aexm_junc_nld45_he_d_body      = (0.350298)
+    nom_ajs_junc_nld45_he_d_body   = (4.82241e-20)
+    nom_delr_ajs_junc_nld45_he_d_body = (1)
+    sig_delr_ajs_junc_nld45_he_d_body = (0.0333)
+    ajnd_junc_nld45_he_d_body      = (0.9827)
+    aeg_junc_nld45_he_d_body       = (0.721367)
+    aalphaeg_junc_nld45_he_d_body  = (0.001)
+    abetaeg_junc_nld45_he_d_body   = (658.631)
+    axti_junc_nld45_he_d_body      = (5)
+    nom_pcj0_junc_nld45_he_d_body  = (1.4671e-16)
+    nom_delr_pcj0_junc_nld45_he_d_body = (1)
+    sig_delr_pcj0_junc_nld45_he_d_body = (0.0333)
+    ptp_junc_nld45_he_d_body       = (2.6207e-03)
+    pphi_junc_nld45_he_d_body      = (0.5)
+    pexm_junc_nld45_he_d_body      = (0.5)
+    nom_pjs_junc_nld45_he_d_body   = (1e-23)
+    nom_delr_pjs_junc_nld45_he_d_body = (1)
+    sig_delr_pjs_junc_nld45_he_d_body = (0.0333)
+    pjnd_junc_nld45_he_d_body      = (0.9827)
+    peg_junc_nld45_he_d_body       = (0.721367)
+    palphaeg_junc_nld45_he_d_body  = (0.001)
+    pbetaeg_junc_nld45_he_d_body   = (658.631)
+    pxti_junc_nld45_he_d_body      = (5)
+    nom_chcj0_junc_nld45_he_d_body = (1e-20)
+    nom_delr_chcj0_junc_nld45_he_d_body = (1)
+    sig_delr_chcj0_junc_nld45_he_d_body = (0.0333)
+    chphi_junc_nld45_he_d_body     = (0.9)
+    chexm_junc_nld45_he_d_body     = (0.1)
+    nom_chjs_junc_nld45_he_d_body  = (2.35851e-17)
+    nom_delr_chjs_junc_nld45_he_d_body = (1)
+    sig_delr_chjs_junc_nld45_he_d_body = (0.0333)
+    chjnd_junc_nld45_he_d_body     = (0.9827)
+    nom_acj0_junc_nld45b_he_d_body = (3.14635e-16)
+    nom_delr_acj0_junc_nld45b_he_d_body = (1)
+    sig_delr_acj0_junc_nld45b_he_d_body = (0.0333)
+    aphi_junc_nld45b_he_d_body     = (0.5)
+    pta_junc_nld45b_he_d_body      = (2.6207e-03)
+    aexm_junc_nld45b_he_d_body     = (0.350298)
+    nom_ajs_junc_nld45b_he_d_body  = (4.82241e-20)
+    nom_delr_ajs_junc_nld45b_he_d_body = (1)
+    sig_delr_ajs_junc_nld45b_he_d_body = (0.0333)
+    ajnd_junc_nld45b_he_d_body     = (0.9827)
+    aeg_junc_nld45b_he_d_body      = (0.721367)
+    aalphaeg_junc_nld45b_he_d_body = (0.001)
+    abetaeg_junc_nld45b_he_d_body  = (658.631)
+    axti_junc_nld45b_he_d_body     = (5)
+    nom_pcj0_junc_nld45b_he_d_body = (1.4671e-16)
+    nom_delr_pcj0_junc_nld45b_he_d_body = (1)
+    sig_delr_pcj0_junc_nld45b_he_d_body = (0.0333)
+    ptp_junc_nld45b_he_d_body      = (2.6207e-03)
+    pphi_junc_nld45b_he_d_body     = (0.5)
+    pexm_junc_nld45b_he_d_body     = (0.5)
+    nom_pjs_junc_nld45b_he_d_body  = (1e-23)
+    nom_delr_pjs_junc_nld45b_he_d_body = (1)
+    sig_delr_pjs_junc_nld45b_he_d_body = (0.0333)
+    pjnd_junc_nld45b_he_d_body     = (0.9827)
+    peg_junc_nld45b_he_d_body      = (0.721367)
+    palphaeg_junc_nld45b_he_d_body = (0.001)
+    pbetaeg_junc_nld45b_he_d_body  = (658.631)
+    pxti_junc_nld45b_he_d_body     = (5)
+    nom_chcj0_junc_nld45b_he_d_body = (1e-20)
+    nom_delr_chcj0_junc_nld45b_he_d_body = (1)
+    sig_delr_chcj0_junc_nld45b_he_d_body = (0.0333)
+    chphi_junc_nld45b_he_d_body    = (0.9)
+    chexm_junc_nld45b_he_d_body    = (0.1)
+    nom_chjs_junc_nld45b_he_d_body = (2.35851e-17)
+    nom_delr_chjs_junc_nld45b_he_d_body = (1)
+    sig_delr_chjs_junc_nld45b_he_d_body = (0.0333)
+    chjnd_junc_nld45b_he_d_body    = (0.9827)
+    nom_acj0_junc_nld45_tlp_d_body = (2.04772e-16)
+    nom_delr_acj0_junc_nld45_tlp_d_body = (1)
+    sig_delr_acj0_junc_nld45_tlp_d_body = (0.0333)
+    aphi_junc_nld45_tlp_d_body     = (0.555122)
+    pta_junc_nld45_tlp_d_body      = (2.437e-03)
+    aexm_junc_nld45_tlp_d_body     = (0.5)
+    nom_ajs_junc_nld45_tlp_d_body  = (1e-30)
+    nom_delr_ajs_junc_nld45_tlp_d_body = (1)
+    sig_delr_ajs_junc_nld45_tlp_d_body = (0.0333)
+    ajnd_junc_nld45_tlp_d_body     = (1.00293)
+    aeg_junc_nld45_tlp_d_body      = (0.835304)
+    aalphaeg_junc_nld45_tlp_d_body = (0.001)
+    abetaeg_junc_nld45_tlp_d_body  = (637.244)
+    axti_junc_nld45_tlp_d_body     = (5)
+    nom_pcj0_junc_nld45_tlp_d_body = (2.70055e-16)
+    nom_delr_pcj0_junc_nld45_tlp_d_body = (1)
+    sig_delr_pcj0_junc_nld45_tlp_d_body = (0.0333)
+    ptp_junc_nld45_tlp_d_body      = (2.5278e-03)
+    pphi_junc_nld45_tlp_d_body     = (0.527884)
+    pexm_junc_nld45_tlp_d_body     = (0.300857)
+    nom_pjs_junc_nld45_tlp_d_body  = (1e-30)
+    nom_delr_pjs_junc_nld45_tlp_d_body = (1)
+    sig_delr_pjs_junc_nld45_tlp_d_body = (0.0333)
+    pjnd_junc_nld45_tlp_d_body     = (1.00293)
+    peg_junc_nld45_tlp_d_body      = (0.835304)
+    palphaeg_junc_nld45_tlp_d_body = (0.001)
+    pbetaeg_junc_nld45_tlp_d_body  = (637.244)
+    pxti_junc_nld45_tlp_d_body     = (5)
+    nom_chcj0_junc_nld45_tlp_d_body = (2.09171e-16)
+    nom_delr_chcj0_junc_nld45_tlp_d_body = (1)
+    sig_delr_chcj0_junc_nld45_tlp_d_body = (0.0333)
+    chphi_junc_nld45_tlp_d_body    = (0.9)
+    chexm_junc_nld45_tlp_d_body    = (0.143126)
+    nom_chjs_junc_nld45_tlp_d_body = (3.86303e-18)
+    nom_delr_chjs_junc_nld45_tlp_d_body = (1)
+    sig_delr_chjs_junc_nld45_tlp_d_body = (0.0333)
+    chjnd_junc_nld45_tlp_d_body    = (1.00293)
+    nom_acj0_junc_nld45b_tlp_d_body = (2.04772e-16)
+    nom_delr_acj0_junc_nld45b_tlp_d_body = (1)
+    sig_delr_acj0_junc_nld45b_tlp_d_body = (0.0333)
+    aphi_junc_nld45b_tlp_d_body    = (0.555122)
+    pta_junc_nld45b_tlp_d_body     = (2.437e-03)
+    aexm_junc_nld45b_tlp_d_body    = (0.5)
+    nom_ajs_junc_nld45b_tlp_d_body = (1e-30)
+    nom_delr_ajs_junc_nld45b_tlp_d_body = (1)
+    sig_delr_ajs_junc_nld45b_tlp_d_body = (0.0333)
+    ajnd_junc_nld45b_tlp_d_body    = (1.00293)
+    aeg_junc_nld45b_tlp_d_body     = (0.835304)
+    aalphaeg_junc_nld45b_tlp_d_body = (0.001)
+    abetaeg_junc_nld45b_tlp_d_body = (637.244)
+    axti_junc_nld45b_tlp_d_body    = (5)
+    nom_pcj0_junc_nld45b_tlp_d_body = (2.70055e-16)
+    nom_delr_pcj0_junc_nld45b_tlp_d_body = (1)
+    sig_delr_pcj0_junc_nld45b_tlp_d_body = (0.0333)
+    ptp_junc_nld45b_tlp_d_body     = (2.5278e-03)
+    pphi_junc_nld45b_tlp_d_body    = (0.527884)
+    pexm_junc_nld45b_tlp_d_body    = (0.300857)
+    nom_pjs_junc_nld45b_tlp_d_body = (1e-30)
+    nom_delr_pjs_junc_nld45b_tlp_d_body = (1)
+    sig_delr_pjs_junc_nld45b_tlp_d_body = (0.0333)
+    pjnd_junc_nld45b_tlp_d_body    = (1.00293)
+    peg_junc_nld45b_tlp_d_body     = (0.835304)
+    palphaeg_junc_nld45b_tlp_d_body = (0.001)
+    pbetaeg_junc_nld45b_tlp_d_body = (637.244)
+    pxti_junc_nld45b_tlp_d_body    = (5)
+    nom_chcj0_junc_nld45b_tlp_d_body = (2.09171e-16)
+    nom_delr_chcj0_junc_nld45b_tlp_d_body = (1)
+    sig_delr_chcj0_junc_nld45b_tlp_d_body = (0.0333)
+    chphi_junc_nld45b_tlp_d_body   = (0.9)
+    chexm_junc_nld45b_tlp_d_body   = (0.143126)
+    nom_chjs_junc_nld45b_tlp_d_body = (3.86303e-18)
+    nom_delr_chjs_junc_nld45b_tlp_d_body = (1)
+    sig_delr_chjs_junc_nld45b_tlp_d_body = (0.0333)
+    chjnd_junc_nld45b_tlp_d_body   = (1.00293)
+    nom_acj0_junc_nld65_d_body     = (1.82021e-16)
+    nom_delr_acj0_junc_nld65_d_body = (1)
+    sig_delr_acj0_junc_nld65_d_body = (0.0333)
+    aphi_junc_nld65_d_body         = (0.50609)
+    pta_junc_nld65_d_body          = (2.6004e-03)
+    aexm_junc_nld65_d_body         = (0.403327)
+    nom_ajs_junc_nld65_d_body      = (1.91012e-20)
+    nom_delr_ajs_junc_nld65_d_body = (1)
+    sig_delr_ajs_junc_nld65_d_body = (0.0333)
+    ajnd_junc_nld65_d_body         = (0.983949)
+    aeg_junc_nld65_d_body          = (0.719925)
+    aalphaeg_junc_nld65_d_body     = (0.001)
+    abetaeg_junc_nld65_d_body      = (630.385)
+    axti_junc_nld65_d_body         = (5)
+    nom_pcj0_junc_nld65_d_body     = (2.29215e-16)
+    nom_delr_pcj0_junc_nld65_d_body = (1)
+    sig_delr_pcj0_junc_nld65_d_body = (0.0333)
+    ptp_junc_nld65_d_body          = (1.7477e-03)
+    pphi_junc_nld65_d_body         = (0.762029)
+    pexm_junc_nld65_d_body         = (0.5)
+    nom_pjs_junc_nld65_d_body      = (8.63905e-23)
+    nom_delr_pjs_junc_nld65_d_body = (1)
+    sig_delr_pjs_junc_nld65_d_body = (0.0333)
+    pjnd_junc_nld65_d_body         = (0.983949)
+    peg_junc_nld65_d_body          = (0.719925)
+    palphaeg_junc_nld65_d_body     = (0.001)
+    pbetaeg_junc_nld65_d_body      = (630.385)
+    pxti_junc_nld65_d_body         = (5)
+    nom_chcj0_junc_nld65_d_body    = (2.09623e-16)
+    nom_delr_chcj0_junc_nld65_d_body = (1)
+    sig_delr_chcj0_junc_nld65_d_body = (0.0333)
+    chphi_junc_nld65_d_body        = (0.9)
+    chexm_junc_nld65_d_body        = (0.318348)
+    nom_chjs_junc_nld65_d_body     = (2.91512e-17)
+    nom_delr_chjs_junc_nld65_d_body = (1)
+    sig_delr_chjs_junc_nld65_d_body = (0.0333)
+    chjnd_junc_nld65_d_body        = (0.983949)
+    nom_acj0_junc_nld65b_d_body    = (1.82021e-16)
+    nom_delr_acj0_junc_nld65b_d_body = (1)
+    sig_delr_acj0_junc_nld65b_d_body = (0.0333)
+    aphi_junc_nld65b_d_body        = (0.50609)
+    pta_junc_nld65b_d_body         = (2.6004e-03)
+    aexm_junc_nld65b_d_body        = (0.403327)
+    nom_ajs_junc_nld65b_d_body     = (1.91012e-20)
+    nom_delr_ajs_junc_nld65b_d_body = (1)
+    sig_delr_ajs_junc_nld65b_d_body = (0.0333)
+    ajnd_junc_nld65b_d_body        = (0.983949)
+    aeg_junc_nld65b_d_body         = (0.719925)
+    aalphaeg_junc_nld65b_d_body    = (0.001)
+    abetaeg_junc_nld65b_d_body     = (630.385)
+    axti_junc_nld65b_d_body        = (5)
+    nom_pcj0_junc_nld65b_d_body    = (2.29215e-16)
+    nom_delr_pcj0_junc_nld65b_d_body = (1)
+    sig_delr_pcj0_junc_nld65b_d_body = (0.0333)
+    ptp_junc_nld65b_d_body         = (1.7477e-03)
+    pphi_junc_nld65b_d_body        = (0.762029)
+    pexm_junc_nld65b_d_body        = (0.5)
+    nom_pjs_junc_nld65b_d_body     = (8.63905e-23)
+    nom_delr_pjs_junc_nld65b_d_body = (1)
+    sig_delr_pjs_junc_nld65b_d_body = (0.0333)
+    pjnd_junc_nld65b_d_body        = (0.983949)
+    peg_junc_nld65b_d_body         = (0.719925)
+    palphaeg_junc_nld65b_d_body    = (0.001)
+    pbetaeg_junc_nld65b_d_body     = (630.385)
+    pxti_junc_nld65b_d_body        = (5)
+    nom_chcj0_junc_nld65b_d_body   = (2.09623e-16)
+    nom_delr_chcj0_junc_nld65b_d_body = (1)
+    sig_delr_chcj0_junc_nld65b_d_body = (0.0333)
+    chphi_junc_nld65b_d_body       = (0.9)
+    chexm_junc_nld65b_d_body       = (0.318348)
+    nom_chjs_junc_nld65b_d_body    = (2.91512e-17)
+    nom_delr_chjs_junc_nld65b_d_body = (1)
+    sig_delr_chjs_junc_nld65b_d_body = (0.0333)
+    chjnd_junc_nld65b_d_body       = (0.983949)
+    nom_acj0_junc_nld90_d_body     = (1.6757e-16)
+    nom_delr_acj0_junc_nld90_d_body = (1)
+    sig_delr_acj0_junc_nld90_d_body = (0.0333)
+    aphi_junc_nld90_d_body         = (0.62417)
+    pta_junc_nld90_d_body          = (2.207e-03)
+    aexm_junc_nld90_d_body         = (0.43269)
+    nom_ajs_junc_nld90_d_body      = (5.22113e-21)
+    nom_delr_ajs_junc_nld90_d_body = (1)
+    sig_delr_ajs_junc_nld90_d_body = (0.0333)
+    ajnd_junc_nld90_d_body         = (0.9937)
+    aeg_junc_nld90_d_body          = (0.856024)
+    aalphaeg_junc_nld90_d_body     = (0.0010036)
+    abetaeg_junc_nld90_d_body      = (638.924)
+    axti_junc_nld90_d_body         = (3.99978)
+    nom_pcj0_junc_nld90_d_body     = (1.9683e-16)
+    nom_delr_pcj0_junc_nld90_d_body = (1)
+    sig_delr_pcj0_junc_nld90_d_body = (0.0333)
+    ptp_junc_nld90_d_body          = (2.1321e-03)
+    pphi_junc_nld90_d_body         = (0.646661)
+    pexm_junc_nld90_d_body         = (0.5)
+    nom_pjs_junc_nld90_d_body      = (5.33899e-23)
+    nom_delr_pjs_junc_nld90_d_body = (1)
+    sig_delr_pjs_junc_nld90_d_body = (0.0333)
+    pjnd_junc_nld90_d_body         = (0.9937)
+    peg_junc_nld90_d_body          = (0.856024)
+    palphaeg_junc_nld90_d_body     = (0.0010036)
+    pbetaeg_junc_nld90_d_body      = (638.924)
+    pxti_junc_nld90_d_body         = (3.99978)
+    nom_chcj0_junc_nld90_d_body    = (1.8532e-16)
+    nom_delr_chcj0_junc_nld90_d_body = (1)
+    sig_delr_chcj0_junc_nld90_d_body = (0.0333)
+    chphi_junc_nld90_d_body        = (0.5)
+    chexm_junc_nld90_d_body        = (0.195599)
+    nom_chjs_junc_nld90_d_body     = (2.72119e-18)
+    nom_delr_chjs_junc_nld90_d_body = (1)
+    sig_delr_chjs_junc_nld90_d_body = (0.0333)
+    chjnd_junc_nld90_d_body        = (0.9937)
+    nom_acj0_junc_nld90b_d_body    = (1.6757e-16)
+    nom_delr_acj0_junc_nld90b_d_body = (1)
+    sig_delr_acj0_junc_nld90b_d_body = (0.0333)
+    aphi_junc_nld90b_d_body        = (0.62417)
+    pta_junc_nld90b_d_body         = (2.207e-03)
+    aexm_junc_nld90b_d_body        = (0.43269)
+    nom_ajs_junc_nld90b_d_body     = (5.22113e-21)
+    nom_delr_ajs_junc_nld90b_d_body = (1)
+    sig_delr_ajs_junc_nld90b_d_body = (0.0333)
+    ajnd_junc_nld90b_d_body        = (0.9937)
+    aeg_junc_nld90b_d_body         = (0.856024)
+    aalphaeg_junc_nld90b_d_body    = (0.0010036)
+    abetaeg_junc_nld90b_d_body     = (638.924)
+    axti_junc_nld90b_d_body        = (3.99978)
+    nom_pcj0_junc_nld90b_d_body    = (1.9683e-16)
+    nom_delr_pcj0_junc_nld90b_d_body = (1)
+    sig_delr_pcj0_junc_nld90b_d_body = (0.0333)
+    ptp_junc_nld90b_d_body         = (2.1321e-03)
+    pphi_junc_nld90b_d_body        = (0.646661)
+    pexm_junc_nld90b_d_body        = (0.5)
+    nom_pjs_junc_nld90b_d_body     = (5.33899e-23)
+    nom_delr_pjs_junc_nld90b_d_body = (1)
+    sig_delr_pjs_junc_nld90b_d_body = (0.0333)
+    pjnd_junc_nld90b_d_body        = (0.9937)
+    peg_junc_nld90b_d_body         = (0.856024)
+    palphaeg_junc_nld90b_d_body    = (0.0010036)
+    pbetaeg_junc_nld90b_d_body     = (638.924)
+    pxti_junc_nld90b_d_body        = (3.99978)
+    nom_chcj0_junc_nld90b_d_body   = (1.8532e-16)
+    nom_delr_chcj0_junc_nld90b_d_body = (1)
+    sig_delr_chcj0_junc_nld90b_d_body = (0.0333)
+    chphi_junc_nld90b_d_body       = (0.5)
+    chexm_junc_nld90b_d_body       = (0.195599)
+    nom_chjs_junc_nld90b_d_body    = (2.72119e-18)
+    nom_delr_chjs_junc_nld90b_d_body = (1)
+    sig_delr_chjs_junc_nld90b_d_body = (0.0333)
+    chjnd_junc_nld90b_d_body       = (0.9937)
+    nom_acj0_junc_pld5_d_body      = (8.36884e-16)
+    nom_delr_acj0_junc_pld5_d_body = (1)
+    sig_delr_acj0_junc_pld5_d_body = (0.0333)
+    aphi_junc_pld5_d_body          = (0.541576)
+    pta_junc_pld5_d_body           = (2.4822e-03)
+    aexm_junc_pld5_d_body          = (0.5)
+    nom_ajs_junc_pld5_d_body       = (8.95049e-22)
+    nom_delr_ajs_junc_pld5_d_body  = (1)
+    sig_delr_ajs_junc_pld5_d_body  = (0.0333)
+    ajnd_junc_pld5_d_body          = (1.04514)
+    aeg_junc_pld5_d_body           = (0.7)
+    aalphaeg_junc_pld5_d_body      = (0.000127415)
+    abetaeg_junc_pld5_d_body       = (800)
+    axti_junc_pld5_d_body          = (0.6)
+    nom_pcj0_junc_pld5_d_body      = (2.79982e-16)
+    nom_delr_pcj0_junc_pld5_d_body = (1)
+    sig_delr_pcj0_junc_pld5_d_body = (0.0333)
+    ptp_junc_pld5_d_body           = (1.288e-03)
+    pphi_junc_pld5_d_body          = (0.9)
+    pexm_junc_pld5_d_body          = (0.127994)
+    nom_pjs_junc_pld5_d_body       = (9.57513e-15)
+    nom_delr_pjs_junc_pld5_d_body  = (1)
+    sig_delr_pjs_junc_pld5_d_body  = (0.0333)
+    pjnd_junc_pld5_d_body          = (1.04514)
+    peg_junc_pld5_d_body           = (0.7)
+    palphaeg_junc_pld5_d_body      = (0.000127415)
+    pbetaeg_junc_pld5_d_body       = (800)
+    pxti_junc_pld5_d_body          = (0.6)
+    nom_chcj0_junc_pld5_d_body     = (0)
+    nom_delr_chcj0_junc_pld5_d_body = (1)
+    sig_delr_chcj0_junc_pld5_d_body = (0.0333)
+    chphi_junc_pld5_d_body         = (0.9)
+    chexm_junc_pld5_d_body         = (0.1000)
+    nom_chjs_junc_pld5_d_body      = (0)
+    nom_delr_chjs_junc_pld5_d_body = (1)
+    sig_delr_chjs_junc_pld5_d_body = (0.0333)
+    chjnd_junc_pld5_d_body         = (1.0472)
+    nom_acj0_junc_pld10_d_body     = (3.6826e-17)
+    nom_delr_acj0_junc_pld10_d_body = (1)
+    sig_delr_acj0_junc_pld10_d_body = (0.0333)
+    aphi_junc_pld10_d_body         = (0.5000)
+    pta_junc_pld10_d_body          = (2.6207e-03)
+    aexm_junc_pld10_d_body         = (0.5000)
+    nom_ajs_junc_pld10_d_body      = (1.0e-23)
+    nom_delr_ajs_junc_pld10_d_body = (1)
+    sig_delr_ajs_junc_pld10_d_body = (0.0333)
+    ajnd_junc_pld10_d_body         = (1.01347)
+    aeg_junc_pld10_d_body          = (0.723408)
+    aalphaeg_junc_pld10_d_body     = (0.00080922)
+    abetaeg_junc_pld10_d_body      = (237.312)
+    axti_junc_pld10_d_body         = (1.085)
+    nom_pcj0_junc_pld10_d_body     = (5.8759e-16)
+    nom_delr_pcj0_junc_pld10_d_body = (1)
+    sig_delr_pcj0_junc_pld10_d_body = (0.0333)
+    ptp_junc_pld10_d_body          = (2.5311e-03)
+    pphi_junc_pld10_d_body         = (0.5269)
+    pexm_junc_pld10_d_body         = (0.2271)
+    nom_pjs_junc_pld10_d_body      = (1.00e-23)
+    nom_delr_pjs_junc_pld10_d_body = (1)
+    sig_delr_pjs_junc_pld10_d_body = (0.0333)
+    pjnd_junc_pld10_d_body         = (1.01347)
+    peg_junc_pld10_d_body          = (0.723408)
+    palphaeg_junc_pld10_d_body     = (0.00080922)
+    pbetaeg_junc_pld10_d_body      = (237.312)
+    pxti_junc_pld10_d_body         = (1.085)
+    nom_chcj0_junc_pld10_d_body    = (7.2679e-16)
+    nom_delr_chcj0_junc_pld10_d_body = (1)
+    sig_delr_chcj0_junc_pld10_d_body = (0.0333)
+    chphi_junc_pld10_d_body        = (0.5000)
+    chexm_junc_pld10_d_body        = (0.2931)
+    nom_chjs_junc_pld10_d_body     = (7.017e-16)
+    nom_delr_chjs_junc_pld10_d_body = (1)
+    sig_delr_chjs_junc_pld10_d_body = (0.0333)
+    chjnd_junc_pld10_d_body        = (1.01347)
+    nom_cj0_junc_pld10b_d_body     = (1)
+    nom_delr_cj0_junc_pld10b_d_body = (1)
+    sig_delr_cj0_junc_pld10b_d_body = (0.0333)
+    nom_js_junc_pld10b_d_body      = (1)
+    nom_delr_js_junc_pld10b_d_body = (1)
+    sig_delr_js_junc_pld10b_d_body = (0.0333)
+    nom_acj0_junc_pld30_d_body     = (4.5642e-16)
+    nom_delr_acj0_junc_pld30_d_body = (1)
+    sig_delr_acj0_junc_pld30_d_body = (0.0333)
+    aphi_junc_pld30_d_body         = (0.5756)
+    pta_junc_pld30_d_body          = (2.3688e-03)
+    aexm_junc_pld30_d_body         = (0.3878)
+    nom_ajs_junc_pld30_d_body      = (8.07e-16)
+    nom_delr_ajs_junc_pld30_d_body = (1)
+    sig_delr_ajs_junc_pld30_d_body = (0.0333)
+    ajnd_junc_pld30_d_body         = (1.01849)
+    aeg_junc_pld30_d_body          = (0.7)
+    aalphaeg_junc_pld30_d_body     = (1e-05)
+    abetaeg_junc_pld30_d_body      = (450.461)
+    axti_junc_pld30_d_body         = (1.35724)
+    nom_pcj0_junc_pld30_d_body     = (1.0000e-17)
+    nom_delr_pcj0_junc_pld30_d_body = (1)
+    sig_delr_pcj0_junc_pld30_d_body = (0.0333)
+    ptp_junc_pld30_d_body          = (1.288e-03)
+    pphi_junc_pld30_d_body         = (0.9000)
+    pexm_junc_pld30_d_body         = (0.1000)
+    nom_pjs_junc_pld30_d_body      = (1e-23)
+    nom_delr_pjs_junc_pld30_d_body = (1)
+    sig_delr_pjs_junc_pld30_d_body = (0.0333)
+    pjnd_junc_pld30_d_body         = (1.01849)
+    peg_junc_pld30_d_body          = (0.7)
+    palphaeg_junc_pld30_d_body     = (1e-05)
+    pbetaeg_junc_pld30_d_body      = (450.461)
+    pxti_junc_pld30_d_body         = (1.35724)
+    nom_chcj0_junc_pld30_d_body    = (8.8434e-17)
+    nom_delr_chcj0_junc_pld30_d_body = (1)
+    sig_delr_chcj0_junc_pld30_d_body = (0.0333)
+    chphi_junc_pld30_d_body        = (0.5000)
+    chexm_junc_pld30_d_body        = (0.5000)
+    nom_chjs_junc_pld30_d_body     = (6.64e-15)
+    nom_delr_chjs_junc_pld30_d_body = (1)
+    sig_delr_chjs_junc_pld30_d_body = (0.0333)
+    chjnd_junc_pld30_d_body        = (1.01849)
+    nom_acj0_junc_pld30b_d_body    = (4.5642e-16)
+    nom_delr_acj0_junc_pld30b_d_body = (1)
+    sig_delr_acj0_junc_pld30b_d_body = (0.0333)
+    aphi_junc_pld30b_d_body        = (0.5756)
+    pta_junc_pld30b_d_body         = (2.3688e-03)
+    aexm_junc_pld30b_d_body        = (0.3878)
+    nom_ajs_junc_pld30b_d_body     = (8.07e-16)
+    nom_delr_ajs_junc_pld30b_d_body = (1)
+    sig_delr_ajs_junc_pld30b_d_body = (0.0333)
+    ajnd_junc_pld30b_d_body        = (1.01849)
+    aeg_junc_pld30b_d_body         = (0.7)
+    aalphaeg_junc_pld30b_d_body    = (1e-05)
+    abetaeg_junc_pld30b_d_body     = (450.461)
+    axti_junc_pld30b_d_body        = (1.35724)
+    nom_pcj0_junc_pld30b_d_body    = (1.0000e-17)
+    nom_delr_pcj0_junc_pld30b_d_body = (1)
+    sig_delr_pcj0_junc_pld30b_d_body = (0.0333)
+    ptp_junc_pld30b_d_body         = (1.288e-03)
+    pphi_junc_pld30b_d_body        = (0.9000)
+    pexm_junc_pld30b_d_body        = (0.1000)
+    nom_pjs_junc_pld30b_d_body     = (1e-23)
+    nom_delr_pjs_junc_pld30b_d_body = (1)
+    sig_delr_pjs_junc_pld30b_d_body = (0.0333)
+    pjnd_junc_pld30b_d_body        = (1.01849)
+    peg_junc_pld30b_d_body         = (0.7)
+    palphaeg_junc_pld30b_d_body    = (1e-05)
+    pbetaeg_junc_pld30b_d_body     = (450.461)
+    pxti_junc_pld30b_d_body        = (1.35724)
+    nom_chcj0_junc_pld30b_d_body   = (8.8434e-17)
+    nom_delr_chcj0_junc_pld30b_d_body = (1)
+    sig_delr_chcj0_junc_pld30b_d_body = (0.0333)
+    chphi_junc_pld30b_d_body       = (0.5000)
+    chexm_junc_pld30b_d_body       = (0.5000)
+    nom_chjs_junc_pld30b_d_body    = (6.64e-15)
+    nom_delr_chjs_junc_pld30b_d_body = (1)
+    sig_delr_chjs_junc_pld30b_d_body = (0.0333)
+    chjnd_junc_pld30b_d_body       = (1.01849)
+    nom_acj0_junc_pld45_d_body     = (2.68799e-16)
+    nom_delr_acj0_junc_pld45_d_body = (1)
+    sig_delr_acj0_junc_pld45_d_body = (0.0333)
+    aphi_junc_pld45_d_body         = (0.5)
+    pta_junc_pld45_d_body          = (2.6207e-03)
+    aexm_junc_pld45_d_body         = (0.364569)
+    nom_ajs_junc_pld45_d_body      = (5.69439e-21)
+    nom_delr_ajs_junc_pld45_d_body = (1)
+    sig_delr_ajs_junc_pld45_d_body = (0.0333)
+    ajnd_junc_pld45_d_body         = (1.0986)
+    aeg_junc_pld45_d_body          = (0.874244)
+    aalphaeg_junc_pld45_d_body     = (0.001)
+    abetaeg_junc_pld45_d_body      = (639.236)
+    axti_junc_pld45_d_body         = (4)
+    nom_pcj0_junc_pld45_d_body     = (1e-20)
+    nom_delr_pcj0_junc_pld45_d_body = (1)
+    sig_delr_pcj0_junc_pld45_d_body = (0.0333)
+    ptp_junc_pld45_d_body          = (2.6207e-03)
+    pphi_junc_pld45_d_body         = (0.5)
+    pexm_junc_pld45_d_body         = (0.1)
+    nom_pjs_junc_pld45_d_body      = (4.65321e-18)
+    nom_delr_pjs_junc_pld45_d_body = (1)
+    sig_delr_pjs_junc_pld45_d_body = (0.0333)
+    pjnd_junc_pld45_d_body         = (1.0986)
+    peg_junc_pld45_d_body          = (0.874244)
+    palphaeg_junc_pld45_d_body     = (0.001)
+    pbetaeg_junc_pld45_d_body      = (639.236)
+    pxti_junc_pld45_d_body         = (4)
+    nom_chcj0_junc_pld45_d_body    = (4.68134e-17)
+    nom_delr_chcj0_junc_pld45_d_body = (1)
+    sig_delr_chcj0_junc_pld45_d_body = (0.0333)
+    chphi_junc_pld45_d_body        = (0.5)
+    chexm_junc_pld45_d_body        = (0.361127)
+    nom_chjs_junc_pld45_d_body     = (3.049e-17)
+    nom_delr_chjs_junc_pld45_d_body = (1)
+    sig_delr_chjs_junc_pld45_d_body = (0.0333)
+    chjnd_junc_pld45_d_body        = (1.0986)
+    nom_acj0_junc_pld45b_d_body    = (2.68799e-16)
+    nom_delr_acj0_junc_pld45b_d_body = (1)
+    sig_delr_acj0_junc_pld45b_d_body = (0.0333)
+    aphi_junc_pld45b_d_body        = (0.5)
+    pta_junc_pld45b_d_body         = (1.95e-03)
+    aexm_junc_pld45b_d_body        = (0.4)
+    nom_ajs_junc_pld45b_d_body     = (5.69439e-21)
+    nom_delr_ajs_junc_pld45b_d_body = (1)
+    sig_delr_ajs_junc_pld45b_d_body = (0.0333)
+    ajnd_junc_pld45b_d_body        = (1.0986)
+    aeg_junc_pld45b_d_body         = (0.874244)
+    aalphaeg_junc_pld45b_d_body    = (0.001)
+    abetaeg_junc_pld45b_d_body     = (639.236)
+    axti_junc_pld45b_d_body        = (4)
+    nom_pcj0_junc_pld45b_d_body    = (1e-20)
+    nom_delr_pcj0_junc_pld45b_d_body = (1)
+    sig_delr_pcj0_junc_pld45b_d_body = (0.0333)
+    ptp_junc_pld45b_d_body         = (1.95e-03)
+    pphi_junc_pld45b_d_body        = (0.5)
+    pexm_junc_pld45b_d_body        = (0.4)
+    nom_pjs_junc_pld45b_d_body     = (4.65321e-18)
+    nom_delr_pjs_junc_pld45b_d_body = (1)
+    sig_delr_pjs_junc_pld45b_d_body = (0.0333)
+    pjnd_junc_pld45b_d_body        = (1.0986)
+    peg_junc_pld45b_d_body         = (0.874244)
+    palphaeg_junc_pld45b_d_body    = (0.001)
+    pbetaeg_junc_pld45b_d_body     = (639.236)
+    pxti_junc_pld45b_d_body        = (4)
+    nom_chcj0_junc_pld45b_d_body   = (4.68134e-17)
+    nom_delr_chcj0_junc_pld45b_d_body = (1)
+    sig_delr_chcj0_junc_pld45b_d_body = (0.0333)
+    chphi_junc_pld45b_d_body       = (0.5)
+    chexm_junc_pld45b_d_body       = (0.4)
+    nom_chjs_junc_pld45b_d_body    = (3.049e-17)
+    nom_delr_chjs_junc_pld45b_d_body = (1)
+    sig_delr_chjs_junc_pld45b_d_body = (0.0333)
+    chjnd_junc_pld45b_d_body       = (1.0986)
+    nom_acj0_junc_pld90_d_body     = (1.79189e-16)
+    nom_delr_acj0_junc_pld90_d_body = (1)
+    sig_delr_acj0_junc_pld90_d_body = (0.0333)
+    aphi_junc_pld90_d_body         = (0.527106)
+    pta_junc_pld90_d_body          = (2.5304e-03)
+    aexm_junc_pld90_d_body         = (0.383059)
+    nom_ajs_junc_pld90_d_body      = (5.63945e-21)
+    nom_delr_ajs_junc_pld90_d_body = (1)
+    sig_delr_ajs_junc_pld90_d_body = (0.0333)
+    ajnd_junc_pld90_d_body         = (1.01316)
+    aeg_junc_pld90_d_body          = (0.7)
+    aalphaeg_junc_pld90_d_body     = (1e-5)
+    abetaeg_junc_pld90_d_body      = (800)
+    axti_junc_pld90_d_body         = (1.89336)
+    nom_pcj0_junc_pld90_d_body     = (1e-20)
+    nom_delr_pcj0_junc_pld90_d_body = (1)
+    sig_delr_pcj0_junc_pld90_d_body = (0.0333)
+    ptp_junc_pld90_d_body          = (2.6207e-03)
+    pphi_junc_pld90_d_body         = (0.5)
+    pexm_junc_pld90_d_body         = (0.5)
+    nom_pjs_junc_pld90_d_body      = (8.13e-22)
+    nom_delr_pjs_junc_pld90_d_body = (1)
+    sig_delr_pjs_junc_pld90_d_body = (0.0333)
+    pjnd_junc_pld90_d_body         = (1.01316)
+    peg_junc_pld90_d_body          = (0.7)
+    palphaeg_junc_pld90_d_body     = (1e-5)
+    pbetaeg_junc_pld90_d_body      = (800)
+    pxti_junc_pld90_d_body         = (1.89336)
+    nom_chcj0_junc_pld90_d_body    = (7.49131e-17)
+    nom_delr_chcj0_junc_pld90_d_body = (1)
+    sig_delr_chcj0_junc_pld90_d_body = (0.0333)
+    chphi_junc_pld90_d_body        = (0.9)
+    chexm_junc_pld90_d_body        = (0.1)
+    nom_chjs_junc_pld90_d_body     = (2.99285e-15)
+    nom_delr_chjs_junc_pld90_d_body = (1)
+    sig_delr_chjs_junc_pld90_d_body = (0.0333)
+    chjnd_junc_pld90_d_body        = (1.01316)
+    nom_acj0_junc_pld90b_d_body    = (1.79189e-16)
+    nom_delr_acj0_junc_pld90b_d_body = (1)
+    sig_delr_acj0_junc_pld90b_d_body = (0.0333)
+    aphi_junc_pld90b_d_body        = (0.527106)
+    pta_junc_pld90b_d_body         = (2.5304e-03)
+    aexm_junc_pld90b_d_body        = (0.383059)
+    nom_ajs_junc_pld90b_d_body     = (5.63945e-21)
+    nom_delr_ajs_junc_pld90b_d_body = (1)
+    sig_delr_ajs_junc_pld90b_d_body = (0.0333)
+    ajnd_junc_pld90b_d_body        = (1.01316)
+    aeg_junc_pld90b_d_body         = (0.7)
+    aalphaeg_junc_pld90b_d_body    = (1e-5)
+    abetaeg_junc_pld90b_d_body     = (800)
+    axti_junc_pld90b_d_body        = (1.89336)
+    nom_pcj0_junc_pld90b_d_body    = (1e-20)
+    nom_delr_pcj0_junc_pld90b_d_body = (1)
+    sig_delr_pcj0_junc_pld90b_d_body = (0.0333)
+    ptp_junc_pld90b_d_body         = (2.6207e-03)
+    pphi_junc_pld90b_d_body        = (0.5)
+    pexm_junc_pld90b_d_body        = (0.5)
+    nom_pjs_junc_pld90b_d_body     = (8.13e-22)
+    nom_delr_pjs_junc_pld90b_d_body = (1)
+    sig_delr_pjs_junc_pld90b_d_body = (0.0333)
+    pjnd_junc_pld90b_d_body        = (1.01316)
+    peg_junc_pld90b_d_body         = (0.7)
+    palphaeg_junc_pld90b_d_body    = (1e-5)
+    pbetaeg_junc_pld90b_d_body     = (800)
+    pxti_junc_pld90b_d_body        = (1.89336)
+    nom_chcj0_junc_pld90b_d_body   = (7.49131e-17)
+    nom_delr_chcj0_junc_pld90b_d_body = (1)
+    sig_delr_chcj0_junc_pld90b_d_body = (0.0333)
+    chphi_junc_pld90b_d_body       = (0.9)
+    chexm_junc_pld90b_d_body       = (0.1)
+    nom_chjs_junc_pld90b_d_body    = (2.99285e-15)
+    nom_delr_chjs_junc_pld90b_d_body = (1)
+    sig_delr_chjs_junc_pld90b_d_body = (0.0333)
+    chjnd_junc_pld90b_d_body       = (1.01316)
+    nom_cpp_alcap_m4               = (0.07994357090909e-15)
+    nom_cfr_alcap_m4               = (0.093416563927875e-15)
+    nom_delr_cpp_alcap_m4          = (1)
+    sig_delr_cpp_alcap_m4          = (0.03030)
+    nom_delr_cfr_alcap_m4          = (1)
+    sig_delr_cfr_alcap_m4          = (0.01236)
+    nom_cpp_alcap_m3               = (0.027337488275862e-15)
+    nom_cfr_alcap_m3               = (0.065187559809215e-15)
+    nom_delr_cpp_alcap_m3          = (1)
+    sig_delr_cpp_alcap_m3          = (0.03333)
+    nom_delr_cfr_alcap_m3          = (1)
+    sig_delr_cfr_alcap_m3          = (0.01376)
+    nom_cpp_alcap_m2               = (0.015831705531915e-15)
+    nom_cfr_alcap_m2               = (0.05365670269823e-15)
+    nom_delr_cpp_alcap_m2          = (1)
+    sig_delr_cpp_alcap_m2          = (0.03333)
+    nom_delr_cfr_alcap_m2          = (1)
+    sig_delr_cfr_alcap_m2          = (0.01353)
+    nom_cpp_alcap_m1               = (0.01154674031746e-15)
+    nom_cfr_alcap_m1               = (0.0484791996498395e-15)
+    nom_delr_cpp_alcap_m1          = (1)
+    sig_delr_cpp_alcap_m1          = (0.03333)
+    nom_delr_cfr_alcap_m1          = (1)
+    sig_delr_cfr_alcap_m1          = (0.01320)
+    nom_cpp_alcap_ply              = (0.0091877276923077e-15)
+    nom_cfr_alcap_ply              = (0.0451350902498935e-15)
+    nom_delr_cpp_alcap_ply         = (1)
+    sig_delr_cpp_alcap_ply         = (0.03333)
+    nom_delr_cfr_alcap_ply         = (1)
+    sig_delr_cfr_alcap_ply         = (0.01287)
+    nom_cpp_alcap_sd               = (0.0087949733333333e-15)
+    nom_cfr_alcap_sd               = (0.04442660343269e-15)
+    nom_delr_cpp_alcap_sd          = (1)
+    sig_delr_cpp_alcap_sd          = (0.03333)
+    nom_delr_cfr_alcap_sd          = (1)
+    sig_delr_cfr_alcap_sd          = (0.01280)
+    nom_cpp_alcap_fld              = (0.00802871118082e-15)
+    nom_cfr_alcap_fld              = (0.043578346412665e-15)
+    nom_delr_cpp_alcap_fld         = (1)
+    sig_delr_cpp_alcap_fld         = (0.03331)
+    nom_delr_cfr_alcap_fld         = (1)
+    sig_delr_cfr_alcap_fld         = (0.01262)
+    nom_cpp_m4_m3                  = (0.074355892e-15)
+    nom_cfr_m4_m3                  = (0.048866488908545e-15)
+    nom_delr_cpp_m4_m3             = (1)
+    sig_delr_cpp_m4_m3             = (0.03333)
+    nom_delr_cfr_m4_m3             = (1)
+    sig_delr_cfr_m4_m3             = (0.01863)
+    nom_cpp_m4_m2                  = (0.024980928571429e-15)
+    nom_cfr_m4_m2                  = (0.03520055150164e-15)
+    nom_delr_cpp_m4_m2             = (1)
+    sig_delr_cpp_m4_m2             = (0.03333)
+    nom_delr_cfr_m4_m2             = (1)
+    sig_delr_cfr_m4_m2             = (0.01548)
+    nom_cpp_m4_m1                  = (0.015752070909091e-15)
+    nom_cfr_m4_m1                  = (0.031495817539294e-15)
+    nom_delr_cpp_m4_m1             = (1)
+    sig_delr_cpp_m4_m1             = (0.03333)
+    nom_delr_cfr_m4_m1             = (1)
+    sig_delr_cfr_m4_m1             = (0.01361)
+    nom_cpp_m4_ply                 = (0.011666270508475e-15)
+    nom_cfr_m4_ply                 = (0.029458171125458e-15)
+    nom_delr_cpp_m4_ply            = (1)
+    sig_delr_cpp_m4_ply            = (0.03333)
+    nom_delr_cfr_m4_ply            = (1)
+    sig_delr_cfr_m4_ply            = (0.01239)
+    nom_cpp_m4_sd                  = (0.01104179483871e-15)
+    nom_cfr_m4_sd                  = (0.0290161877699435e-15)
+    nom_delr_cpp_m4_sd             = (1)
+    sig_delr_cpp_m4_sd             = (0.03333)
+    nom_delr_cfr_m4_sd             = (1)
+    sig_delr_cfr_m4_sd             = (0.01215)
+    nom_cpp_m4_fld                 = (0.0098621411898662e-15)
+    nom_cfr_m4_fld                 = (0.0286827750316095e-15)
+    nom_delr_cpp_m4_fld            = (1)
+    sig_delr_cpp_m4_fld            = (0.03330)
+    nom_delr_cfr_m4_fld            = (1)
+    sig_delr_cfr_m4_fld            = (0.01162)
+    nom_cpp_m3_m2                  = (0.0672904e-15)
+    nom_cfr_m3_m2                  = (0.04422306688556e-15)
+    nom_delr_cpp_m3_m2             = (1)
+    sig_delr_cpp_m3_m2             = (0.03333)
+    nom_delr_cfr_m3_m2             = (1)
+    sig_delr_cfr_m3_m2             = (0.01863)
+    nom_cpp_m3_m1                  = (0.026105678461538e-15)
+    nom_cfr_m3_m1                  = (0.0347696665106795e-15)
+    nom_delr_cpp_m3_m1             = (1)
+    sig_delr_cpp_m3_m1             = (0.03333)
+    nom_delr_cfr_m3_m1             = (1)
+    sig_delr_cfr_m3_m1             = (0.01576)
+    nom_cpp_m3_ply                 = (0.016515949268292e-15)
+    nom_cfr_m3_ply                 = (0.0312438978945075e-15)
+    nom_delr_cpp_m3_ply            = (1)
+    sig_delr_cpp_m3_ply            = (0.03333)
+    nom_delr_cfr_m3_ply            = (1)
+    sig_delr_cfr_m3_ply            = (0.01393)
+    nom_cpp_m3_sd                  = (0.015293272727273e-15)
+    nom_cfr_m3_sd                  = (0.0305784636303825e-15)
+    nom_delr_cpp_m3_sd             = (1)
+    sig_delr_cpp_m3_sd             = (0.03333)
+    nom_delr_cfr_m3_sd             = (1)
+    sig_delr_cfr_m3_sd             = (0.01361)
+    nom_cpp_m3_fld                 = (0.013116660543437e-15)
+    nom_cfr_m3_fld                 = (0.030054782526698e-15)
+    nom_delr_cpp_m3_fld            = (1)
+    sig_delr_cpp_m3_fld            = (0.03330)
+    nom_delr_cfr_m3_fld            = (1)
+    sig_delr_cfr_m3_fld            = (0.01287)
+    nom_cpp_m2_m1                  = (0.0672904e-15)
+    nom_cfr_m2_m1                  = (0.0412247297136575e-15)
+    nom_delr_cpp_m2_m1             = (1)
+    sig_delr_cpp_m2_m1             = (0.03333)
+    nom_delr_cfr_m2_m1             = (1)
+    sig_delr_cfr_m2_m1             = (0.02111)
+    nom_cpp_m2_ply                 = (0.0269586592e-15)
+    nom_cfr_m2_ply                 = (0.0328181197349055e-15)
+    nom_delr_cpp_m2_ply            = (1)
+    sig_delr_cpp_m2_ply            = (0.03333)
+    nom_delr_cfr_m2_ply            = (1)
+    sig_delr_cfr_m2_ply            = (0.01729)
+    nom_cpp_m2_sd                  = (0.023842557142857e-15)
+    nom_cfr_m2_sd                  = (0.031683461822632e-15)
+    nom_delr_cpp_m2_sd             = (1)
+    sig_delr_cpp_m2_sd             = (0.03333)
+    nom_delr_cfr_m2_sd             = (1)
+    sig_delr_cfr_m2_sd             = (0.01674)
+    nom_cpp_m2_fld                 = (0.018943555432984e-15)
+    nom_cfr_m2_fld                 = (0.030829176016707e-15)
+    nom_delr_cpp_m2_fld            = (1)
+    sig_delr_cpp_m2_fld            = (0.03328)
+    nom_delr_cfr_m2_fld            = (1)
+    sig_delr_cfr_m2_fld            = (0.01544)
+    nom_cpp_m1_ply                 = (0.073252093333333e-15)
+    nom_cfr_m1_ply                 = (0.0415527948956505e-15)
+    nom_delr_cpp_m1_ply            = (1)
+    sig_delr_cpp_m1_ply            = (0.05193)
+    nom_delr_cfr_m1_ply            = (1)
+    sig_delr_cfr_m1_ply            = (0.02607)
+    nom_cpp_m1_sd                  = (0.054083183333333e-15)
+    nom_cfr_m1_sd                  = (0.037882901970884e-15)
+    nom_delr_cpp_m1_sd             = (1)
+    sig_delr_cpp_m1_sd             = (0.03889)
+    nom_delr_cfr_m1_sd             = (1)
+    sig_delr_cfr_m1_sd             = (0.02183)
+    nom_cpp_m1_fld                 = (0.034087462981243e-15)
+    nom_cfr_m1_fld                 = (0.0353301299380335e-15)
+    nom_delr_cpp_m1_fld            = (1)
+    sig_delr_cpp_m1_fld            = (0.03521)
+    nom_delr_cfr_m1_fld            = (1)
+    sig_delr_cfr_m1_fld            = (0.01870)
+    nom_cpp_ply_ply0               = (1.8656642857143e-15)
+    nom_cfr_ply_ply0               = (0.10059238026465e-15)
+    nom_delr_cpp_ply_ply0          = (1)
+    sig_delr_cpp_ply_ply0          = (0.03497)
+    nom_delr_cfr_ply_ply0          = (1)
+    sig_delr_cfr_ply_ply0          = (0.01344)
+    nom_cpp_ply_sd                 = (9.865885714286e-15)
+    nom_cfr_ply_sd                 = (0.1219681640962e-15)
+    nom_delr_cpp_ply_sd            = (1)
+    sig_delr_cpp_ply_sd            = (0.01000)
+    nom_delr_cfr_ply_sd            = (1)
+    sig_delr_cfr_ply_sd            = (0.00567)
+    nom_cpp_ply_fld                = (0.092229166666667e-15)
+    nom_cfr_ply_fld                = (0.042429385448008e-15)
+    nom_delr_cpp_ply_fld           = (1)
+    sig_delr_cpp_ply_fld           = (0.03004)
+    nom_delr_cfr_ply_fld           = (1)
+    sig_delr_cfr_ply_fld           = (0.01209)
+    nom_cpp_ply_sdt                = (2.6460229885057e-15)
+    nom_cfr_ply_sdt                = (0.09405957612185e-15)
+    nom_delr_cpp_ply_sdt           = (1)
+    sig_delr_cpp_ply_sdt           = (0.00996)
+    nom_delr_cfr_ply_sdt           = (1)
+    sig_delr_cfr_ply_sdt           = (0.00700)
+    nom_cpp_ply0_fld               = (0.092229166666666e-15)
+    nom_cfr_ply0_fld               = (0.05168827881925e-15)
+    nom_delr_cpp_ply0_fld          = (1)
+    sig_delr_cpp_ply0_fld          = (0.03004)
+    nom_delr_cfr_ply0_fld          = (1)
+    sig_delr_cfr_ply0_fld          = (0.01033)
+    nom_cpp_ply0_fld_cdp           = (0.092229166666666e-15)
+    nom_cfr_ply0_fld_cdp           = (0.05168827881925e-15)
+    nom_delr_cpp_ply0_fld_cdp      = (1)
+    sig_delr_cpp_ply0_fld_cdp      = (0.03004*1.58)
+    nom_delr_cfr_ply0_fld_cdp      = (1)
+    sig_delr_cfr_ply0_fld_cdp      = (0.01033*1.58)
+    nom_delr_tox                   = (1)
+    sig_delr_tox                   = (1.5/100)
+    nom_dela_dwox                  = (0)
+    sig_dela_dwox                  = (0.05)
+    nom_delr_tox_box               = (1)
+    sig_delr_tox_box               = (0.03333)
+    nom_dela_bv_dz5_10hv           = (0.01084)
+    nom_delr_isr_dz5_10hv          = (1.001)
+    sig_dela_bv_dz5_10hv           = (0.049)
+    sig_delr_isr_dz5_10hv          = (0.4451)
+    nom_dela_bv_dz5b_10hv          = (-0.002758)
+    nom_dela_bv_tc2_dz5b_10hv      = (0)
+    nom_delr_isr_dz5b_10hv         = (1.076)
+    sig_dela_bv_dz5b_10hv          = (0.049)
+    sig_dela_bv_tc2_dz5b_10hv      = (3.0e-8)
+    sig_delr_isr_dz5b_10hv         = (0.4524)
+    nom_delr_isr_drsf45_10hv       = (0.96836803)
+    sig_delr_isr_drsf45_10hv       = (1.0475566)
+    nom_delr_isf_drsf45_10hv       = (0.98240488)
+    sig_delr_isf_drsf45_10hv       = (0.13185376)
+    nom_delr_isr_drsf45b_10hv      = (1.772)
+    sig_delr_isr_drsf45b_10hv      = (1.066)
+    nom_delr_isf_drsf45b_10hv      = (1)
+    sig_delr_isf_drsf45b_10hv      = (0.09368)
+    nom_dela_dw_isf_drsf45b_10hv   = (0.0)
+    sig_dela_dw_isf_drsf45b_10hv   = (0.08116)
+    nom_delr_isr_drsf90_10hv       = (0.49473386)
+    sig_delr_isr_drsf90_10hv       = (0.98729093)
+    nom_delr_isf_drsf90_10hv       = (1.1168814)
+    sig_delr_isf_drsf90_10hv       = (0.1263678)
+    nom_delr_isr_drsf90b_10hv      = (1.452)
+    sig_delr_isr_drsf90b_10hv      = (0.6653)
+    nom_delr_isf_drsf90b_10hv      = (0.9609)
+    sig_delr_isf_drsf90b_10hv      = (0.09976)
+    nom_dela_dw_isf_drsf90b_10hv   = (0.0)
+    sig_dela_dw_isf_drsf90b_10hv   = (0.04142)
+    nom_delr_cpp_cdp_10hv          = (0.9724371)
+    sig_delr_cpp_cdp_10hv          = (0.040868)
+    nom_delr_cfr_cdp_10hv          = (0.9724371)
+    sig_delr_cfr_cdp_10hv          = (0.040868)
+    nom_delr_cpp_cdpf_10hv         = (0.966325625)
+    sig_delr_cpp_cdpf_10hv         = (0.052437658)
+    nom_delr_cfr_cdpf_10hv         = (0.966325625)
+    sig_delr_cfr_cdpf_10hv         = (7.63333e-06)
+    nom_delr_cfrlv_cdpf_10hv       = (0.96020909)
+    sig_delr_cfrlv_cdpf_10hv       = (0.024669912)
+    nom_delr_cpp_cdpf_m1m2m3_10hv  = (0.96*1.01036)
+    sig_delr_cpp_cdpf_m1m2m3_10hv  = (0.034139135*0.988308579)
+    nom_delr_cfr_cdpf_m1m2m3_10hv  = (0.96*1.01036)
+    sig_delr_cfr_cdpf_m1m2m3_10hv  = (0.034139135*0.988308579)
+    nom_delr_cfrlv_cdpf_m1m2m3_10hv = (0.96*1.01036)
+    sig_delr_cfrlv_cdpf_m1m2m3_10hv = (0.036056448*0.988308579)
+    nom_delr_cglv_10hv_tox         = (0.99746055)
+    sig_delr_cglv_10hv_tox         = (0.013681155)
+    nom_dela_cglv_10hv_vfb         = (0)
+    sig_dela_cglv_10hv_vfb         = (0.015)
+    nom_delr_cglv_10hv_ileak       = (1.010274)
+    sig_delr_cglv_10hv_ileak       = (0.851957)
+    nom_delr_tox_cghv_10hv         = (0.9948)
+    sig_delr_tox_cghv_10hv         = (0.0169)
+    nom_dela_vfb_cghv_10hv         = (0)
+    sig_dela_vfb_cghv_10hv         = (0.017)
+    nom_delr_cfrlv_cghvf_10hv      = (0.96628*1.01017)
+    sig_delr_cfrlv_cghvf_10hv      = (0.057714*0.988418079)
+    nom_delr_tox_cghvf_10hv        = (1.001/1.01017)
+    sig_delr_tox_cghvf_10hv        = (0.0169/1.018)
+    nom_dela_vfb_cghvf_10hv        = (0)
+    sig_dela_vfb_cghvf_10hv        = (0.017)
+    nom_delr_cfrlv_cghvf_m1m2m3_10hv = (0.9635*1.00335)
+    sig_delr_cfrlv_cghvf_m1m2m3_10hv = (0.017476*1.006)
+    nom_delr_tox_cghvf_m1m2m3_10hv = (1.037883/1.00335)
+    sig_delr_tox_cghvf_m1m2m3_10hv = (0.016478/1.01)
+    nom_dela_vfb_cghvf_m1m2m3_10hv = (0)
+    sig_dela_vfb_cghvf_m1m2m3_10hv = (0.0195)
+    nom_delr_cfrlv_10hv            = (0.966281882*1.0777702518)
+    sig_delr_cfrlv_10hv            = (0.08079669*0.7638367226159)
+    nom_delr_cfrlv_m1m2m3_10hv     = (0.902756122379601*1.074176160367)
+    sig_delr_cfrlv_m1m2m3_10hv     = (0.0447912639672446*1.5039675875986)
+    nom_delr_cfr45_10hv            = (0.970891*1.062800258675222)
+    sig_delr_cfr45_10hv            = (0.049825610*1.119704641987235)
+    nom_delr_cfr45_m1m2m3_10hv     = (0.908625471591462*1.06719541069176)
+    sig_delr_cfr45_m1m2m3_10hv     = (0.0422912792345794*1.520487845533763)
+    nom_delr_cfr90_10hv            = (0.96310225*1.052631578999326)
+    sig_delr_cfr90_10hv            = (0.04339797*1.212669388372)
+    nom_delr_cfr90_m1m2m3_10hv     = (1*0.9265*1.058975606)
+    sig_delr_cfr90_m1m2m3_10hv     = (0.0429363717641142*0.876*1.6202093378)
+    nom_delr_cfr120_10hv           = (1)
+    sig_delr_cfr120_10hv           = (0.042396234)
+    nom_delr_cfr120_m1m2m3_10hv    = (1)
+    sig_delr_cfr120_m1m2m3_10hv    = (0.041455203)
+    nom_cfr_nld90_s_ply_m1ct       = (1.15e-16)
+    nom_delr_cfr_nld90_s_ply_m1ct  = (1)
+    sig_delr_cfr_nld90_s_ply_m1ct  = (0.0280)
+    nom_cfr_pmoshs45b_s_ply_met    = (5.62e-17)
+    nom_delr_cfr_pmoshs45b_s_ply_met = (1)
+    sig_delr_cfr_pmoshs45b_s_ply_met = (0.0406)
+    nom_cfr_pld5_s_ply_m1ct        = (1.13e-16)
+    nom_delr_cfr_pld5_s_ply_m1ct   = (1)
+    sig_delr_cfr_pld5_s_ply_m1ct   = (0.0194)
+    nom_cfr_nsrampd_s_ply_met      = (1.67e-17)
+    nom_delr_cfr_nsrampd_s_ply_met = (1)
+    sig_delr_cfr_nsrampd_s_ply_met = (0.0599)
+    nom_cfr_psrampu_d_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_psrampu_d_ply_m1ct = (1)
+    sig_delr_cfr_psrampu_d_ply_m1ct = (0.0197)
+    nom_cfr_nld45b_tlp_d_ply_met   = (4.05e-17)
+    nom_delr_cfr_nld45b_tlp_d_ply_met = (1)
+    sig_delr_cfr_nld45b_tlp_d_ply_met = (0.0286)
+    nom_cfr_pmos_ll_s_ply_met      = (1.67e-17)
+    nom_delr_cfr_pmos_ll_s_ply_met = (1)
+    sig_delr_cfr_pmos_ll_s_ply_met = (0.0599)
+    nom_cfr_nmos_ull_s_ply_met     = (1.4e-17)
+    nom_delr_cfr_nmos_ull_s_ply_met = (1)
+    sig_delr_cfr_nmos_ull_s_ply_met = (0.0599)
+    nom_cfr_pmos_ana_s_ply_met     = (3.04e-17)
+    nom_delr_cfr_pmos_ana_s_ply_met = (1)
+    sig_delr_cfr_pmos_ana_s_ply_met = (0.0564)
+    nom_cfr_pld45_d_ply_met        = (3.87e-17)
+    nom_delr_cfr_pld45_d_ply_met   = (1)
+    sig_delr_cfr_pld45_d_ply_met   = (0.0274)
+    nom_cfr_nld65_d_ply_met        = (1.99e-17)
+    nom_delr_cfr_nld65_d_ply_met   = (1)
+    sig_delr_cfr_nld65_d_ply_met   = (0.0151)
+    nom_cfr_pmos45b_d_ply_met      = (1.99e-17)
+    nom_delr_cfr_pmos45b_d_ply_met = (1)
+    sig_delr_cfr_pmos45b_d_ply_met = (0.0168)
+    nom_cfr_pmos_d_ply_m1ct        = (5.12e-17)
+    nom_delr_cfr_pmos_d_ply_m1ct   = (1)
+    sig_delr_cfr_pmos_d_ply_m1ct   = (0.0197)
+    nom_cfr_nld65b_s_ply_met       = (6.53e-17)
+    nom_delr_cfr_nld65b_s_ply_met  = (1)
+    sig_delr_cfr_nld65b_s_ply_met  = (0.0456)
+    nom_cfr_pmos90b_d_ply_met      = (5.69e-18)
+    nom_delr_cfr_pmos90b_d_ply_met = (1)
+    sig_delr_cfr_pmos90b_d_ply_met = (0.0083)
+    nom_cfr_nmos3_zvt_d_ply_m1ct   = (3.61e-17)
+    nom_delr_cfr_nmos3_zvt_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos3_zvt_d_ply_m1ct = (0.0128)
+    nom_cfr_pmoshs45_s_ply_m1ct    = (1.43e-16)
+    nom_delr_cfr_pmoshs45_s_ply_m1ct = (1)
+    sig_delr_cfr_pmoshs45_s_ply_m1ct = (0.0162)
+    nom_cfr_nmos_ull_d_ply_ct      = (6.0e-17)
+    nom_delr_cfr_nmos_ull_d_ply_ct = (1)
+    sig_delr_cfr_nmos_ull_d_ply_ct = (0.0197)
+    nom_cfr_pld10_s_ply_m1ct       = (3.78e-17)
+    nom_delr_cfr_pld10_s_ply_m1ct  = (1)
+    sig_delr_cfr_pld10_s_ply_m1ct  = (0.0294)
+    nom_cfr_pld30b_d_ply_m1ct      = (4.84e-17)
+    nom_delr_cfr_pld30b_d_ply_m1ct = (1)
+    sig_delr_cfr_pld30b_d_ply_m1ct = (0.0271)
+    nom_cfr_nmos90b_s_ply_m1ct     = (1.34e-16)
+    nom_delr_cfr_nmos90b_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos90b_s_ply_m1ct = (0.0152)
+    nom_cfr_nld45b_d_ply_met       = (3.97e-17)
+    nom_delr_cfr_nld45b_d_ply_met  = (1)
+    sig_delr_cfr_nld45b_d_ply_met  = (0.0344)
+    nom_cfr_pmos45_d_ply_met       = (1.99e-17)
+    nom_delr_cfr_pmos45_d_ply_met  = (1)
+    sig_delr_cfr_pmos45_d_ply_met  = (0.0168)
+    nom_cfr_pld45_s_ply_met        = (5.19e-17)
+    nom_delr_cfr_pld45_s_ply_met   = (1)
+    sig_delr_cfr_pld45_s_ply_met   = (0.0365)
+    nom_cfr_nld45b_he_d_ply_met    = (4.14e-17)
+    nom_delr_cfr_nld45b_he_d_ply_met = (1)
+    sig_delr_cfr_nld45b_he_d_ply_met = (0.0331)
+    nom_cfr_nld90b_d_ply_m1ct      = (1.06e-17)
+    nom_delr_cfr_nld90b_d_ply_m1ct = (1)
+    sig_delr_cfr_nld90b_d_ply_m1ct = (0.0063)
+    nom_cfr_pld30_s_ply_met        = (4.07e-17)
+    nom_delr_cfr_pld30_s_ply_met   = (1)
+    sig_delr_cfr_pld30_s_ply_met   = (0.0351)
+    nom_cfr_nmos_ull_s_ply_m1ct    = (5.12e-17)
+    nom_delr_cfr_nmos_ull_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ull_s_ply_m1ct = (0.0197)
+    nom_cfr_nld90_d_ply_met        = (1.04e-17)
+    nom_delr_cfr_nld90_d_ply_met   = (1)
+    sig_delr_cfr_nld90_d_ply_met   = (0.0096)
+    nom_cfr_pmos_s_ply_met         = (1.67e-17)
+    nom_delr_cfr_pmos_s_ply_met    = (1)
+    sig_delr_cfr_pmos_s_ply_met    = (0.0599)
+    nom_cfr_nld45_s_ply_m1ct       = (1.61e-16)
+    nom_delr_cfr_nld45_s_ply_m1ct  = (1)
+    sig_delr_cfr_nld45_s_ply_m1ct  = (0.0273)
+    nom_cfr_pmos_ll_s_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_pmos_ll_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ll_s_ply_m1ct = (0.0197)
+    nom_cfr_nsrampg_s_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nsrampg_s_ply_m1ct = (1)
+    sig_delr_cfr_nsrampg_s_ply_m1ct = (0.0197)
+    nom_cfr_nsrampd_d_ply_met      = (1.67e-17)
+    nom_delr_cfr_nsrampd_d_ply_met = (1)
+    sig_delr_cfr_nsrampd_d_ply_met = (0.0599)
+    nom_cfr_pmos45b_d_ply_m1ct     = (2.19e-17)
+    nom_delr_cfr_pmos45b_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos45b_d_ply_m1ct = (0.0075)
+    nom_cfr_nmos_ull_d_ply_met     = (1.4e-17)
+    nom_delr_cfr_nmos_ull_d_ply_met = (1)
+    sig_delr_cfr_nmos_ull_d_ply_met = (0.0599)
+    nom_cfr_nld10_s_ply_met        = (4.25e-17)
+    nom_delr_cfr_nld10_s_ply_met   = (1)
+    sig_delr_cfr_nld10_s_ply_met   = (0.0473)
+    nom_cfr_psrampu_d_ply_met      = (1.67e-17)
+    nom_delr_cfr_psrampu_d_ply_met = (1)
+    sig_delr_cfr_psrampu_d_ply_met = (0.0599)
+    nom_cfr_pld45b_s_ply_met       = (5.19e-17)
+    nom_delr_cfr_pld45b_s_ply_met  = (1)
+    sig_delr_cfr_pld45b_s_ply_met  = (0.0365)
+    nom_cfr_nsrampg_s_ply_met      = (1.67e-17)
+    nom_delr_cfr_nsrampg_s_ply_met = (1)
+    sig_delr_cfr_nsrampg_s_ply_met = (0.0599)
+    nom_cfr_nld90b_d_ply_met       = (1.04e-17)
+    nom_delr_cfr_nld90b_d_ply_met  = (1)
+    sig_delr_cfr_nld90b_d_ply_met  = (0.0096)
+    nom_cfr_pmos_ll_d_ply_met      = (1.67e-17)
+    nom_delr_cfr_pmos_ll_d_ply_met = (1)
+    sig_delr_cfr_pmos_ll_d_ply_met = (0.0599)
+    nom_cfr_pld45b_s_ply_m1ct      = (5.78e-17)
+    nom_delr_cfr_pld45b_s_ply_m1ct = (1)
+    sig_delr_cfr_pld45b_s_ply_m1ct = (0.0271)
+    nom_cfr_pmoshs45b_s_ply_m1ct   = (1.43e-16)
+    nom_delr_cfr_pmoshs45b_s_ply_m1ct = (1)
+    sig_delr_cfr_pmoshs45b_s_ply_m1ct = (0.0162)
+    nom_cfr_pmos_ull_s_ply_ct_end  = (1.75e-17)
+    nom_delr_cfr_pmos_ull_s_ply_ct_end = (1)
+    sig_delr_cfr_pmos_ull_s_ply_ct_end = (0.0197)
+    nom_cfr_nld10_s_ply_m1ct       = (1.29e-16)
+    nom_delr_cfr_nld10_s_ply_m1ct  = (1)
+    sig_delr_cfr_nld10_s_ply_m1ct  = (0.0164)
+    nom_cfr_nmos5_s_ply_met        = (4.06e-17)
+    nom_delr_cfr_nmos5_s_ply_met   = (1)
+    sig_delr_cfr_nmos5_s_ply_met   = (0.0471)
+    nom_cfr_nld30b_s_ply_m1ct      = (1.59e-16)
+    nom_delr_cfr_nld30b_s_ply_m1ct = (1)
+    sig_delr_cfr_nld30b_s_ply_m1ct = (0.0275)
+    nom_cfr_nld5_s_ply_m1ct        = (6.56e-17)
+    nom_delr_cfr_nld5_s_ply_m1ct   = (1)
+    sig_delr_cfr_nld5_s_ply_m1ct   = (0.0234)
+    nom_cfr_pmos45_d_ply_m1ct      = (2.19e-17)
+    nom_delr_cfr_pmos45_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos45_d_ply_m1ct = (0.0075)
+    nom_cfr_nmos45b_d_ply_met      = (3.14e-17)
+    nom_delr_cfr_nmos45b_d_ply_met = (1)
+    sig_delr_cfr_nmos45b_d_ply_met = (0.0193)
+    nom_cfr_pld90b_d_ply_m1ct      = (4.23e-18)
+    nom_delr_cfr_pld90b_d_ply_m1ct = (1)
+    sig_delr_cfr_pld90b_d_ply_m1ct = (0.0055)
+    nom_cfr_nld45b_he_d_ply_m1ct   = (4.56e-17)
+    nom_delr_cfr_nld45b_he_d_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_he_d_ply_m1ct = (0.0241)
+    nom_cfr_nmos10_s_ply_met       = (4.69e-17)
+    nom_delr_cfr_nmos10_s_ply_met  = (1)
+    sig_delr_cfr_nmos10_s_ply_met  = (0.0438)
+    nom_cfr_nld45b_tlp_s_ply_m1ct  = (1.65e-16)
+    nom_delr_cfr_nld45b_tlp_s_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_tlp_s_ply_m1ct = (0.0271)
+    nom_cfr_pmos_ull_s_ply_ct      = (6.0e-17)
+    nom_delr_cfr_pmos_ull_s_ply_ct = (1)
+    sig_delr_cfr_pmos_ull_s_ply_ct = (0.0197)
+    nom_cfr_nld45_he_s_ply_m1ct    = (1.64e-16)
+    nom_delr_cfr_nld45_he_s_ply_m1ct = (1)
+    sig_delr_cfr_nld45_he_s_ply_m1ct = (0.0273)
+    nom_cfr_nld45_tlp_s_ply_m1ct   = (1.65e-16)
+    nom_delr_cfr_nld45_tlp_s_ply_m1ct = (1)
+    sig_delr_cfr_nld45_tlp_s_ply_m1ct = (0.0271)
+    nom_cfr_nmos_ull_s_ply_met_end = (2.5e-17)
+    nom_delr_cfr_nmos_ull_s_ply_met_end = (1)
+    sig_delr_cfr_nmos_ull_s_ply_met_end = (0.0599)
+    nom_cfr_nsrampd_s_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nsrampd_s_ply_m1ct = (1)
+    sig_delr_cfr_nsrampd_s_ply_m1ct = (0.0197)
+    nom_cfr_psrampu_s_ply_met      = (1.67e-17)
+    nom_delr_cfr_psrampu_s_ply_met = (1)
+    sig_delr_cfr_psrampu_s_ply_met = (0.0599)
+    nom_cfr_nmos90_d_ply_m1ct      = (7.89e-18)
+    nom_delr_cfr_nmos90_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos90_d_ply_m1ct = (0.0076)
+    nom_cfr_pmos_ull_d_ply_met     = (1.4e-17)
+    nom_delr_cfr_pmos_ull_d_ply_met = (1)
+    sig_delr_cfr_pmos_ull_d_ply_met = (0.0599)
+    nom_cfr_pld5_d_ply_m1ct        = (1.13e-16)
+    nom_delr_cfr_pld5_d_ply_m1ct   = (1)
+    sig_delr_cfr_pld5_d_ply_m1ct   = (0.0194)
+    nom_cfr_nld30_d_ply_met        = (4.17e-17)
+    nom_delr_cfr_nld30_d_ply_met   = (1)
+    sig_delr_cfr_nld30_d_ply_met   = (0.0428)
+    nom_cfr_pmos_ana_d_ply_m1ct    = (1.07e-16)
+    nom_delr_cfr_pmos_ana_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ana_d_ply_m1ct = (0.0186)
+    nom_cfr_nld45b_s_ply_met       = (7.84e-17)
+    nom_delr_cfr_nld45b_s_ply_met  = (1)
+    sig_delr_cfr_nld45b_s_ply_met  = (0.0540)
+    nom_cfr_pmoshs45b_d_ply_met    = (2.27e-17)
+    nom_delr_cfr_pmoshs45b_d_ply_met = (1)
+    sig_delr_cfr_pmoshs45b_d_ply_met = (0.0162)
+    nom_cfr_nld65_s_ply_m1ct       = (1.50e-16)
+    nom_delr_cfr_nld65_s_ply_m1ct  = (1)
+    sig_delr_cfr_nld65_s_ply_m1ct  = (0.0203)
+    nom_cfr_nld90_d_ply_m1ct       = (1.06e-17)
+    nom_delr_cfr_nld90_d_ply_m1ct  = (1)
+    sig_delr_cfr_nld90_d_ply_m1ct  = (0.0063)
+    nom_cfr_pmos_d_ply_met         = (1.67e-17)
+    nom_delr_cfr_pmos_d_ply_met    = (1)
+    sig_delr_cfr_pmos_d_ply_met    = (0.0599)
+    nom_cfr_nld5_lvt_s_ply_met     = (3.05e-17)
+    nom_delr_cfr_nld5_lvt_s_ply_met = (1)
+    sig_delr_cfr_nld5_lvt_s_ply_met = (0.0625)
+    nom_cfr_nmos_ll_d_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nmos_ll_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ll_d_ply_m1ct = (0.0197)
+    nom_cfr_nmos10_d_ply_met       = (2.69e-17)
+    nom_delr_cfr_nmos10_d_ply_met  = (1)
+    sig_delr_cfr_nmos10_d_ply_met  = (0.0269)
+    nom_cfr_nmos_s_ply_m1ct        = (5.12e-17)
+    nom_delr_cfr_nmos_s_ply_m1ct   = (1)
+    sig_delr_cfr_nmos_s_ply_m1ct   = (0.0197)
+    nom_cfr_nmos5_d_ply_m1ct       = (1.28e-16)
+    nom_delr_cfr_nmos5_d_ply_m1ct  = (1)
+    sig_delr_cfr_nmos5_d_ply_m1ct  = (0.0168)
+    nom_cfr_nld10_d_ply_met        = (3.96e-17)
+    nom_delr_cfr_nld10_d_ply_met   = (1)
+    sig_delr_cfr_nld10_d_ply_met   = (0.0416)
+    nom_cfr_pmos90b_s_ply_m1ct     = (1.44e-16)
+    nom_delr_cfr_pmos90b_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos90b_s_ply_m1ct = (0.0158)
+    nom_cfr_nld45b_tlp_s_ply_met   = (8.27e-17)
+    nom_delr_cfr_nld45b_tlp_s_ply_met = (1)
+    sig_delr_cfr_nld45b_tlp_s_ply_met = (0.0521)
+    nom_cfr_pld10_d_ply_m1ct       = (9.39e-17)
+    nom_delr_cfr_pld10_d_ply_m1ct  = (1)
+    sig_delr_cfr_pld10_d_ply_m1ct  = (0.0322)
+    nom_cfr_nmos90_s_ply_m1ct      = (1.34e-16)
+    nom_delr_cfr_nmos90_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos90_s_ply_m1ct = (0.0152)
+    nom_cfr_nmos_ana_d_ply_m1ct    = (1.07e-16)
+    nom_delr_cfr_nmos_ana_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ana_d_ply_m1ct = (0.0186)
+    nom_cfr_pmos90_s_ply_met       = (5.71e-17)
+    nom_delr_cfr_pmos90_s_ply_met  = (1)
+    sig_delr_cfr_pmos90_s_ply_met  = (0.0394)
+    nom_cfr_nmos3_zvt_d_ply_met    = (2.76e-17)
+    nom_delr_cfr_nmos3_zvt_d_ply_met = (1)
+    sig_delr_cfr_nmos3_zvt_d_ply_met = (0.0296)
+    nom_cfr_pmos5_d_ply_m1ct       = (1.18e-16)
+    nom_delr_cfr_pmos5_d_ply_m1ct  = (1)
+    sig_delr_cfr_pmos5_d_ply_m1ct  = (0.0168)
+    nom_cfr_pmos_ull_s_ply_m1ct    = (5.12e-17)
+    nom_delr_cfr_pmos_ull_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ull_s_ply_m1ct = (0.0197)
+    nom_cfr_pmos_ana_d_ply_met     = (3.04e-17)
+    nom_delr_cfr_pmos_ana_d_ply_met = (1)
+    sig_delr_cfr_pmos_ana_d_ply_met = (0.0564)
+    nom_cfr_nmos90b_s_ply_met      = (5.51e-17)
+    nom_delr_cfr_nmos90b_s_ply_met = (1)
+    sig_delr_cfr_nmos90b_s_ply_met = (0.0375)
+    nom_cfr_nmos45_s_ply_m1ct      = (1.44e-16)
+    nom_delr_cfr_nmos45_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos45_s_ply_m1ct = (0.0160)
+    nom_cfr_nld45b_he_s_ply_m1ct   = (1.64e-16)
+    nom_delr_cfr_nld45b_he_s_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_he_s_ply_m1ct = (0.0273)
+    nom_cfr_nsrampg_d_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nsrampg_d_ply_m1ct = (1)
+    sig_delr_cfr_nsrampg_d_ply_m1ct = (0.0197)
+    nom_cfr_nld45_d_ply_met        = (3.97e-17)
+    nom_delr_cfr_nld45_d_ply_met   = (1)
+    sig_delr_cfr_nld45_d_ply_met   = (0.0344)
+    nom_cfr_nmos_ll_s_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nmos_ll_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ll_s_ply_m1ct = (0.0197)
+    nom_cfr_pmos_ull_d_ply_met_end = (2.5e-17)
+    nom_delr_cfr_pmos_ull_d_ply_met_end = (1)
+    sig_delr_cfr_pmos_ull_d_ply_met_end = (0.0599)
+    nom_cfr_nld45b_tlp_d_ply_m1ct  = (4.39e-17)
+    nom_delr_cfr_nld45b_tlp_d_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_tlp_d_ply_m1ct = (0.0211)
+    nom_cfr_nmos90_s_ply_met       = (5.51e-17)
+    nom_delr_cfr_nmos90_s_ply_met  = (1)
+    sig_delr_cfr_nmos90_s_ply_met  = (0.0375)
+    nom_cfr_nmos_ana_d_ply_met     = (3.04e-17)
+    nom_delr_cfr_nmos_ana_d_ply_met = (1)
+    sig_delr_cfr_nmos_ana_d_ply_met = (0.0564)
+    nom_cfr_pld10_d_ply_met        = (6.18e-17)
+    nom_delr_cfr_pld10_d_ply_met   = (1)
+    sig_delr_cfr_pld10_d_ply_met   = (0.0567)
+    nom_cfr_nld5_d_ply_m1ct        = (8.24e-17)
+    nom_delr_cfr_nld5_d_ply_m1ct   = (1)
+    sig_delr_cfr_nld5_d_ply_m1ct   = (0.0230)
+    nom_cfr_nmos_s_ply_met         = (1.67e-17)
+    nom_delr_cfr_nmos_s_ply_met    = (1)
+    sig_delr_cfr_nmos_s_ply_met    = (0.0599)
+    nom_cfr_pmos_ull_s_ply_met_end = (2.5e-17)
+    nom_delr_cfr_pmos_ull_s_ply_met_end = (1)
+    sig_delr_cfr_pmos_ull_s_ply_met_end = (0.0599)
+    nom_cfr_pmos90_d_ply_m1ct      = (5.78e-18)
+    nom_delr_cfr_pmos90_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos90_d_ply_m1ct = (0.0066)
+    nom_cfr_nld65b_s_ply_m1ct      = (1.50e-16)
+    nom_delr_cfr_nld65b_s_ply_m1ct = (1)
+    sig_delr_cfr_nld65b_s_ply_m1ct = (0.0203)
+    nom_cfr_nld30b_d_ply_m1ct      = (4.90e-17)
+    nom_delr_cfr_nld30b_d_ply_m1ct = (1)
+    sig_delr_cfr_nld30b_d_ply_m1ct = (0.0292)
+    nom_cfr_nmos_ana_s_ply_m1ct    = (1.07e-16)
+    nom_delr_cfr_nmos_ana_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ana_s_ply_m1ct = (0.0186)
+    nom_cfr_nld65b_d_ply_met       = (1.99e-17)
+    nom_delr_cfr_nld65b_d_ply_met  = (1)
+    sig_delr_cfr_nld65b_d_ply_met  = (0.0151)
+    nom_cfr_nmos_ll_d_ply_met      = (1.67e-17)
+    nom_delr_cfr_nmos_ll_d_ply_met = (1)
+    sig_delr_cfr_nmos_ll_d_ply_met = (0.0599)
+    nom_cfr_pld10_s_ply_met        = (3.42e-17)
+    nom_delr_cfr_pld10_s_ply_met   = (1)
+    sig_delr_cfr_pld10_s_ply_met   = (0.0392)
+    nom_cfr_nmos10_s_ply_m1ct      = (1.34e-16)
+    nom_delr_cfr_nmos10_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos10_s_ply_m1ct = (0.0159)
+    nom_cfr_nmos_ull_s_ply_ct      = (6.0e-17)
+    nom_delr_cfr_nmos_ull_s_ply_ct = (1)
+    sig_delr_cfr_nmos_ull_s_ply_ct = (0.0197)
+    nom_cfr_pmos90b_s_ply_met      = (5.71e-17)
+    nom_delr_cfr_pmos90b_s_ply_met = (1)
+    sig_delr_cfr_pmos90b_s_ply_met = (0.0394)
+    nom_cfr_pld5_s_ply_met         = (2.99e-17)
+    nom_delr_cfr_pld5_s_ply_met    = (1)
+    sig_delr_cfr_pld5_s_ply_met    = (0.0624)
+    nom_cfr_pmos_ull_d_ply_ct_end  = (1.75e-17)
+    nom_delr_cfr_pmos_ull_d_ply_ct_end = (1)
+    sig_delr_cfr_pmos_ull_d_ply_ct_end = (0.0197)
+    nom_cfr_pmos45b_s_ply_m1ct     = (1.43e-16)
+    nom_delr_cfr_pmos45b_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos45b_s_ply_m1ct = (0.0162)
+    nom_cfr_nld90b_s_ply_met       = (7.97e-17)
+    nom_delr_cfr_nld90b_s_ply_met  = (1)
+    sig_delr_cfr_nld90b_s_ply_met  = (0.0465)
+    nom_cfr_pmos45b_s_ply_met      = (5.63e-17)
+    nom_delr_cfr_pmos45b_s_ply_met = (1)
+    sig_delr_cfr_pmos45b_s_ply_met = (0.0406)
+    nom_cfr_pmoshs45b_d_ply_m1ct   = (2.43e-17)
+    nom_delr_cfr_pmoshs45b_d_ply_m1ct = (1)
+    sig_delr_cfr_pmoshs45b_d_ply_m1ct = (0.0097)
+    nom_cfr_pld90_d_ply_met        = (4.07e-18)
+    nom_delr_cfr_pld90_d_ply_met   = (1)
+    sig_delr_cfr_pld90_d_ply_met   = (0.0106)
+    nom_cfr_pmos_ll_d_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_pmos_ll_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ll_d_ply_m1ct = (0.0197)
+    nom_cfr_pmos5_s_ply_met        = (4.00e-17)
+    nom_delr_cfr_pmos5_s_ply_met   = (1)
+    sig_delr_cfr_pmos5_s_ply_met   = (0.0468)
+    nom_cfr_pld90_s_ply_m1ct       = (7.05e-17)
+    nom_delr_cfr_pld90_s_ply_m1ct  = (1)
+    sig_delr_cfr_pld90_s_ply_m1ct  = (0.0278)
+    nom_cfr_nld90_s_ply_met        = (7.97e-17)
+    nom_delr_cfr_nld90_s_ply_met   = (1)
+    sig_delr_cfr_nld90_s_ply_met   = (0.0465)
+    nom_cfr_pmos_ull_s_ply_met     = (1.4e-17)
+    nom_delr_cfr_pmos_ull_s_ply_met = (1)
+    sig_delr_cfr_pmos_ull_s_ply_met = (0.0599)
+    nom_cfr_pmos10_s_ply_met       = (4.70e-17)
+    nom_delr_cfr_pmos10_s_ply_met  = (1)
+    sig_delr_cfr_pmos10_s_ply_met  = (0.0428)
+    nom_cfr_nld65_d_ply_m1ct       = (2.07e-17)
+    nom_delr_cfr_nld65_d_ply_m1ct  = (1)
+    sig_delr_cfr_nld65_d_ply_m1ct  = (0.0108)
+    nom_cfr_nld45b_s_ply_m1ct      = (1.61e-16)
+    nom_delr_cfr_nld45b_s_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_s_ply_m1ct = (0.0273)
+    nom_cfr_pmos90_d_ply_met       = (5.69e-18)
+    nom_delr_cfr_pmos90_d_ply_met  = (1)
+    sig_delr_cfr_pmos90_d_ply_met  = (0.0083)
+    nom_cfr_nld10_d_ply_m1ct       = (4.36e-17)
+    nom_delr_cfr_nld10_d_ply_m1ct  = (1)
+    sig_delr_cfr_nld10_d_ply_m1ct  = (0.0327)
+    nom_cfr_pld5_d_ply_met         = (2.99e-17)
+    nom_delr_cfr_pld5_d_ply_met    = (1)
+    sig_delr_cfr_pld5_d_ply_met    = (0.0624)
+    nom_cfr_pmos5_s_ply_m1ct       = (1.18e-16)
+    nom_delr_cfr_pmos5_s_ply_m1ct  = (1)
+    sig_delr_cfr_pmos5_s_ply_m1ct  = (0.0169)
+    nom_cfr_nld30b_d_ply_met       = (4.17e-17)
+    nom_delr_cfr_nld30b_d_ply_met  = (1)
+    sig_delr_cfr_nld30b_d_ply_met  = (0.0428)
+    nom_cfr_nmos_ll_s_ply_met      = (1.67e-17)
+    nom_delr_cfr_nmos_ll_s_ply_met = (1)
+    sig_delr_cfr_nmos_ll_s_ply_met = (0.0599)
+    nom_cfr_nld90b_s_ply_m1ct      = (1.15e-16)
+    nom_delr_cfr_nld90b_s_ply_m1ct = (1)
+    sig_delr_cfr_nld90b_s_ply_m1ct = (0.0280)
+    nom_cfr_pld45_s_ply_m1ct       = (5.78e-17)
+    nom_delr_cfr_pld45_s_ply_m1ct  = (1)
+    sig_delr_cfr_pld45_s_ply_m1ct  = (0.0271)
+    nom_cfr_nld65b_d_ply_m1ct      = (2.07e-17)
+    nom_delr_cfr_nld65b_d_ply_m1ct = (1)
+    sig_delr_cfr_nld65b_d_ply_m1ct = (0.0108)
+    nom_cfr_nsrampg_d_ply_met      = (1.67e-17)
+    nom_delr_cfr_nsrampg_d_ply_met = (1)
+    sig_delr_cfr_nsrampg_d_ply_met = (0.0599)
+    nom_cfr_nmos90b_d_ply_m1ct     = (7.89e-18)
+    nom_delr_cfr_nmos90b_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos90b_d_ply_m1ct = (0.0076)
+    nom_cfr_nld5_lvt_d_ply_m1ct    = (8.24e-17)
+    nom_delr_cfr_nld5_lvt_d_ply_m1ct = (1)
+    sig_delr_cfr_nld5_lvt_d_ply_m1ct = (0.0230)
+    nom_cfr_pmos10_s_ply_m1ct      = (1.25e-16)
+    nom_delr_cfr_pmos10_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos10_s_ply_m1ct = (0.0162)
+    nom_cfr_nld5_d_ply_met         = (3.30e-17)
+    nom_delr_cfr_nld5_d_ply_met    = (1)
+    sig_delr_cfr_nld5_d_ply_met    = (0.0653)
+    nom_cfr_nld30b_s_ply_met       = (7.65e-17)
+    nom_delr_cfr_nld30b_s_ply_met  = (1)
+    sig_delr_cfr_nld30b_s_ply_met  = (0.0550)
+    nom_cfr_nld65_s_ply_met        = (6.53e-17)
+    nom_delr_cfr_nld65_s_ply_met   = (1)
+    sig_delr_cfr_nld65_s_ply_met   = (0.0456)
+    nom_cfr_nld45_he_d_ply_met     = (4.14e-17)
+    nom_delr_cfr_nld45_he_d_ply_met = (1)
+    sig_delr_cfr_nld45_he_d_ply_met = (0.0331)
+    nom_cfr_pld30_s_ply_m1ct       = (4.96e-17)
+    nom_delr_cfr_pld30_s_ply_m1ct  = (1)
+    sig_delr_cfr_pld30_s_ply_m1ct  = (0.0205)
+    nom_cfr_pld90_d_ply_m1ct       = (4.23e-18)
+    nom_delr_cfr_pld90_d_ply_m1ct  = (1)
+    sig_delr_cfr_pld90_d_ply_m1ct  = (0.0055)
+    nom_cfr_nmos90b_d_ply_met      = (7.80e-18)
+    nom_delr_cfr_nmos90b_d_ply_met = (1)
+    sig_delr_cfr_nmos90b_d_ply_met = (0.0085)
+    nom_cfr_pmos45_s_ply_met       = (5.63e-17)
+    nom_delr_cfr_pmos45_s_ply_met  = (1)
+    sig_delr_cfr_pmos45_s_ply_met  = (0.0406)
+    nom_cfr_pmoshs45_d_ply_m1ct    = (2.43e-17)
+    nom_delr_cfr_pmoshs45_d_ply_m1ct = (1)
+    sig_delr_cfr_pmoshs45_d_ply_m1ct = (0.0097)
+    nom_cfr_nmos_ull_d_ply_m1ct    = (5.12e-17)
+    nom_delr_cfr_nmos_ull_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos_ull_d_ply_m1ct = (0.0197)
+    nom_cfr_pmos5_d_ply_met        = (4.00e-17)
+    nom_delr_cfr_pmos5_d_ply_met   = (1)
+    sig_delr_cfr_pmos5_d_ply_met   = (0.0468)
+    nom_cfr_pld45_d_ply_m1ct       = (4.13e-17)
+    nom_delr_cfr_pld45_d_ply_m1ct  = (1)
+    sig_delr_cfr_pld45_d_ply_m1ct  = (0.0209)
+    nom_cfr_nmos45b_s_ply_met      = (5.73e-17)
+    nom_delr_cfr_nmos45b_s_ply_met = (1)
+    sig_delr_cfr_nmos45b_s_ply_met = (0.0399)
+    nom_cfr_nld45_tlp_d_ply_met    = (4.05e-17)
+    nom_delr_cfr_nld45_tlp_d_ply_met = (1)
+    sig_delr_cfr_nld45_tlp_d_ply_met = (0.0286)
+    nom_cfr_nmos_ull_d_ply_met_end = (2.5e-17)
+    nom_delr_cfr_nmos_ull_d_ply_met_end = (1)
+    sig_delr_cfr_nmos_ull_d_ply_met_end = (0.0599)
+    nom_cfr_nmos45b_d_ply_m1ct     = (3.47e-17)
+    nom_delr_cfr_nmos45b_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos45b_d_ply_m1ct = (0.0111)
+    nom_cfr_nld45_tlp_d_ply_m1ct   = (4.39e-17)
+    nom_delr_cfr_nld45_tlp_d_ply_m1ct = (1)
+    sig_delr_cfr_nld45_tlp_d_ply_m1ct = (0.0211)
+    nom_cfr_pld90_s_ply_met        = (6.23e-17)
+    nom_delr_cfr_pld90_s_ply_met   = (1)
+    sig_delr_cfr_pld90_s_ply_met   = (0.0377)
+    nom_cfr_nld30_d_ply_m1ct       = (4.90e-17)
+    nom_delr_cfr_nld30_d_ply_m1ct  = (1)
+    sig_delr_cfr_nld30_d_ply_m1ct  = (0.0292)
+    nom_cfr_nmos5_d_ply_met        = (4.06e-17)
+    nom_delr_cfr_nmos5_d_ply_met   = (1)
+    sig_delr_cfr_nmos5_d_ply_met   = (0.0485)
+    nom_cfr_nmos3_zvt_s_ply_met    = (2.68e-17)
+    nom_delr_cfr_nmos3_zvt_s_ply_met = (1)
+    sig_delr_cfr_nmos3_zvt_s_ply_met = (0.0275)
+    nom_cfr_nmos_d_ply_met         = (1.67e-17)
+    nom_delr_cfr_nmos_d_ply_met    = (1)
+    sig_delr_cfr_nmos_d_ply_met    = (0.0599)
+    nom_cfr_pld30b_d_ply_met       = (4.41e-17)
+    nom_delr_cfr_pld30b_d_ply_met  = (1)
+    sig_delr_cfr_pld30b_d_ply_met  = (0.0358)
+    nom_cfr_nld30_s_ply_met        = (7.65e-17)
+    nom_delr_cfr_nld30_s_ply_met   = (1)
+    sig_delr_cfr_nld30_s_ply_met   = (0.0550)
+    nom_cfr_pmoshs45_d_ply_met     = (2.27e-17)
+    nom_delr_cfr_pmoshs45_d_ply_met = (1)
+    sig_delr_cfr_pmoshs45_d_ply_met = (0.0162)
+    nom_cfr_nmos5_s_ply_m1ct       = (1.28e-16)
+    nom_delr_cfr_nmos5_s_ply_m1ct  = (1)
+    sig_delr_cfr_nmos5_s_ply_m1ct  = (0.0164)
+    nom_cfr_pmos10_d_ply_met       = (4.93e-17)
+    nom_delr_cfr_pmos10_d_ply_met  = (1)
+    sig_delr_cfr_pmos10_d_ply_met  = (0.0409)
+    nom_cfr_pld30b_s_ply_m1ct      = (4.96e-17)
+    nom_delr_cfr_pld30b_s_ply_m1ct = (1)
+    sig_delr_cfr_pld30b_s_ply_m1ct = (0.0205)
+    nom_cfr_nmos45_s_ply_met       = (5.73e-17)
+    nom_delr_cfr_nmos45_s_ply_met  = (1)
+    sig_delr_cfr_nmos45_s_ply_met  = (0.0399)
+    nom_cfr_pmoshs45_s_ply_met     = (5.62e-17)
+    nom_delr_cfr_pmoshs45_s_ply_met = (1)
+    sig_delr_cfr_pmoshs45_s_ply_met = (0.0406)
+    nom_cfr_nld5_lvt_s_ply_m1ct    = (6.56e-17)
+    nom_delr_cfr_nld5_lvt_s_ply_m1ct = (1)
+    sig_delr_cfr_nld5_lvt_s_ply_m1ct = (0.0234)
+    nom_cfr_pld90b_s_ply_m1ct      = (7.05e-17)
+    nom_delr_cfr_pld90b_s_ply_m1ct = (1)
+    sig_delr_cfr_pld90b_s_ply_m1ct = (0.0278)
+    nom_cfr_pld90b_s_ply_met       = (6.23e-17)
+    nom_delr_cfr_pld90b_s_ply_met  = (1)
+    sig_delr_cfr_pld90b_s_ply_met  = (0.0377)
+    nom_cfr_nmos45_d_ply_met       = (3.14e-17)
+    nom_delr_cfr_nmos45_d_ply_met  = (1)
+    sig_delr_cfr_nmos45_d_ply_met  = (0.0193)
+    nom_cfr_nld5_s_ply_met         = (3.05e-17)
+    nom_delr_cfr_nld5_s_ply_met    = (1)
+    sig_delr_cfr_nld5_s_ply_met    = (0.0625)
+    nom_cfr_pld30_d_ply_met        = (4.41e-17)
+    nom_delr_cfr_pld30_d_ply_met   = (1)
+    sig_delr_cfr_pld30_d_ply_met   = (0.0358)
+    nom_cfr_pmos_s_ply_m1ct        = (5.12e-17)
+    nom_delr_cfr_pmos_s_ply_m1ct   = (1)
+    sig_delr_cfr_pmos_s_ply_m1ct   = (0.0197)
+    nom_cfr_pmos90b_d_ply_m1ct     = (5.78e-18)
+    nom_delr_cfr_pmos90b_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos90b_d_ply_m1ct = (0.0066)
+    nom_cfr_nld5_lvt_d_ply_met     = (3.30e-17)
+    nom_delr_cfr_nld5_lvt_d_ply_met = (1)
+    sig_delr_cfr_nld5_lvt_d_ply_met = (0.0653)
+    nom_cfr_nmos10_d_ply_m1ct      = (3.28e-17)
+    nom_delr_cfr_nmos10_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos10_d_ply_m1ct = (0.0136)
+    nom_cfr_pmos10_d_ply_m1ct      = (7.14e-17)
+    nom_delr_cfr_pmos10_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos10_d_ply_m1ct = (0.0207)
+    nom_cfr_nld30_s_ply_m1ct       = (1.59e-16)
+    nom_delr_cfr_nld30_s_ply_m1ct  = (1)
+    sig_delr_cfr_nld30_s_ply_m1ct  = (0.0275)
+    nom_cfr_pmos_ull_d_ply_ct      = (6.0e-17)
+    nom_delr_cfr_pmos_ull_d_ply_ct = (1)
+    sig_delr_cfr_pmos_ull_d_ply_ct = (0.0197)
+    nom_cfr_nld45_tlp_s_ply_met    = (8.27e-17)
+    nom_delr_cfr_nld45_tlp_s_ply_met = (1)
+    sig_delr_cfr_nld45_tlp_s_ply_met = (0.0521)
+    nom_cfr_nmos45_d_ply_m1ct      = (3.47e-17)
+    nom_delr_cfr_nmos45_d_ply_m1ct = (1)
+    sig_delr_cfr_nmos45_d_ply_m1ct = (0.0111)
+    nom_cfr_nmos_ull_s_ply_ct_end  = (1.75e-17)
+    nom_delr_cfr_nmos_ull_s_ply_ct_end = (1)
+    sig_delr_cfr_nmos_ull_s_ply_ct_end = (0.0197)
+    nom_cfr_pmos45_s_ply_m1ct      = (1.43e-16)
+    nom_delr_cfr_pmos45_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos45_s_ply_m1ct = (0.0162)
+    nom_cfr_pmos_ana_s_ply_m1ct    = (1.07e-16)
+    nom_delr_cfr_pmos_ana_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ana_s_ply_m1ct = (0.0186)
+    nom_cfr_pld30b_s_ply_met       = (4.07e-17)
+    nom_delr_cfr_pld30b_s_ply_met  = (1)
+    sig_delr_cfr_pld30b_s_ply_met  = (0.0351)
+    nom_cfr_pld90b_d_ply_met       = (4.07e-18)
+    nom_delr_cfr_pld90b_d_ply_met  = (1)
+    sig_delr_cfr_pld90b_d_ply_met  = (0.0106)
+    nom_cfr_pld45b_d_ply_m1ct      = (4.13e-17)
+    nom_delr_cfr_pld45b_d_ply_m1ct = (1)
+    sig_delr_cfr_pld45b_d_ply_m1ct = (0.0209)
+    nom_cfr_nld45b_he_s_ply_met    = (8.10e-17)
+    nom_delr_cfr_nld45b_he_s_ply_met = (1)
+    sig_delr_cfr_nld45b_he_s_ply_met = (0.0531)
+    nom_cfr_nld45_s_ply_met        = (7.84e-17)
+    nom_delr_cfr_nld45_s_ply_met   = (1)
+    sig_delr_cfr_nld45_s_ply_met   = (0.0540)
+    nom_cfr_nmos_d_ply_m1ct        = (5.12e-17)
+    nom_delr_cfr_nmos_d_ply_m1ct   = (1)
+    sig_delr_cfr_nmos_d_ply_m1ct   = (0.0197)
+    nom_cfr_pmos_ull_d_ply_m1ct    = (5.12e-17)
+    nom_delr_cfr_pmos_ull_d_ply_m1ct = (1)
+    sig_delr_cfr_pmos_ull_d_ply_m1ct = (0.0197)
+    nom_cfr_pld45b_d_ply_met       = (3.87e-17)
+    nom_delr_cfr_pld45b_d_ply_met  = (1)
+    sig_delr_cfr_pld45b_d_ply_met  = (0.0274)
+    nom_cfr_pmos90_s_ply_m1ct      = (1.44e-16)
+    nom_delr_cfr_pmos90_s_ply_m1ct = (1)
+    sig_delr_cfr_pmos90_s_ply_m1ct = (0.0158)
+    nom_cfr_pld30_d_ply_m1ct       = (4.84e-17)
+    nom_delr_cfr_pld30_d_ply_m1ct  = (1)
+    sig_delr_cfr_pld30_d_ply_m1ct  = (0.0271)
+    nom_cfr_nld45_he_s_ply_met     = (8.10e-17)
+    nom_delr_cfr_nld45_he_s_ply_met = (1)
+    sig_delr_cfr_nld45_he_s_ply_met = (0.0531)
+    nom_cfr_nmos3_zvt_s_ply_m1ct   = (3.42e-17)
+    nom_delr_cfr_nmos3_zvt_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos3_zvt_s_ply_m1ct = (0.0117)
+    nom_cfr_nsrampd_d_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_nsrampd_d_ply_m1ct = (1)
+    sig_delr_cfr_nsrampd_d_ply_m1ct = (0.0197)
+    nom_cfr_nmos90_d_ply_met       = (7.80e-18)
+    nom_delr_cfr_nmos90_d_ply_met  = (1)
+    sig_delr_cfr_nmos90_d_ply_met  = (0.0085)
+    nom_cfr_nmos_ana_s_ply_met     = (3.04e-17)
+    nom_delr_cfr_nmos_ana_s_ply_met = (1)
+    sig_delr_cfr_nmos_ana_s_ply_met = (0.0564)
+    nom_cfr_psrampu_s_ply_m1ct     = (5.12e-17)
+    nom_delr_cfr_psrampu_s_ply_m1ct = (1)
+    sig_delr_cfr_psrampu_s_ply_m1ct = (0.0197)
+    nom_cfr_nmos45b_s_ply_m1ct     = (1.44e-16)
+    nom_delr_cfr_nmos45b_s_ply_m1ct = (1)
+    sig_delr_cfr_nmos45b_s_ply_m1ct = (0.0160)
+    nom_cfr_nld45_he_d_ply_m1ct    = (4.56e-17)
+    nom_delr_cfr_nld45_he_d_ply_m1ct = (1)
+    sig_delr_cfr_nld45_he_d_ply_m1ct = (0.0241)
+    nom_cfr_nld45b_d_ply_m1ct      = (4.39e-17)
+    nom_delr_cfr_nld45b_d_ply_m1ct = (1)
+    sig_delr_cfr_nld45b_d_ply_m1ct = (0.0252)
+    nom_cfr_nld45_d_ply_m1ct       = (4.39e-17)
+    nom_delr_cfr_nld45_d_ply_m1ct  = (1)
+    sig_delr_cfr_nld45_d_ply_m1ct  = (0.0252)
+    nom_cfr_nmos_ull_d_ply_ct_end  = (1.75e-17)
+    nom_delr_cfr_nmos_ull_d_ply_ct_end = (1)
+    sig_delr_cfr_nmos_ull_d_ply_ct_end = (0.0197)
+    cpp_alcap_m4                   = (nom_cpp_alcap_m4*(nom_delr_cpp_alcap_m4*(1+nsig_delr_cpp_alcap_m4*sig_delr_cpp_alcap_m4)))
+    cfr_alcap_m4                   = (nom_cfr_alcap_m4*(nom_delr_cfr_alcap_m4*(1+nsig_delr_cfr_alcap_m4*sig_delr_cfr_alcap_m4)))
+    cpp_alcap_m3                   = (nom_cpp_alcap_m3*(nom_delr_cpp_alcap_m3*(1+nsig_delr_cpp_alcap_m3*sig_delr_cpp_alcap_m3)))
+    cfr_alcap_m3                   = (nom_cfr_alcap_m3*(nom_delr_cfr_alcap_m3*(1+nsig_delr_cfr_alcap_m3*sig_delr_cfr_alcap_m3)))
+    cpp_alcap_m2                   = (nom_cpp_alcap_m2*(nom_delr_cpp_alcap_m2*(1+nsig_delr_cpp_alcap_m2*sig_delr_cpp_alcap_m2)))
+    cfr_alcap_m2                   = (nom_cfr_alcap_m2*(nom_delr_cfr_alcap_m2*(1+nsig_delr_cfr_alcap_m2*sig_delr_cfr_alcap_m2)))
+    cpp_alcap_m1                   = (nom_cpp_alcap_m1*(nom_delr_cpp_alcap_m1*(1+nsig_delr_cpp_alcap_m1*sig_delr_cpp_alcap_m1)))
+    cfr_alcap_m1                   = (nom_cfr_alcap_m1*(nom_delr_cfr_alcap_m1*(1+nsig_delr_cfr_alcap_m1*sig_delr_cfr_alcap_m1)))
+    cpp_alcap_ply                  = (nom_cpp_alcap_ply*(nom_delr_cpp_alcap_ply*(1+nsig_delr_cpp_alcap_ply*sig_delr_cpp_alcap_ply)))
+    cfr_alcap_ply                  = (nom_cfr_alcap_ply*(nom_delr_cfr_alcap_ply*(1+nsig_delr_cfr_alcap_ply*sig_delr_cfr_alcap_ply)))
+    cpp_alcap_sd                   = (nom_cpp_alcap_sd*(nom_delr_cpp_alcap_sd*(1+nsig_delr_cpp_alcap_sd*sig_delr_cpp_alcap_sd)))
+    cfr_alcap_sd                   = (nom_cfr_alcap_sd*(nom_delr_cfr_alcap_sd*(1+nsig_delr_cfr_alcap_sd*sig_delr_cfr_alcap_sd)))
+    cpp_alcap_fld                  = (nom_cpp_alcap_fld*(nom_delr_cpp_alcap_fld*(1+nsig_delr_cpp_alcap_fld*sig_delr_cpp_alcap_fld)))
+    cfr_alcap_fld                  = (nom_cfr_alcap_fld*(nom_delr_cfr_alcap_fld*(1+nsig_delr_cfr_alcap_fld*sig_delr_cfr_alcap_fld)))
+    cpp_m4_m3                      = (nom_cpp_m4_m3*(nom_delr_cpp_m4_m3*(1+nsig_delr_cpp_m4_m3*sig_delr_cpp_m4_m3)))
+    cfr_m4_m3                      = (nom_cfr_m4_m3*(nom_delr_cfr_m4_m3*(1+nsig_delr_cfr_m4_m3*sig_delr_cfr_m4_m3)))
+    cpp_m4_m2                      = (nom_cpp_m4_m2*(nom_delr_cpp_m4_m2*(1+nsig_delr_cpp_m4_m2*sig_delr_cpp_m4_m2)))
+    cfr_m4_m2                      = (nom_cfr_m4_m2*(nom_delr_cfr_m4_m2*(1+nsig_delr_cfr_m4_m2*sig_delr_cfr_m4_m2)))
+    cpp_m4_m1                      = (nom_cpp_m4_m1*(nom_delr_cpp_m4_m1*(1+nsig_delr_cpp_m4_m1*sig_delr_cpp_m4_m1)))
+    cfr_m4_m1                      = (nom_cfr_m4_m1*(nom_delr_cfr_m4_m1*(1+nsig_delr_cfr_m4_m1*sig_delr_cfr_m4_m1)))
+    cpp_m4_ply                     = (nom_cpp_m4_ply*(nom_delr_cpp_m4_ply*(1+nsig_delr_cpp_m4_ply*sig_delr_cpp_m4_ply)))
+    cfr_m4_ply                     = (nom_cfr_m4_ply*(nom_delr_cfr_m4_ply*(1+nsig_delr_cfr_m4_ply*sig_delr_cfr_m4_ply)))
+    cpp_m4_sd                      = (nom_cpp_m4_sd*(nom_delr_cpp_m4_sd*(1+nsig_delr_cpp_m4_sd*sig_delr_cpp_m4_sd)))
+    cfr_m4_sd                      = (nom_cfr_m4_sd*(nom_delr_cfr_m4_sd*(1+nsig_delr_cfr_m4_sd*sig_delr_cfr_m4_sd)))
+    cpp_m4_fld                     = (nom_cpp_m4_fld*(nom_delr_cpp_m4_fld*(1+nsig_delr_cpp_m4_fld*sig_delr_cpp_m4_fld)))
+    cfr_m4_fld                     = (nom_cfr_m4_fld*(nom_delr_cfr_m4_fld*(1+nsig_delr_cfr_m4_fld*sig_delr_cfr_m4_fld)))
+    cpp_m3_m2                      = (nom_cpp_m3_m2*(nom_delr_cpp_m3_m2*(1+nsig_delr_cpp_m3_m2*sig_delr_cpp_m3_m2)))
+    cfr_m3_m2                      = (nom_cfr_m3_m2*(nom_delr_cfr_m3_m2*(1+nsig_delr_cfr_m3_m2*sig_delr_cfr_m3_m2)))
+    cpp_m3_m1                      = (nom_cpp_m3_m1*(nom_delr_cpp_m3_m1*(1+nsig_delr_cpp_m3_m1*sig_delr_cpp_m3_m1)))
+    cfr_m3_m1                      = (nom_cfr_m3_m1*(nom_delr_cfr_m3_m1*(1+nsig_delr_cfr_m3_m1*sig_delr_cfr_m3_m1)))
+    cpp_m3_ply                     = (nom_cpp_m3_ply*(nom_delr_cpp_m3_ply*(1+nsig_delr_cpp_m3_ply*sig_delr_cpp_m3_ply)))
+    cfr_m3_ply                     = (nom_cfr_m3_ply*(nom_delr_cfr_m3_ply*(1+nsig_delr_cfr_m3_ply*sig_delr_cfr_m3_ply)))
+    cpp_m3_sd                      = (nom_cpp_m3_sd*(nom_delr_cpp_m3_sd*(1+nsig_delr_cpp_m3_sd*sig_delr_cpp_m3_sd)))
+    cfr_m3_sd                      = (nom_cfr_m3_sd*(nom_delr_cfr_m3_sd*(1+nsig_delr_cfr_m3_sd*sig_delr_cfr_m3_sd)))
+    cpp_m3_fld                     = (nom_cpp_m3_fld*(nom_delr_cpp_m3_fld*(1+nsig_delr_cpp_m3_fld*sig_delr_cpp_m3_fld)))
+    cfr_m3_fld                     = (nom_cfr_m3_fld*(nom_delr_cfr_m3_fld*(1+nsig_delr_cfr_m3_fld*sig_delr_cfr_m3_fld)))
+    cpp_m2_m1                      = (nom_cpp_m2_m1*(nom_delr_cpp_m2_m1*(1+nsig_delr_cpp_m2_m1*sig_delr_cpp_m2_m1)))
+    cfr_m2_m1                      = (nom_cfr_m2_m1*(nom_delr_cfr_m2_m1*(1+nsig_delr_cfr_m2_m1*sig_delr_cfr_m2_m1)))
+    cpp_m2_ply                     = (nom_cpp_m2_ply*(nom_delr_cpp_m2_ply*(1+nsig_delr_cpp_m2_ply*sig_delr_cpp_m2_ply)))
+    cfr_m2_ply                     = (nom_cfr_m2_ply*(nom_delr_cfr_m2_ply*(1+nsig_delr_cfr_m2_ply*sig_delr_cfr_m2_ply)))
+    cpp_m2_sd                      = (nom_cpp_m2_sd*(nom_delr_cpp_m2_sd*(1+nsig_delr_cpp_m2_sd*sig_delr_cpp_m2_sd)))
+    cfr_m2_sd                      = (nom_cfr_m2_sd*(nom_delr_cfr_m2_sd*(1+nsig_delr_cfr_m2_sd*sig_delr_cfr_m2_sd)))
+    cpp_m2_fld                     = (nom_cpp_m2_fld*(nom_delr_cpp_m2_fld*(1+nsig_delr_cpp_m2_fld*sig_delr_cpp_m2_fld)))
+    cfr_m2_fld                     = (nom_cfr_m2_fld*(nom_delr_cfr_m2_fld*(1+nsig_delr_cfr_m2_fld*sig_delr_cfr_m2_fld)))
+    cpp_m1_ply                     = (nom_cpp_m1_ply*(nom_delr_cpp_m1_ply*(1+nsig_delr_cpp_m1_ply*sig_delr_cpp_m1_ply)))
+    cfr_m1_ply                     = (nom_cfr_m1_ply*(nom_delr_cfr_m1_ply*(1+nsig_delr_cfr_m1_ply*sig_delr_cfr_m1_ply)))
+    cpp_m1_sd                      = (nom_cpp_m1_sd*(nom_delr_cpp_m1_sd*(1+nsig_delr_cpp_m1_sd*sig_delr_cpp_m1_sd)))
+    cfr_m1_sd                      = (nom_cfr_m1_sd*(nom_delr_cfr_m1_sd*(1+nsig_delr_cfr_m1_sd*sig_delr_cfr_m1_sd)))
+    cpp_m1_fld                     = (nom_cpp_m1_fld*(nom_delr_cpp_m1_fld*(1+nsig_delr_cpp_m1_fld*sig_delr_cpp_m1_fld)))
+    cfr_m1_fld                     = (nom_cfr_m1_fld*(nom_delr_cfr_m1_fld*(1+nsig_delr_cfr_m1_fld*sig_delr_cfr_m1_fld)))
+    cpp_ply_ply0                   = (nom_cpp_ply_ply0*(nom_delr_cpp_ply_ply0*(1+nsig_delr_cpp_ply_ply0*sig_delr_cpp_ply_ply0)))
+    cfr_ply_ply0                   = (nom_cfr_ply_ply0*(nom_delr_cfr_ply_ply0*(1+nsig_delr_cfr_ply_ply0*sig_delr_cfr_ply_ply0)))
+    cpp_ply_sd                     = (nom_cpp_ply_sd*(nom_delr_cpp_ply_sd*(1+nsig_delr_cpp_ply_sd*sig_delr_cpp_ply_sd)))
+    cfr_ply_sd                     = (nom_cfr_ply_sd*(nom_delr_cfr_ply_sd*(1+nsig_delr_cfr_ply_sd*sig_delr_cfr_ply_sd)))
+    cpp_ply_fld                    = (nom_cpp_ply_fld*(nom_delr_cpp_ply_fld*(1+nsig_delr_cpp_ply_fld*sig_delr_cpp_ply_fld)))
+    cfr_ply_fld                    = (nom_cfr_ply_fld*(nom_delr_cfr_ply_fld*(1+nsig_delr_cfr_ply_fld*sig_delr_cfr_ply_fld)))
+    cpp_ply_sdt                    = (nom_cpp_ply_sdt*(nom_delr_cpp_ply_sdt*(1+nsig_delr_cpp_ply_sdt*sig_delr_cpp_ply_sdt)))
+    cfr_ply_sdt                    = (nom_cfr_ply_sdt*(nom_delr_cfr_ply_sdt*(1+nsig_delr_cfr_ply_sdt*sig_delr_cfr_ply_sdt)))
+    cpp_ply0_fld                   = (nom_cpp_ply0_fld*(nom_delr_cpp_ply0_fld*(1+nsig_delr_cpp_ply0_fld*sig_delr_cpp_ply0_fld)))
+    cfr_ply0_fld                   = (nom_cfr_ply0_fld*(nom_delr_cfr_ply0_fld*(1+nsig_delr_cfr_ply0_fld*sig_delr_cfr_ply0_fld)))
+    acj0_junc_psd_nw               = (nom_acj0_junc_psd_nw*(nom_delr_acj0_junc_psd_nw*(1+nsig_delr_acj0_junc_psd_nw*sig_delr_acj0_junc_psd_nw)))
+    ajs_junc_psd_nw                = (nom_ajs_junc_psd_nw*(nom_delr_ajs_junc_psd_nw*(1+nsig_delr_ajs_junc_psd_nw*sig_delr_ajs_junc_psd_nw)))
+    pcj0_junc_psd_nw               = (nom_pcj0_junc_psd_nw*(nom_delr_pcj0_junc_psd_nw*(1+nsig_delr_pcj0_junc_psd_nw*sig_delr_pcj0_junc_psd_nw)))
+    pjs_junc_psd_nw                = (nom_pjs_junc_psd_nw*(nom_delr_pjs_junc_psd_nw*(1+nsig_delr_pjs_junc_psd_nw*sig_delr_pjs_junc_psd_nw)))
+    acj0_junc_nsd_pw               = (nom_acj0_junc_nsd_pw*(nom_delr_acj0_junc_nsd_pw*(1+nsig_delr_acj0_junc_nsd_pw*sig_delr_acj0_junc_nsd_pw)))
+    ajs_junc_nsd_pw                = (nom_ajs_junc_nsd_pw*(nom_delr_ajs_junc_nsd_pw*(1+nsig_delr_ajs_junc_nsd_pw*sig_delr_ajs_junc_nsd_pw)))
+    pcj0_junc_nsd_pw               = (nom_pcj0_junc_nsd_pw*(nom_delr_pcj0_junc_nsd_pw*(1+nsig_delr_pcj0_junc_nsd_pw*sig_delr_pcj0_junc_nsd_pw)))
+    pjs_junc_nsd_pw                = (nom_pjs_junc_nsd_pw*(nom_delr_pjs_junc_nsd_pw*(1+nsig_delr_pjs_junc_nsd_pw*sig_delr_pjs_junc_nsd_pw)))
+    acj0_junc_psd_nhv              = (nom_acj0_junc_psd_nhv*(nom_delr_acj0_junc_psd_nhv*(1+nsig_delr_acj0_junc_psd_nhv*sig_delr_acj0_junc_psd_nhv)))
+    ajs_junc_psd_nhv               = (nom_ajs_junc_psd_nhv*(nom_delr_ajs_junc_psd_nhv*(1+nsig_delr_ajs_junc_psd_nhv*sig_delr_ajs_junc_psd_nhv)))
+    pcj0_junc_psd_nhv              = (nom_pcj0_junc_psd_nhv*(nom_delr_pcj0_junc_psd_nhv*(1+nsig_delr_pcj0_junc_psd_nhv*sig_delr_pcj0_junc_psd_nhv)))
+    pjs_junc_psd_nhv               = (nom_pjs_junc_psd_nhv*(nom_delr_pjs_junc_psd_nhv*(1+nsig_delr_pjs_junc_psd_nhv*sig_delr_pjs_junc_psd_nhv)))
+    acj0_junc_nsd_phv              = (nom_acj0_junc_nsd_phv*(nom_delr_acj0_junc_nsd_phv*(1+nsig_delr_acj0_junc_nsd_phv*sig_delr_acj0_junc_nsd_phv)))
+    ajs_junc_nsd_phv               = (nom_ajs_junc_nsd_phv*(nom_delr_ajs_junc_nsd_phv*(1+nsig_delr_ajs_junc_nsd_phv*sig_delr_ajs_junc_nsd_phv)))
+    pcj0_junc_nsd_phv              = (nom_pcj0_junc_nsd_phv*(nom_delr_pcj0_junc_nsd_phv*(1+nsig_delr_pcj0_junc_nsd_phv*sig_delr_pcj0_junc_nsd_phv)))
+    pjs_junc_nsd_phv               = (nom_pjs_junc_nsd_phv*(nom_delr_pjs_junc_nsd_phv*(1+nsig_delr_pjs_junc_nsd_phv*sig_delr_pjs_junc_nsd_phv)))
+    acj0_junc_pepi_nbl             = (nom_acj0_junc_pepi_nbl*(nom_delr_acj0_junc_pepi_nbl*(1+nsig_delr_acj0_junc_pepi_nbl*sig_delr_acj0_junc_pepi_nbl)))
+    ajs_junc_pepi_nbl              = (nom_ajs_junc_pepi_nbl*(nom_delr_ajs_junc_pepi_nbl*(1+nsig_delr_ajs_junc_pepi_nbl*sig_delr_ajs_junc_pepi_nbl)))
+    pcj0_junc_pepi_nbl             = (nom_pcj0_junc_pepi_nbl*(nom_delr_pcj0_junc_pepi_nbl*(1+nsig_delr_pcj0_junc_pepi_nbl*sig_delr_pcj0_junc_pepi_nbl)))
+    pjs_junc_pepi_nbl              = (nom_pjs_junc_pepi_nbl*(nom_delr_pjs_junc_pepi_nbl*(1+nsig_delr_pjs_junc_pepi_nbl*sig_delr_pjs_junc_pepi_nbl)))
+    acj0_junc_nw_pepi              = (nom_acj0_junc_nw_pepi*(nom_delr_acj0_junc_nw_pepi*(1+nsig_delr_acj0_junc_nw_pepi*sig_delr_acj0_junc_nw_pepi)))
+    ajs_junc_nw_pepi               = (nom_ajs_junc_nw_pepi*(nom_delr_ajs_junc_nw_pepi*(1+nsig_delr_ajs_junc_nw_pepi*sig_delr_ajs_junc_nw_pepi)))
+    pcj0_junc_nw_pepi              = (nom_pcj0_junc_nw_pepi*(nom_delr_pcj0_junc_nw_pepi*(1+nsig_delr_pcj0_junc_nw_pepi*sig_delr_pcj0_junc_nw_pepi)))
+    pjs_junc_nw_pepi               = (nom_pjs_junc_nw_pepi*(nom_delr_pjs_junc_nw_pepi*(1+nsig_delr_pjs_junc_nw_pepi*sig_delr_pjs_junc_nw_pepi)))
+    acj0_junc_nw_pepi_tr           = (nom_acj0_junc_nw_pepi_tr*(nom_delr_acj0_junc_nw_pepi_tr*(1+nsig_delr_acj0_junc_nw_pepi_tr*sig_delr_acj0_junc_nw_pepi_tr)))
+    ajs_junc_nw_pepi_tr            = (nom_ajs_junc_nw_pepi_tr*(nom_delr_ajs_junc_nw_pepi_tr*(1+nsig_delr_ajs_junc_nw_pepi_tr*sig_delr_ajs_junc_nw_pepi_tr)))
+    pcj0_junc_nw_pepi_tr           = (nom_pcj0_junc_nw_pepi_tr*(nom_delr_pcj0_junc_nw_pepi_tr*(1+nsig_delr_pcj0_junc_nw_pepi_tr*sig_delr_pcj0_junc_nw_pepi_tr)))
+    pjs_junc_nw_pepi_tr            = (nom_pjs_junc_nw_pepi_tr*(nom_delr_pjs_junc_nw_pepi_tr*(1+nsig_delr_pjs_junc_nw_pepi_tr*sig_delr_pjs_junc_nw_pepi_tr)))
+    acj0_junc_nhv_pepi_tr          = (nom_acj0_junc_nhv_pepi_tr*(nom_delr_acj0_junc_nhv_pepi_tr*(1+nsig_delr_acj0_junc_nhv_pepi_tr*sig_delr_acj0_junc_nhv_pepi_tr)))
+    ajs_junc_nhv_pepi_tr           = (nom_ajs_junc_nhv_pepi_tr*(nom_delr_ajs_junc_nhv_pepi_tr*(1+nsig_delr_ajs_junc_nhv_pepi_tr*sig_delr_ajs_junc_nhv_pepi_tr)))
+    pcj0_junc_nhv_pepi_tr          = (nom_pcj0_junc_nhv_pepi_tr*(nom_delr_pcj0_junc_nhv_pepi_tr*(1+nsig_delr_pcj0_junc_nhv_pepi_tr*sig_delr_pcj0_junc_nhv_pepi_tr)))
+    pjs_junc_nhv_pepi_tr           = (nom_pjs_junc_nhv_pepi_tr*(nom_delr_pjs_junc_nhv_pepi_tr*(1+nsig_delr_pjs_junc_nhv_pepi_tr*sig_delr_pjs_junc_nhv_pepi_tr)))
+    acj0_junc_nbl_pepi_tr          = (nom_acj0_junc_nbl_pepi_tr*(nom_delr_acj0_junc_nbl_pepi_tr*(1+nsig_delr_acj0_junc_nbl_pepi_tr*sig_delr_acj0_junc_nbl_pepi_tr)))
+    ajs_junc_nbl_pepi_tr           = (nom_ajs_junc_nbl_pepi_tr*(nom_delr_ajs_junc_nbl_pepi_tr*(1+nsig_delr_ajs_junc_nbl_pepi_tr*sig_delr_ajs_junc_nbl_pepi_tr)))
+    pcj0_junc_nbl_pepi_tr          = (nom_pcj0_junc_nbl_pepi_tr*(nom_delr_pcj0_junc_nbl_pepi_tr*(1+nsig_delr_pcj0_junc_nbl_pepi_tr*sig_delr_pcj0_junc_nbl_pepi_tr)))
+    pjs_junc_nbl_pepi_tr           = (nom_pjs_junc_nbl_pepi_tr*(nom_delr_pjs_junc_nbl_pepi_tr*(1+nsig_delr_pjs_junc_nbl_pepi_tr*sig_delr_pjs_junc_nbl_pepi_tr)))
+    acj0_junc_nmos_sd_body         = (nom_acj0_junc_nmos_sd_body*(nom_delr_acj0_junc_nmos_sd_body*(1+nsig_delr_acj0_junc_nmos_sd_body*sig_delr_acj0_junc_nmos_sd_body)))
+    ajs_junc_nmos_sd_body          = (nom_ajs_junc_nmos_sd_body*(nom_delr_ajs_junc_nmos_sd_body*(1+nsig_delr_ajs_junc_nmos_sd_body*sig_delr_ajs_junc_nmos_sd_body)))
+    pcj0_junc_nmos_sd_body         = (nom_pcj0_junc_nmos_sd_body*(nom_delr_pcj0_junc_nmos_sd_body*(1+nsig_delr_pcj0_junc_nmos_sd_body*sig_delr_pcj0_junc_nmos_sd_body)))
+    pjs_junc_nmos_sd_body          = (nom_pjs_junc_nmos_sd_body*(nom_delr_pjs_junc_nmos_sd_body*(1+nsig_delr_pjs_junc_nmos_sd_body*sig_delr_pjs_junc_nmos_sd_body)))
+    chcj0_junc_nmos_sd_body        = (nom_chcj0_junc_nmos_sd_body*(nom_delr_chcj0_junc_nmos_sd_body*(1+nsig_delr_chcj0_junc_nmos_sd_body*sig_delr_chcj0_junc_nmos_sd_body)))
+    chjs_junc_nmos_sd_body         = (nom_chjs_junc_nmos_sd_body*(nom_delr_chjs_junc_nmos_sd_body*(1+nsig_delr_chjs_junc_nmos_sd_body*sig_delr_chjs_junc_nmos_sd_body)))
+    acj0_junc_nmos_ll_sd_body      = (nom_acj0_junc_nmos_ll_sd_body*(nom_delr_acj0_junc_nmos_ll_sd_body*(1+nsig_delr_acj0_junc_nmos_ll_sd_body*sig_delr_acj0_junc_nmos_ll_sd_body)))
+    ajs_junc_nmos_ll_sd_body       = (nom_ajs_junc_nmos_ll_sd_body*(nom_delr_ajs_junc_nmos_ll_sd_body*(1+nsig_delr_ajs_junc_nmos_ll_sd_body*sig_delr_ajs_junc_nmos_ll_sd_body)))
+    pcj0_junc_nmos_ll_sd_body      = (nom_pcj0_junc_nmos_ll_sd_body*(nom_delr_pcj0_junc_nmos_ll_sd_body*(1+nsig_delr_pcj0_junc_nmos_ll_sd_body*sig_delr_pcj0_junc_nmos_ll_sd_body)))
+    pjs_junc_nmos_ll_sd_body       = (nom_pjs_junc_nmos_ll_sd_body*(nom_delr_pjs_junc_nmos_ll_sd_body*(1+nsig_delr_pjs_junc_nmos_ll_sd_body*sig_delr_pjs_junc_nmos_ll_sd_body)))
+    chcj0_junc_nmos_ll_sd_body     = (nom_chcj0_junc_nmos_ll_sd_body*(nom_delr_chcj0_junc_nmos_ll_sd_body*(1+nsig_delr_chcj0_junc_nmos_ll_sd_body*sig_delr_chcj0_junc_nmos_ll_sd_body)))
+    chjs_junc_nmos_ll_sd_body      = (nom_chjs_junc_nmos_ll_sd_body*(nom_delr_chjs_junc_nmos_ll_sd_body*(1+nsig_delr_chjs_junc_nmos_ll_sd_body*sig_delr_chjs_junc_nmos_ll_sd_body)))
+    acj0_junc_nmos_ull_sd_body     = (nom_acj0_junc_nmos_ull_sd_body*(nom_delr_acj0_junc_nmos_ull_sd_body*(1+nsig_delr_acj0_junc_nmos_ull_sd_body*sig_delr_acj0_junc_nmos_ull_sd_body)))
+    ajs_junc_nmos_ull_sd_body      = (nom_ajs_junc_nmos_ull_sd_body*(nom_delr_ajs_junc_nmos_ull_sd_body*(1+nsig_delr_ajs_junc_nmos_ull_sd_body*sig_delr_ajs_junc_nmos_ull_sd_body)))
+    pcj0_junc_nmos_ull_sd_body     = (nom_pcj0_junc_nmos_ull_sd_body*(nom_delr_pcj0_junc_nmos_ull_sd_body*(1+nsig_delr_pcj0_junc_nmos_ull_sd_body*sig_delr_pcj0_junc_nmos_ull_sd_body)))
+    pjs_junc_nmos_ull_sd_body      = (nom_pjs_junc_nmos_ull_sd_body*(nom_delr_pjs_junc_nmos_ull_sd_body*(1+nsig_delr_pjs_junc_nmos_ull_sd_body*sig_delr_pjs_junc_nmos_ull_sd_body)))
+    chcj0_junc_nmos_ull_sd_body    = (nom_chcj0_junc_nmos_ull_sd_body*(nom_delr_chcj0_junc_nmos_ull_sd_body*(1+nsig_delr_chcj0_junc_nmos_ull_sd_body*sig_delr_chcj0_junc_nmos_ull_sd_body)))
+    chjs_junc_nmos_ull_sd_body     = (nom_chjs_junc_nmos_ull_sd_body*(nom_delr_chjs_junc_nmos_ull_sd_body*(1+nsig_delr_chjs_junc_nmos_ull_sd_body*sig_delr_chjs_junc_nmos_ull_sd_body)))
+    acj0_junc_nmos_ana_sd_body     = (nom_acj0_junc_nmos_ana_sd_body*(nom_delr_acj0_junc_nmos_ana_sd_body*(1+nsig_delr_acj0_junc_nmos_ana_sd_body*sig_delr_acj0_junc_nmos_ana_sd_body)))
+    ajs_junc_nmos_ana_sd_body      = (nom_ajs_junc_nmos_ana_sd_body*(nom_delr_ajs_junc_nmos_ana_sd_body*(1+nsig_delr_ajs_junc_nmos_ana_sd_body*sig_delr_ajs_junc_nmos_ana_sd_body)))
+    pcj0_junc_nmos_ana_sd_body     = (nom_pcj0_junc_nmos_ana_sd_body*(nom_delr_pcj0_junc_nmos_ana_sd_body*(1+nsig_delr_pcj0_junc_nmos_ana_sd_body*sig_delr_pcj0_junc_nmos_ana_sd_body)))
+    pjs_junc_nmos_ana_sd_body      = (nom_pjs_junc_nmos_ana_sd_body*(nom_delr_pjs_junc_nmos_ana_sd_body*(1+nsig_delr_pjs_junc_nmos_ana_sd_body*sig_delr_pjs_junc_nmos_ana_sd_body)))
+    chcj0_junc_nmos_ana_sd_body    = (nom_chcj0_junc_nmos_ana_sd_body*(nom_delr_chcj0_junc_nmos_ana_sd_body*(1+nsig_delr_chcj0_junc_nmos_ana_sd_body*sig_delr_chcj0_junc_nmos_ana_sd_body)))
+    chjs_junc_nmos_ana_sd_body     = (nom_chjs_junc_nmos_ana_sd_body*(nom_delr_chjs_junc_nmos_ana_sd_body*(1+nsig_delr_chjs_junc_nmos_ana_sd_body*sig_delr_chjs_junc_nmos_ana_sd_body)))
+    acj0_junc_nsrampg_sd_body      = (nom_acj0_junc_nsrampg_sd_body*(nom_delr_acj0_junc_nsrampg_sd_body*(1+nsig_delr_acj0_junc_nsrampg_sd_body*sig_delr_acj0_junc_nsrampg_sd_body)))
+    ajs_junc_nsrampg_sd_body       = (nom_ajs_junc_nsrampg_sd_body*(nom_delr_ajs_junc_nsrampg_sd_body*(1+nsig_delr_ajs_junc_nsrampg_sd_body*sig_delr_ajs_junc_nsrampg_sd_body)))
+    pcj0_junc_nsrampg_sd_body      = (nom_pcj0_junc_nsrampg_sd_body*(nom_delr_pcj0_junc_nsrampg_sd_body*(1+nsig_delr_pcj0_junc_nsrampg_sd_body*sig_delr_pcj0_junc_nsrampg_sd_body)))
+    pjs_junc_nsrampg_sd_body       = (nom_pjs_junc_nsrampg_sd_body*(nom_delr_pjs_junc_nsrampg_sd_body*(1+nsig_delr_pjs_junc_nsrampg_sd_body*sig_delr_pjs_junc_nsrampg_sd_body)))
+    chcj0_junc_nsrampg_sd_body     = (nom_chcj0_junc_nsrampg_sd_body*(nom_delr_chcj0_junc_nsrampg_sd_body*(1+nsig_delr_chcj0_junc_nsrampg_sd_body*sig_delr_chcj0_junc_nsrampg_sd_body)))
+    chjs_junc_nsrampg_sd_body      = (nom_chjs_junc_nsrampg_sd_body*(nom_delr_chjs_junc_nsrampg_sd_body*(1+nsig_delr_chjs_junc_nsrampg_sd_body*sig_delr_chjs_junc_nsrampg_sd_body)))
+    acj0_junc_nsrampd_sd_body      = (nom_acj0_junc_nsrampd_sd_body*(nom_delr_acj0_junc_nsrampd_sd_body*(1+nsig_delr_acj0_junc_nsrampd_sd_body*sig_delr_acj0_junc_nsrampd_sd_body)))
+    ajs_junc_nsrampd_sd_body       = (nom_ajs_junc_nsrampd_sd_body*(nom_delr_ajs_junc_nsrampd_sd_body*(1+nsig_delr_ajs_junc_nsrampd_sd_body*sig_delr_ajs_junc_nsrampd_sd_body)))
+    pcj0_junc_nsrampd_sd_body      = (nom_pcj0_junc_nsrampd_sd_body*(nom_delr_pcj0_junc_nsrampd_sd_body*(1+nsig_delr_pcj0_junc_nsrampd_sd_body*sig_delr_pcj0_junc_nsrampd_sd_body)))
+    pjs_junc_nsrampd_sd_body       = (nom_pjs_junc_nsrampd_sd_body*(nom_delr_pjs_junc_nsrampd_sd_body*(1+nsig_delr_pjs_junc_nsrampd_sd_body*sig_delr_pjs_junc_nsrampd_sd_body)))
+    chcj0_junc_nsrampd_sd_body     = (nom_chcj0_junc_nsrampd_sd_body*(nom_delr_chcj0_junc_nsrampd_sd_body*(1+nsig_delr_chcj0_junc_nsrampd_sd_body*sig_delr_chcj0_junc_nsrampd_sd_body)))
+    chjs_junc_nsrampd_sd_body      = (nom_chjs_junc_nsrampd_sd_body*(nom_delr_chjs_junc_nsrampd_sd_body*(1+nsig_delr_chjs_junc_nsrampd_sd_body*sig_delr_chjs_junc_nsrampd_sd_body)))
+    acj0_junc_pmos_sd_body         = (nom_acj0_junc_pmos_sd_body*(nom_delr_acj0_junc_pmos_sd_body*(1+nsig_delr_acj0_junc_pmos_sd_body*sig_delr_acj0_junc_pmos_sd_body)))
+    ajs_junc_pmos_sd_body          = (nom_ajs_junc_pmos_sd_body*(nom_delr_ajs_junc_pmos_sd_body*(1+nsig_delr_ajs_junc_pmos_sd_body*sig_delr_ajs_junc_pmos_sd_body)))
+    pcj0_junc_pmos_sd_body         = (nom_pcj0_junc_pmos_sd_body*(nom_delr_pcj0_junc_pmos_sd_body*(1+nsig_delr_pcj0_junc_pmos_sd_body*sig_delr_pcj0_junc_pmos_sd_body)))
+    pjs_junc_pmos_sd_body          = (nom_pjs_junc_pmos_sd_body*(nom_delr_pjs_junc_pmos_sd_body*(1+nsig_delr_pjs_junc_pmos_sd_body*sig_delr_pjs_junc_pmos_sd_body)))
+    chcj0_junc_pmos_sd_body        = (nom_chcj0_junc_pmos_sd_body*(nom_delr_chcj0_junc_pmos_sd_body*(1+nsig_delr_chcj0_junc_pmos_sd_body*sig_delr_chcj0_junc_pmos_sd_body)))
+    chjs_junc_pmos_sd_body         = (nom_chjs_junc_pmos_sd_body*(nom_delr_chjs_junc_pmos_sd_body*(1+nsig_delr_chjs_junc_pmos_sd_body*sig_delr_chjs_junc_pmos_sd_body)))
+    acj0_junc_pmos_ll_sd_body      = (nom_acj0_junc_pmos_ll_sd_body*(nom_delr_acj0_junc_pmos_ll_sd_body*(1+nsig_delr_acj0_junc_pmos_ll_sd_body*sig_delr_acj0_junc_pmos_ll_sd_body)))
+    ajs_junc_pmos_ll_sd_body       = (nom_ajs_junc_pmos_ll_sd_body*(nom_delr_ajs_junc_pmos_ll_sd_body*(1+nsig_delr_ajs_junc_pmos_ll_sd_body*sig_delr_ajs_junc_pmos_ll_sd_body)))
+    pcj0_junc_pmos_ll_sd_body      = (nom_pcj0_junc_pmos_ll_sd_body*(nom_delr_pcj0_junc_pmos_ll_sd_body*(1+nsig_delr_pcj0_junc_pmos_ll_sd_body*sig_delr_pcj0_junc_pmos_ll_sd_body)))
+    pjs_junc_pmos_ll_sd_body       = (nom_pjs_junc_pmos_ll_sd_body*(nom_delr_pjs_junc_pmos_ll_sd_body*(1+nsig_delr_pjs_junc_pmos_ll_sd_body*sig_delr_pjs_junc_pmos_ll_sd_body)))
+    chcj0_junc_pmos_ll_sd_body     = (nom_chcj0_junc_pmos_ll_sd_body*(nom_delr_chcj0_junc_pmos_ll_sd_body*(1+nsig_delr_chcj0_junc_pmos_ll_sd_body*sig_delr_chcj0_junc_pmos_ll_sd_body)))
+    chjs_junc_pmos_ll_sd_body      = (nom_chjs_junc_pmos_ll_sd_body*(nom_delr_chjs_junc_pmos_ll_sd_body*(1+nsig_delr_chjs_junc_pmos_ll_sd_body*sig_delr_chjs_junc_pmos_ll_sd_body)))
+    acj0_junc_pmos_ull_sd_body     = (nom_acj0_junc_pmos_ull_sd_body*(nom_delr_acj0_junc_pmos_ull_sd_body*(1+nsig_delr_acj0_junc_pmos_ull_sd_body*sig_delr_acj0_junc_pmos_ull_sd_body)))
+    ajs_junc_pmos_ull_sd_body      = (nom_ajs_junc_pmos_ull_sd_body*(nom_delr_ajs_junc_pmos_ull_sd_body*(1+nsig_delr_ajs_junc_pmos_ull_sd_body*sig_delr_ajs_junc_pmos_ull_sd_body)))
+    pcj0_junc_pmos_ull_sd_body     = (nom_pcj0_junc_pmos_ull_sd_body*(nom_delr_pcj0_junc_pmos_ull_sd_body*(1+nsig_delr_pcj0_junc_pmos_ull_sd_body*sig_delr_pcj0_junc_pmos_ull_sd_body)))
+    pjs_junc_pmos_ull_sd_body      = (nom_pjs_junc_pmos_ull_sd_body*(nom_delr_pjs_junc_pmos_ull_sd_body*(1+nsig_delr_pjs_junc_pmos_ull_sd_body*sig_delr_pjs_junc_pmos_ull_sd_body)))
+    chcj0_junc_pmos_ull_sd_body    = (nom_chcj0_junc_pmos_ull_sd_body*(nom_delr_chcj0_junc_pmos_ull_sd_body*(1+nsig_delr_chcj0_junc_pmos_ull_sd_body*sig_delr_chcj0_junc_pmos_ull_sd_body)))
+    chjs_junc_pmos_ull_sd_body     = (nom_chjs_junc_pmos_ull_sd_body*(nom_delr_chjs_junc_pmos_ull_sd_body*(1+nsig_delr_chjs_junc_pmos_ull_sd_body*sig_delr_chjs_junc_pmos_ull_sd_body)))
+    acj0_junc_pmos_ana_sd_body     = (nom_acj0_junc_pmos_ana_sd_body*(nom_delr_acj0_junc_pmos_ana_sd_body*(1+nsig_delr_acj0_junc_pmos_ana_sd_body*sig_delr_acj0_junc_pmos_ana_sd_body)))
+    ajs_junc_pmos_ana_sd_body      = (nom_ajs_junc_pmos_ana_sd_body*(nom_delr_ajs_junc_pmos_ana_sd_body*(1+nsig_delr_ajs_junc_pmos_ana_sd_body*sig_delr_ajs_junc_pmos_ana_sd_body)))
+    pcj0_junc_pmos_ana_sd_body     = (nom_pcj0_junc_pmos_ana_sd_body*(nom_delr_pcj0_junc_pmos_ana_sd_body*(1+nsig_delr_pcj0_junc_pmos_ana_sd_body*sig_delr_pcj0_junc_pmos_ana_sd_body)))
+    pjs_junc_pmos_ana_sd_body      = (nom_pjs_junc_pmos_ana_sd_body*(nom_delr_pjs_junc_pmos_ana_sd_body*(1+nsig_delr_pjs_junc_pmos_ana_sd_body*sig_delr_pjs_junc_pmos_ana_sd_body)))
+    chcj0_junc_pmos_ana_sd_body    = (nom_chcj0_junc_pmos_ana_sd_body*(nom_delr_chcj0_junc_pmos_ana_sd_body*(1+nsig_delr_chcj0_junc_pmos_ana_sd_body*sig_delr_chcj0_junc_pmos_ana_sd_body)))
+    chjs_junc_pmos_ana_sd_body     = (nom_chjs_junc_pmos_ana_sd_body*(nom_delr_chjs_junc_pmos_ana_sd_body*(1+nsig_delr_chjs_junc_pmos_ana_sd_body*sig_delr_chjs_junc_pmos_ana_sd_body)))
+    acj0_junc_nmos3_zvt_d_body     = (nom_acj0_junc_nmos3_zvt_d_body*(nom_delr_acj0_junc_nmos3_zvt_d_body*(1+nsig_delr_acj0_junc_nmos3_zvt_d_body*sig_delr_acj0_junc_nmos3_zvt_d_body)))
+    ajs_junc_nmos3_zvt_d_body      = (nom_ajs_junc_nmos3_zvt_d_body*(nom_delr_ajs_junc_nmos3_zvt_d_body*(1+nsig_delr_ajs_junc_nmos3_zvt_d_body*sig_delr_ajs_junc_nmos3_zvt_d_body)))
+    pcj0_junc_nmos3_zvt_d_body     = (nom_pcj0_junc_nmos3_zvt_d_body*(nom_delr_pcj0_junc_nmos3_zvt_d_body*(1+nsig_delr_pcj0_junc_nmos3_zvt_d_body*sig_delr_pcj0_junc_nmos3_zvt_d_body)))
+    pjs_junc_nmos3_zvt_d_body      = (nom_pjs_junc_nmos3_zvt_d_body*(nom_delr_pjs_junc_nmos3_zvt_d_body*(1+nsig_delr_pjs_junc_nmos3_zvt_d_body*sig_delr_pjs_junc_nmos3_zvt_d_body)))
+    chcj0_junc_nmos3_zvt_d_body    = (nom_chcj0_junc_nmos3_zvt_d_body*(nom_delr_chcj0_junc_nmos3_zvt_d_body*(1+nsig_delr_chcj0_junc_nmos3_zvt_d_body*sig_delr_chcj0_junc_nmos3_zvt_d_body)))
+    chjs_junc_nmos3_zvt_d_body     = (nom_chjs_junc_nmos3_zvt_d_body*(nom_delr_chjs_junc_nmos3_zvt_d_body*(1+nsig_delr_chjs_junc_nmos3_zvt_d_body*sig_delr_chjs_junc_nmos3_zvt_d_body)))
+    acj0_junc_nmos3_zvt_s_body     = (nom_acj0_junc_nmos3_zvt_s_body*(nom_delr_acj0_junc_nmos3_zvt_s_body*(1+nsig_delr_acj0_junc_nmos3_zvt_s_body*sig_delr_acj0_junc_nmos3_zvt_s_body)))
+    ajs_junc_nmos3_zvt_s_body      = (nom_ajs_junc_nmos3_zvt_s_body*(nom_delr_ajs_junc_nmos3_zvt_s_body*(1+nsig_delr_ajs_junc_nmos3_zvt_s_body*sig_delr_ajs_junc_nmos3_zvt_s_body)))
+    pcj0_junc_nmos3_zvt_s_body     = (nom_pcj0_junc_nmos3_zvt_s_body*(nom_delr_pcj0_junc_nmos3_zvt_s_body*(1+nsig_delr_pcj0_junc_nmos3_zvt_s_body*sig_delr_pcj0_junc_nmos3_zvt_s_body)))
+    pjs_junc_nmos3_zvt_s_body      = (nom_pjs_junc_nmos3_zvt_s_body*(nom_delr_pjs_junc_nmos3_zvt_s_body*(1+nsig_delr_pjs_junc_nmos3_zvt_s_body*sig_delr_pjs_junc_nmos3_zvt_s_body)))
+    chcj0_junc_nmos3_zvt_s_body    = (nom_chcj0_junc_nmos3_zvt_s_body*(nom_delr_chcj0_junc_nmos3_zvt_s_body*(1+nsig_delr_chcj0_junc_nmos3_zvt_s_body*sig_delr_chcj0_junc_nmos3_zvt_s_body)))
+    chjs_junc_nmos3_zvt_s_body     = (nom_chjs_junc_nmos3_zvt_s_body*(nom_delr_chjs_junc_nmos3_zvt_s_body*(1+nsig_delr_chjs_junc_nmos3_zvt_s_body*sig_delr_chjs_junc_nmos3_zvt_s_body)))
+    acj0_junc_psrampu_sd_body      = (nom_acj0_junc_psrampu_sd_body*(nom_delr_acj0_junc_psrampu_sd_body*(1+nsig_delr_acj0_junc_psrampu_sd_body*sig_delr_acj0_junc_psrampu_sd_body)))
+    ajs_junc_psrampu_sd_body       = (nom_ajs_junc_psrampu_sd_body*(nom_delr_ajs_junc_psrampu_sd_body*(1+nsig_delr_ajs_junc_psrampu_sd_body*sig_delr_ajs_junc_psrampu_sd_body)))
+    pcj0_junc_psrampu_sd_body      = (nom_pcj0_junc_psrampu_sd_body*(nom_delr_pcj0_junc_psrampu_sd_body*(1+nsig_delr_pcj0_junc_psrampu_sd_body*sig_delr_pcj0_junc_psrampu_sd_body)))
+    pjs_junc_psrampu_sd_body       = (nom_pjs_junc_psrampu_sd_body*(nom_delr_pjs_junc_psrampu_sd_body*(1+nsig_delr_pjs_junc_psrampu_sd_body*sig_delr_pjs_junc_psrampu_sd_body)))
+    chcj0_junc_psrampu_sd_body     = (nom_chcj0_junc_psrampu_sd_body*(nom_delr_chcj0_junc_psrampu_sd_body*(1+nsig_delr_chcj0_junc_psrampu_sd_body*sig_delr_chcj0_junc_psrampu_sd_body)))
+    chjs_junc_psrampu_sd_body      = (nom_chjs_junc_psrampu_sd_body*(nom_delr_chjs_junc_psrampu_sd_body*(1+nsig_delr_chjs_junc_psrampu_sd_body*sig_delr_chjs_junc_psrampu_sd_body)))
+    acj0_junc_nmos5_s_body         = (nom_acj0_junc_nmos5_s_body*(nom_delr_acj0_junc_nmos5_s_body*(1+nsig_delr_acj0_junc_nmos5_s_body*sig_delr_acj0_junc_nmos5_s_body)))
+    ajs_junc_nmos5_s_body          = (nom_ajs_junc_nmos5_s_body*(nom_delr_ajs_junc_nmos5_s_body*(1+nsig_delr_ajs_junc_nmos5_s_body*sig_delr_ajs_junc_nmos5_s_body)))
+    pcj0_junc_nmos5_s_body         = (nom_pcj0_junc_nmos5_s_body*(nom_delr_pcj0_junc_nmos5_s_body*(1+nsig_delr_pcj0_junc_nmos5_s_body*sig_delr_pcj0_junc_nmos5_s_body)))
+    pjs_junc_nmos5_s_body          = (nom_pjs_junc_nmos5_s_body*(nom_delr_pjs_junc_nmos5_s_body*(1+nsig_delr_pjs_junc_nmos5_s_body*sig_delr_pjs_junc_nmos5_s_body)))
+    chcj0_junc_nmos5_s_body        = (nom_chcj0_junc_nmos5_s_body*(nom_delr_chcj0_junc_nmos5_s_body*(1+nsig_delr_chcj0_junc_nmos5_s_body*sig_delr_chcj0_junc_nmos5_s_body)))
+    chjs_junc_nmos5_s_body         = (nom_chjs_junc_nmos5_s_body*(nom_delr_chjs_junc_nmos5_s_body*(1+nsig_delr_chjs_junc_nmos5_s_body*sig_delr_chjs_junc_nmos5_s_body)))
+    acj0_junc_nmos5_d_body         = (nom_acj0_junc_nmos5_d_body*(nom_delr_acj0_junc_nmos5_d_body*(1+nsig_delr_acj0_junc_nmos5_d_body*sig_delr_acj0_junc_nmos5_d_body)))
+    ajs_junc_nmos5_d_body          = (nom_ajs_junc_nmos5_d_body*(nom_delr_ajs_junc_nmos5_d_body*(1+nsig_delr_ajs_junc_nmos5_d_body*sig_delr_ajs_junc_nmos5_d_body)))
+    pcj0_junc_nmos5_d_body         = (nom_pcj0_junc_nmos5_d_body*(nom_delr_pcj0_junc_nmos5_d_body*(1+nsig_delr_pcj0_junc_nmos5_d_body*sig_delr_pcj0_junc_nmos5_d_body)))
+    pjs_junc_nmos5_d_body          = (nom_pjs_junc_nmos5_d_body*(nom_delr_pjs_junc_nmos5_d_body*(1+nsig_delr_pjs_junc_nmos5_d_body*sig_delr_pjs_junc_nmos5_d_body)))
+    chcj0_junc_nmos5_d_body        = (nom_chcj0_junc_nmos5_d_body*(nom_delr_chcj0_junc_nmos5_d_body*(1+nsig_delr_chcj0_junc_nmos5_d_body*sig_delr_chcj0_junc_nmos5_d_body)))
+    chjs_junc_nmos5_d_body         = (nom_chjs_junc_nmos5_d_body*(nom_delr_chjs_junc_nmos5_d_body*(1+nsig_delr_chjs_junc_nmos5_d_body*sig_delr_chjs_junc_nmos5_d_body)))
+    acj0_junc_pmos5_sd_body        = (nom_acj0_junc_pmos5_sd_body*(nom_delr_acj0_junc_pmos5_sd_body*(1+nsig_delr_acj0_junc_pmos5_sd_body*sig_delr_acj0_junc_pmos5_sd_body)))
+    ajs_junc_pmos5_sd_body         = (nom_ajs_junc_pmos5_sd_body*(nom_delr_ajs_junc_pmos5_sd_body*(1+nsig_delr_ajs_junc_pmos5_sd_body*sig_delr_ajs_junc_pmos5_sd_body)))
+    pcj0_junc_pmos5_sd_body        = (nom_pcj0_junc_pmos5_sd_body*(nom_delr_pcj0_junc_pmos5_sd_body*(1+nsig_delr_pcj0_junc_pmos5_sd_body*sig_delr_pcj0_junc_pmos5_sd_body)))
+    pjs_junc_pmos5_sd_body         = (nom_pjs_junc_pmos5_sd_body*(nom_delr_pjs_junc_pmos5_sd_body*(1+nsig_delr_pjs_junc_pmos5_sd_body*sig_delr_pjs_junc_pmos5_sd_body)))
+    chcj0_junc_pmos5_sd_body       = (nom_chcj0_junc_pmos5_sd_body*(nom_delr_chcj0_junc_pmos5_sd_body*(1+nsig_delr_chcj0_junc_pmos5_sd_body*sig_delr_chcj0_junc_pmos5_sd_body)))
+    chjs_junc_pmos5_sd_body        = (nom_chjs_junc_pmos5_sd_body*(nom_delr_chjs_junc_pmos5_sd_body*(1+nsig_delr_chjs_junc_pmos5_sd_body*sig_delr_chjs_junc_pmos5_sd_body)))
+    acj0_junc_nmos10_d_body        = (nom_acj0_junc_nmos10_d_body*(nom_delr_acj0_junc_nmos10_d_body*(1+nsig_delr_acj0_junc_nmos10_d_body*sig_delr_acj0_junc_nmos10_d_body)))
+    ajs_junc_nmos10_d_body         = (nom_ajs_junc_nmos10_d_body*(nom_delr_ajs_junc_nmos10_d_body*(1+nsig_delr_ajs_junc_nmos10_d_body*sig_delr_ajs_junc_nmos10_d_body)))
+    pcj0_junc_nmos10_d_body        = (nom_pcj0_junc_nmos10_d_body*(nom_delr_pcj0_junc_nmos10_d_body*(1+nsig_delr_pcj0_junc_nmos10_d_body*sig_delr_pcj0_junc_nmos10_d_body)))
+    pjs_junc_nmos10_d_body         = (nom_pjs_junc_nmos10_d_body*(nom_delr_pjs_junc_nmos10_d_body*(1+nsig_delr_pjs_junc_nmos10_d_body*sig_delr_pjs_junc_nmos10_d_body)))
+    chcj0_junc_nmos10_d_body       = (nom_chcj0_junc_nmos10_d_body*(nom_delr_chcj0_junc_nmos10_d_body*(1+nsig_delr_chcj0_junc_nmos10_d_body*sig_delr_chcj0_junc_nmos10_d_body)))
+    chjs_junc_nmos10_d_body        = (nom_chjs_junc_nmos10_d_body*(nom_delr_chjs_junc_nmos10_d_body*(1+nsig_delr_chjs_junc_nmos10_d_body*sig_delr_chjs_junc_nmos10_d_body)))
+    acj0_junc_nmos10_s_body        = (nom_acj0_junc_nmos10_s_body*(nom_delr_acj0_junc_nmos10_s_body*(1+nsig_delr_acj0_junc_nmos10_s_body*sig_delr_acj0_junc_nmos10_s_body)))
+    ajs_junc_nmos10_s_body         = (nom_ajs_junc_nmos10_s_body*(nom_delr_ajs_junc_nmos10_s_body*(1+nsig_delr_ajs_junc_nmos10_s_body*sig_delr_ajs_junc_nmos10_s_body)))
+    pcj0_junc_nmos10_s_body        = (nom_pcj0_junc_nmos10_s_body*(nom_delr_pcj0_junc_nmos10_s_body*(1+nsig_delr_pcj0_junc_nmos10_s_body*sig_delr_pcj0_junc_nmos10_s_body)))
+    pjs_junc_nmos10_s_body         = (nom_pjs_junc_nmos10_s_body*(nom_delr_pjs_junc_nmos10_s_body*(1+nsig_delr_pjs_junc_nmos10_s_body*sig_delr_pjs_junc_nmos10_s_body)))
+    chcj0_junc_nmos10_s_body       = (nom_chcj0_junc_nmos10_s_body*(nom_delr_chcj0_junc_nmos10_s_body*(1+nsig_delr_chcj0_junc_nmos10_s_body*sig_delr_chcj0_junc_nmos10_s_body)))
+    chjs_junc_nmos10_s_body        = (nom_chjs_junc_nmos10_s_body*(nom_delr_chjs_junc_nmos10_s_body*(1+nsig_delr_chjs_junc_nmos10_s_body*sig_delr_chjs_junc_nmos10_s_body)))
+    acj0_junc_pmos10_d_body        = (nom_acj0_junc_pmos10_d_body*(nom_delr_acj0_junc_pmos10_d_body*(1+nsig_delr_acj0_junc_pmos10_d_body*sig_delr_acj0_junc_pmos10_d_body)))
+    ajs_junc_pmos10_d_body         = (nom_ajs_junc_pmos10_d_body*(nom_delr_ajs_junc_pmos10_d_body*(1+nsig_delr_ajs_junc_pmos10_d_body*sig_delr_ajs_junc_pmos10_d_body)))
+    pcj0_junc_pmos10_d_body        = (nom_pcj0_junc_pmos10_d_body*(nom_delr_pcj0_junc_pmos10_d_body*(1+nsig_delr_pcj0_junc_pmos10_d_body*sig_delr_pcj0_junc_pmos10_d_body)))
+    pjs_junc_pmos10_d_body         = (nom_pjs_junc_pmos10_d_body*(nom_delr_pjs_junc_pmos10_d_body*(1+nsig_delr_pjs_junc_pmos10_d_body*sig_delr_pjs_junc_pmos10_d_body)))
+    chcj0_junc_pmos10_d_body       = (nom_chcj0_junc_pmos10_d_body*(nom_delr_chcj0_junc_pmos10_d_body*(1+nsig_delr_chcj0_junc_pmos10_d_body*sig_delr_chcj0_junc_pmos10_d_body)))
+    chjs_junc_pmos10_d_body        = (nom_chjs_junc_pmos10_d_body*(nom_delr_chjs_junc_pmos10_d_body*(1+nsig_delr_chjs_junc_pmos10_d_body*sig_delr_chjs_junc_pmos10_d_body)))
+    acj0_junc_pmos10_s_body        = (nom_acj0_junc_pmos10_s_body*(nom_delr_acj0_junc_pmos10_s_body*(1+nsig_delr_acj0_junc_pmos10_s_body*sig_delr_acj0_junc_pmos10_s_body)))
+    ajs_junc_pmos10_s_body         = (nom_ajs_junc_pmos10_s_body*(nom_delr_ajs_junc_pmos10_s_body*(1+nsig_delr_ajs_junc_pmos10_s_body*sig_delr_ajs_junc_pmos10_s_body)))
+    pcj0_junc_pmos10_s_body        = (nom_pcj0_junc_pmos10_s_body*(nom_delr_pcj0_junc_pmos10_s_body*(1+nsig_delr_pcj0_junc_pmos10_s_body*sig_delr_pcj0_junc_pmos10_s_body)))
+    pjs_junc_pmos10_s_body         = (nom_pjs_junc_pmos10_s_body*(nom_delr_pjs_junc_pmos10_s_body*(1+nsig_delr_pjs_junc_pmos10_s_body*sig_delr_pjs_junc_pmos10_s_body)))
+    chcj0_junc_pmos10_s_body       = (nom_chcj0_junc_pmos10_s_body*(nom_delr_chcj0_junc_pmos10_s_body*(1+nsig_delr_chcj0_junc_pmos10_s_body*sig_delr_chcj0_junc_pmos10_s_body)))
+    chjs_junc_pmos10_s_body        = (nom_chjs_junc_pmos10_s_body*(nom_delr_chjs_junc_pmos10_s_body*(1+nsig_delr_chjs_junc_pmos10_s_body*sig_delr_chjs_junc_pmos10_s_body)))
+    acj0_junc_nmos45_d_body        = (nom_acj0_junc_nmos45_d_body*(nom_delr_acj0_junc_nmos45_d_body*(1+nsig_delr_acj0_junc_nmos45_d_body*sig_delr_acj0_junc_nmos45_d_body)))
+    ajs_junc_nmos45_d_body         = (nom_ajs_junc_nmos45_d_body*(nom_delr_ajs_junc_nmos45_d_body*(1+nsig_delr_ajs_junc_nmos45_d_body*sig_delr_ajs_junc_nmos45_d_body)))
+    pcj0_junc_nmos45_d_body        = (nom_pcj0_junc_nmos45_d_body*(nom_delr_pcj0_junc_nmos45_d_body*(1+nsig_delr_pcj0_junc_nmos45_d_body*sig_delr_pcj0_junc_nmos45_d_body)))
+    pjs_junc_nmos45_d_body         = (nom_pjs_junc_nmos45_d_body*(nom_delr_pjs_junc_nmos45_d_body*(1+nsig_delr_pjs_junc_nmos45_d_body*sig_delr_pjs_junc_nmos45_d_body)))
+    chcj0_junc_nmos45_d_body       = (nom_chcj0_junc_nmos45_d_body*(nom_delr_chcj0_junc_nmos45_d_body*(1+nsig_delr_chcj0_junc_nmos45_d_body*sig_delr_chcj0_junc_nmos45_d_body)))
+    chjs_junc_nmos45_d_body        = (nom_chjs_junc_nmos45_d_body*(nom_delr_chjs_junc_nmos45_d_body*(1+nsig_delr_chjs_junc_nmos45_d_body*sig_delr_chjs_junc_nmos45_d_body)))
+    acj0_junc_nmos45_s_body        = (nom_acj0_junc_nmos45_s_body*(nom_delr_acj0_junc_nmos45_s_body*(1+nsig_delr_acj0_junc_nmos45_s_body*sig_delr_acj0_junc_nmos45_s_body)))
+    ajs_junc_nmos45_s_body         = (nom_ajs_junc_nmos45_s_body*(nom_delr_ajs_junc_nmos45_s_body*(1+nsig_delr_ajs_junc_nmos45_s_body*sig_delr_ajs_junc_nmos45_s_body)))
+    pcj0_junc_nmos45_s_body        = (nom_pcj0_junc_nmos45_s_body*(nom_delr_pcj0_junc_nmos45_s_body*(1+nsig_delr_pcj0_junc_nmos45_s_body*sig_delr_pcj0_junc_nmos45_s_body)))
+    pjs_junc_nmos45_s_body         = (nom_pjs_junc_nmos45_s_body*(nom_delr_pjs_junc_nmos45_s_body*(1+nsig_delr_pjs_junc_nmos45_s_body*sig_delr_pjs_junc_nmos45_s_body)))
+    chcj0_junc_nmos45_s_body       = (nom_chcj0_junc_nmos45_s_body*(nom_delr_chcj0_junc_nmos45_s_body*(1+nsig_delr_chcj0_junc_nmos45_s_body*sig_delr_chcj0_junc_nmos45_s_body)))
+    chjs_junc_nmos45_s_body        = (nom_chjs_junc_nmos45_s_body*(nom_delr_chjs_junc_nmos45_s_body*(1+nsig_delr_chjs_junc_nmos45_s_body*sig_delr_chjs_junc_nmos45_s_body)))
+    acj0_junc_nmos45b_d_body       = (nom_acj0_junc_nmos45b_d_body*(nom_delr_acj0_junc_nmos45b_d_body*(1+nsig_delr_acj0_junc_nmos45b_d_body*sig_delr_acj0_junc_nmos45b_d_body)))
+    ajs_junc_nmos45b_d_body        = (nom_ajs_junc_nmos45b_d_body*(nom_delr_ajs_junc_nmos45b_d_body*(1+nsig_delr_ajs_junc_nmos45b_d_body*sig_delr_ajs_junc_nmos45b_d_body)))
+    pcj0_junc_nmos45b_d_body       = (nom_pcj0_junc_nmos45b_d_body*(nom_delr_pcj0_junc_nmos45b_d_body*(1+nsig_delr_pcj0_junc_nmos45b_d_body*sig_delr_pcj0_junc_nmos45b_d_body)))
+    pjs_junc_nmos45b_d_body        = (nom_pjs_junc_nmos45b_d_body*(nom_delr_pjs_junc_nmos45b_d_body*(1+nsig_delr_pjs_junc_nmos45b_d_body*sig_delr_pjs_junc_nmos45b_d_body)))
+    chcj0_junc_nmos45b_d_body      = (nom_chcj0_junc_nmos45b_d_body*(nom_delr_chcj0_junc_nmos45b_d_body*(1+nsig_delr_chcj0_junc_nmos45b_d_body*sig_delr_chcj0_junc_nmos45b_d_body)))
+    chjs_junc_nmos45b_d_body       = (nom_chjs_junc_nmos45b_d_body*(nom_delr_chjs_junc_nmos45b_d_body*(1+nsig_delr_chjs_junc_nmos45b_d_body*sig_delr_chjs_junc_nmos45b_d_body)))
+    acj0_junc_nmos45b_s_body       = (nom_acj0_junc_nmos45b_s_body*(nom_delr_acj0_junc_nmos45b_s_body*(1+nsig_delr_acj0_junc_nmos45b_s_body*sig_delr_acj0_junc_nmos45b_s_body)))
+    ajs_junc_nmos45b_s_body        = (nom_ajs_junc_nmos45b_s_body*(nom_delr_ajs_junc_nmos45b_s_body*(1+nsig_delr_ajs_junc_nmos45b_s_body*sig_delr_ajs_junc_nmos45b_s_body)))
+    pcj0_junc_nmos45b_s_body       = (nom_pcj0_junc_nmos45b_s_body*(nom_delr_pcj0_junc_nmos45b_s_body*(1+nsig_delr_pcj0_junc_nmos45b_s_body*sig_delr_pcj0_junc_nmos45b_s_body)))
+    pjs_junc_nmos45b_s_body        = (nom_pjs_junc_nmos45b_s_body*(nom_delr_pjs_junc_nmos45b_s_body*(1+nsig_delr_pjs_junc_nmos45b_s_body*sig_delr_pjs_junc_nmos45b_s_body)))
+    chcj0_junc_nmos45b_s_body      = (nom_chcj0_junc_nmos45b_s_body*(nom_delr_chcj0_junc_nmos45b_s_body*(1+nsig_delr_chcj0_junc_nmos45b_s_body*sig_delr_chcj0_junc_nmos45b_s_body)))
+    chjs_junc_nmos45b_s_body       = (nom_chjs_junc_nmos45b_s_body*(nom_delr_chjs_junc_nmos45b_s_body*(1+nsig_delr_chjs_junc_nmos45b_s_body*sig_delr_chjs_junc_nmos45b_s_body)))
+    acj0_junc_pmos45_d_body        = (nom_acj0_junc_pmos45_d_body*(nom_delr_acj0_junc_pmos45_d_body*(1+nsig_delr_acj0_junc_pmos45_d_body*sig_delr_acj0_junc_pmos45_d_body)))
+    ajs_junc_pmos45_d_body         = (nom_ajs_junc_pmos45_d_body*(nom_delr_ajs_junc_pmos45_d_body*(1+nsig_delr_ajs_junc_pmos45_d_body*sig_delr_ajs_junc_pmos45_d_body)))
+    pcj0_junc_pmos45_d_body        = (nom_pcj0_junc_pmos45_d_body*(nom_delr_pcj0_junc_pmos45_d_body*(1+nsig_delr_pcj0_junc_pmos45_d_body*sig_delr_pcj0_junc_pmos45_d_body)))
+    pjs_junc_pmos45_d_body         = (nom_pjs_junc_pmos45_d_body*(nom_delr_pjs_junc_pmos45_d_body*(1+nsig_delr_pjs_junc_pmos45_d_body*sig_delr_pjs_junc_pmos45_d_body)))
+    chcj0_junc_pmos45_d_body       = (nom_chcj0_junc_pmos45_d_body*(nom_delr_chcj0_junc_pmos45_d_body*(1+nsig_delr_chcj0_junc_pmos45_d_body*sig_delr_chcj0_junc_pmos45_d_body)))
+    chjs_junc_pmos45_d_body        = (nom_chjs_junc_pmos45_d_body*(nom_delr_chjs_junc_pmos45_d_body*(1+nsig_delr_chjs_junc_pmos45_d_body*sig_delr_chjs_junc_pmos45_d_body)))
+    acj0_junc_pmos45_s_body        = (nom_acj0_junc_pmos45_s_body*(nom_delr_acj0_junc_pmos45_s_body*(1+nsig_delr_acj0_junc_pmos45_s_body*sig_delr_acj0_junc_pmos45_s_body)))
+    ajs_junc_pmos45_s_body         = (nom_ajs_junc_pmos45_s_body*(nom_delr_ajs_junc_pmos45_s_body*(1+nsig_delr_ajs_junc_pmos45_s_body*sig_delr_ajs_junc_pmos45_s_body)))
+    pcj0_junc_pmos45_s_body        = (nom_pcj0_junc_pmos45_s_body*(nom_delr_pcj0_junc_pmos45_s_body*(1+nsig_delr_pcj0_junc_pmos45_s_body*sig_delr_pcj0_junc_pmos45_s_body)))
+    pjs_junc_pmos45_s_body         = (nom_pjs_junc_pmos45_s_body*(nom_delr_pjs_junc_pmos45_s_body*(1+nsig_delr_pjs_junc_pmos45_s_body*sig_delr_pjs_junc_pmos45_s_body)))
+    chcj0_junc_pmos45_s_body       = (nom_chcj0_junc_pmos45_s_body*(nom_delr_chcj0_junc_pmos45_s_body*(1+nsig_delr_chcj0_junc_pmos45_s_body*sig_delr_chcj0_junc_pmos45_s_body)))
+    chjs_junc_pmos45_s_body        = (nom_chjs_junc_pmos45_s_body*(nom_delr_chjs_junc_pmos45_s_body*(1+nsig_delr_chjs_junc_pmos45_s_body*sig_delr_chjs_junc_pmos45_s_body)))
+    acj0_junc_pmos45b_d_body       = (nom_acj0_junc_pmos45b_d_body*(nom_delr_acj0_junc_pmos45b_d_body*(1+nsig_delr_acj0_junc_pmos45b_d_body*sig_delr_acj0_junc_pmos45b_d_body)))
+    ajs_junc_pmos45b_d_body        = (nom_ajs_junc_pmos45b_d_body*(nom_delr_ajs_junc_pmos45b_d_body*(1+nsig_delr_ajs_junc_pmos45b_d_body*sig_delr_ajs_junc_pmos45b_d_body)))
+    pcj0_junc_pmos45b_d_body       = (nom_pcj0_junc_pmos45b_d_body*(nom_delr_pcj0_junc_pmos45b_d_body*(1+nsig_delr_pcj0_junc_pmos45b_d_body*sig_delr_pcj0_junc_pmos45b_d_body)))
+    pjs_junc_pmos45b_d_body        = (nom_pjs_junc_pmos45b_d_body*(nom_delr_pjs_junc_pmos45b_d_body*(1+nsig_delr_pjs_junc_pmos45b_d_body*sig_delr_pjs_junc_pmos45b_d_body)))
+    chcj0_junc_pmos45b_d_body      = (nom_chcj0_junc_pmos45b_d_body*(nom_delr_chcj0_junc_pmos45b_d_body*(1+nsig_delr_chcj0_junc_pmos45b_d_body*sig_delr_chcj0_junc_pmos45b_d_body)))
+    chjs_junc_pmos45b_d_body       = (nom_chjs_junc_pmos45b_d_body*(nom_delr_chjs_junc_pmos45b_d_body*(1+nsig_delr_chjs_junc_pmos45b_d_body*sig_delr_chjs_junc_pmos45b_d_body)))
+    acj0_junc_pmos45b_s_body       = (nom_acj0_junc_pmos45b_s_body*(nom_delr_acj0_junc_pmos45b_s_body*(1+nsig_delr_acj0_junc_pmos45b_s_body*sig_delr_acj0_junc_pmos45b_s_body)))
+    ajs_junc_pmos45b_s_body        = (nom_ajs_junc_pmos45b_s_body*(nom_delr_ajs_junc_pmos45b_s_body*(1+nsig_delr_ajs_junc_pmos45b_s_body*sig_delr_ajs_junc_pmos45b_s_body)))
+    pcj0_junc_pmos45b_s_body       = (nom_pcj0_junc_pmos45b_s_body*(nom_delr_pcj0_junc_pmos45b_s_body*(1+nsig_delr_pcj0_junc_pmos45b_s_body*sig_delr_pcj0_junc_pmos45b_s_body)))
+    pjs_junc_pmos45b_s_body        = (nom_pjs_junc_pmos45b_s_body*(nom_delr_pjs_junc_pmos45b_s_body*(1+nsig_delr_pjs_junc_pmos45b_s_body*sig_delr_pjs_junc_pmos45b_s_body)))
+    chcj0_junc_pmos45b_s_body      = (nom_chcj0_junc_pmos45b_s_body*(nom_delr_chcj0_junc_pmos45b_s_body*(1+nsig_delr_chcj0_junc_pmos45b_s_body*sig_delr_chcj0_junc_pmos45b_s_body)))
+    chjs_junc_pmos45b_s_body       = (nom_chjs_junc_pmos45b_s_body*(nom_delr_chjs_junc_pmos45b_s_body*(1+nsig_delr_chjs_junc_pmos45b_s_body*sig_delr_chjs_junc_pmos45b_s_body)))
+    acj0_junc_pmoshs45_d_body      = (nom_acj0_junc_pmoshs45_d_body*(nom_delr_acj0_junc_pmoshs45_d_body*(1+nsig_delr_acj0_junc_pmoshs45_d_body*sig_delr_acj0_junc_pmoshs45_d_body)))
+    ajs_junc_pmoshs45_d_body       = (nom_ajs_junc_pmoshs45_d_body*(nom_delr_ajs_junc_pmoshs45_d_body*(1+nsig_delr_ajs_junc_pmoshs45_d_body*sig_delr_ajs_junc_pmoshs45_d_body)))
+    pcj0_junc_pmoshs45_d_body      = (nom_pcj0_junc_pmoshs45_d_body*(nom_delr_pcj0_junc_pmoshs45_d_body*(1+nsig_delr_pcj0_junc_pmoshs45_d_body*sig_delr_pcj0_junc_pmoshs45_d_body)))
+    pjs_junc_pmoshs45_d_body       = (nom_pjs_junc_pmoshs45_d_body*(nom_delr_pjs_junc_pmoshs45_d_body*(1+nsig_delr_pjs_junc_pmoshs45_d_body*sig_delr_pjs_junc_pmoshs45_d_body)))
+    chcj0_junc_pmoshs45_d_body     = (nom_chcj0_junc_pmoshs45_d_body*(nom_delr_chcj0_junc_pmoshs45_d_body*(1+nsig_delr_chcj0_junc_pmoshs45_d_body*sig_delr_chcj0_junc_pmoshs45_d_body)))
+    chjs_junc_pmoshs45_d_body      = (nom_chjs_junc_pmoshs45_d_body*(nom_delr_chjs_junc_pmoshs45_d_body*(1+nsig_delr_chjs_junc_pmoshs45_d_body*sig_delr_chjs_junc_pmoshs45_d_body)))
+    acj0_junc_pmoshs45_s_body      = (nom_acj0_junc_pmoshs45_s_body*(nom_delr_acj0_junc_pmoshs45_s_body*(1+nsig_delr_acj0_junc_pmoshs45_s_body*sig_delr_acj0_junc_pmoshs45_s_body)))
+    ajs_junc_pmoshs45_s_body       = (nom_ajs_junc_pmoshs45_s_body*(nom_delr_ajs_junc_pmoshs45_s_body*(1+nsig_delr_ajs_junc_pmoshs45_s_body*sig_delr_ajs_junc_pmoshs45_s_body)))
+    pcj0_junc_pmoshs45_s_body      = (nom_pcj0_junc_pmoshs45_s_body*(nom_delr_pcj0_junc_pmoshs45_s_body*(1+nsig_delr_pcj0_junc_pmoshs45_s_body*sig_delr_pcj0_junc_pmoshs45_s_body)))
+    pjs_junc_pmoshs45_s_body       = (nom_pjs_junc_pmoshs45_s_body*(nom_delr_pjs_junc_pmoshs45_s_body*(1+nsig_delr_pjs_junc_pmoshs45_s_body*sig_delr_pjs_junc_pmoshs45_s_body)))
+    chcj0_junc_pmoshs45_s_body     = (nom_chcj0_junc_pmoshs45_s_body*(nom_delr_chcj0_junc_pmoshs45_s_body*(1+nsig_delr_chcj0_junc_pmoshs45_s_body*sig_delr_chcj0_junc_pmoshs45_s_body)))
+    chjs_junc_pmoshs45_s_body      = (nom_chjs_junc_pmoshs45_s_body*(nom_delr_chjs_junc_pmoshs45_s_body*(1+nsig_delr_chjs_junc_pmoshs45_s_body*sig_delr_chjs_junc_pmoshs45_s_body)))
+    acj0_junc_pmoshs45b_d_body     = (nom_acj0_junc_pmoshs45b_d_body*(nom_delr_acj0_junc_pmoshs45b_d_body*(1+nsig_delr_acj0_junc_pmoshs45b_d_body*sig_delr_acj0_junc_pmoshs45b_d_body)))
+    ajs_junc_pmoshs45b_d_body      = (nom_ajs_junc_pmoshs45b_d_body*(nom_delr_ajs_junc_pmoshs45b_d_body*(1+nsig_delr_ajs_junc_pmoshs45b_d_body*sig_delr_ajs_junc_pmoshs45b_d_body)))
+    pcj0_junc_pmoshs45b_d_body     = (nom_pcj0_junc_pmoshs45b_d_body*(nom_delr_pcj0_junc_pmoshs45b_d_body*(1+nsig_delr_pcj0_junc_pmoshs45b_d_body*sig_delr_pcj0_junc_pmoshs45b_d_body)))
+    pjs_junc_pmoshs45b_d_body      = (nom_pjs_junc_pmoshs45b_d_body*(nom_delr_pjs_junc_pmoshs45b_d_body*(1+nsig_delr_pjs_junc_pmoshs45b_d_body*sig_delr_pjs_junc_pmoshs45b_d_body)))
+    chcj0_junc_pmoshs45b_d_body    = (nom_chcj0_junc_pmoshs45b_d_body*(nom_delr_chcj0_junc_pmoshs45b_d_body*(1+nsig_delr_chcj0_junc_pmoshs45b_d_body*sig_delr_chcj0_junc_pmoshs45b_d_body)))
+    chjs_junc_pmoshs45b_d_body     = (nom_chjs_junc_pmoshs45b_d_body*(nom_delr_chjs_junc_pmoshs45b_d_body*(1+nsig_delr_chjs_junc_pmoshs45b_d_body*sig_delr_chjs_junc_pmoshs45b_d_body)))
+    acj0_junc_pmoshs45b_s_body     = (nom_acj0_junc_pmoshs45b_s_body*(nom_delr_acj0_junc_pmoshs45b_s_body*(1+nsig_delr_acj0_junc_pmoshs45b_s_body*sig_delr_acj0_junc_pmoshs45b_s_body)))
+    ajs_junc_pmoshs45b_s_body      = (nom_ajs_junc_pmoshs45b_s_body*(nom_delr_ajs_junc_pmoshs45b_s_body*(1+nsig_delr_ajs_junc_pmoshs45b_s_body*sig_delr_ajs_junc_pmoshs45b_s_body)))
+    pcj0_junc_pmoshs45b_s_body     = (nom_pcj0_junc_pmoshs45b_s_body*(nom_delr_pcj0_junc_pmoshs45b_s_body*(1+nsig_delr_pcj0_junc_pmoshs45b_s_body*sig_delr_pcj0_junc_pmoshs45b_s_body)))
+    pjs_junc_pmoshs45b_s_body      = (nom_pjs_junc_pmoshs45b_s_body*(nom_delr_pjs_junc_pmoshs45b_s_body*(1+nsig_delr_pjs_junc_pmoshs45b_s_body*sig_delr_pjs_junc_pmoshs45b_s_body)))
+    chcj0_junc_pmoshs45b_s_body    = (nom_chcj0_junc_pmoshs45b_s_body*(nom_delr_chcj0_junc_pmoshs45b_s_body*(1+nsig_delr_chcj0_junc_pmoshs45b_s_body*sig_delr_chcj0_junc_pmoshs45b_s_body)))
+    chjs_junc_pmoshs45b_s_body     = (nom_chjs_junc_pmoshs45b_s_body*(nom_delr_chjs_junc_pmoshs45b_s_body*(1+nsig_delr_chjs_junc_pmoshs45b_s_body*sig_delr_chjs_junc_pmoshs45b_s_body)))
+    acj0_junc_nmos90_d_body        = (nom_acj0_junc_nmos90_d_body*(nom_delr_acj0_junc_nmos90_d_body*(1+nsig_delr_acj0_junc_nmos90_d_body*sig_delr_acj0_junc_nmos90_d_body)))
+    ajs_junc_nmos90_d_body         = (nom_ajs_junc_nmos90_d_body*(nom_delr_ajs_junc_nmos90_d_body*(1+nsig_delr_ajs_junc_nmos90_d_body*sig_delr_ajs_junc_nmos90_d_body)))
+    pcj0_junc_nmos90_d_body        = (nom_pcj0_junc_nmos90_d_body*(nom_delr_pcj0_junc_nmos90_d_body*(1+nsig_delr_pcj0_junc_nmos90_d_body*sig_delr_pcj0_junc_nmos90_d_body)))
+    pjs_junc_nmos90_d_body         = (nom_pjs_junc_nmos90_d_body*(nom_delr_pjs_junc_nmos90_d_body*(1+nsig_delr_pjs_junc_nmos90_d_body*sig_delr_pjs_junc_nmos90_d_body)))
+    chcj0_junc_nmos90_d_body       = (nom_chcj0_junc_nmos90_d_body*(nom_delr_chcj0_junc_nmos90_d_body*(1+nsig_delr_chcj0_junc_nmos90_d_body*sig_delr_chcj0_junc_nmos90_d_body)))
+    chjs_junc_nmos90_d_body        = (nom_chjs_junc_nmos90_d_body*(nom_delr_chjs_junc_nmos90_d_body*(1+nsig_delr_chjs_junc_nmos90_d_body*sig_delr_chjs_junc_nmos90_d_body)))
+    acj0_junc_nmos90_s_body        = (nom_acj0_junc_nmos90_s_body*(nom_delr_acj0_junc_nmos90_s_body*(1+nsig_delr_acj0_junc_nmos90_s_body*sig_delr_acj0_junc_nmos90_s_body)))
+    ajs_junc_nmos90_s_body         = (nom_ajs_junc_nmos90_s_body*(nom_delr_ajs_junc_nmos90_s_body*(1+nsig_delr_ajs_junc_nmos90_s_body*sig_delr_ajs_junc_nmos90_s_body)))
+    pcj0_junc_nmos90_s_body        = (nom_pcj0_junc_nmos90_s_body*(nom_delr_pcj0_junc_nmos90_s_body*(1+nsig_delr_pcj0_junc_nmos90_s_body*sig_delr_pcj0_junc_nmos90_s_body)))
+    pjs_junc_nmos90_s_body         = (nom_pjs_junc_nmos90_s_body*(nom_delr_pjs_junc_nmos90_s_body*(1+nsig_delr_pjs_junc_nmos90_s_body*sig_delr_pjs_junc_nmos90_s_body)))
+    chcj0_junc_nmos90_s_body       = (nom_chcj0_junc_nmos90_s_body*(nom_delr_chcj0_junc_nmos90_s_body*(1+nsig_delr_chcj0_junc_nmos90_s_body*sig_delr_chcj0_junc_nmos90_s_body)))
+    chjs_junc_nmos90_s_body        = (nom_chjs_junc_nmos90_s_body*(nom_delr_chjs_junc_nmos90_s_body*(1+nsig_delr_chjs_junc_nmos90_s_body*sig_delr_chjs_junc_nmos90_s_body)))
+    acj0_junc_nmos90b_d_body       = (nom_acj0_junc_nmos90b_d_body*(nom_delr_acj0_junc_nmos90b_d_body*(1+nsig_delr_acj0_junc_nmos90b_d_body*sig_delr_acj0_junc_nmos90b_d_body)))
+    ajs_junc_nmos90b_d_body        = (nom_ajs_junc_nmos90b_d_body*(nom_delr_ajs_junc_nmos90b_d_body*(1+nsig_delr_ajs_junc_nmos90b_d_body*sig_delr_ajs_junc_nmos90b_d_body)))
+    pcj0_junc_nmos90b_d_body       = (nom_pcj0_junc_nmos90b_d_body*(nom_delr_pcj0_junc_nmos90b_d_body*(1+nsig_delr_pcj0_junc_nmos90b_d_body*sig_delr_pcj0_junc_nmos90b_d_body)))
+    pjs_junc_nmos90b_d_body        = (nom_pjs_junc_nmos90b_d_body*(nom_delr_pjs_junc_nmos90b_d_body*(1+nsig_delr_pjs_junc_nmos90b_d_body*sig_delr_pjs_junc_nmos90b_d_body)))
+    chcj0_junc_nmos90b_d_body      = (nom_chcj0_junc_nmos90b_d_body*(nom_delr_chcj0_junc_nmos90b_d_body*(1+nsig_delr_chcj0_junc_nmos90b_d_body*sig_delr_chcj0_junc_nmos90b_d_body)))
+    chjs_junc_nmos90b_d_body       = (nom_chjs_junc_nmos90b_d_body*(nom_delr_chjs_junc_nmos90b_d_body*(1+nsig_delr_chjs_junc_nmos90b_d_body*sig_delr_chjs_junc_nmos90b_d_body)))
+    acj0_junc_nmos90b_s_body       = (nom_acj0_junc_nmos90b_s_body*(nom_delr_acj0_junc_nmos90b_s_body*(1+nsig_delr_acj0_junc_nmos90b_s_body*sig_delr_acj0_junc_nmos90b_s_body)))
+    ajs_junc_nmos90b_s_body        = (nom_ajs_junc_nmos90b_s_body*(nom_delr_ajs_junc_nmos90b_s_body*(1+nsig_delr_ajs_junc_nmos90b_s_body*sig_delr_ajs_junc_nmos90b_s_body)))
+    pcj0_junc_nmos90b_s_body       = (nom_pcj0_junc_nmos90b_s_body*(nom_delr_pcj0_junc_nmos90b_s_body*(1+nsig_delr_pcj0_junc_nmos90b_s_body*sig_delr_pcj0_junc_nmos90b_s_body)))
+    pjs_junc_nmos90b_s_body        = (nom_pjs_junc_nmos90b_s_body*(nom_delr_pjs_junc_nmos90b_s_body*(1+nsig_delr_pjs_junc_nmos90b_s_body*sig_delr_pjs_junc_nmos90b_s_body)))
+    chcj0_junc_nmos90b_s_body      = (nom_chcj0_junc_nmos90b_s_body*(nom_delr_chcj0_junc_nmos90b_s_body*(1+nsig_delr_chcj0_junc_nmos90b_s_body*sig_delr_chcj0_junc_nmos90b_s_body)))
+    chjs_junc_nmos90b_s_body       = (nom_chjs_junc_nmos90b_s_body*(nom_delr_chjs_junc_nmos90b_s_body*(1+nsig_delr_chjs_junc_nmos90b_s_body*sig_delr_chjs_junc_nmos90b_s_body)))
+    acj0_junc_pmos90_d_body        = (nom_acj0_junc_pmos90_d_body*(nom_delr_acj0_junc_pmos90_d_body*(1+nsig_delr_acj0_junc_pmos90_d_body*sig_delr_acj0_junc_pmos90_d_body)))
+    ajs_junc_pmos90_d_body         = (nom_ajs_junc_pmos90_d_body*(nom_delr_ajs_junc_pmos90_d_body*(1+nsig_delr_ajs_junc_pmos90_d_body*sig_delr_ajs_junc_pmos90_d_body)))
+    pcj0_junc_pmos90_d_body        = (nom_pcj0_junc_pmos90_d_body*(nom_delr_pcj0_junc_pmos90_d_body*(1+nsig_delr_pcj0_junc_pmos90_d_body*sig_delr_pcj0_junc_pmos90_d_body)))
+    pjs_junc_pmos90_d_body         = (nom_pjs_junc_pmos90_d_body*(nom_delr_pjs_junc_pmos90_d_body*(1+nsig_delr_pjs_junc_pmos90_d_body*sig_delr_pjs_junc_pmos90_d_body)))
+    chcj0_junc_pmos90_d_body       = (nom_chcj0_junc_pmos90_d_body*(nom_delr_chcj0_junc_pmos90_d_body*(1+nsig_delr_chcj0_junc_pmos90_d_body*sig_delr_chcj0_junc_pmos90_d_body)))
+    chjs_junc_pmos90_d_body        = (nom_chjs_junc_pmos90_d_body*(nom_delr_chjs_junc_pmos90_d_body*(1+nsig_delr_chjs_junc_pmos90_d_body*sig_delr_chjs_junc_pmos90_d_body)))
+    acj0_junc_pmos90b_d_body       = (nom_acj0_junc_pmos90b_d_body*(nom_delr_acj0_junc_pmos90b_d_body*(1+nsig_delr_acj0_junc_pmos90b_d_body*sig_delr_acj0_junc_pmos90b_d_body)))
+    ajs_junc_pmos90b_d_body        = (nom_ajs_junc_pmos90b_d_body*(nom_delr_ajs_junc_pmos90b_d_body*(1+nsig_delr_ajs_junc_pmos90b_d_body*sig_delr_ajs_junc_pmos90b_d_body)))
+    pcj0_junc_pmos90b_d_body       = (nom_pcj0_junc_pmos90b_d_body*(nom_delr_pcj0_junc_pmos90b_d_body*(1+nsig_delr_pcj0_junc_pmos90b_d_body*sig_delr_pcj0_junc_pmos90b_d_body)))
+    pjs_junc_pmos90b_d_body        = (nom_pjs_junc_pmos90b_d_body*(nom_delr_pjs_junc_pmos90b_d_body*(1+nsig_delr_pjs_junc_pmos90b_d_body*sig_delr_pjs_junc_pmos90b_d_body)))
+    chcj0_junc_pmos90b_d_body      = (nom_chcj0_junc_pmos90b_d_body*(nom_delr_chcj0_junc_pmos90b_d_body*(1+nsig_delr_chcj0_junc_pmos90b_d_body*sig_delr_chcj0_junc_pmos90b_d_body)))
+    chjs_junc_pmos90b_d_body       = (nom_chjs_junc_pmos90b_d_body*(nom_delr_chjs_junc_pmos90b_d_body*(1+nsig_delr_chjs_junc_pmos90b_d_body*sig_delr_chjs_junc_pmos90b_d_body)))
+    acj0_junc_pmos90_s_body        = (nom_acj0_junc_pmos90_s_body*(nom_delr_acj0_junc_pmos90_s_body*(1+nsig_delr_acj0_junc_pmos90_s_body*sig_delr_acj0_junc_pmos90_s_body)))
+    ajs_junc_pmos90_s_body         = (nom_ajs_junc_pmos90_s_body*(nom_delr_ajs_junc_pmos90_s_body*(1+nsig_delr_ajs_junc_pmos90_s_body*sig_delr_ajs_junc_pmos90_s_body)))
+    pcj0_junc_pmos90_s_body        = (nom_pcj0_junc_pmos90_s_body*(nom_delr_pcj0_junc_pmos90_s_body*(1+nsig_delr_pcj0_junc_pmos90_s_body*sig_delr_pcj0_junc_pmos90_s_body)))
+    pjs_junc_pmos90_s_body         = (nom_pjs_junc_pmos90_s_body*(nom_delr_pjs_junc_pmos90_s_body*(1+nsig_delr_pjs_junc_pmos90_s_body*sig_delr_pjs_junc_pmos90_s_body)))
+    chcj0_junc_pmos90_s_body       = (nom_chcj0_junc_pmos90_s_body*(nom_delr_chcj0_junc_pmos90_s_body*(1+nsig_delr_chcj0_junc_pmos90_s_body*sig_delr_chcj0_junc_pmos90_s_body)))
+    chjs_junc_pmos90_s_body        = (nom_chjs_junc_pmos90_s_body*(nom_delr_chjs_junc_pmos90_s_body*(1+nsig_delr_chjs_junc_pmos90_s_body*sig_delr_chjs_junc_pmos90_s_body)))
+    acj0_junc_pmos90b_s_body       = (nom_acj0_junc_pmos90b_s_body*(nom_delr_acj0_junc_pmos90b_s_body*(1+nsig_delr_acj0_junc_pmos90b_s_body*sig_delr_acj0_junc_pmos90b_s_body)))
+    ajs_junc_pmos90b_s_body        = (nom_ajs_junc_pmos90b_s_body*(nom_delr_ajs_junc_pmos90b_s_body*(1+nsig_delr_ajs_junc_pmos90b_s_body*sig_delr_ajs_junc_pmos90b_s_body)))
+    pcj0_junc_pmos90b_s_body       = (nom_pcj0_junc_pmos90b_s_body*(nom_delr_pcj0_junc_pmos90b_s_body*(1+nsig_delr_pcj0_junc_pmos90b_s_body*sig_delr_pcj0_junc_pmos90b_s_body)))
+    pjs_junc_pmos90b_s_body        = (nom_pjs_junc_pmos90b_s_body*(nom_delr_pjs_junc_pmos90b_s_body*(1+nsig_delr_pjs_junc_pmos90b_s_body*sig_delr_pjs_junc_pmos90b_s_body)))
+    chcj0_junc_pmos90b_s_body      = (nom_chcj0_junc_pmos90b_s_body*(nom_delr_chcj0_junc_pmos90b_s_body*(1+nsig_delr_chcj0_junc_pmos90b_s_body*sig_delr_chcj0_junc_pmos90b_s_body)))
+    chjs_junc_pmos90b_s_body       = (nom_chjs_junc_pmos90b_s_body*(nom_delr_chjs_junc_pmos90b_s_body*(1+nsig_delr_chjs_junc_pmos90b_s_body*sig_delr_chjs_junc_pmos90b_s_body)))
+    acj0_junc_nld5_d_body          = (nom_acj0_junc_nld5_d_body*(nom_delr_acj0_junc_nld5_d_body*(1+nsig_delr_acj0_junc_nld5_d_body*sig_delr_acj0_junc_nld5_d_body)))
+    ajs_junc_nld5_d_body           = (nom_ajs_junc_nld5_d_body*(nom_delr_ajs_junc_nld5_d_body*(1+nsig_delr_ajs_junc_nld5_d_body*sig_delr_ajs_junc_nld5_d_body)))
+    pcj0_junc_nld5_d_body          = (nom_pcj0_junc_nld5_d_body*(nom_delr_pcj0_junc_nld5_d_body*(1+nsig_delr_pcj0_junc_nld5_d_body*sig_delr_pcj0_junc_nld5_d_body)))
+    pjs_junc_nld5_d_body           = (nom_pjs_junc_nld5_d_body*(nom_delr_pjs_junc_nld5_d_body*(1+nsig_delr_pjs_junc_nld5_d_body*sig_delr_pjs_junc_nld5_d_body)))
+    chcj0_junc_nld5_d_body         = (nom_chcj0_junc_nld5_d_body*(nom_delr_chcj0_junc_nld5_d_body*(1+nsig_delr_chcj0_junc_nld5_d_body*sig_delr_chcj0_junc_nld5_d_body)))
+    chjs_junc_nld5_d_body          = (nom_chjs_junc_nld5_d_body*(nom_delr_chjs_junc_nld5_d_body*(1+nsig_delr_chjs_junc_nld5_d_body*sig_delr_chjs_junc_nld5_d_body)))
+    acj0_junc_nld5_lvt_d_body      = (nom_acj0_junc_nld5_lvt_d_body*(nom_delr_acj0_junc_nld5_lvt_d_body*(1+nsig_delr_acj0_junc_nld5_lvt_d_body*sig_delr_acj0_junc_nld5_lvt_d_body)))
+    ajs_junc_nld5_lvt_d_body       = (nom_ajs_junc_nld5_lvt_d_body*(nom_delr_ajs_junc_nld5_lvt_d_body*(1+nsig_delr_ajs_junc_nld5_lvt_d_body*sig_delr_ajs_junc_nld5_lvt_d_body)))
+    pcj0_junc_nld5_lvt_d_body      = (nom_pcj0_junc_nld5_lvt_d_body*(nom_delr_pcj0_junc_nld5_lvt_d_body*(1+nsig_delr_pcj0_junc_nld5_lvt_d_body*sig_delr_pcj0_junc_nld5_lvt_d_body)))
+    pjs_junc_nld5_lvt_d_body       = (nom_pjs_junc_nld5_lvt_d_body*(nom_delr_pjs_junc_nld5_lvt_d_body*(1+nsig_delr_pjs_junc_nld5_lvt_d_body*sig_delr_pjs_junc_nld5_lvt_d_body)))
+    chcj0_junc_nld5_lvt_d_body     = (nom_chcj0_junc_nld5_lvt_d_body*(nom_delr_chcj0_junc_nld5_lvt_d_body*(1+nsig_delr_chcj0_junc_nld5_lvt_d_body*sig_delr_chcj0_junc_nld5_lvt_d_body)))
+    chjs_junc_nld5_lvt_d_body      = (nom_chjs_junc_nld5_lvt_d_body*(nom_delr_chjs_junc_nld5_lvt_d_body*(1+nsig_delr_chjs_junc_nld5_lvt_d_body*sig_delr_chjs_junc_nld5_lvt_d_body)))
+    acj0_junc_nld10_d_body         = (nom_acj0_junc_nld10_d_body*(nom_delr_acj0_junc_nld10_d_body*(1+nsig_delr_acj0_junc_nld10_d_body*sig_delr_acj0_junc_nld10_d_body)))
+    ajs_junc_nld10_d_body          = (nom_ajs_junc_nld10_d_body*(nom_delr_ajs_junc_nld10_d_body*(1+nsig_delr_ajs_junc_nld10_d_body*sig_delr_ajs_junc_nld10_d_body)))
+    pcj0_junc_nld10_d_body         = (nom_pcj0_junc_nld10_d_body*(nom_delr_pcj0_junc_nld10_d_body*(1+nsig_delr_pcj0_junc_nld10_d_body*sig_delr_pcj0_junc_nld10_d_body)))
+    pjs_junc_nld10_d_body          = (nom_pjs_junc_nld10_d_body*(nom_delr_pjs_junc_nld10_d_body*(1+nsig_delr_pjs_junc_nld10_d_body*sig_delr_pjs_junc_nld10_d_body)))
+    chcj0_junc_nld10_d_body        = (nom_chcj0_junc_nld10_d_body*(nom_delr_chcj0_junc_nld10_d_body*(1+nsig_delr_chcj0_junc_nld10_d_body*sig_delr_chcj0_junc_nld10_d_body)))
+    chjs_junc_nld10_d_body         = (nom_chjs_junc_nld10_d_body*(nom_delr_chjs_junc_nld10_d_body*(1+nsig_delr_chjs_junc_nld10_d_body*sig_delr_chjs_junc_nld10_d_body)))
+    acj0_junc_nld30_d_body         = (nom_acj0_junc_nld30_d_body*(nom_delr_acj0_junc_nld30_d_body*(1+nsig_delr_acj0_junc_nld30_d_body*sig_delr_acj0_junc_nld30_d_body)))
+    ajs_junc_nld30_d_body          = (nom_ajs_junc_nld30_d_body*(nom_delr_ajs_junc_nld30_d_body*(1+nsig_delr_ajs_junc_nld30_d_body*sig_delr_ajs_junc_nld30_d_body)))
+    pcj0_junc_nld30_d_body         = (nom_pcj0_junc_nld30_d_body*(nom_delr_pcj0_junc_nld30_d_body*(1+nsig_delr_pcj0_junc_nld30_d_body*sig_delr_pcj0_junc_nld30_d_body)))
+    pjs_junc_nld30_d_body          = (nom_pjs_junc_nld30_d_body*(nom_delr_pjs_junc_nld30_d_body*(1+nsig_delr_pjs_junc_nld30_d_body*sig_delr_pjs_junc_nld30_d_body)))
+    chcj0_junc_nld30_d_body        = (nom_chcj0_junc_nld30_d_body*(nom_delr_chcj0_junc_nld30_d_body*(1+nsig_delr_chcj0_junc_nld30_d_body*sig_delr_chcj0_junc_nld30_d_body)))
+    chjs_junc_nld30_d_body         = (nom_chjs_junc_nld30_d_body*(nom_delr_chjs_junc_nld30_d_body*(1+nsig_delr_chjs_junc_nld30_d_body*sig_delr_chjs_junc_nld30_d_body)))
+    acj0_junc_nld30b_d_body        = (nom_acj0_junc_nld30b_d_body*(nom_delr_acj0_junc_nld30b_d_body*(1+nsig_delr_acj0_junc_nld30b_d_body*sig_delr_acj0_junc_nld30b_d_body)))
+    ajs_junc_nld30b_d_body         = (nom_ajs_junc_nld30b_d_body*(nom_delr_ajs_junc_nld30b_d_body*(1+nsig_delr_ajs_junc_nld30b_d_body*sig_delr_ajs_junc_nld30b_d_body)))
+    pcj0_junc_nld30b_d_body        = (nom_pcj0_junc_nld30b_d_body*(nom_delr_pcj0_junc_nld30b_d_body*(1+nsig_delr_pcj0_junc_nld30b_d_body*sig_delr_pcj0_junc_nld30b_d_body)))
+    pjs_junc_nld30b_d_body         = (nom_pjs_junc_nld30b_d_body*(nom_delr_pjs_junc_nld30b_d_body*(1+nsig_delr_pjs_junc_nld30b_d_body*sig_delr_pjs_junc_nld30b_d_body)))
+    chcj0_junc_nld30b_d_body       = (nom_chcj0_junc_nld30b_d_body*(nom_delr_chcj0_junc_nld30b_d_body*(1+nsig_delr_chcj0_junc_nld30b_d_body*sig_delr_chcj0_junc_nld30b_d_body)))
+    chjs_junc_nld30b_d_body        = (nom_chjs_junc_nld30b_d_body*(nom_delr_chjs_junc_nld30b_d_body*(1+nsig_delr_chjs_junc_nld30b_d_body*sig_delr_chjs_junc_nld30b_d_body)))
+    acj0_junc_nld45_d_body         = (nom_acj0_junc_nld45_d_body*(nom_delr_acj0_junc_nld45_d_body*(1+nsig_delr_acj0_junc_nld45_d_body*sig_delr_acj0_junc_nld45_d_body)))
+    ajs_junc_nld45_d_body          = (nom_ajs_junc_nld45_d_body*(nom_delr_ajs_junc_nld45_d_body*(1+nsig_delr_ajs_junc_nld45_d_body*sig_delr_ajs_junc_nld45_d_body)))
+    pcj0_junc_nld45_d_body         = (nom_pcj0_junc_nld45_d_body*(nom_delr_pcj0_junc_nld45_d_body*(1+nsig_delr_pcj0_junc_nld45_d_body*sig_delr_pcj0_junc_nld45_d_body)))
+    pjs_junc_nld45_d_body          = (nom_pjs_junc_nld45_d_body*(nom_delr_pjs_junc_nld45_d_body*(1+nsig_delr_pjs_junc_nld45_d_body*sig_delr_pjs_junc_nld45_d_body)))
+    chcj0_junc_nld45_d_body        = (nom_chcj0_junc_nld45_d_body*(nom_delr_chcj0_junc_nld45_d_body*(1+nsig_delr_chcj0_junc_nld45_d_body*sig_delr_chcj0_junc_nld45_d_body)))
+    chjs_junc_nld45_d_body         = (nom_chjs_junc_nld45_d_body*(nom_delr_chjs_junc_nld45_d_body*(1+nsig_delr_chjs_junc_nld45_d_body*sig_delr_chjs_junc_nld45_d_body)))
+    acj0_junc_nld45b_d_body        = (nom_acj0_junc_nld45b_d_body*(nom_delr_acj0_junc_nld45b_d_body*(1+nsig_delr_acj0_junc_nld45b_d_body*sig_delr_acj0_junc_nld45b_d_body)))
+    ajs_junc_nld45b_d_body         = (nom_ajs_junc_nld45b_d_body*(nom_delr_ajs_junc_nld45b_d_body*(1+nsig_delr_ajs_junc_nld45b_d_body*sig_delr_ajs_junc_nld45b_d_body)))
+    pcj0_junc_nld45b_d_body        = (nom_pcj0_junc_nld45b_d_body*(nom_delr_pcj0_junc_nld45b_d_body*(1+nsig_delr_pcj0_junc_nld45b_d_body*sig_delr_pcj0_junc_nld45b_d_body)))
+    pjs_junc_nld45b_d_body         = (nom_pjs_junc_nld45b_d_body*(nom_delr_pjs_junc_nld45b_d_body*(1+nsig_delr_pjs_junc_nld45b_d_body*sig_delr_pjs_junc_nld45b_d_body)))
+    chcj0_junc_nld45b_d_body       = (nom_chcj0_junc_nld45b_d_body*(nom_delr_chcj0_junc_nld45b_d_body*(1+nsig_delr_chcj0_junc_nld45b_d_body*sig_delr_chcj0_junc_nld45b_d_body)))
+    chjs_junc_nld45b_d_body        = (nom_chjs_junc_nld45b_d_body*(nom_delr_chjs_junc_nld45b_d_body*(1+nsig_delr_chjs_junc_nld45b_d_body*sig_delr_chjs_junc_nld45b_d_body)))
+    acj0_junc_nld45_he_d_body      = (nom_acj0_junc_nld45_he_d_body*(nom_delr_acj0_junc_nld45_he_d_body*(1+nsig_delr_acj0_junc_nld45_he_d_body*sig_delr_acj0_junc_nld45_he_d_body)))
+    ajs_junc_nld45_he_d_body       = (nom_ajs_junc_nld45_he_d_body*(nom_delr_ajs_junc_nld45_he_d_body*(1+nsig_delr_ajs_junc_nld45_he_d_body*sig_delr_ajs_junc_nld45_he_d_body)))
+    pcj0_junc_nld45_he_d_body      = (nom_pcj0_junc_nld45_he_d_body*(nom_delr_pcj0_junc_nld45_he_d_body*(1+nsig_delr_pcj0_junc_nld45_he_d_body*sig_delr_pcj0_junc_nld45_he_d_body)))
+    pjs_junc_nld45_he_d_body       = (nom_pjs_junc_nld45_he_d_body*(nom_delr_pjs_junc_nld45_he_d_body*(1+nsig_delr_pjs_junc_nld45_he_d_body*sig_delr_pjs_junc_nld45_he_d_body)))
+    chcj0_junc_nld45_he_d_body     = (nom_chcj0_junc_nld45_he_d_body*(nom_delr_chcj0_junc_nld45_he_d_body*(1+nsig_delr_chcj0_junc_nld45_he_d_body*sig_delr_chcj0_junc_nld45_he_d_body)))
+    chjs_junc_nld45_he_d_body      = (nom_chjs_junc_nld45_he_d_body*(nom_delr_chjs_junc_nld45_he_d_body*(1+nsig_delr_chjs_junc_nld45_he_d_body*sig_delr_chjs_junc_nld45_he_d_body)))
+    acj0_junc_nld45b_he_d_body     = (nom_acj0_junc_nld45b_he_d_body*(nom_delr_acj0_junc_nld45b_he_d_body*(1+nsig_delr_acj0_junc_nld45b_he_d_body*sig_delr_acj0_junc_nld45b_he_d_body)))
+    ajs_junc_nld45b_he_d_body      = (nom_ajs_junc_nld45b_he_d_body*(nom_delr_ajs_junc_nld45b_he_d_body*(1+nsig_delr_ajs_junc_nld45b_he_d_body*sig_delr_ajs_junc_nld45b_he_d_body)))
+    pcj0_junc_nld45b_he_d_body     = (nom_pcj0_junc_nld45b_he_d_body*(nom_delr_pcj0_junc_nld45b_he_d_body*(1+nsig_delr_pcj0_junc_nld45b_he_d_body*sig_delr_pcj0_junc_nld45b_he_d_body)))
+    pjs_junc_nld45b_he_d_body      = (nom_pjs_junc_nld45b_he_d_body*(nom_delr_pjs_junc_nld45b_he_d_body*(1+nsig_delr_pjs_junc_nld45b_he_d_body*sig_delr_pjs_junc_nld45b_he_d_body)))
+    chcj0_junc_nld45b_he_d_body    = (nom_chcj0_junc_nld45b_he_d_body*(nom_delr_chcj0_junc_nld45b_he_d_body*(1+nsig_delr_chcj0_junc_nld45b_he_d_body*sig_delr_chcj0_junc_nld45b_he_d_body)))
+    chjs_junc_nld45b_he_d_body     = (nom_chjs_junc_nld45b_he_d_body*(nom_delr_chjs_junc_nld45b_he_d_body*(1+nsig_delr_chjs_junc_nld45b_he_d_body*sig_delr_chjs_junc_nld45b_he_d_body)))
+    acj0_junc_nld45_tlp_d_body     = (nom_acj0_junc_nld45_tlp_d_body*(nom_delr_acj0_junc_nld45_tlp_d_body*(1+nsig_delr_acj0_junc_nld45_tlp_d_body*sig_delr_acj0_junc_nld45_tlp_d_body)))
+    ajs_junc_nld45_tlp_d_body      = (nom_ajs_junc_nld45_tlp_d_body*(nom_delr_ajs_junc_nld45_tlp_d_body*(1+nsig_delr_ajs_junc_nld45_tlp_d_body*sig_delr_ajs_junc_nld45_tlp_d_body)))
+    pcj0_junc_nld45_tlp_d_body     = (nom_pcj0_junc_nld45_tlp_d_body*(nom_delr_pcj0_junc_nld45_tlp_d_body*(1+nsig_delr_pcj0_junc_nld45_tlp_d_body*sig_delr_pcj0_junc_nld45_tlp_d_body)))
+    pjs_junc_nld45_tlp_d_body      = (nom_pjs_junc_nld45_tlp_d_body*(nom_delr_pjs_junc_nld45_tlp_d_body*(1+nsig_delr_pjs_junc_nld45_tlp_d_body*sig_delr_pjs_junc_nld45_tlp_d_body)))
+    chcj0_junc_nld45_tlp_d_body    = (nom_chcj0_junc_nld45_tlp_d_body*(nom_delr_chcj0_junc_nld45_tlp_d_body*(1+nsig_delr_chcj0_junc_nld45_tlp_d_body*sig_delr_chcj0_junc_nld45_tlp_d_body)))
+    chjs_junc_nld45_tlp_d_body     = (nom_chjs_junc_nld45_tlp_d_body*(nom_delr_chjs_junc_nld45_tlp_d_body*(1+nsig_delr_chjs_junc_nld45_tlp_d_body*sig_delr_chjs_junc_nld45_tlp_d_body)))
+    acj0_junc_nld45b_tlp_d_body    = (nom_acj0_junc_nld45b_tlp_d_body*(nom_delr_acj0_junc_nld45b_tlp_d_body*(1+nsig_delr_acj0_junc_nld45b_tlp_d_body*sig_delr_acj0_junc_nld45b_tlp_d_body)))
+    ajs_junc_nld45b_tlp_d_body     = (nom_ajs_junc_nld45b_tlp_d_body*(nom_delr_ajs_junc_nld45b_tlp_d_body*(1+nsig_delr_ajs_junc_nld45b_tlp_d_body*sig_delr_ajs_junc_nld45b_tlp_d_body)))
+    pcj0_junc_nld45b_tlp_d_body    = (nom_pcj0_junc_nld45b_tlp_d_body*(nom_delr_pcj0_junc_nld45b_tlp_d_body*(1+nsig_delr_pcj0_junc_nld45b_tlp_d_body*sig_delr_pcj0_junc_nld45b_tlp_d_body)))
+    pjs_junc_nld45b_tlp_d_body     = (nom_pjs_junc_nld45b_tlp_d_body*(nom_delr_pjs_junc_nld45b_tlp_d_body*(1+nsig_delr_pjs_junc_nld45b_tlp_d_body*sig_delr_pjs_junc_nld45b_tlp_d_body)))
+    chcj0_junc_nld45b_tlp_d_body   = (nom_chcj0_junc_nld45b_tlp_d_body*(nom_delr_chcj0_junc_nld45b_tlp_d_body*(1+nsig_delr_chcj0_junc_nld45b_tlp_d_body*sig_delr_chcj0_junc_nld45b_tlp_d_body)))
+    chjs_junc_nld45b_tlp_d_body    = (nom_chjs_junc_nld45b_tlp_d_body*(nom_delr_chjs_junc_nld45b_tlp_d_body*(1+nsig_delr_chjs_junc_nld45b_tlp_d_body*sig_delr_chjs_junc_nld45b_tlp_d_body)))
+    acj0_junc_nld65_d_body         = (nom_acj0_junc_nld65_d_body*(nom_delr_acj0_junc_nld65_d_body*(1+nsig_delr_acj0_junc_nld65_d_body*sig_delr_acj0_junc_nld65_d_body)))
+    ajs_junc_nld65_d_body          = (nom_ajs_junc_nld65_d_body*(nom_delr_ajs_junc_nld65_d_body*(1+nsig_delr_ajs_junc_nld65_d_body*sig_delr_ajs_junc_nld65_d_body)))
+    pcj0_junc_nld65_d_body         = (nom_pcj0_junc_nld65_d_body*(nom_delr_pcj0_junc_nld65_d_body*(1+nsig_delr_pcj0_junc_nld65_d_body*sig_delr_pcj0_junc_nld65_d_body)))
+    pjs_junc_nld65_d_body          = (nom_pjs_junc_nld65_d_body*(nom_delr_pjs_junc_nld65_d_body*(1+nsig_delr_pjs_junc_nld65_d_body*sig_delr_pjs_junc_nld65_d_body)))
+    chcj0_junc_nld65_d_body        = (nom_chcj0_junc_nld65_d_body*(nom_delr_chcj0_junc_nld65_d_body*(1+nsig_delr_chcj0_junc_nld65_d_body*sig_delr_chcj0_junc_nld65_d_body)))
+    chjs_junc_nld65_d_body         = (nom_chjs_junc_nld65_d_body*(nom_delr_chjs_junc_nld65_d_body*(1+nsig_delr_chjs_junc_nld65_d_body*sig_delr_chjs_junc_nld65_d_body)))
+    acj0_junc_nld65b_d_body        = (nom_acj0_junc_nld65b_d_body*(nom_delr_acj0_junc_nld65b_d_body*(1+nsig_delr_acj0_junc_nld65b_d_body*sig_delr_acj0_junc_nld65b_d_body)))
+    ajs_junc_nld65b_d_body         = (nom_ajs_junc_nld65b_d_body*(nom_delr_ajs_junc_nld65b_d_body*(1+nsig_delr_ajs_junc_nld65b_d_body*sig_delr_ajs_junc_nld65b_d_body)))
+    pcj0_junc_nld65b_d_body        = (nom_pcj0_junc_nld65b_d_body*(nom_delr_pcj0_junc_nld65b_d_body*(1+nsig_delr_pcj0_junc_nld65b_d_body*sig_delr_pcj0_junc_nld65b_d_body)))
+    pjs_junc_nld65b_d_body         = (nom_pjs_junc_nld65b_d_body*(nom_delr_pjs_junc_nld65b_d_body*(1+nsig_delr_pjs_junc_nld65b_d_body*sig_delr_pjs_junc_nld65b_d_body)))
+    chcj0_junc_nld65b_d_body       = (nom_chcj0_junc_nld65b_d_body*(nom_delr_chcj0_junc_nld65b_d_body*(1+nsig_delr_chcj0_junc_nld65b_d_body*sig_delr_chcj0_junc_nld65b_d_body)))
+    chjs_junc_nld65b_d_body        = (nom_chjs_junc_nld65b_d_body*(nom_delr_chjs_junc_nld65b_d_body*(1+nsig_delr_chjs_junc_nld65b_d_body*sig_delr_chjs_junc_nld65b_d_body)))
+    acj0_junc_nld90_d_body         = (nom_acj0_junc_nld90_d_body*(nom_delr_acj0_junc_nld90_d_body*(1+nsig_delr_acj0_junc_nld90_d_body*sig_delr_acj0_junc_nld90_d_body)))
+    ajs_junc_nld90_d_body          = (nom_ajs_junc_nld90_d_body*(nom_delr_ajs_junc_nld90_d_body*(1+nsig_delr_ajs_junc_nld90_d_body*sig_delr_ajs_junc_nld90_d_body)))
+    pcj0_junc_nld90_d_body         = (nom_pcj0_junc_nld90_d_body*(nom_delr_pcj0_junc_nld90_d_body*(1+nsig_delr_pcj0_junc_nld90_d_body*sig_delr_pcj0_junc_nld90_d_body)))
+    pjs_junc_nld90_d_body          = (nom_pjs_junc_nld90_d_body*(nom_delr_pjs_junc_nld90_d_body*(1+nsig_delr_pjs_junc_nld90_d_body*sig_delr_pjs_junc_nld90_d_body)))
+    chcj0_junc_nld90_d_body        = (nom_chcj0_junc_nld90_d_body*(nom_delr_chcj0_junc_nld90_d_body*(1+nsig_delr_chcj0_junc_nld90_d_body*sig_delr_chcj0_junc_nld90_d_body)))
+    chjs_junc_nld90_d_body         = (nom_chjs_junc_nld90_d_body*(nom_delr_chjs_junc_nld90_d_body*(1+nsig_delr_chjs_junc_nld90_d_body*sig_delr_chjs_junc_nld90_d_body)))
+    acj0_junc_nld90b_d_body        = (nom_acj0_junc_nld90b_d_body*(nom_delr_acj0_junc_nld90b_d_body*(1+nsig_delr_acj0_junc_nld90b_d_body*sig_delr_acj0_junc_nld90b_d_body)))
+    ajs_junc_nld90b_d_body         = (nom_ajs_junc_nld90b_d_body*(nom_delr_ajs_junc_nld90b_d_body*(1+nsig_delr_ajs_junc_nld90b_d_body*sig_delr_ajs_junc_nld90b_d_body)))
+    pcj0_junc_nld90b_d_body        = (nom_pcj0_junc_nld90b_d_body*(nom_delr_pcj0_junc_nld90b_d_body*(1+nsig_delr_pcj0_junc_nld90b_d_body*sig_delr_pcj0_junc_nld90b_d_body)))
+    pjs_junc_nld90b_d_body         = (nom_pjs_junc_nld90b_d_body*(nom_delr_pjs_junc_nld90b_d_body*(1+nsig_delr_pjs_junc_nld90b_d_body*sig_delr_pjs_junc_nld90b_d_body)))
+    chcj0_junc_nld90b_d_body       = (nom_chcj0_junc_nld90b_d_body*(nom_delr_chcj0_junc_nld90b_d_body*(1+nsig_delr_chcj0_junc_nld90b_d_body*sig_delr_chcj0_junc_nld90b_d_body)))
+    chjs_junc_nld90b_d_body        = (nom_chjs_junc_nld90b_d_body*(nom_delr_chjs_junc_nld90b_d_body*(1+nsig_delr_chjs_junc_nld90b_d_body*sig_delr_chjs_junc_nld90b_d_body)))
+    acj0_junc_pld5_d_body          = (nom_acj0_junc_pld5_d_body*(nom_delr_acj0_junc_pld5_d_body*(1+nsig_delr_acj0_junc_pld5_d_body*sig_delr_acj0_junc_pld5_d_body)))
+    ajs_junc_pld5_d_body           = (nom_ajs_junc_pld5_d_body*(nom_delr_ajs_junc_pld5_d_body*(1+nsig_delr_ajs_junc_pld5_d_body*sig_delr_ajs_junc_pld5_d_body)))
+    pcj0_junc_pld5_d_body          = (nom_pcj0_junc_pld5_d_body*(nom_delr_pcj0_junc_pld5_d_body*(1+nsig_delr_pcj0_junc_pld5_d_body*sig_delr_pcj0_junc_pld5_d_body)))
+    pjs_junc_pld5_d_body           = (nom_pjs_junc_pld5_d_body*(nom_delr_pjs_junc_pld5_d_body*(1+nsig_delr_pjs_junc_pld5_d_body*sig_delr_pjs_junc_pld5_d_body)))
+    chcj0_junc_pld5_d_body         = (nom_chcj0_junc_pld5_d_body*(nom_delr_chcj0_junc_pld5_d_body*(1+nsig_delr_chcj0_junc_pld5_d_body*sig_delr_chcj0_junc_pld5_d_body)))
+    chjs_junc_pld5_d_body          = (nom_chjs_junc_pld5_d_body*(nom_delr_chjs_junc_pld5_d_body*(1+nsig_delr_chjs_junc_pld5_d_body*sig_delr_chjs_junc_pld5_d_body)))
+    acj0_junc_pld10_d_body         = (nom_acj0_junc_pld10_d_body*(nom_delr_acj0_junc_pld10_d_body*(1+nsig_delr_acj0_junc_pld10_d_body*sig_delr_acj0_junc_pld10_d_body)))
+    ajs_junc_pld10_d_body          = (nom_ajs_junc_pld10_d_body*(nom_delr_ajs_junc_pld10_d_body*(1+nsig_delr_ajs_junc_pld10_d_body*sig_delr_ajs_junc_pld10_d_body)))
+    pcj0_junc_pld10_d_body         = (nom_pcj0_junc_pld10_d_body*(nom_delr_pcj0_junc_pld10_d_body*(1+nsig_delr_pcj0_junc_pld10_d_body*sig_delr_pcj0_junc_pld10_d_body)))
+    pjs_junc_pld10_d_body          = (nom_pjs_junc_pld10_d_body*(nom_delr_pjs_junc_pld10_d_body*(1+nsig_delr_pjs_junc_pld10_d_body*sig_delr_pjs_junc_pld10_d_body)))
+    chcj0_junc_pld10_d_body        = (nom_chcj0_junc_pld10_d_body*(nom_delr_chcj0_junc_pld10_d_body*(1+nsig_delr_chcj0_junc_pld10_d_body*sig_delr_chcj0_junc_pld10_d_body)))
+    chjs_junc_pld10_d_body         = (nom_chjs_junc_pld10_d_body*(nom_delr_chjs_junc_pld10_d_body*(1+nsig_delr_chjs_junc_pld10_d_body*sig_delr_chjs_junc_pld10_d_body)))
+    cj0_junc_pld10b_d_body         = (nom_cj0_junc_pld10b_d_body*(nom_delr_cj0_junc_pld10b_d_body*(1+nsig_delr_cj0_junc_pld10b_d_body*sig_delr_cj0_junc_pld10b_d_body)))
+    js_junc_pld10b_d_body          = (nom_js_junc_pld10b_d_body*(nom_delr_js_junc_pld10b_d_body*(1+nsig_delr_js_junc_pld10b_d_body*sig_delr_js_junc_pld10b_d_body)))
+    acj0_junc_pld30_d_body         = (nom_acj0_junc_pld30_d_body*(nom_delr_acj0_junc_pld30_d_body*(1+nsig_delr_acj0_junc_pld30_d_body*sig_delr_acj0_junc_pld30_d_body)))
+    ajs_junc_pld30_d_body          = (nom_ajs_junc_pld30_d_body*(nom_delr_ajs_junc_pld30_d_body*(1+nsig_delr_ajs_junc_pld30_d_body*sig_delr_ajs_junc_pld30_d_body)))
+    pcj0_junc_pld30_d_body         = (nom_pcj0_junc_pld30_d_body*(nom_delr_pcj0_junc_pld30_d_body*(1+nsig_delr_pcj0_junc_pld30_d_body*sig_delr_pcj0_junc_pld30_d_body)))
+    pjs_junc_pld30_d_body          = (nom_pjs_junc_pld30_d_body*(nom_delr_pjs_junc_pld30_d_body*(1+nsig_delr_pjs_junc_pld30_d_body*sig_delr_pjs_junc_pld30_d_body)))
+    chcj0_junc_pld30_d_body        = (nom_chcj0_junc_pld30_d_body*(nom_delr_chcj0_junc_pld30_d_body*(1+nsig_delr_chcj0_junc_pld30_d_body*sig_delr_chcj0_junc_pld30_d_body)))
+    chjs_junc_pld30_d_body         = (nom_chjs_junc_pld30_d_body*(nom_delr_chjs_junc_pld30_d_body*(1+nsig_delr_chjs_junc_pld30_d_body*sig_delr_chjs_junc_pld30_d_body)))
+    acj0_junc_pld30b_d_body        = (nom_acj0_junc_pld30b_d_body*(nom_delr_acj0_junc_pld30b_d_body*(1+nsig_delr_acj0_junc_pld30b_d_body*sig_delr_acj0_junc_pld30b_d_body)))
+    ajs_junc_pld30b_d_body         = (nom_ajs_junc_pld30b_d_body*(nom_delr_ajs_junc_pld30b_d_body*(1+nsig_delr_ajs_junc_pld30b_d_body*sig_delr_ajs_junc_pld30b_d_body)))
+    pcj0_junc_pld30b_d_body        = (nom_pcj0_junc_pld30b_d_body*(nom_delr_pcj0_junc_pld30b_d_body*(1+nsig_delr_pcj0_junc_pld30b_d_body*sig_delr_pcj0_junc_pld30b_d_body)))
+    pjs_junc_pld30b_d_body         = (nom_pjs_junc_pld30b_d_body*(nom_delr_pjs_junc_pld30b_d_body*(1+nsig_delr_pjs_junc_pld30b_d_body*sig_delr_pjs_junc_pld30b_d_body)))
+    chcj0_junc_pld30b_d_body       = (nom_chcj0_junc_pld30b_d_body*(nom_delr_chcj0_junc_pld30b_d_body*(1+nsig_delr_chcj0_junc_pld30b_d_body*sig_delr_chcj0_junc_pld30b_d_body)))
+    chjs_junc_pld30b_d_body        = (nom_chjs_junc_pld30b_d_body*(nom_delr_chjs_junc_pld30b_d_body*(1+nsig_delr_chjs_junc_pld30b_d_body*sig_delr_chjs_junc_pld30b_d_body)))
+    acj0_junc_pld45_d_body         = (nom_acj0_junc_pld45_d_body*(nom_delr_acj0_junc_pld45_d_body*(1+nsig_delr_acj0_junc_pld45_d_body*sig_delr_acj0_junc_pld45_d_body)))
+    ajs_junc_pld45_d_body          = (nom_ajs_junc_pld45_d_body*(nom_delr_ajs_junc_pld45_d_body*(1+nsig_delr_ajs_junc_pld45_d_body*sig_delr_ajs_junc_pld45_d_body)))
+    pcj0_junc_pld45_d_body         = (nom_pcj0_junc_pld45_d_body*(nom_delr_pcj0_junc_pld45_d_body*(1+nsig_delr_pcj0_junc_pld45_d_body*sig_delr_pcj0_junc_pld45_d_body)))
+    pjs_junc_pld45_d_body          = (nom_pjs_junc_pld45_d_body*(nom_delr_pjs_junc_pld45_d_body*(1+nsig_delr_pjs_junc_pld45_d_body*sig_delr_pjs_junc_pld45_d_body)))
+    chcj0_junc_pld45_d_body        = (nom_chcj0_junc_pld45_d_body*(nom_delr_chcj0_junc_pld45_d_body*(1+nsig_delr_chcj0_junc_pld45_d_body*sig_delr_chcj0_junc_pld45_d_body)))
+    chjs_junc_pld45_d_body         = (nom_chjs_junc_pld45_d_body*(nom_delr_chjs_junc_pld45_d_body*(1+nsig_delr_chjs_junc_pld45_d_body*sig_delr_chjs_junc_pld45_d_body)))
+    acj0_junc_pld45b_d_body        = (nom_acj0_junc_pld45b_d_body*(nom_delr_acj0_junc_pld45b_d_body*(1+nsig_delr_acj0_junc_pld45b_d_body*sig_delr_acj0_junc_pld45b_d_body)))
+    ajs_junc_pld45b_d_body         = (nom_ajs_junc_pld45b_d_body*(nom_delr_ajs_junc_pld45b_d_body*(1+nsig_delr_ajs_junc_pld45b_d_body*sig_delr_ajs_junc_pld45b_d_body)))
+    pcj0_junc_pld45b_d_body        = (nom_pcj0_junc_pld45b_d_body*(nom_delr_pcj0_junc_pld45b_d_body*(1+nsig_delr_pcj0_junc_pld45b_d_body*sig_delr_pcj0_junc_pld45b_d_body)))
+    pjs_junc_pld45b_d_body         = (nom_pjs_junc_pld45b_d_body*(nom_delr_pjs_junc_pld45b_d_body*(1+nsig_delr_pjs_junc_pld45b_d_body*sig_delr_pjs_junc_pld45b_d_body)))
+    chcj0_junc_pld45b_d_body       = (nom_chcj0_junc_pld45b_d_body*(nom_delr_chcj0_junc_pld45b_d_body*(1+nsig_delr_chcj0_junc_pld45b_d_body*sig_delr_chcj0_junc_pld45b_d_body)))
+    chjs_junc_pld45b_d_body        = (nom_chjs_junc_pld45b_d_body*(nom_delr_chjs_junc_pld45b_d_body*(1+nsig_delr_chjs_junc_pld45b_d_body*sig_delr_chjs_junc_pld45b_d_body)))
+    acj0_junc_pld90_d_body         = (nom_acj0_junc_pld90_d_body*(nom_delr_acj0_junc_pld90_d_body*(1+nsig_delr_acj0_junc_pld90_d_body*sig_delr_acj0_junc_pld90_d_body)))
+    ajs_junc_pld90_d_body          = (nom_ajs_junc_pld90_d_body*(nom_delr_ajs_junc_pld90_d_body*(1+nsig_delr_ajs_junc_pld90_d_body*sig_delr_ajs_junc_pld90_d_body)))
+    pcj0_junc_pld90_d_body         = (nom_pcj0_junc_pld90_d_body*(nom_delr_pcj0_junc_pld90_d_body*(1+nsig_delr_pcj0_junc_pld90_d_body*sig_delr_pcj0_junc_pld90_d_body)))
+    pjs_junc_pld90_d_body          = (nom_pjs_junc_pld90_d_body*(nom_delr_pjs_junc_pld90_d_body*(1+nsig_delr_pjs_junc_pld90_d_body*sig_delr_pjs_junc_pld90_d_body)))
+    chcj0_junc_pld90_d_body        = (nom_chcj0_junc_pld90_d_body*(nom_delr_chcj0_junc_pld90_d_body*(1+nsig_delr_chcj0_junc_pld90_d_body*sig_delr_chcj0_junc_pld90_d_body)))
+    chjs_junc_pld90_d_body         = (nom_chjs_junc_pld90_d_body*(nom_delr_chjs_junc_pld90_d_body*(1+nsig_delr_chjs_junc_pld90_d_body*sig_delr_chjs_junc_pld90_d_body)))
+    acj0_junc_pld90b_d_body        = (nom_acj0_junc_pld90b_d_body*(nom_delr_acj0_junc_pld90b_d_body*(1+nsig_delr_acj0_junc_pld90b_d_body*sig_delr_acj0_junc_pld90b_d_body)))
+    ajs_junc_pld90b_d_body         = (nom_ajs_junc_pld90b_d_body*(nom_delr_ajs_junc_pld90b_d_body*(1+nsig_delr_ajs_junc_pld90b_d_body*sig_delr_ajs_junc_pld90b_d_body)))
+    pcj0_junc_pld90b_d_body        = (nom_pcj0_junc_pld90b_d_body*(nom_delr_pcj0_junc_pld90b_d_body*(1+nsig_delr_pcj0_junc_pld90b_d_body*sig_delr_pcj0_junc_pld90b_d_body)))
+    pjs_junc_pld90b_d_body         = (nom_pjs_junc_pld90b_d_body*(nom_delr_pjs_junc_pld90b_d_body*(1+nsig_delr_pjs_junc_pld90b_d_body*sig_delr_pjs_junc_pld90b_d_body)))
+    chcj0_junc_pld90b_d_body       = (nom_chcj0_junc_pld90b_d_body*(nom_delr_chcj0_junc_pld90b_d_body*(1+nsig_delr_chcj0_junc_pld90b_d_body*sig_delr_chcj0_junc_pld90b_d_body)))
+    chjs_junc_pld90b_d_body        = (nom_chjs_junc_pld90b_d_body*(nom_delr_chjs_junc_pld90b_d_body*(1+nsig_delr_chjs_junc_pld90b_d_body*sig_delr_chjs_junc_pld90b_d_body)))
+    cfr_nld90_s_ply_m1ct           = (nom_cfr_nld90_s_ply_m1ct*(nom_delr_cfr_nld90_s_ply_m1ct+nsig_delr_cfr_nld90_s_ply_m1ct*sig_delr_cfr_nld90_s_ply_m1ct))
+    cfr_pmoshs45b_s_ply_met        = (nom_cfr_pmoshs45b_s_ply_met*(nom_delr_cfr_pmoshs45b_s_ply_met+nsig_delr_cfr_pmoshs45b_s_ply_met*sig_delr_cfr_pmoshs45b_s_ply_met))
+    cfr_pld5_s_ply_m1ct            = (nom_cfr_pld5_s_ply_m1ct*(nom_delr_cfr_pld5_s_ply_m1ct+nsig_delr_cfr_pld5_s_ply_m1ct*sig_delr_cfr_pld5_s_ply_m1ct))
+    cfr_nsrampd_s_ply_met          = (nom_cfr_nsrampd_s_ply_met*(nom_delr_cfr_nsrampd_s_ply_met+nsig_delr_cfr_nsrampd_s_ply_met*sig_delr_cfr_nsrampd_s_ply_met))
+    cfr_psrampu_d_ply_m1ct         = (nom_cfr_psrampu_d_ply_m1ct*(nom_delr_cfr_psrampu_d_ply_m1ct+nsig_delr_cfr_psrampu_d_ply_m1ct*sig_delr_cfr_psrampu_d_ply_m1ct))
+    cfr_nld45b_tlp_d_ply_met       = (nom_cfr_nld45b_tlp_d_ply_met*(nom_delr_cfr_nld45b_tlp_d_ply_met+nsig_delr_cfr_nld45b_tlp_d_ply_met*sig_delr_cfr_nld45b_tlp_d_ply_met))
+    cfr_pmos_ll_s_ply_met          = (nom_cfr_pmos_ll_s_ply_met*(nom_delr_cfr_pmos_ll_s_ply_met+nsig_delr_cfr_pmos_ll_s_ply_met*sig_delr_cfr_pmos_ll_s_ply_met))
+    cfr_nmos_ull_s_ply_met         = (nom_cfr_nmos_ull_s_ply_met*(nom_delr_cfr_nmos_ull_s_ply_met+nsig_delr_cfr_nmos_ull_s_ply_met*sig_delr_cfr_nmos_ull_s_ply_met))
+    cfr_pmos_ana_s_ply_met         = (nom_cfr_pmos_ana_s_ply_met*(nom_delr_cfr_pmos_ana_s_ply_met+nsig_delr_cfr_pmos_ana_s_ply_met*sig_delr_cfr_pmos_ana_s_ply_met))
+    cfr_pld45_d_ply_met            = (nom_cfr_pld45_d_ply_met*(nom_delr_cfr_pld45_d_ply_met+nsig_delr_cfr_pld45_d_ply_met*sig_delr_cfr_pld45_d_ply_met))
+    cfr_nld65_d_ply_met            = (nom_cfr_nld65_d_ply_met*(nom_delr_cfr_nld65_d_ply_met+nsig_delr_cfr_nld65_d_ply_met*sig_delr_cfr_nld65_d_ply_met))
+    cfr_pmos45b_d_ply_met          = (nom_cfr_pmos45b_d_ply_met*(nom_delr_cfr_pmos45b_d_ply_met+nsig_delr_cfr_pmos45b_d_ply_met*sig_delr_cfr_pmos45b_d_ply_met))
+    cfr_pmos_d_ply_m1ct            = (nom_cfr_pmos_d_ply_m1ct*(nom_delr_cfr_pmos_d_ply_m1ct+nsig_delr_cfr_pmos_d_ply_m1ct*sig_delr_cfr_pmos_d_ply_m1ct))
+    cfr_nld65b_s_ply_met           = (nom_cfr_nld65b_s_ply_met*(nom_delr_cfr_nld65b_s_ply_met+nsig_delr_cfr_nld65b_s_ply_met*sig_delr_cfr_nld65b_s_ply_met))
+    cfr_pmos90b_d_ply_met          = (nom_cfr_pmos90b_d_ply_met*(nom_delr_cfr_pmos90b_d_ply_met+nsig_delr_cfr_pmos90b_d_ply_met*sig_delr_cfr_pmos90b_d_ply_met))
+    cfr_nmos3_zvt_d_ply_m1ct       = (nom_cfr_nmos3_zvt_d_ply_m1ct*(nom_delr_cfr_nmos3_zvt_d_ply_m1ct+nsig_delr_cfr_nmos3_zvt_d_ply_m1ct*sig_delr_cfr_nmos3_zvt_d_ply_m1ct))
+    cfr_pmoshs45_s_ply_m1ct        = (nom_cfr_pmoshs45_s_ply_m1ct*(nom_delr_cfr_pmoshs45_s_ply_m1ct+nsig_delr_cfr_pmoshs45_s_ply_m1ct*sig_delr_cfr_pmoshs45_s_ply_m1ct))
+    cfr_nmos_ull_d_ply_ct          = (nom_cfr_nmos_ull_d_ply_ct*(nom_delr_cfr_nmos_ull_d_ply_ct+nsig_delr_cfr_nmos_ull_d_ply_ct*sig_delr_cfr_nmos_ull_d_ply_ct))
+    cfr_pld10_s_ply_m1ct           = (nom_cfr_pld10_s_ply_m1ct*(nom_delr_cfr_pld10_s_ply_m1ct+nsig_delr_cfr_pld10_s_ply_m1ct*sig_delr_cfr_pld10_s_ply_m1ct))
+    cfr_pld30b_d_ply_m1ct          = (nom_cfr_pld30b_d_ply_m1ct*(nom_delr_cfr_pld30b_d_ply_m1ct+nsig_delr_cfr_pld30b_d_ply_m1ct*sig_delr_cfr_pld30b_d_ply_m1ct))
+    cfr_nmos90b_s_ply_m1ct         = (nom_cfr_nmos90b_s_ply_m1ct*(nom_delr_cfr_nmos90b_s_ply_m1ct+nsig_delr_cfr_nmos90b_s_ply_m1ct*sig_delr_cfr_nmos90b_s_ply_m1ct))
+    cfr_nld45b_d_ply_met           = (nom_cfr_nld45b_d_ply_met*(nom_delr_cfr_nld45b_d_ply_met+nsig_delr_cfr_nld45b_d_ply_met*sig_delr_cfr_nld45b_d_ply_met))
+    cfr_pmos45_d_ply_met           = (nom_cfr_pmos45_d_ply_met*(nom_delr_cfr_pmos45_d_ply_met+nsig_delr_cfr_pmos45_d_ply_met*sig_delr_cfr_pmos45_d_ply_met))
+    cfr_pld45_s_ply_met            = (nom_cfr_pld45_s_ply_met*(nom_delr_cfr_pld45_s_ply_met+nsig_delr_cfr_pld45_s_ply_met*sig_delr_cfr_pld45_s_ply_met))
+    cfr_nld45b_he_d_ply_met        = (nom_cfr_nld45b_he_d_ply_met*(nom_delr_cfr_nld45b_he_d_ply_met+nsig_delr_cfr_nld45b_he_d_ply_met*sig_delr_cfr_nld45b_he_d_ply_met))
+    cfr_nld90b_d_ply_m1ct          = (nom_cfr_nld90b_d_ply_m1ct*(nom_delr_cfr_nld90b_d_ply_m1ct+nsig_delr_cfr_nld90b_d_ply_m1ct*sig_delr_cfr_nld90b_d_ply_m1ct))
+    cfr_pld30_s_ply_met            = (nom_cfr_pld30_s_ply_met*(nom_delr_cfr_pld30_s_ply_met+nsig_delr_cfr_pld30_s_ply_met*sig_delr_cfr_pld30_s_ply_met))
+    cfr_nmos_ull_s_ply_m1ct        = (nom_cfr_nmos_ull_s_ply_m1ct*(nom_delr_cfr_nmos_ull_s_ply_m1ct+nsig_delr_cfr_nmos_ull_s_ply_m1ct*sig_delr_cfr_nmos_ull_s_ply_m1ct))
+    cfr_nld90_d_ply_met            = (nom_cfr_nld90_d_ply_met*(nom_delr_cfr_nld90_d_ply_met+nsig_delr_cfr_nld90_d_ply_met*sig_delr_cfr_nld90_d_ply_met))
+    cfr_pmos_s_ply_met             = (nom_cfr_pmos_s_ply_met*(nom_delr_cfr_pmos_s_ply_met+nsig_delr_cfr_pmos_s_ply_met*sig_delr_cfr_pmos_s_ply_met))
+    cfr_nld45_s_ply_m1ct           = (nom_cfr_nld45_s_ply_m1ct*(nom_delr_cfr_nld45_s_ply_m1ct+nsig_delr_cfr_nld45_s_ply_m1ct*sig_delr_cfr_nld45_s_ply_m1ct))
+    cfr_pmos_ll_s_ply_m1ct         = (nom_cfr_pmos_ll_s_ply_m1ct*(nom_delr_cfr_pmos_ll_s_ply_m1ct+nsig_delr_cfr_pmos_ll_s_ply_m1ct*sig_delr_cfr_pmos_ll_s_ply_m1ct))
+    cfr_nsrampg_s_ply_m1ct         = (nom_cfr_nsrampg_s_ply_m1ct*(nom_delr_cfr_nsrampg_s_ply_m1ct+nsig_delr_cfr_nsrampg_s_ply_m1ct*sig_delr_cfr_nsrampg_s_ply_m1ct))
+    cfr_nsrampd_d_ply_met          = (nom_cfr_nsrampd_d_ply_met*(nom_delr_cfr_nsrampd_d_ply_met+nsig_delr_cfr_nsrampd_d_ply_met*sig_delr_cfr_nsrampd_d_ply_met))
+    cfr_pmos45b_d_ply_m1ct         = (nom_cfr_pmos45b_d_ply_m1ct*(nom_delr_cfr_pmos45b_d_ply_m1ct+nsig_delr_cfr_pmos45b_d_ply_m1ct*sig_delr_cfr_pmos45b_d_ply_m1ct))
+    cfr_nmos_ull_d_ply_met         = (nom_cfr_nmos_ull_d_ply_met*(nom_delr_cfr_nmos_ull_d_ply_met+nsig_delr_cfr_nmos_ull_d_ply_met*sig_delr_cfr_nmos_ull_d_ply_met))
+    cfr_nld10_s_ply_met            = (nom_cfr_nld10_s_ply_met*(nom_delr_cfr_nld10_s_ply_met+nsig_delr_cfr_nld10_s_ply_met*sig_delr_cfr_nld10_s_ply_met))
+    cfr_psrampu_d_ply_met          = (nom_cfr_psrampu_d_ply_met*(nom_delr_cfr_psrampu_d_ply_met+nsig_delr_cfr_psrampu_d_ply_met*sig_delr_cfr_psrampu_d_ply_met))
+    cfr_pld45b_s_ply_met           = (nom_cfr_pld45b_s_ply_met*(nom_delr_cfr_pld45b_s_ply_met+nsig_delr_cfr_pld45b_s_ply_met*sig_delr_cfr_pld45b_s_ply_met))
+    cfr_nsrampg_s_ply_met          = (nom_cfr_nsrampg_s_ply_met*(nom_delr_cfr_nsrampg_s_ply_met+nsig_delr_cfr_nsrampg_s_ply_met*sig_delr_cfr_nsrampg_s_ply_met))
+    cfr_nld90b_d_ply_met           = (nom_cfr_nld90b_d_ply_met*(nom_delr_cfr_nld90b_d_ply_met+nsig_delr_cfr_nld90b_d_ply_met*sig_delr_cfr_nld90b_d_ply_met))
+    cfr_pmos_ll_d_ply_met          = (nom_cfr_pmos_ll_d_ply_met*(nom_delr_cfr_pmos_ll_d_ply_met+nsig_delr_cfr_pmos_ll_d_ply_met*sig_delr_cfr_pmos_ll_d_ply_met))
+    cfr_pld45b_s_ply_m1ct          = (nom_cfr_pld45b_s_ply_m1ct*(nom_delr_cfr_pld45b_s_ply_m1ct+nsig_delr_cfr_pld45b_s_ply_m1ct*sig_delr_cfr_pld45b_s_ply_m1ct))
+    cfr_pmoshs45b_s_ply_m1ct       = (nom_cfr_pmoshs45b_s_ply_m1ct*(nom_delr_cfr_pmoshs45b_s_ply_m1ct+nsig_delr_cfr_pmoshs45b_s_ply_m1ct*sig_delr_cfr_pmoshs45b_s_ply_m1ct))
+    cfr_pmos_ull_s_ply_ct_end      = (nom_cfr_pmos_ull_s_ply_ct_end*(nom_delr_cfr_pmos_ull_s_ply_ct_end+nsig_delr_cfr_pmos_ull_s_ply_ct_end*sig_delr_cfr_pmos_ull_s_ply_ct_end))
+    cfr_nld10_s_ply_m1ct           = (nom_cfr_nld10_s_ply_m1ct*(nom_delr_cfr_nld10_s_ply_m1ct+nsig_delr_cfr_nld10_s_ply_m1ct*sig_delr_cfr_nld10_s_ply_m1ct))
+    cfr_nmos5_s_ply_met            = (nom_cfr_nmos5_s_ply_met*(nom_delr_cfr_nmos5_s_ply_met+nsig_delr_cfr_nmos5_s_ply_met*sig_delr_cfr_nmos5_s_ply_met))
+    cfr_nld30b_s_ply_m1ct          = (nom_cfr_nld30b_s_ply_m1ct*(nom_delr_cfr_nld30b_s_ply_m1ct+nsig_delr_cfr_nld30b_s_ply_m1ct*sig_delr_cfr_nld30b_s_ply_m1ct))
+    cfr_nld5_s_ply_m1ct            = (nom_cfr_nld5_s_ply_m1ct*(nom_delr_cfr_nld5_s_ply_m1ct+nsig_delr_cfr_nld5_s_ply_m1ct*sig_delr_cfr_nld5_s_ply_m1ct))
+    cfr_pmos45_d_ply_m1ct          = (nom_cfr_pmos45_d_ply_m1ct*(nom_delr_cfr_pmos45_d_ply_m1ct+nsig_delr_cfr_pmos45_d_ply_m1ct*sig_delr_cfr_pmos45_d_ply_m1ct))
+    cfr_nmos45b_d_ply_met          = (nom_cfr_nmos45b_d_ply_met*(nom_delr_cfr_nmos45b_d_ply_met+nsig_delr_cfr_nmos45b_d_ply_met*sig_delr_cfr_nmos45b_d_ply_met))
+    cfr_pld90b_d_ply_m1ct          = (nom_cfr_pld90b_d_ply_m1ct*(nom_delr_cfr_pld90b_d_ply_m1ct+nsig_delr_cfr_pld90b_d_ply_m1ct*sig_delr_cfr_pld90b_d_ply_m1ct))
+    cfr_nld45b_he_d_ply_m1ct       = (nom_cfr_nld45b_he_d_ply_m1ct*(nom_delr_cfr_nld45b_he_d_ply_m1ct+nsig_delr_cfr_nld45b_he_d_ply_m1ct*sig_delr_cfr_nld45b_he_d_ply_m1ct))
+    cfr_nmos10_s_ply_met           = (nom_cfr_nmos10_s_ply_met*(nom_delr_cfr_nmos10_s_ply_met+nsig_delr_cfr_nmos10_s_ply_met*sig_delr_cfr_nmos10_s_ply_met))
+    cfr_nld45b_tlp_s_ply_m1ct      = (nom_cfr_nld45b_tlp_s_ply_m1ct*(nom_delr_cfr_nld45b_tlp_s_ply_m1ct+nsig_delr_cfr_nld45b_tlp_s_ply_m1ct*sig_delr_cfr_nld45b_tlp_s_ply_m1ct))
+    cfr_pmos_ull_s_ply_ct          = (nom_cfr_pmos_ull_s_ply_ct*(nom_delr_cfr_pmos_ull_s_ply_ct+nsig_delr_cfr_pmos_ull_s_ply_ct*sig_delr_cfr_pmos_ull_s_ply_ct))
+    cfr_nld45_he_s_ply_m1ct        = (nom_cfr_nld45_he_s_ply_m1ct*(nom_delr_cfr_nld45_he_s_ply_m1ct+nsig_delr_cfr_nld45_he_s_ply_m1ct*sig_delr_cfr_nld45_he_s_ply_m1ct))
+    cfr_nld45_tlp_s_ply_m1ct       = (nom_cfr_nld45_tlp_s_ply_m1ct*(nom_delr_cfr_nld45_tlp_s_ply_m1ct+nsig_delr_cfr_nld45_tlp_s_ply_m1ct*sig_delr_cfr_nld45_tlp_s_ply_m1ct))
+    cfr_nmos_ull_s_ply_met_end     = (nom_cfr_nmos_ull_s_ply_met_end*(nom_delr_cfr_nmos_ull_s_ply_met_end+nsig_delr_cfr_nmos_ull_s_ply_met_end*sig_delr_cfr_nmos_ull_s_ply_met_end))
+    cfr_nsrampd_s_ply_m1ct         = (nom_cfr_nsrampd_s_ply_m1ct*(nom_delr_cfr_nsrampd_s_ply_m1ct+nsig_delr_cfr_nsrampd_s_ply_m1ct*sig_delr_cfr_nsrampd_s_ply_m1ct))
+    cfr_psrampu_s_ply_met          = (nom_cfr_psrampu_s_ply_met*(nom_delr_cfr_psrampu_s_ply_met+nsig_delr_cfr_psrampu_s_ply_met*sig_delr_cfr_psrampu_s_ply_met))
+    cfr_nmos90_d_ply_m1ct          = (nom_cfr_nmos90_d_ply_m1ct*(nom_delr_cfr_nmos90_d_ply_m1ct+nsig_delr_cfr_nmos90_d_ply_m1ct*sig_delr_cfr_nmos90_d_ply_m1ct))
+    cfr_pmos_ull_d_ply_met         = (nom_cfr_pmos_ull_d_ply_met*(nom_delr_cfr_pmos_ull_d_ply_met+nsig_delr_cfr_pmos_ull_d_ply_met*sig_delr_cfr_pmos_ull_d_ply_met))
+    cfr_pld5_d_ply_m1ct            = (nom_cfr_pld5_d_ply_m1ct*(nom_delr_cfr_pld5_d_ply_m1ct+nsig_delr_cfr_pld5_d_ply_m1ct*sig_delr_cfr_pld5_d_ply_m1ct))
+    cfr_nld30_d_ply_met            = (nom_cfr_nld30_d_ply_met*(nom_delr_cfr_nld30_d_ply_met+nsig_delr_cfr_nld30_d_ply_met*sig_delr_cfr_nld30_d_ply_met))
+    cfr_pmos_ana_d_ply_m1ct        = (nom_cfr_pmos_ana_d_ply_m1ct*(nom_delr_cfr_pmos_ana_d_ply_m1ct+nsig_delr_cfr_pmos_ana_d_ply_m1ct*sig_delr_cfr_pmos_ana_d_ply_m1ct))
+    cfr_nld45b_s_ply_met           = (nom_cfr_nld45b_s_ply_met*(nom_delr_cfr_nld45b_s_ply_met+nsig_delr_cfr_nld45b_s_ply_met*sig_delr_cfr_nld45b_s_ply_met))
+    cfr_pmoshs45b_d_ply_met        = (nom_cfr_pmoshs45b_d_ply_met*(nom_delr_cfr_pmoshs45b_d_ply_met+nsig_delr_cfr_pmoshs45b_d_ply_met*sig_delr_cfr_pmoshs45b_d_ply_met))
+    cfr_nld65_s_ply_m1ct           = (nom_cfr_nld65_s_ply_m1ct*(nom_delr_cfr_nld65_s_ply_m1ct+nsig_delr_cfr_nld65_s_ply_m1ct*sig_delr_cfr_nld65_s_ply_m1ct))
+    cfr_nld90_d_ply_m1ct           = (nom_cfr_nld90_d_ply_m1ct*(nom_delr_cfr_nld90_d_ply_m1ct+nsig_delr_cfr_nld90_d_ply_m1ct*sig_delr_cfr_nld90_d_ply_m1ct))
+    cfr_pmos_d_ply_met             = (nom_cfr_pmos_d_ply_met*(nom_delr_cfr_pmos_d_ply_met+nsig_delr_cfr_pmos_d_ply_met*sig_delr_cfr_pmos_d_ply_met))
+    cfr_nld5_lvt_s_ply_met         = (nom_cfr_nld5_lvt_s_ply_met*(nom_delr_cfr_nld5_lvt_s_ply_met+nsig_delr_cfr_nld5_lvt_s_ply_met*sig_delr_cfr_nld5_lvt_s_ply_met))
+    cfr_nmos_ll_d_ply_m1ct         = (nom_cfr_nmos_ll_d_ply_m1ct*(nom_delr_cfr_nmos_ll_d_ply_m1ct+nsig_delr_cfr_nmos_ll_d_ply_m1ct*sig_delr_cfr_nmos_ll_d_ply_m1ct))
+    cfr_nmos10_d_ply_met           = (nom_cfr_nmos10_d_ply_met*(nom_delr_cfr_nmos10_d_ply_met+nsig_delr_cfr_nmos10_d_ply_met*sig_delr_cfr_nmos10_d_ply_met))
+    cfr_nmos_s_ply_m1ct            = (nom_cfr_nmos_s_ply_m1ct*(nom_delr_cfr_nmos_s_ply_m1ct+nsig_delr_cfr_nmos_s_ply_m1ct*sig_delr_cfr_nmos_s_ply_m1ct))
+    cfr_nmos5_d_ply_m1ct           = (nom_cfr_nmos5_d_ply_m1ct*(nom_delr_cfr_nmos5_d_ply_m1ct+nsig_delr_cfr_nmos5_d_ply_m1ct*sig_delr_cfr_nmos5_d_ply_m1ct))
+    cfr_nld10_d_ply_met            = (nom_cfr_nld10_d_ply_met*(nom_delr_cfr_nld10_d_ply_met+nsig_delr_cfr_nld10_d_ply_met*sig_delr_cfr_nld10_d_ply_met))
+    cfr_pmos90b_s_ply_m1ct         = (nom_cfr_pmos90b_s_ply_m1ct*(nom_delr_cfr_pmos90b_s_ply_m1ct+nsig_delr_cfr_pmos90b_s_ply_m1ct*sig_delr_cfr_pmos90b_s_ply_m1ct))
+    cfr_nld45b_tlp_s_ply_met       = (nom_cfr_nld45b_tlp_s_ply_met*(nom_delr_cfr_nld45b_tlp_s_ply_met+nsig_delr_cfr_nld45b_tlp_s_ply_met*sig_delr_cfr_nld45b_tlp_s_ply_met))
+    cfr_pld10_d_ply_m1ct           = (nom_cfr_pld10_d_ply_m1ct*(nom_delr_cfr_pld10_d_ply_m1ct+nsig_delr_cfr_pld10_d_ply_m1ct*sig_delr_cfr_pld10_d_ply_m1ct))
+    cfr_nmos90_s_ply_m1ct          = (nom_cfr_nmos90_s_ply_m1ct*(nom_delr_cfr_nmos90_s_ply_m1ct+nsig_delr_cfr_nmos90_s_ply_m1ct*sig_delr_cfr_nmos90_s_ply_m1ct))
+    cfr_nmos_ana_d_ply_m1ct        = (nom_cfr_nmos_ana_d_ply_m1ct*(nom_delr_cfr_nmos_ana_d_ply_m1ct+nsig_delr_cfr_nmos_ana_d_ply_m1ct*sig_delr_cfr_nmos_ana_d_ply_m1ct))
+    cfr_pmos90_s_ply_met           = (nom_cfr_pmos90_s_ply_met*(nom_delr_cfr_pmos90_s_ply_met+nsig_delr_cfr_pmos90_s_ply_met*sig_delr_cfr_pmos90_s_ply_met))
+    cfr_nmos3_zvt_d_ply_met        = (nom_cfr_nmos3_zvt_d_ply_met*(nom_delr_cfr_nmos3_zvt_d_ply_met+nsig_delr_cfr_nmos3_zvt_d_ply_met*sig_delr_cfr_nmos3_zvt_d_ply_met))
+    cfr_pmos5_d_ply_m1ct           = (nom_cfr_pmos5_d_ply_m1ct*(nom_delr_cfr_pmos5_d_ply_m1ct+nsig_delr_cfr_pmos5_d_ply_m1ct*sig_delr_cfr_pmos5_d_ply_m1ct))
+    cfr_pmos_ull_s_ply_m1ct        = (nom_cfr_pmos_ull_s_ply_m1ct*(nom_delr_cfr_pmos_ull_s_ply_m1ct+nsig_delr_cfr_pmos_ull_s_ply_m1ct*sig_delr_cfr_pmos_ull_s_ply_m1ct))
+    cfr_pmos_ana_d_ply_met         = (nom_cfr_pmos_ana_d_ply_met*(nom_delr_cfr_pmos_ana_d_ply_met+nsig_delr_cfr_pmos_ana_d_ply_met*sig_delr_cfr_pmos_ana_d_ply_met))
+    cfr_nmos90b_s_ply_met          = (nom_cfr_nmos90b_s_ply_met*(nom_delr_cfr_nmos90b_s_ply_met+nsig_delr_cfr_nmos90b_s_ply_met*sig_delr_cfr_nmos90b_s_ply_met))
+    cfr_nmos45_s_ply_m1ct          = (nom_cfr_nmos45_s_ply_m1ct*(nom_delr_cfr_nmos45_s_ply_m1ct+nsig_delr_cfr_nmos45_s_ply_m1ct*sig_delr_cfr_nmos45_s_ply_m1ct))
+    cfr_nld45b_he_s_ply_m1ct       = (nom_cfr_nld45b_he_s_ply_m1ct*(nom_delr_cfr_nld45b_he_s_ply_m1ct+nsig_delr_cfr_nld45b_he_s_ply_m1ct*sig_delr_cfr_nld45b_he_s_ply_m1ct))
+    cfr_nsrampg_d_ply_m1ct         = (nom_cfr_nsrampg_d_ply_m1ct*(nom_delr_cfr_nsrampg_d_ply_m1ct+nsig_delr_cfr_nsrampg_d_ply_m1ct*sig_delr_cfr_nsrampg_d_ply_m1ct))
+    cfr_nld45_d_ply_met            = (nom_cfr_nld45_d_ply_met*(nom_delr_cfr_nld45_d_ply_met+nsig_delr_cfr_nld45_d_ply_met*sig_delr_cfr_nld45_d_ply_met))
+    cfr_nmos_ll_s_ply_m1ct         = (nom_cfr_nmos_ll_s_ply_m1ct*(nom_delr_cfr_nmos_ll_s_ply_m1ct+nsig_delr_cfr_nmos_ll_s_ply_m1ct*sig_delr_cfr_nmos_ll_s_ply_m1ct))
+    cfr_pmos_ull_d_ply_met_end     = (nom_cfr_pmos_ull_d_ply_met_end*(nom_delr_cfr_pmos_ull_d_ply_met_end+nsig_delr_cfr_pmos_ull_d_ply_met_end*sig_delr_cfr_pmos_ull_d_ply_met_end))
+    cfr_nld45b_tlp_d_ply_m1ct      = (nom_cfr_nld45b_tlp_d_ply_m1ct*(nom_delr_cfr_nld45b_tlp_d_ply_m1ct+nsig_delr_cfr_nld45b_tlp_d_ply_m1ct*sig_delr_cfr_nld45b_tlp_d_ply_m1ct))
+    cfr_nmos90_s_ply_met           = (nom_cfr_nmos90_s_ply_met*(nom_delr_cfr_nmos90_s_ply_met+nsig_delr_cfr_nmos90_s_ply_met*sig_delr_cfr_nmos90_s_ply_met))
+    cfr_nmos_ana_d_ply_met         = (nom_cfr_nmos_ana_d_ply_met*(nom_delr_cfr_nmos_ana_d_ply_met+nsig_delr_cfr_nmos_ana_d_ply_met*sig_delr_cfr_nmos_ana_d_ply_met))
+    cfr_pld10_d_ply_met            = (nom_cfr_pld10_d_ply_met*(nom_delr_cfr_pld10_d_ply_met+nsig_delr_cfr_pld10_d_ply_met*sig_delr_cfr_pld10_d_ply_met))
+    cfr_nld5_d_ply_m1ct            = (nom_cfr_nld5_d_ply_m1ct*(nom_delr_cfr_nld5_d_ply_m1ct+nsig_delr_cfr_nld5_d_ply_m1ct*sig_delr_cfr_nld5_d_ply_m1ct))
+    cfr_nmos_s_ply_met             = (nom_cfr_nmos_s_ply_met*(nom_delr_cfr_nmos_s_ply_met+nsig_delr_cfr_nmos_s_ply_met*sig_delr_cfr_nmos_s_ply_met))
+    cfr_pmos_ull_s_ply_met_end     = (nom_cfr_pmos_ull_s_ply_met_end*(nom_delr_cfr_pmos_ull_s_ply_met_end+nsig_delr_cfr_pmos_ull_s_ply_met_end*sig_delr_cfr_pmos_ull_s_ply_met_end))
+    cfr_pmos90_d_ply_m1ct          = (nom_cfr_pmos90_d_ply_m1ct*(nom_delr_cfr_pmos90_d_ply_m1ct+nsig_delr_cfr_pmos90_d_ply_m1ct*sig_delr_cfr_pmos90_d_ply_m1ct))
+    cfr_nld65b_s_ply_m1ct          = (nom_cfr_nld65b_s_ply_m1ct*(nom_delr_cfr_nld65b_s_ply_m1ct+nsig_delr_cfr_nld65b_s_ply_m1ct*sig_delr_cfr_nld65b_s_ply_m1ct))
+    cfr_nld30b_d_ply_m1ct          = (nom_cfr_nld30b_d_ply_m1ct*(nom_delr_cfr_nld30b_d_ply_m1ct+nsig_delr_cfr_nld30b_d_ply_m1ct*sig_delr_cfr_nld30b_d_ply_m1ct))
+    cfr_nmos_ana_s_ply_m1ct        = (nom_cfr_nmos_ana_s_ply_m1ct*(nom_delr_cfr_nmos_ana_s_ply_m1ct+nsig_delr_cfr_nmos_ana_s_ply_m1ct*sig_delr_cfr_nmos_ana_s_ply_m1ct))
+    cfr_nld65b_d_ply_met           = (nom_cfr_nld65b_d_ply_met*(nom_delr_cfr_nld65b_d_ply_met+nsig_delr_cfr_nld65b_d_ply_met*sig_delr_cfr_nld65b_d_ply_met))
+    cfr_nmos_ll_d_ply_met          = (nom_cfr_nmos_ll_d_ply_met*(nom_delr_cfr_nmos_ll_d_ply_met+nsig_delr_cfr_nmos_ll_d_ply_met*sig_delr_cfr_nmos_ll_d_ply_met))
+    cfr_pld10_s_ply_met            = (nom_cfr_pld10_s_ply_met*(nom_delr_cfr_pld10_s_ply_met+nsig_delr_cfr_pld10_s_ply_met*sig_delr_cfr_pld10_s_ply_met))
+    cfr_nmos10_s_ply_m1ct          = (nom_cfr_nmos10_s_ply_m1ct*(nom_delr_cfr_nmos10_s_ply_m1ct+nsig_delr_cfr_nmos10_s_ply_m1ct*sig_delr_cfr_nmos10_s_ply_m1ct))
+    cfr_nmos_ull_s_ply_ct          = (nom_cfr_nmos_ull_s_ply_ct*(nom_delr_cfr_nmos_ull_s_ply_ct+nsig_delr_cfr_nmos_ull_s_ply_ct*sig_delr_cfr_nmos_ull_s_ply_ct))
+    cfr_pmos90b_s_ply_met          = (nom_cfr_pmos90b_s_ply_met*(nom_delr_cfr_pmos90b_s_ply_met+nsig_delr_cfr_pmos90b_s_ply_met*sig_delr_cfr_pmos90b_s_ply_met))
+    cfr_pld5_s_ply_met             = (nom_cfr_pld5_s_ply_met*(nom_delr_cfr_pld5_s_ply_met+nsig_delr_cfr_pld5_s_ply_met*sig_delr_cfr_pld5_s_ply_met))
+    cfr_pmos_ull_d_ply_ct_end      = (nom_cfr_pmos_ull_d_ply_ct_end*(nom_delr_cfr_pmos_ull_d_ply_ct_end+nsig_delr_cfr_pmos_ull_d_ply_ct_end*sig_delr_cfr_pmos_ull_d_ply_ct_end))
+    cfr_pmos45b_s_ply_m1ct         = (nom_cfr_pmos45b_s_ply_m1ct*(nom_delr_cfr_pmos45b_s_ply_m1ct+nsig_delr_cfr_pmos45b_s_ply_m1ct*sig_delr_cfr_pmos45b_s_ply_m1ct))
+    cfr_nld90b_s_ply_met           = (nom_cfr_nld90b_s_ply_met*(nom_delr_cfr_nld90b_s_ply_met+nsig_delr_cfr_nld90b_s_ply_met*sig_delr_cfr_nld90b_s_ply_met))
+    cfr_pmos45b_s_ply_met          = (nom_cfr_pmos45b_s_ply_met*(nom_delr_cfr_pmos45b_s_ply_met+nsig_delr_cfr_pmos45b_s_ply_met*sig_delr_cfr_pmos45b_s_ply_met))
+    cfr_pmoshs45b_d_ply_m1ct       = (nom_cfr_pmoshs45b_d_ply_m1ct*(nom_delr_cfr_pmoshs45b_d_ply_m1ct+nsig_delr_cfr_pmoshs45b_d_ply_m1ct*sig_delr_cfr_pmoshs45b_d_ply_m1ct))
+    cfr_pld90_d_ply_met            = (nom_cfr_pld90_d_ply_met*(nom_delr_cfr_pld90_d_ply_met+nsig_delr_cfr_pld90_d_ply_met*sig_delr_cfr_pld90_d_ply_met))
+    cfr_pmos_ll_d_ply_m1ct         = (nom_cfr_pmos_ll_d_ply_m1ct*(nom_delr_cfr_pmos_ll_d_ply_m1ct+nsig_delr_cfr_pmos_ll_d_ply_m1ct*sig_delr_cfr_pmos_ll_d_ply_m1ct))
+    cfr_pmos5_s_ply_met            = (nom_cfr_pmos5_s_ply_met*(nom_delr_cfr_pmos5_s_ply_met+nsig_delr_cfr_pmos5_s_ply_met*sig_delr_cfr_pmos5_s_ply_met))
+    cfr_pld90_s_ply_m1ct           = (nom_cfr_pld90_s_ply_m1ct*(nom_delr_cfr_pld90_s_ply_m1ct+nsig_delr_cfr_pld90_s_ply_m1ct*sig_delr_cfr_pld90_s_ply_m1ct))
+    cfr_nld90_s_ply_met            = (nom_cfr_nld90_s_ply_met*(nom_delr_cfr_nld90_s_ply_met+nsig_delr_cfr_nld90_s_ply_met*sig_delr_cfr_nld90_s_ply_met))
+    cfr_pmos_ull_s_ply_met         = (nom_cfr_pmos_ull_s_ply_met*(nom_delr_cfr_pmos_ull_s_ply_met+nsig_delr_cfr_pmos_ull_s_ply_met*sig_delr_cfr_pmos_ull_s_ply_met))
+    cfr_pmos10_s_ply_met           = (nom_cfr_pmos10_s_ply_met*(nom_delr_cfr_pmos10_s_ply_met+nsig_delr_cfr_pmos10_s_ply_met*sig_delr_cfr_pmos10_s_ply_met))
+    cfr_nld65_d_ply_m1ct           = (nom_cfr_nld65_d_ply_m1ct*(nom_delr_cfr_nld65_d_ply_m1ct+nsig_delr_cfr_nld65_d_ply_m1ct*sig_delr_cfr_nld65_d_ply_m1ct))
+    cfr_nld45b_s_ply_m1ct          = (nom_cfr_nld45b_s_ply_m1ct*(nom_delr_cfr_nld45b_s_ply_m1ct+nsig_delr_cfr_nld45b_s_ply_m1ct*sig_delr_cfr_nld45b_s_ply_m1ct))
+    cfr_pmos90_d_ply_met           = (nom_cfr_pmos90_d_ply_met*(nom_delr_cfr_pmos90_d_ply_met+nsig_delr_cfr_pmos90_d_ply_met*sig_delr_cfr_pmos90_d_ply_met))
+    cfr_nld10_d_ply_m1ct           = (nom_cfr_nld10_d_ply_m1ct*(nom_delr_cfr_nld10_d_ply_m1ct+nsig_delr_cfr_nld10_d_ply_m1ct*sig_delr_cfr_nld10_d_ply_m1ct))
+    cfr_pld5_d_ply_met             = (nom_cfr_pld5_d_ply_met*(nom_delr_cfr_pld5_d_ply_met+nsig_delr_cfr_pld5_d_ply_met*sig_delr_cfr_pld5_d_ply_met))
+    cfr_pmos5_s_ply_m1ct           = (nom_cfr_pmos5_s_ply_m1ct*(nom_delr_cfr_pmos5_s_ply_m1ct+nsig_delr_cfr_pmos5_s_ply_m1ct*sig_delr_cfr_pmos5_s_ply_m1ct))
+    cfr_nld30b_d_ply_met           = (nom_cfr_nld30b_d_ply_met*(nom_delr_cfr_nld30b_d_ply_met+nsig_delr_cfr_nld30b_d_ply_met*sig_delr_cfr_nld30b_d_ply_met))
+    cfr_nmos_ll_s_ply_met          = (nom_cfr_nmos_ll_s_ply_met*(nom_delr_cfr_nmos_ll_s_ply_met+nsig_delr_cfr_nmos_ll_s_ply_met*sig_delr_cfr_nmos_ll_s_ply_met))
+    cfr_nld90b_s_ply_m1ct          = (nom_cfr_nld90b_s_ply_m1ct*(nom_delr_cfr_nld90b_s_ply_m1ct+nsig_delr_cfr_nld90b_s_ply_m1ct*sig_delr_cfr_nld90b_s_ply_m1ct))
+    cfr_pld45_s_ply_m1ct           = (nom_cfr_pld45_s_ply_m1ct*(nom_delr_cfr_pld45_s_ply_m1ct+nsig_delr_cfr_pld45_s_ply_m1ct*sig_delr_cfr_pld45_s_ply_m1ct))
+    cfr_nld65b_d_ply_m1ct          = (nom_cfr_nld65b_d_ply_m1ct*(nom_delr_cfr_nld65b_d_ply_m1ct+nsig_delr_cfr_nld65b_d_ply_m1ct*sig_delr_cfr_nld65b_d_ply_m1ct))
+    cfr_nsrampg_d_ply_met          = (nom_cfr_nsrampg_d_ply_met*(nom_delr_cfr_nsrampg_d_ply_met+nsig_delr_cfr_nsrampg_d_ply_met*sig_delr_cfr_nsrampg_d_ply_met))
+    cfr_nmos90b_d_ply_m1ct         = (nom_cfr_nmos90b_d_ply_m1ct*(nom_delr_cfr_nmos90b_d_ply_m1ct+nsig_delr_cfr_nmos90b_d_ply_m1ct*sig_delr_cfr_nmos90b_d_ply_m1ct))
+    cfr_nld5_lvt_d_ply_m1ct        = (nom_cfr_nld5_lvt_d_ply_m1ct*(nom_delr_cfr_nld5_lvt_d_ply_m1ct+nsig_delr_cfr_nld5_lvt_d_ply_m1ct*sig_delr_cfr_nld5_lvt_d_ply_m1ct))
+    cfr_pmos10_s_ply_m1ct          = (nom_cfr_pmos10_s_ply_m1ct*(nom_delr_cfr_pmos10_s_ply_m1ct+nsig_delr_cfr_pmos10_s_ply_m1ct*sig_delr_cfr_pmos10_s_ply_m1ct))
+    cfr_nld5_d_ply_met             = (nom_cfr_nld5_d_ply_met*(nom_delr_cfr_nld5_d_ply_met+nsig_delr_cfr_nld5_d_ply_met*sig_delr_cfr_nld5_d_ply_met))
+    cfr_nld30b_s_ply_met           = (nom_cfr_nld30b_s_ply_met*(nom_delr_cfr_nld30b_s_ply_met+nsig_delr_cfr_nld30b_s_ply_met*sig_delr_cfr_nld30b_s_ply_met))
+    cfr_nld65_s_ply_met            = (nom_cfr_nld65_s_ply_met*(nom_delr_cfr_nld65_s_ply_met+nsig_delr_cfr_nld65_s_ply_met*sig_delr_cfr_nld65_s_ply_met))
+    cfr_nld45_he_d_ply_met         = (nom_cfr_nld45_he_d_ply_met*(nom_delr_cfr_nld45_he_d_ply_met+nsig_delr_cfr_nld45_he_d_ply_met*sig_delr_cfr_nld45_he_d_ply_met))
+    cfr_pld30_s_ply_m1ct           = (nom_cfr_pld30_s_ply_m1ct*(nom_delr_cfr_pld30_s_ply_m1ct+nsig_delr_cfr_pld30_s_ply_m1ct*sig_delr_cfr_pld30_s_ply_m1ct))
+    cfr_pld90_d_ply_m1ct           = (nom_cfr_pld90_d_ply_m1ct*(nom_delr_cfr_pld90_d_ply_m1ct+nsig_delr_cfr_pld90_d_ply_m1ct*sig_delr_cfr_pld90_d_ply_m1ct))
+    cfr_nmos90b_d_ply_met          = (nom_cfr_nmos90b_d_ply_met*(nom_delr_cfr_nmos90b_d_ply_met+nsig_delr_cfr_nmos90b_d_ply_met*sig_delr_cfr_nmos90b_d_ply_met))
+    cfr_pmos45_s_ply_met           = (nom_cfr_pmos45_s_ply_met*(nom_delr_cfr_pmos45_s_ply_met+nsig_delr_cfr_pmos45_s_ply_met*sig_delr_cfr_pmos45_s_ply_met))
+    cfr_pmoshs45_d_ply_m1ct        = (nom_cfr_pmoshs45_d_ply_m1ct*(nom_delr_cfr_pmoshs45_d_ply_m1ct+nsig_delr_cfr_pmoshs45_d_ply_m1ct*sig_delr_cfr_pmoshs45_d_ply_m1ct))
+    cfr_nmos_ull_d_ply_m1ct        = (nom_cfr_nmos_ull_d_ply_m1ct*(nom_delr_cfr_nmos_ull_d_ply_m1ct+nsig_delr_cfr_nmos_ull_d_ply_m1ct*sig_delr_cfr_nmos_ull_d_ply_m1ct))
+    cfr_pmos5_d_ply_met            = (nom_cfr_pmos5_d_ply_met*(nom_delr_cfr_pmos5_d_ply_met+nsig_delr_cfr_pmos5_d_ply_met*sig_delr_cfr_pmos5_d_ply_met))
+    cfr_pld45_d_ply_m1ct           = (nom_cfr_pld45_d_ply_m1ct*(nom_delr_cfr_pld45_d_ply_m1ct+nsig_delr_cfr_pld45_d_ply_m1ct*sig_delr_cfr_pld45_d_ply_m1ct))
+    cfr_nmos45b_s_ply_met          = (nom_cfr_nmos45b_s_ply_met*(nom_delr_cfr_nmos45b_s_ply_met+nsig_delr_cfr_nmos45b_s_ply_met*sig_delr_cfr_nmos45b_s_ply_met))
+    cfr_nld45_tlp_d_ply_met        = (nom_cfr_nld45_tlp_d_ply_met*(nom_delr_cfr_nld45_tlp_d_ply_met+nsig_delr_cfr_nld45_tlp_d_ply_met*sig_delr_cfr_nld45_tlp_d_ply_met))
+    cfr_nmos_ull_d_ply_met_end     = (nom_cfr_nmos_ull_d_ply_met_end*(nom_delr_cfr_nmos_ull_d_ply_met_end+nsig_delr_cfr_nmos_ull_d_ply_met_end*sig_delr_cfr_nmos_ull_d_ply_met_end))
+    cfr_nmos45b_d_ply_m1ct         = (nom_cfr_nmos45b_d_ply_m1ct*(nom_delr_cfr_nmos45b_d_ply_m1ct+nsig_delr_cfr_nmos45b_d_ply_m1ct*sig_delr_cfr_nmos45b_d_ply_m1ct))
+    cfr_nld45_tlp_d_ply_m1ct       = (nom_cfr_nld45_tlp_d_ply_m1ct*(nom_delr_cfr_nld45_tlp_d_ply_m1ct+nsig_delr_cfr_nld45_tlp_d_ply_m1ct*sig_delr_cfr_nld45_tlp_d_ply_m1ct))
+    cfr_pld90_s_ply_met            = (nom_cfr_pld90_s_ply_met*(nom_delr_cfr_pld90_s_ply_met+nsig_delr_cfr_pld90_s_ply_met*sig_delr_cfr_pld90_s_ply_met))
+    cfr_nld30_d_ply_m1ct           = (nom_cfr_nld30_d_ply_m1ct*(nom_delr_cfr_nld30_d_ply_m1ct+nsig_delr_cfr_nld30_d_ply_m1ct*sig_delr_cfr_nld30_d_ply_m1ct))
+    cfr_nmos5_d_ply_met            = (nom_cfr_nmos5_d_ply_met*(nom_delr_cfr_nmos5_d_ply_met+nsig_delr_cfr_nmos5_d_ply_met*sig_delr_cfr_nmos5_d_ply_met))
+    cfr_nmos3_zvt_s_ply_met        = (nom_cfr_nmos3_zvt_s_ply_met*(nom_delr_cfr_nmos3_zvt_s_ply_met+nsig_delr_cfr_nmos3_zvt_s_ply_met*sig_delr_cfr_nmos3_zvt_s_ply_met))
+    cfr_nmos_d_ply_met             = (nom_cfr_nmos_d_ply_met*(nom_delr_cfr_nmos_d_ply_met+nsig_delr_cfr_nmos_d_ply_met*sig_delr_cfr_nmos_d_ply_met))
+    cfr_pld30b_d_ply_met           = (nom_cfr_pld30b_d_ply_met*(nom_delr_cfr_pld30b_d_ply_met+nsig_delr_cfr_pld30b_d_ply_met*sig_delr_cfr_pld30b_d_ply_met))
+    cfr_nld30_s_ply_met            = (nom_cfr_nld30_s_ply_met*(nom_delr_cfr_nld30_s_ply_met+nsig_delr_cfr_nld30_s_ply_met*sig_delr_cfr_nld30_s_ply_met))
+    cfr_pmoshs45_d_ply_met         = (nom_cfr_pmoshs45_d_ply_met*(nom_delr_cfr_pmoshs45_d_ply_met+nsig_delr_cfr_pmoshs45_d_ply_met*sig_delr_cfr_pmoshs45_d_ply_met))
+    cfr_nmos5_s_ply_m1ct           = (nom_cfr_nmos5_s_ply_m1ct*(nom_delr_cfr_nmos5_s_ply_m1ct+nsig_delr_cfr_nmos5_s_ply_m1ct*sig_delr_cfr_nmos5_s_ply_m1ct))
+    cfr_pmos10_d_ply_met           = (nom_cfr_pmos10_d_ply_met*(nom_delr_cfr_pmos10_d_ply_met+nsig_delr_cfr_pmos10_d_ply_met*sig_delr_cfr_pmos10_d_ply_met))
+    cfr_pld30b_s_ply_m1ct          = (nom_cfr_pld30b_s_ply_m1ct*(nom_delr_cfr_pld30b_s_ply_m1ct+nsig_delr_cfr_pld30b_s_ply_m1ct*sig_delr_cfr_pld30b_s_ply_m1ct))
+    cfr_nmos45_s_ply_met           = (nom_cfr_nmos45_s_ply_met*(nom_delr_cfr_nmos45_s_ply_met+nsig_delr_cfr_nmos45_s_ply_met*sig_delr_cfr_nmos45_s_ply_met))
+    cfr_pmoshs45_s_ply_met         = (nom_cfr_pmoshs45_s_ply_met*(nom_delr_cfr_pmoshs45_s_ply_met+nsig_delr_cfr_pmoshs45_s_ply_met*sig_delr_cfr_pmoshs45_s_ply_met))
+    cfr_nld5_lvt_s_ply_m1ct        = (nom_cfr_nld5_lvt_s_ply_m1ct*(nom_delr_cfr_nld5_lvt_s_ply_m1ct+nsig_delr_cfr_nld5_lvt_s_ply_m1ct*sig_delr_cfr_nld5_lvt_s_ply_m1ct))
+    cfr_pld90b_s_ply_m1ct          = (nom_cfr_pld90b_s_ply_m1ct*(nom_delr_cfr_pld90b_s_ply_m1ct+nsig_delr_cfr_pld90b_s_ply_m1ct*sig_delr_cfr_pld90b_s_ply_m1ct))
+    cfr_pld90b_s_ply_met           = (nom_cfr_pld90b_s_ply_met*(nom_delr_cfr_pld90b_s_ply_met+nsig_delr_cfr_pld90b_s_ply_met*sig_delr_cfr_pld90b_s_ply_met))
+    cfr_nmos45_d_ply_met           = (nom_cfr_nmos45_d_ply_met*(nom_delr_cfr_nmos45_d_ply_met+nsig_delr_cfr_nmos45_d_ply_met*sig_delr_cfr_nmos45_d_ply_met))
+    cfr_nld5_s_ply_met             = (nom_cfr_nld5_s_ply_met*(nom_delr_cfr_nld5_s_ply_met+nsig_delr_cfr_nld5_s_ply_met*sig_delr_cfr_nld5_s_ply_met))
+    cfr_pld30_d_ply_met            = (nom_cfr_pld30_d_ply_met*(nom_delr_cfr_pld30_d_ply_met+nsig_delr_cfr_pld30_d_ply_met*sig_delr_cfr_pld30_d_ply_met))
+    cfr_pmos_s_ply_m1ct            = (nom_cfr_pmos_s_ply_m1ct*(nom_delr_cfr_pmos_s_ply_m1ct+nsig_delr_cfr_pmos_s_ply_m1ct*sig_delr_cfr_pmos_s_ply_m1ct))
+    cfr_pmos90b_d_ply_m1ct         = (nom_cfr_pmos90b_d_ply_m1ct*(nom_delr_cfr_pmos90b_d_ply_m1ct+nsig_delr_cfr_pmos90b_d_ply_m1ct*sig_delr_cfr_pmos90b_d_ply_m1ct))
+    cfr_nld5_lvt_d_ply_met         = (nom_cfr_nld5_lvt_d_ply_met*(nom_delr_cfr_nld5_lvt_d_ply_met+nsig_delr_cfr_nld5_lvt_d_ply_met*sig_delr_cfr_nld5_lvt_d_ply_met))
+    cfr_nmos10_d_ply_m1ct          = (nom_cfr_nmos10_d_ply_m1ct*(nom_delr_cfr_nmos10_d_ply_m1ct+nsig_delr_cfr_nmos10_d_ply_m1ct*sig_delr_cfr_nmos10_d_ply_m1ct))
+    cfr_pmos10_d_ply_m1ct          = (nom_cfr_pmos10_d_ply_m1ct*(nom_delr_cfr_pmos10_d_ply_m1ct+nsig_delr_cfr_pmos10_d_ply_m1ct*sig_delr_cfr_pmos10_d_ply_m1ct))
+    cfr_nld30_s_ply_m1ct           = (nom_cfr_nld30_s_ply_m1ct*(nom_delr_cfr_nld30_s_ply_m1ct+nsig_delr_cfr_nld30_s_ply_m1ct*sig_delr_cfr_nld30_s_ply_m1ct))
+    cfr_pmos_ull_d_ply_ct          = (nom_cfr_pmos_ull_d_ply_ct*(nom_delr_cfr_pmos_ull_d_ply_ct+nsig_delr_cfr_pmos_ull_d_ply_ct*sig_delr_cfr_pmos_ull_d_ply_ct))
+    cfr_nld45_tlp_s_ply_met        = (nom_cfr_nld45_tlp_s_ply_met*(nom_delr_cfr_nld45_tlp_s_ply_met+nsig_delr_cfr_nld45_tlp_s_ply_met*sig_delr_cfr_nld45_tlp_s_ply_met))
+    cfr_nmos45_d_ply_m1ct          = (nom_cfr_nmos45_d_ply_m1ct*(nom_delr_cfr_nmos45_d_ply_m1ct+nsig_delr_cfr_nmos45_d_ply_m1ct*sig_delr_cfr_nmos45_d_ply_m1ct))
+    cfr_nmos_ull_s_ply_ct_end      = (nom_cfr_nmos_ull_s_ply_ct_end*(nom_delr_cfr_nmos_ull_s_ply_ct_end+nsig_delr_cfr_nmos_ull_s_ply_ct_end*sig_delr_cfr_nmos_ull_s_ply_ct_end))
+    cfr_pmos45_s_ply_m1ct          = (nom_cfr_pmos45_s_ply_m1ct*(nom_delr_cfr_pmos45_s_ply_m1ct+nsig_delr_cfr_pmos45_s_ply_m1ct*sig_delr_cfr_pmos45_s_ply_m1ct))
+    cfr_pmos_ana_s_ply_m1ct        = (nom_cfr_pmos_ana_s_ply_m1ct*(nom_delr_cfr_pmos_ana_s_ply_m1ct+nsig_delr_cfr_pmos_ana_s_ply_m1ct*sig_delr_cfr_pmos_ana_s_ply_m1ct))
+    cfr_pld30b_s_ply_met           = (nom_cfr_pld30b_s_ply_met*(nom_delr_cfr_pld30b_s_ply_met+nsig_delr_cfr_pld30b_s_ply_met*sig_delr_cfr_pld30b_s_ply_met))
+    cfr_pld90b_d_ply_met           = (nom_cfr_pld90b_d_ply_met*(nom_delr_cfr_pld90b_d_ply_met+nsig_delr_cfr_pld90b_d_ply_met*sig_delr_cfr_pld90b_d_ply_met))
+    cfr_pld45b_d_ply_m1ct          = (nom_cfr_pld45b_d_ply_m1ct*(nom_delr_cfr_pld45b_d_ply_m1ct+nsig_delr_cfr_pld45b_d_ply_m1ct*sig_delr_cfr_pld45b_d_ply_m1ct))
+    cfr_nld45b_he_s_ply_met        = (nom_cfr_nld45b_he_s_ply_met*(nom_delr_cfr_nld45b_he_s_ply_met+nsig_delr_cfr_nld45b_he_s_ply_met*sig_delr_cfr_nld45b_he_s_ply_met))
+    cfr_nld45_s_ply_met            = (nom_cfr_nld45_s_ply_met*(nom_delr_cfr_nld45_s_ply_met+nsig_delr_cfr_nld45_s_ply_met*sig_delr_cfr_nld45_s_ply_met))
+    cfr_nmos_d_ply_m1ct            = (nom_cfr_nmos_d_ply_m1ct*(nom_delr_cfr_nmos_d_ply_m1ct+nsig_delr_cfr_nmos_d_ply_m1ct*sig_delr_cfr_nmos_d_ply_m1ct))
+    cfr_pmos_ull_d_ply_m1ct        = (nom_cfr_pmos_ull_d_ply_m1ct*(nom_delr_cfr_pmos_ull_d_ply_m1ct+nsig_delr_cfr_pmos_ull_d_ply_m1ct*sig_delr_cfr_pmos_ull_d_ply_m1ct))
+    cfr_pld45b_d_ply_met           = (nom_cfr_pld45b_d_ply_met*(nom_delr_cfr_pld45b_d_ply_met+nsig_delr_cfr_pld45b_d_ply_met*sig_delr_cfr_pld45b_d_ply_met))
+    cfr_pmos90_s_ply_m1ct          = (nom_cfr_pmos90_s_ply_m1ct*(nom_delr_cfr_pmos90_s_ply_m1ct+nsig_delr_cfr_pmos90_s_ply_m1ct*sig_delr_cfr_pmos90_s_ply_m1ct))
+    cfr_pld30_d_ply_m1ct           = (nom_cfr_pld30_d_ply_m1ct*(nom_delr_cfr_pld30_d_ply_m1ct+nsig_delr_cfr_pld30_d_ply_m1ct*sig_delr_cfr_pld30_d_ply_m1ct))
+    cfr_nld45_he_s_ply_met         = (nom_cfr_nld45_he_s_ply_met*(nom_delr_cfr_nld45_he_s_ply_met+nsig_delr_cfr_nld45_he_s_ply_met*sig_delr_cfr_nld45_he_s_ply_met))
+    cfr_nmos3_zvt_s_ply_m1ct       = (nom_cfr_nmos3_zvt_s_ply_m1ct*(nom_delr_cfr_nmos3_zvt_s_ply_m1ct+nsig_delr_cfr_nmos3_zvt_s_ply_m1ct*sig_delr_cfr_nmos3_zvt_s_ply_m1ct))
+    cfr_nsrampd_d_ply_m1ct         = (nom_cfr_nsrampd_d_ply_m1ct*(nom_delr_cfr_nsrampd_d_ply_m1ct+nsig_delr_cfr_nsrampd_d_ply_m1ct*sig_delr_cfr_nsrampd_d_ply_m1ct))
+    cfr_nmos90_d_ply_met           = (nom_cfr_nmos90_d_ply_met*(nom_delr_cfr_nmos90_d_ply_met+nsig_delr_cfr_nmos90_d_ply_met*sig_delr_cfr_nmos90_d_ply_met))
+    cfr_nmos_ana_s_ply_met         = (nom_cfr_nmos_ana_s_ply_met*(nom_delr_cfr_nmos_ana_s_ply_met+nsig_delr_cfr_nmos_ana_s_ply_met*sig_delr_cfr_nmos_ana_s_ply_met))
+    cfr_psrampu_s_ply_m1ct         = (nom_cfr_psrampu_s_ply_m1ct*(nom_delr_cfr_psrampu_s_ply_m1ct+nsig_delr_cfr_psrampu_s_ply_m1ct*sig_delr_cfr_psrampu_s_ply_m1ct))
+    cfr_nmos45b_s_ply_m1ct         = (nom_cfr_nmos45b_s_ply_m1ct*(nom_delr_cfr_nmos45b_s_ply_m1ct+nsig_delr_cfr_nmos45b_s_ply_m1ct*sig_delr_cfr_nmos45b_s_ply_m1ct))
+    cfr_nld45_he_d_ply_m1ct        = (nom_cfr_nld45_he_d_ply_m1ct*(nom_delr_cfr_nld45_he_d_ply_m1ct+nsig_delr_cfr_nld45_he_d_ply_m1ct*sig_delr_cfr_nld45_he_d_ply_m1ct))
+    cfr_nld45b_d_ply_m1ct          = (nom_cfr_nld45b_d_ply_m1ct*(nom_delr_cfr_nld45b_d_ply_m1ct+nsig_delr_cfr_nld45b_d_ply_m1ct*sig_delr_cfr_nld45b_d_ply_m1ct))
+    cfr_nld45_d_ply_m1ct           = (nom_cfr_nld45_d_ply_m1ct*(nom_delr_cfr_nld45_d_ply_m1ct+nsig_delr_cfr_nld45_d_ply_m1ct*sig_delr_cfr_nld45_d_ply_m1ct))
+    cfr_nmos_ull_d_ply_ct_end      = (nom_cfr_nmos_ull_d_ply_ct_end*(nom_delr_cfr_nmos_ull_d_ply_ct_end+nsig_delr_cfr_nmos_ull_d_ply_ct_end*sig_delr_cfr_nmos_ull_d_ply_ct_end))


parameters
+    d_dt                      = 5.3
+    t_dt                      = 1.5
+    t_ox_dt                   = 0.50
+    d_nbl                     = 2.15
+    t_si                      = 5
+    t_box                     = 0.3
+    nom_delr_is_dpldd_junc_10hv = 1.0
+    nom_delr_ir_dpldd_junc_10hv = 1.0
+    nom_dela_bv_dpldd_junc_10hv = 0.0
+    nom_delr_cj_dpldd_junc_10hv = 1.0
+    sig_delr_is_dpldd_junc_10hv = 0.1
+    sig_delr_ir_dpldd_junc_10hv = 0.768
+    sig_dela_bv_dpldd_junc_10hv = 0.2492
+    sig_delr_cj_dpldd_junc_10hv = 0.0333
+    gsbot_dpldd_junc_10hv     = 0.0
+    gssti_dpldd_junc_10hv     = 0.0
+    gsgat_dpldd_junc_10hv     = 0.0
+    idsatrbot_dpldd_junc_10hv = 1.65e-07
+    idsatrsti_dpldd_junc_10hv = 0.0
+    nbot_dpldd_junc_10hv      = 1.02
+    ikrbot_dpldd_junc_10hv    = 80000000.0
+    nkbot_dpldd_junc_10hv     = 0.5
+    csrhbot_dpldd_junc_10hv   = 0.0
+    csrhsti_dpldd_junc_10hv   = 0.0
+    ctatbot_dpldd_junc_10hv   = 2000.0
+    ctatsti_dpldd_junc_10hv   = 0.0
+    mefftatbot_dpldd_junc_10hv = 0.25
+    mefftatsti_dpldd_junc_10hv = 0.25
+    cbbtbot_dpldd_junc_10hv   = 2.2000000000000002e-16
+    cbbtsti_dpldd_junc_10hv   = 0.0
+    fbbtrbot_dpldd_junc_10hv  = 1000.0
+    fbbtrsti_dpldd_junc_10hv  = 1000000000.0
+    xjunsti_dpldd_junc_10hv   = 1e-07
+    xjungat_dpldd_junc_10hv   = 1e-07
+    vbrbot_dpldd_junc_10hv    = 11.68
+    vbrsti_dpldd_junc_10hv    = 11.68
+    vbrgat_dpldd_junc_10hv    = 11.68
+    pbrbot_dpldd_junc_10hv    = 0.9500000000000001
+    pbrsti_dpldd_junc_10hv    = 4.0
+    pbrgat_dpldd_junc_10hv    = 4.0
+    frev_dpldd_junc_10hv      = 1000000000.0
+    cjorbot_dpldd_junc_10hv   = 0.00102
+    cjorsti_dpldd_junc_10hv   = 0.0
+    vbirbot_dpldd_junc_10hv   = 0.7000000000000001
+    vbirsti_dpldd_junc_10hv   = 1.0
+    pbot_dpldd_junc_10hv      = 0.326
+    psti_dpldd_junc_10hv      = 0.5
+    phigbot_dpldd_junc_10hv   = 1.1
+    phigsti_dpldd_junc_10hv   = 1.09
+    neffbot_dpldd_junc_10hv   = 1e+20
+    neffsti_dpldd_junc_10hv   = 1.2e+26
+    stfbbtbot_dpldd_junc_10hv = -0.001
+    stfbbtsti_dpldd_junc_10hv = -0.001
+    stvbrbot_dpldd_junc_10hv  = 0.0006299999999999999
+    stvbrsti_dpldd_junc_10hv  = 0.0006299999999999999
+    xisbot_dpldd_junc_10hv    = 2.6
+    tc1rs_dpldd_junc_10hv     = -0.0025
+    xikbot_dpldd_junc_10hv    = 1.0
+    nom_delr_tox_pmos90b_sphv_10hv = 1.0
+    nom_delr_uch_pmos90b_sphv_10hv = 0.95
+    nom_delr_res_pmos90b_sphv_10hv = 1.0
+    nom_dela_vfb_pmos90b_sphv_10hv = -0.025
+    nom_dela_vtw_pmos90b_sphv_10hv = 0.0
+    nom_dela_vtl_pmos90b_sphv_10hv = 0.005
+    nom_dela_dw_pmos90b_sphv_10hv = -0.007
+    nom_dela_mueo_pmos90b_sphv_10hv = -0.4
+    nom_dela_vdscale_pmos90b_sphv_10hv = -0.1
+    nom_dela_vdscalel_pmos90b_sphv_10hv = 0.028
+    nom_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nom_dela_vdscalelw_pmos90b_sphv_10hv = -0.05
+    sig_delr_tox_pmos90b_sphv_10hv = 0.012
+    sig_delr_uch_pmos90b_sphv_10hv = 0.035
+    sig_delr_res_pmos90b_sphv_10hv = 0.085
+    sig_dela_vfb_pmos90b_sphv_10hv = 0.015
+    sig_dela_vtw_pmos90b_sphv_10hv = 0.004
+    sig_dela_vtl_pmos90b_sphv_10hv = 0.00465
+    sig_dela_mueo_pmos90b_sphv_10hv = 0.065
+    sig_dela_dw_pmos90b_sphv_10hv = 0.0
+    sig_dela_vdscale_pmos90b_sphv_10hv = 0.002
+    sig_dela_vdscalel_pmos90b_sphv_10hv = 0.005
+    sig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    sig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nom_delr_cj_pmos90b_sphv_10hv = 1.0
+    nom_delr_is_pmos90b_sphv_10hv = 1.0
+    nom_delr_is2_pmos90b_sphv_10hv = 1.0
+    nom_delr_ir_pmos90b_sphv_10hv = 1.0
+    sig_delr_cj_pmos90b_sphv_10hv = 0.0333
+    sig_delr_is_pmos90b_sphv_10hv = 0.055
+    sig_delr_is2_pmos90b_sphv_10hv = 0.768
+    sig_delr_ir_pmos90b_sphv_10hv = 0.768
+    fac_rth_pmos90b_sphv_10hv = 0.7
+    tc1_ecrit_pmos90b_sphv_10hv = 0.002
+    tc2_ecrit_pmos90b_sphv_10hv = 0.0
+    dwrjundo_pmos90b_sphv_10hv = 20.0
+    dwrjunso_pmos90b_sphv_10hv = 0.0
+    qmc_pmos90b_sphv_10hv     = 0.0
+    lvaro_pmos90b_sphv_10hv   = 2.4e-07
+    lvarl_pmos90b_sphv_10hv   = 0.0
+    lvarw_pmos90b_sphv_10hv   = 2.0
+    lap_pmos90b_sphv_10hv     = 0.0
+    wvaro_pmos90b_sphv_10hv   = 0.0
+    wvarl_pmos90b_sphv_10hv   = 0.0
+    wvarw_pmos90b_sphv_10hv   = 0.0
+    wot_pmos90b_sphv_10hv     = 0.0
+    dlq_pmos90b_sphv_10hv     = -1.3e-07
+    dwq_pmos90b_sphv_10hv     = -1.5e-07
+    vfbo_pmos90b_sphv_10hv    = -0.943
+    vfbl_pmos90b_sphv_10hv    = -0.067
+    vfbw_pmos90b_sphv_10hv    = 0.012
+    vfblw_pmos90b_sphv_10hv   = 0.05
+    stvfbo_pmos90b_sphv_10hv  = 0.0008808
+    stvfbl_pmos90b_sphv_10hv  = 0.0
+    stvfbw_pmos90b_sphv_10hv  = 0.0
+    stvfblw_pmos90b_sphv_10hv = 0.0
+    toxo_pmos90b_sphv_10hv    = 1.31e-08
+    epsroxo_pmos90b_sphv_10hv = 3.9
+    nsubo_pmos90b_sphv_10hv   = 1.3e+23
+    nsubw_pmos90b_sphv_10hv   = 0.0
+    wseg_pmos90b_sphv_10hv    = 1e-09
+    npck_pmos90b_sphv_10hv    = 1e+23
+    npckw_pmos90b_sphv_10hv   = 0.0
+    wsegp_pmos90b_sphv_10hv   = 2.474e-06
+    lpck_pmos90b_sphv_10hv    = 1e-10
+    lpckw_pmos90b_sphv_10hv   = 0.0
+    fol1_pmos90b_sphv_10hv    = 0.0
+    fol2_pmos90b_sphv_10hv    = 0.0
+    facneffaco_pmos90b_sphv_10hv = 1.0
+    facneffacl_pmos90b_sphv_10hv = 0.0
+    facneffacw_pmos90b_sphv_10hv = 0.0
+    facneffaclw_pmos90b_sphv_10hv = 0.0
+    gfacnudo_pmos90b_sphv_10hv = 1.0
+    gfacnudl_pmos90b_sphv_10hv = 0.0
+    gfacnudlexp_pmos90b_sphv_10hv = 1.0
+    gfacnudw_pmos90b_sphv_10hv = 0.0
+    gfacnudlw_pmos90b_sphv_10hv = 0.0
+    vsbnudo_pmos90b_sphv_10hv = 2.75
+    dvsbnudo_pmos90b_sphv_10hv = 1.0
+    vnsubo_pmos90b_sphv_10hv  = 0.0
+    nslpo_pmos90b_sphv_10hv   = 0.05
+    dnsubo_pmos90b_sphv_10hv  = 0.013
+    dphibo_pmos90b_sphv_10hv  = 0.0
+    dphibl_pmos90b_sphv_10hv  = 0.001
+    dphiblexp_pmos90b_sphv_10hv = 1.0
+    dphibw_pmos90b_sphv_10hv  = 0.0
+    dphiblw_pmos90b_sphv_10hv = 0.0
+    delvtaco_pmos90b_sphv_10hv = 0.0
+    delvtacl_pmos90b_sphv_10hv = 0.0
+    delvtaclexp_pmos90b_sphv_10hv = 1.0
+    delvtacw_pmos90b_sphv_10hv = 0.0
+    delvtaclw_pmos90b_sphv_10hv = 0.0
+    npo_pmos90b_sphv_10hv     = 2e+26
+    npl_pmos90b_sphv_10hv     = 0.0
+    cto_pmos90b_sphv_10hv     = 0.02
+    ctl_pmos90b_sphv_10hv     = 0.0
+    ctlexp_pmos90b_sphv_10hv  = 0.4772
+    ctw_pmos90b_sphv_10hv     = -0.09186
+    ctlw_pmos90b_sphv_10hv    = 0.0
+    toxovo_pmos90b_sphv_10hv  = 1.31e-08
+    toxovdo_pmos90b_sphv_10hv = 1.31e-08
+    lov_pmos90b_sphv_10hv     = 1.2e-07
+    dlovd_pmos90b_sphv_10hv   = -1e-07
+    novo_pmos90b_sphv_10hv    = 2e+24
+    novdo_pmos90b_sphv_10hv   = 1e+22
+    cfl_pmos90b_sphv_10hv     = 0.0
+    cflexp_pmos90b_sphv_10hv  = 0.839
+    cfw_pmos90b_sphv_10hv     = 0.0
+    cfbo_pmos90b_sphv_10hv    = 2.22e-15
+    uo_pmos90b_sphv_10hv      = 0.0265
+    fbet1_pmos90b_sphv_10hv   = 0.0
+    fbet1w_pmos90b_sphv_10hv  = 0.0
+    lp1_pmos90b_sphv_10hv     = 0.0
+    lp1w_pmos90b_sphv_10hv    = 0.0
+    fbet2_pmos90b_sphv_10hv   = 0.0
+    lp2_pmos90b_sphv_10hv     = 0.0
+    betw1_pmos90b_sphv_10hv   = 0.0
+    betw2_pmos90b_sphv_10hv   = 0.0
+    wbet_pmos90b_sphv_10hv    = 0.0
+    stbeto_pmos90b_sphv_10hv  = 1.55
+    stbetl_pmos90b_sphv_10hv  = 0.0
+    stbetw_pmos90b_sphv_10hv  = 0.0
+    stbetlw_pmos90b_sphv_10hv = 0.5
+    mueo_pmos90b_sphv_10hv    = 4.5
+    muew_pmos90b_sphv_10hv    = 0.2
+    stmueo_pmos90b_sphv_10hv  = 0.8
+    themuo_pmos90b_sphv_10hv  = 0.9
+    stthemuo_pmos90b_sphv_10hv = 0.25
+    cso_pmos90b_sphv_10hv     = 0.0
+    csl_pmos90b_sphv_10hv     = 0.0
+    cslexp_pmos90b_sphv_10hv  = 0.0
+    csw_pmos90b_sphv_10hv     = 0.0
+    cslw_pmos90b_sphv_10hv    = 0.0
+    stcso_pmos90b_sphv_10hv   = 0.0
+    xcoro_pmos90b_sphv_10hv   = 0.01
+    xcorl_pmos90b_sphv_10hv   = 0.0
+    xcorw_pmos90b_sphv_10hv   = 0.0
+    xcorlw_pmos90b_sphv_10hv  = 0.0
+    stxcoro_pmos90b_sphv_10hv = 1.4
+    fetao_pmos90b_sphv_10hv   = 1.0
+    rsw1_pmos90b_sphv_10hv    = 0.0
+    rsw2_pmos90b_sphv_10hv    = 0.0
+    strso_pmos90b_sphv_10hv   = 0.0
+    rsbo_pmos90b_sphv_10hv    = 0.0
+    rsgo_pmos90b_sphv_10hv    = 0.0
+    thesato_pmos90b_sphv_10hv = 0.0
+    thesatl_pmos90b_sphv_10hv = 0.0
+    thesatlexp_pmos90b_sphv_10hv = 2.0
+    thesatw_pmos90b_sphv_10hv = 0.0
+    thesatlw_pmos90b_sphv_10hv = 0.0
+    stthesato_pmos90b_sphv_10hv = 0.5
+    stthesatl_pmos90b_sphv_10hv = 5.0
+    stthesatw_pmos90b_sphv_10hv = 2.5
+    stthesatlw_pmos90b_sphv_10hv = 0.0
+    thesatbo_pmos90b_sphv_10hv = 0.0
+    thesatgo_pmos90b_sphv_10hv = 0.0
+    thesatgl_pmos90b_sphv_10hv = 0.0
+    thesatgw_pmos90b_sphv_10hv = 0.0
+    axo_pmos90b_sphv_10hv     = 5.0
+    axl_pmos90b_sphv_10hv     = 2.0
+    alpl_pmos90b_sphv_10hv    = 0.0
+    alplexp_pmos90b_sphv_10hv = 1.0
+    alpw_pmos90b_sphv_10hv    = 0.0
+    alp1l1_pmos90b_sphv_10hv  = 0.0
+    alp1lexp_pmos90b_sphv_10hv = 0.5
+    alp1l2_pmos90b_sphv_10hv  = 0.0
+    alp1w_pmos90b_sphv_10hv   = 0.0
+    alp2l1_pmos90b_sphv_10hv  = 0.0
+    alp2lexp_pmos90b_sphv_10hv = 1.0
+    alp2l2_pmos90b_sphv_10hv  = 0.0
+    alp2w_pmos90b_sphv_10hv   = 0.0
+    vpo_pmos90b_sphv_10hv     = 10.0
+    a1o_pmos90b_sphv_10hv     = 0.0015
+    a1l_pmos90b_sphv_10hv     = 0.3
+    a1w_pmos90b_sphv_10hv     = 1.5
+    a2o_pmos90b_sphv_10hv     = 90.0
+    sta2o_pmos90b_sphv_10hv   = 0.4
+    a3o_pmos90b_sphv_10hv     = 1.0
+    a3l_pmos90b_sphv_10hv     = 0.0
+    a3w_pmos90b_sphv_10hv     = 0.0
+    a4o_pmos90b_sphv_10hv     = 0.0
+    a4l_pmos90b_sphv_10hv     = 0.0
+    a4w_pmos90b_sphv_10hv     = 0.0
+    gcoo_pmos90b_sphv_10hv    = 0.0
+    iginvlw_pmos90b_sphv_10hv = 0.0
+    igovw_pmos90b_sphv_10hv   = 0.0
+    igovdw_pmos90b_sphv_10hv  = 0.0
+    stigo_pmos90b_sphv_10hv   = 2.0
+    gc2o_pmos90b_sphv_10hv    = 0.375
+    gc3o_pmos90b_sphv_10hv    = 0.063
+    chibo_pmos90b_sphv_10hv   = 3.1
+    agidlw_pmos90b_sphv_10hv  = 1.5e-06
+    agidldw_pmos90b_sphv_10hv = 0.0
+    bgidlo_pmos90b_sphv_10hv  = 7.0
+    bgidldo_pmos90b_sphv_10hv = 10.0
+    stbgidlo_pmos90b_sphv_10hv = -0.0015
+    stbgidldo_pmos90b_sphv_10hv = 0.0
+    cgidlo_pmos90b_sphv_10hv  = 0.0
+    cgidldo_pmos90b_sphv_10hv = 1.0
+    cgbovl_pmos90b_sphv_10hv  = 1.06e-15
+    cfrw_pmos90b_sphv_10hv    = 0.0
+    cfrdw_pmos90b_sphv_10hv   = 0.0
+    fnto_pmos90b_sphv_10hv    = 1.0
+    nfalw_pmos90b_sphv_10hv   = 3e+23
+    nfblw_pmos90b_sphv_10hv   = 0.0
+    nfclw_pmos90b_sphv_10hv   = 3e-07
+    efo_pmos90b_sphv_10hv     = 1.0
+    lintnoi_pmos90b_sphv_10hv = 0.0
+    alpnoi_pmos90b_sphv_10hv  = 2.0
+    kvthoweo_pmos90b_sphv_10hv = 0.0
+    kvthowel_pmos90b_sphv_10hv = 0.0
+    kvthowew_pmos90b_sphv_10hv = 0.0
+    kvthowelw_pmos90b_sphv_10hv = 0.0
+    kuoweo_pmos90b_sphv_10hv  = 0.0
+    kuowel_pmos90b_sphv_10hv  = 0.0
+    kuowew_pmos90b_sphv_10hv  = 0.0
+    kuowelw_pmos90b_sphv_10hv = 0.0
+    rgo_pmos90b_sphv_10hv     = 0.0
+    rsh_pmos90b_sphv_10hv     = 0.0
+    rbulko_pmos90b_sphv_10hv  = 0.0
+    rwello_pmos90b_sphv_10hv  = 0.0
+    rjunso_pmos90b_sphv_10hv  = 1000.0
+    rjundo_pmos90b_sphv_10hv  = 3500.0
+    rint_pmos90b_sphv_10hv    = 0.0
+    rvpoly_pmos90b_sphv_10hv  = 0.0
+    rshg_pmos90b_sphv_10hv    = 0.0
+    dlsil_pmos90b_sphv_10hv   = 0.0
+    saref_pmos90b_sphv_10hv   = 1e-06
+    sbref_pmos90b_sphv_10hv   = 1e-06
+    wlod_pmos90b_sphv_10hv    = 0.0
+    kuo_pmos90b_sphv_10hv     = 0.0
+    kvsat_pmos90b_sphv_10hv   = 0.0
+    tkuo_pmos90b_sphv_10hv    = 0.0
+    lkuo_pmos90b_sphv_10hv    = 0.0
+    wkuo_pmos90b_sphv_10hv    = 0.0
+    pkuo_pmos90b_sphv_10hv    = 0.0
+    llodkuo_pmos90b_sphv_10hv = 0.0
+    wlodkuo_pmos90b_sphv_10hv = 0.0
+    kvtho_pmos90b_sphv_10hv   = 0.0
+    lkvtho_pmos90b_sphv_10hv  = 0.0
+    wkvtho_pmos90b_sphv_10hv  = 0.0
+    pkvtho_pmos90b_sphv_10hv  = 0.0
+    llodvth_pmos90b_sphv_10hv = 0.0
+    wlodvth_pmos90b_sphv_10hv = 0.0
+    stetao_pmos90b_sphv_10hv  = 0.0
+    lodetao_pmos90b_sphv_10hv = 1.0
+    scref_pmos90b_sphv_10hv   = 1e-05
+    web_pmos90b_sphv_10hv     = 0.0
+    wec_pmos90b_sphv_10hv     = 0.0
+    adr1o_pmos90b_sphv_10hv   = 0.0003
+    adr1l_pmos90b_sphv_10hv   = 0.0
+    adr1w_pmos90b_sphv_10hv   = 0.0
+    adr2o_pmos90b_sphv_10hv   = 101.0
+    stadr2o_pmos90b_sphv_10hv = 0.5
+    adr3o_pmos90b_sphv_10hv   = 0.0
+    adr3l_pmos90b_sphv_10hv   = 0.0
+    adr3w_pmos90b_sphv_10hv   = 0.0
+    adr4o_pmos90b_sphv_10hv   = 0.0
+    adr4l_pmos90b_sphv_10hv   = 0.0
+    adr4w_pmos90b_sphv_10hv   = 0.0
+    adr5o_pmos90b_sphv_10hv   = 0.0
+    adr5l_pmos90b_sphv_10hv   = 0.0
+    adr5w_pmos90b_sphv_10hv   = 0.0
+    bidr1o_pmos90b_sphv_10hv  = 0.0
+    bidr1l_pmos90b_sphv_10hv  = 0.0
+    bidr1w_pmos90b_sphv_10hv  = 0.0
+    bidr2o_pmos90b_sphv_10hv  = 0.0
+    bidr2w_pmos90b_sphv_10hv  = 0.0
+    rtho_pmos90b_sphv_10hv    = 650.0
+    rthl_pmos90b_sphv_10hv    = 0.0
+    rthw_pmos90b_sphv_10hv    = 0.0
+    rthlw_pmos90b_sphv_10hv   = 0.0
+    strtho_pmos90b_sphv_10hv  = 0.5
+    strthao_pmos90b_sphv_10hv = 0.0
+    ctho_pmos90b_sphv_10hv    = 0.0
+    cthl_pmos90b_sphv_10hv    = 0.0
+    cthw_pmos90b_sphv_10hv    = 0.0
+    cthlw_pmos90b_sphv_10hv   = 0.0
+    rshldd_pmos90b_sphv_10hv  = 20400.0
+    xw_pmos90b_sphv_10hv      = 1.35e-06
+    nwxw_pmos90b_sphv_10hv    = 5e-13
+    xl_pmos90b_sphv_10hv      = 0.0
+    xlw_pmos90b_sphv_10hv     = 0.0
+    dxlsat_pmos90b_sphv_10hv  = 0.0
+    nst_pmos90b_sphv_10hv     = 1.0
+    ats_pmos90b_sphv_10hv     = 0.0
+    dfinf_pmos90b_sphv_10hv   = 0.04
+    dfw_pmos90b_sphv_10hv     = 0.0
+    dfl_pmos90b_sphv_10hv     = 0.0
+    dflw_pmos90b_sphv_10hv    = 1e-12
+    dp_pmos90b_sphv_10hv      = 2.0
+    ecrit_pmos90b_sphv_10hv   = 6000000.0
+    ecorn_pmos90b_sphv_10hv   = 50000.0
+    xvsat_pmos90b_sphv_10hv   = 0.0
+    du_pmos90b_sphv_10hv      = 0.0
+    tc1_pmos90b_sphv_10hv     = 0.0054
+    tc2_pmos90b_sphv_10hv     = 3e-06
+    tc1l_pmos90b_sphv_10hv    = 0.0
+    tc2l_pmos90b_sphv_10hv    = 0.0
+    tc1w_pmos90b_sphv_10hv    = -3e-09
+    tc2w_pmos90b_sphv_10hv    = 0.0
+    theacc_pmos90b_sphv_10hv  = 0.0
+    theacc2_pmos90b_sphv_10hv = 0.08
+    aacc_pmos90b_sphv_10hv    = 36.0
+    rva_pmos90b_sphv_10hv     = 200.0
+    dta_pmos90b_sphv_10hv     = 0.0
+    trj_pmos90b_sphv_10hv     = 27.0
+    cjarea_pmos90b_sphv_10hv  = 0.000215
+    cjlsti_pmos90b_sphv_10hv  = 0.0
+    cjlgat_pmos90b_sphv_10hv  = 5.375e-10
+    vbiarea_pmos90b_sphv_10hv = 0.75
+    vbisti_pmos90b_sphv_10hv  = 0.75
+    vbigat_pmos90b_sphv_10hv  = 0.75
+    parea_pmos90b_sphv_10hv   = 0.3
+    psti_pmos90b_sphv_10hv    = 0.3
+    pgat_pmos90b_sphv_10hv    = 0.3
+    is1area_pmos90b_sphv_10hv = 2e-08
+    ttarea_pmos90b_sphv_10hv  = 3e-09
+    is2area_pmos90b_sphv_10hv = 4e-05
+    irarea_pmos90b_sphv_10hv  = 0.0003
+    stis1area_pmos90b_sphv_10hv = 3.0
+    stis2area_pmos90b_sphv_10hv = 3.0
+    stirarea_pmos90b_sphv_10hv = 1100.0
+    n1area_pmos90b_sphv_10hv  = 1.02
+    n2area_pmos90b_sphv_10hv  = 2.0
+    nrarea_pmos90b_sphv_10hv  = 50.0
+    is1lsti_pmos90b_sphv_10hv = 1e-16
+    ttlsti_pmos90b_sphv_10hv  = 3e-09
+    is2lsti_pmos90b_sphv_10hv = 1e-13
+    irlsti_pmos90b_sphv_10hv  = 5e-15
+    stis1sti_pmos90b_sphv_10hv = 3.0
+    stis2sti_pmos90b_sphv_10hv = 3.0
+    stirsti_pmos90b_sphv_10hv = 1100.0
+    n1sti_pmos90b_sphv_10hv   = 1.02
+    n2sti_pmos90b_sphv_10hv   = 2.0
+    nrsti_pmos90b_sphv_10hv   = 50.0
+    is1lgat_pmos90b_sphv_10hv = 5e-14
+    ttlgat_pmos90b_sphv_10hv  = 3e-09
+    is2lgat_pmos90b_sphv_10hv = 1e-10
+    irlgat_pmos90b_sphv_10hv  = 7.5e-12
+    stis1gat_pmos90b_sphv_10hv = 3.0
+    stis2gat_pmos90b_sphv_10hv = 3.0
+    stirgat_pmos90b_sphv_10hv = 1100.0
+    n1gat_pmos90b_sphv_10hv   = 1.02
+    n2gat_pmos90b_sphv_10hv   = 2.0
+    nrgat_pmos90b_sphv_10hv   = 50.0
+    cjaread_pmos90b_sphv_10hv = 0.00016
+    cjlstid_pmos90b_sphv_10hv = 5e-11
+    cjlgatd_pmos90b_sphv_10hv = 0.0
+    vbiaread_pmos90b_sphv_10hv = 0.5
+    vbistid_pmos90b_sphv_10hv = 0.5
+    vbigatd_pmos90b_sphv_10hv = 0.5
+    paread_pmos90b_sphv_10hv  = 0.38
+    pstid_pmos90b_sphv_10hv   = 0.38
+    pgatd_pmos90b_sphv_10hv   = 0.38
+    is1aread_pmos90b_sphv_10hv = 3.6e-08
+    ttaread_pmos90b_sphv_10hv = 7e-08
+    is2aread_pmos90b_sphv_10hv = 2e-05
+    iraread_pmos90b_sphv_10hv = 0.0004
+    stis1aread_pmos90b_sphv_10hv = 2.0
+    stis2aread_pmos90b_sphv_10hv = 10.0
+    stiraread_pmos90b_sphv_10hv = 172000.0
+    n1aread_pmos90b_sphv_10hv = 1.02
+    n2aread_pmos90b_sphv_10hv = 2.0
+    nraread_pmos90b_sphv_10hv = 8000.0
+    is1lstid_pmos90b_sphv_10hv = 0
+    ttlstid_pmos90b_sphv_10hv = 1e-07
+    is2lstid_pmos90b_sphv_10hv = 0.0
+    irlstid_pmos90b_sphv_10hv = 1.5e-15
+    stis1stid_pmos90b_sphv_10hv = 2.0
+    stis2stid_pmos90b_sphv_10hv = 10.0
+    stirstid_pmos90b_sphv_10hv = 172000.0
+    n1stid_pmos90b_sphv_10hv  = 1.02
+    n2stid_pmos90b_sphv_10hv  = 2.0
+    nrstid_pmos90b_sphv_10hv  = 8000.0
+    is1lgatd_pmos90b_sphv_10hv = 0
+    ttlgatd_pmos90b_sphv_10hv = 7e-08
+    is2lgatd_pmos90b_sphv_10hv = 0.0
+    irlgatd_pmos90b_sphv_10hv = 1e-09
+    stis1gatd_pmos90b_sphv_10hv = 2.0
+    stis2gatd_pmos90b_sphv_10hv = 10.0
+    stirgatd_pmos90b_sphv_10hv = 172000.0
+    n1gatd_pmos90b_sphv_10hv  = 1.02
+    n2gatd_pmos90b_sphv_10hv  = 2.0
+    nrgatd_pmos90b_sphv_10hv  = 8000.0
+    cjaread2_pmos90b_sphv_10hv = 1e-12
+    cjlstid2_pmos90b_sphv_10hv = 1e-18
+    vbiaread2_pmos90b_sphv_10hv = 0.5
+    vbistid2_pmos90b_sphv_10hv = 0.5
+    paread2_pmos90b_sphv_10hv = 0.38
+    pstid2_pmos90b_sphv_10hv  = 0.38
+    is1aread2_pmos90b_sphv_10hv = 0
+    ttaread2_pmos90b_sphv_10hv = 7e-08
+    is2aread2_pmos90b_sphv_10hv = 0.0
+    iraread2_pmos90b_sphv_10hv = 0.0004
+    stis1aread2_pmos90b_sphv_10hv = 25
+    stis2aread2_pmos90b_sphv_10hv = 15
+    stiraread2_pmos90b_sphv_10hv = 172000.0
+    n1aread2_pmos90b_sphv_10hv = 1.02
+    n2aread2_pmos90b_sphv_10hv = 2.0
+    nraread2_pmos90b_sphv_10hv = 8000.0
+    is1lstid2_pmos90b_sphv_10hv = 0
+    ttlstid2_pmos90b_sphv_10hv = 1e-07
+    is2lstid2_pmos90b_sphv_10hv = 0.0
+    irlstid2_pmos90b_sphv_10hv = 1.5e-15
+    stis1stid2_pmos90b_sphv_10hv = 2.0
+    stis2stid2_pmos90b_sphv_10hv = 10.0
+    stirstid2_pmos90b_sphv_10hv = 172000.0
+    n1stid2_pmos90b_sphv_10hv = 1.02
+    n2stid2_pmos90b_sphv_10hv = 2.0
+    nrstid2_pmos90b_sphv_10hv = 8000.0
+    eais1area_pmos90b_sphv_10hv = 1.12
+    eais2area_pmos90b_sphv_10hv = 1.12
+    eairarea_pmos90b_sphv_10hv = 1.12
+    eais1sti_pmos90b_sphv_10hv = 1.12
+    eais2sti_pmos90b_sphv_10hv = 1.12
+    eairsti_pmos90b_sphv_10hv = 1.12
+    eais1gat_pmos90b_sphv_10hv = 1.12
+    eais2gat_pmos90b_sphv_10hv = 1.12
+    eairgat_pmos90b_sphv_10hv = 1.12
+    eais1aread_pmos90b_sphv_10hv = 1.12
+    eais2aread_pmos90b_sphv_10hv = 1.12
+    eairaread_pmos90b_sphv_10hv = 1.12
+    eais1stid_pmos90b_sphv_10hv = 1.12
+    eais2stid_pmos90b_sphv_10hv = 1.12
+    eairstid_pmos90b_sphv_10hv = 1.12
+    eais1gatd_pmos90b_sphv_10hv = 1.12
+    eais2gatd_pmos90b_sphv_10hv = 1.12
+    eairgatd_pmos90b_sphv_10hv = 1.12
+    eais1aread2_pmos90b_sphv_10hv = 1.12
+    eais2aread2_pmos90b_sphv_10hv = 1.12
+    eairaread2_pmos90b_sphv_10hv = 1.12
+    eais1stid2_pmos90b_sphv_10hv = 1.12
+    eais2stid2_pmos90b_sphv_10hv = 1.12
+    eairstid2_pmos90b_sphv_10hv = 1.12
+    vdscale_pmos90b_sphv_10hv = 1.09
+    vdscalel_pmos90b_sphv_10hv = 0.377
+    vdscalew_pmos90b_sphv_10hv = -0.13
+    vdscalelw_pmos90b_sphv_10hv = 0.41
+    vdscaleb_pmos90b_sphv_10hv = 0.01
+    vdscalebl_pmos90b_sphv_10hv = 5.0
+    mumb_pmos90b_sphv_10hv    = 0.19
+    mumbexp_pmos90b_sphv_10hv = 1.8
+    mumbvclmp_pmos90b_sphv_10hv = 10.0
+    stvdscale_pmos90b_sphv_10hv = 0.0
+    ctgo_pmos90b_sphv_10hv    = 0.0
+    ctbo_pmos90b_sphv_10hv    = 0.0
+    stcto_pmos90b_sphv_10hv   = 0.0
+    ikfarea_pmos90b_sphv_10hv = 0.0
+    stikfarea_pmos90b_sphv_10hv = 0.0
+    ikfaread_pmos90b_sphv_10hv = 1000000.0
+    dwikfaread_pmos90b_sphv_10hv = 10.0
+    stikfaread_pmos90b_sphv_10hv = 3.0
+    nom_delr_tox_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_uch_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_res_pmoshs45b_sphv_10hv = 1.0
+    nom_dela_vfb_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_vtl_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_dl_pmoshs45b_sphv_10hv = 0.0
+    nom_dela_dlw_pmoshs45b_sphv_10hv = 0.0
+    nom_delr_cjs_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_cjd_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_jsideal_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_jdideal_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_jsnonideal_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_jdnonideal_pmoshs45b_sphv_10hv = 1.0
+    nom_delr_jsdideal_pmoshs45b_sphv_10hv = 1.0
+    sig_delr_tox_pmoshs45b_sphv_10hv = 0.012
+    sig_delr_uch_pmoshs45b_sphv_10hv = 0.01076654
+    sig_delr_res_pmoshs45b_sphv_10hv = 0.02
+    sig_dela_vfb_pmoshs45b_sphv_10hv = 0.0187
+    sig_dela_vtw_pmoshs45b_sphv_10hv = 0.00063
+    sig_dela_vtl_pmoshs45b_sphv_10hv = 0.008
+    sig_dela_vtm_pmoshs45b_sphv_10hv = 0.00622
+    sig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    sig_dela_dl_pmoshs45b_sphv_10hv = 0.01219
+    sig_dela_dlw_pmoshs45b_sphv_10hv = 0.0087768
+    sig_delr_cjs_pmoshs45b_sphv_10hv = 0.033
+    sig_delr_cjd_pmoshs45b_sphv_10hv = 0.033
+    sig_delr_jsideal_pmoshs45b_sphv_10hv = 0.055
+    sig_delr_jdideal_pmoshs45b_sphv_10hv = 0.055
+    sig_delr_jsnonideal_pmoshs45b_sphv_10hv = 0.768
+    sig_delr_jdnonideal_pmoshs45b_sphv_10hv = 0.768
+    sig_delr_jsdideal_pmoshs45b_sphv_10hv = 0.055
+    fac_rth_pmoshs45b_sphv_10hv = 0.8
+    tc1_ecrit_pmoshs45b_sphv_10hv = 0.0
+    tc2_ecrit_pmoshs45b_sphv_10hv = 0.0
+    dwrjundo_pmoshs45b_sphv_10hv = 4.0
+    dwrjunso_pmoshs45b_sphv_10hv = 18.0
+    qmc_pmoshs45b_sphv_10hv   = 0.0
+    lvaro_pmoshs45b_sphv_10hv = 3.64754502774e-08
+    lvarl_pmoshs45b_sphv_10hv = 0.0
+    lvarw_pmoshs45b_sphv_10hv = 7.88902253753
+    lap_pmoshs45b_sphv_10hv   = 0.0
+    wvaro_pmoshs45b_sphv_10hv = -2.17961408658e-07
+    wvarl_pmoshs45b_sphv_10hv = 0.0
+    wvarw_pmoshs45b_sphv_10hv = 0.0
+    wot_pmoshs45b_sphv_10hv   = 0.0
+    dlq_pmoshs45b_sphv_10hv   = 8.5e-08
+    dwq_pmoshs45b_sphv_10hv   = 2.3e-07
+    vfbo_pmoshs45b_sphv_10hv  = -0.898573661521
+    vfbl_pmoshs45b_sphv_10hv  = -0.00561029219368
+    vfbw_pmoshs45b_sphv_10hv  = -0.0160292180632
+    vfblw_pmoshs45b_sphv_10hv = 0.0408271482991
+    stvfbo_pmoshs45b_sphv_10hv = 0.0008808
+    stvfbl_pmoshs45b_sphv_10hv = 0.0
+    stvfbw_pmoshs45b_sphv_10hv = 5e-05
+    stvfblw_pmoshs45b_sphv_10hv = 0.0
+    toxo_pmoshs45b_sphv_10hv  = 1.3e-08
+    epsroxo_pmoshs45b_sphv_10hv = 3.9
+    nsubo_pmoshs45b_sphv_10hv = 1.06e+23
+    nsubw_pmoshs45b_sphv_10hv = 0.0
+    wseg_pmoshs45b_sphv_10hv  = 1e-09
+    npck_pmoshs45b_sphv_10hv  = 1e+23
+    npckw_pmoshs45b_sphv_10hv = 0.0
+    wsegp_pmoshs45b_sphv_10hv = 2.474e-06
+    lpck_pmoshs45b_sphv_10hv  = 0.0
+    lpckw_pmoshs45b_sphv_10hv = 0.0
+    fol1_pmoshs45b_sphv_10hv  = 0.0
+    fol2_pmoshs45b_sphv_10hv  = 0.0
+    facneffaco_pmoshs45b_sphv_10hv = 1.0
+    facneffacl_pmoshs45b_sphv_10hv = 0.0
+    facneffacw_pmoshs45b_sphv_10hv = 0.0
+    facneffaclw_pmoshs45b_sphv_10hv = 0.0
+    gfacnudo_pmoshs45b_sphv_10hv = 1.0
+    gfacnudl_pmoshs45b_sphv_10hv = 0.0
+    gfacnudlexp_pmoshs45b_sphv_10hv = 1.0
+    gfacnudw_pmoshs45b_sphv_10hv = 0.0
+    gfacnudlw_pmoshs45b_sphv_10hv = 0.0
+    vsbnudo_pmoshs45b_sphv_10hv = 2.75
+    dvsbnudo_pmoshs45b_sphv_10hv = 1.0
+    vnsubo_pmoshs45b_sphv_10hv = 0.0
+    nslpo_pmoshs45b_sphv_10hv = 0.05
+    dnsubo_pmoshs45b_sphv_10hv = 0.03
+    dphibo_pmoshs45b_sphv_10hv = 0.008
+    dphibl_pmoshs45b_sphv_10hv = 0.0
+    dphiblexp_pmoshs45b_sphv_10hv = 1.0
+    dphibw_pmoshs45b_sphv_10hv = 0.0
+    dphiblw_pmoshs45b_sphv_10hv = 0.0
+    delvtaco_pmoshs45b_sphv_10hv = 0.0
+    delvtacl_pmoshs45b_sphv_10hv = 0.0
+    delvtaclexp_pmoshs45b_sphv_10hv = 1.0
+    delvtacw_pmoshs45b_sphv_10hv = 0.0
+    delvtaclw_pmoshs45b_sphv_10hv = 0.0
+    npo_pmoshs45b_sphv_10hv   = 9e+25
+    npl_pmoshs45b_sphv_10hv   = 0.0
+    cto_pmoshs45b_sphv_10hv   = 0.02
+    ctl_pmoshs45b_sphv_10hv   = 0.0
+    ctlexp_pmoshs45b_sphv_10hv = 0.4772
+    ctw_pmoshs45b_sphv_10hv   = 0.0
+    ctlw_pmoshs45b_sphv_10hv  = 0.0
+    toxovo_pmoshs45b_sphv_10hv = 1.3e-08
+    toxovdo_pmoshs45b_sphv_10hv = 1.3e-08
+    lov_pmoshs45b_sphv_10hv   = 6.5e-08
+    dlovd_pmoshs45b_sphv_10hv = -2e-07
+    novo_pmoshs45b_sphv_10hv  = 5e+25
+    novdo_pmoshs45b_sphv_10hv = 5e+21
+    cfl_pmoshs45b_sphv_10hv   = 0.0
+    cflexp_pmoshs45b_sphv_10hv = 0.839
+    cfw_pmoshs45b_sphv_10hv   = 0.0
+    cfbo_pmoshs45b_sphv_10hv  = 2.22e-15
+    uo_pmoshs45b_sphv_10hv    = 0.0292633817061
+    fbet1_pmoshs45b_sphv_10hv = 0.0
+    fbet1w_pmoshs45b_sphv_10hv = 0.0
+    lp1_pmoshs45b_sphv_10hv   = 1e-08
+    lp1w_pmoshs45b_sphv_10hv  = 0.0
+    fbet2_pmoshs45b_sphv_10hv = 0.0
+    lp2_pmoshs45b_sphv_10hv   = 1e-08
+    betw1_pmoshs45b_sphv_10hv = 0.0
+    betw2_pmoshs45b_sphv_10hv = 0.0
+    wbet_pmoshs45b_sphv_10hv  = 0.0
+    stbeto_pmoshs45b_sphv_10hv = 1.55
+    stbetl_pmoshs45b_sphv_10hv = 0.0
+    stbetw_pmoshs45b_sphv_10hv = -0.09
+    stbetlw_pmoshs45b_sphv_10hv = 0.0
+    mueo_pmoshs45b_sphv_10hv  = 5.8
+    muew_pmoshs45b_sphv_10hv  = -0.05
+    stmueo_pmoshs45b_sphv_10hv = 0.8
+    themuo_pmoshs45b_sphv_10hv = 0.82
+    stthemuo_pmoshs45b_sphv_10hv = 0.25
+    cso_pmoshs45b_sphv_10hv   = 0.0
+    csl_pmoshs45b_sphv_10hv   = 0.0
+    cslexp_pmoshs45b_sphv_10hv = 0.0
+    csw_pmoshs45b_sphv_10hv   = 0.0
+    cslw_pmoshs45b_sphv_10hv  = 0.0
+    stcso_pmoshs45b_sphv_10hv = 0.0
+    xcoro_pmoshs45b_sphv_10hv = 0.01
+    xcorl_pmoshs45b_sphv_10hv = 0.0
+    xcorw_pmoshs45b_sphv_10hv = 0.0
+    xcorlw_pmoshs45b_sphv_10hv = 0.0
+    stxcoro_pmoshs45b_sphv_10hv = 1.4
+    fetao_pmoshs45b_sphv_10hv = 1.0
+    rsw1_pmoshs45b_sphv_10hv  = 0.0
+    rsw2_pmoshs45b_sphv_10hv  = 0.0
+    strso_pmoshs45b_sphv_10hv = 0.0
+    rsbo_pmoshs45b_sphv_10hv  = 0.0
+    rsgo_pmoshs45b_sphv_10hv  = 0.0
+    thesato_pmoshs45b_sphv_10hv = 1e-09
+    thesatl_pmoshs45b_sphv_10hv = 0.23
+    thesatlexp_pmoshs45b_sphv_10hv = 2.0
+    thesatw_pmoshs45b_sphv_10hv = 0.0
+    thesatlw_pmoshs45b_sphv_10hv = 0.18
+    stthesato_pmoshs45b_sphv_10hv = 0.5
+    stthesatl_pmoshs45b_sphv_10hv = 1.0
+    stthesatw_pmoshs45b_sphv_10hv = 1.5
+    stthesatlw_pmoshs45b_sphv_10hv = 0.0
+    thesatbo_pmoshs45b_sphv_10hv = 0.3
+    thesatgo_pmoshs45b_sphv_10hv = 1.7
+    thesatgl_pmoshs45b_sphv_10hv = 0.0
+    thesatgw_pmoshs45b_sphv_10hv = 0.0
+    axo_pmoshs45b_sphv_10hv   = 10.0
+    axl_pmoshs45b_sphv_10hv   = 2.0
+    alpl_pmoshs45b_sphv_10hv  = 0.0
+    alplexp_pmoshs45b_sphv_10hv = 1.0
+    alpw_pmoshs45b_sphv_10hv  = 0.0
+    alp1l1_pmoshs45b_sphv_10hv = 0.0
+    alp1lexp_pmoshs45b_sphv_10hv = 0.5
+    alp1l2_pmoshs45b_sphv_10hv = 0.0
+    alp1w_pmoshs45b_sphv_10hv = 0.0
+    alp2l1_pmoshs45b_sphv_10hv = 0.0
+    alp2lexp_pmoshs45b_sphv_10hv = 1.0
+    alp2l2_pmoshs45b_sphv_10hv = 0.0
+    alp2w_pmoshs45b_sphv_10hv = 0.0
+    vpo_pmoshs45b_sphv_10hv   = 10.0
+    a1o_pmoshs45b_sphv_10hv   = 0.00014
+    a1l_pmoshs45b_sphv_10hv   = 5e-06
+    a1w_pmoshs45b_sphv_10hv   = 0.0
+    a2o_pmoshs45b_sphv_10hv   = 70.0
+    sta2o_pmoshs45b_sphv_10hv = 0.8
+    a3o_pmoshs45b_sphv_10hv   = 1.4
+    a3l_pmoshs45b_sphv_10hv   = 0.0
+    a3w_pmoshs45b_sphv_10hv   = 0.0
+    a4o_pmoshs45b_sphv_10hv   = 0.0
+    a4l_pmoshs45b_sphv_10hv   = 0.0
+    a4w_pmoshs45b_sphv_10hv   = 0.0
+    gcoo_pmoshs45b_sphv_10hv  = 0.0
+    iginvlw_pmoshs45b_sphv_10hv = 0.0
+    igovw_pmoshs45b_sphv_10hv = 0.0
+    igovdw_pmoshs45b_sphv_10hv = 0.0
+    stigo_pmoshs45b_sphv_10hv = 2.0
+    gc2o_pmoshs45b_sphv_10hv  = 0.375
+    gc3o_pmoshs45b_sphv_10hv  = 0.063
+    chibo_pmoshs45b_sphv_10hv = 3.1
+    agidlw_pmoshs45b_sphv_10hv = 1e-08
+    agidldw_pmoshs45b_sphv_10hv = 0.0
+    bgidlo_pmoshs45b_sphv_10hv = 5.0
+    bgidldo_pmoshs45b_sphv_10hv = 10.0
+    stbgidlo_pmoshs45b_sphv_10hv = -0.0031
+    stbgidldo_pmoshs45b_sphv_10hv = 0.0
+    cgidlo_pmoshs45b_sphv_10hv = 0.0
+    cgidldo_pmoshs45b_sphv_10hv = 1.0
+    cgbovl_pmoshs45b_sphv_10hv = 0.0
+    cfrw_pmoshs45b_sphv_10hv  = 0.0
+    cfrdw_pmoshs45b_sphv_10hv = 0.0
+    fnto_pmoshs45b_sphv_10hv  = 1.0
+    nfalw_pmoshs45b_sphv_10hv = 2e+23
+    nfblw_pmoshs45b_sphv_10hv = 1500000000.0
+    nfclw_pmoshs45b_sphv_10hv = 6.6e-08
+    efo_pmoshs45b_sphv_10hv   = 1.0
+    lintnoi_pmoshs45b_sphv_10hv = 0.0
+    alpnoi_pmoshs45b_sphv_10hv = 2.0
+    kvthoweo_pmoshs45b_sphv_10hv = 0.0
+    kvthowel_pmoshs45b_sphv_10hv = 0.0
+    kvthowew_pmoshs45b_sphv_10hv = 0.0
+    kvthowelw_pmoshs45b_sphv_10hv = 0.0
+    kuoweo_pmoshs45b_sphv_10hv = 0.0
+    kuowel_pmoshs45b_sphv_10hv = 0.0
+    kuowew_pmoshs45b_sphv_10hv = 0.0
+    kuowelw_pmoshs45b_sphv_10hv = 0.0
+    rgo_pmoshs45b_sphv_10hv   = 0.0
+    rsh_pmoshs45b_sphv_10hv   = 0.0
+    rbulko_pmoshs45b_sphv_10hv = 0.0
+    rwello_pmoshs45b_sphv_10hv = 0.0
+    rjunso_pmoshs45b_sphv_10hv = 1800.0
+    rjundo_pmoshs45b_sphv_10hv = 3500.0
+    rint_pmoshs45b_sphv_10hv  = 0.0
+    rvpoly_pmoshs45b_sphv_10hv = 0.0
+    rshg_pmoshs45b_sphv_10hv  = 0.0
+    dlsil_pmoshs45b_sphv_10hv = 0.0
+    saref_pmoshs45b_sphv_10hv = 1e-06
+    sbref_pmoshs45b_sphv_10hv = 1e-06
+    wlod_pmoshs45b_sphv_10hv  = 0.0
+    kuo_pmoshs45b_sphv_10hv   = 0.0
+    kvsat_pmoshs45b_sphv_10hv = 0.0
+    tkuo_pmoshs45b_sphv_10hv  = 0.0
+    lkuo_pmoshs45b_sphv_10hv  = 0.0
+    wkuo_pmoshs45b_sphv_10hv  = 0.0
+    pkuo_pmoshs45b_sphv_10hv  = 0.0
+    llodkuo_pmoshs45b_sphv_10hv = 0.0
+    wlodkuo_pmoshs45b_sphv_10hv = 0.0
+    kvtho_pmoshs45b_sphv_10hv = 0.0
+    lkvtho_pmoshs45b_sphv_10hv = 0.0
+    wkvtho_pmoshs45b_sphv_10hv = 0.0
+    pkvtho_pmoshs45b_sphv_10hv = 0.0
+    llodvth_pmoshs45b_sphv_10hv = 0.0
+    wlodvth_pmoshs45b_sphv_10hv = 0.0
+    stetao_pmoshs45b_sphv_10hv = 0.0
+    lodetao_pmoshs45b_sphv_10hv = 1.0
+    scref_pmoshs45b_sphv_10hv = 1e-05
+    web_pmoshs45b_sphv_10hv   = 0.0
+    wec_pmoshs45b_sphv_10hv   = 0.0
+    adr1o_pmoshs45b_sphv_10hv = 0.0003
+    adr1l_pmoshs45b_sphv_10hv = 0.0
+    adr1w_pmoshs45b_sphv_10hv = 0.0
+    adr2o_pmoshs45b_sphv_10hv = 101.0
+    stadr2o_pmoshs45b_sphv_10hv = 0.5
+    adr3o_pmoshs45b_sphv_10hv = 0.0
+    adr3l_pmoshs45b_sphv_10hv = 0.0
+    adr3w_pmoshs45b_sphv_10hv = 0.0
+    adr4o_pmoshs45b_sphv_10hv = 0.0
+    adr4l_pmoshs45b_sphv_10hv = 0.0
+    adr4w_pmoshs45b_sphv_10hv = 0.0
+    adr5o_pmoshs45b_sphv_10hv = 0.0
+    adr5l_pmoshs45b_sphv_10hv = 0.0
+    adr5w_pmoshs45b_sphv_10hv = 0.0
+    bidr1o_pmoshs45b_sphv_10hv = 0.0
+    bidr1l_pmoshs45b_sphv_10hv = 0.0
+    bidr1w_pmoshs45b_sphv_10hv = 0.0
+    bidr2o_pmoshs45b_sphv_10hv = 0.0
+    bidr2w_pmoshs45b_sphv_10hv = 0.0
+    rtho_pmoshs45b_sphv_10hv  = 650.0
+    rthl_pmoshs45b_sphv_10hv  = 0.0
+    rthw_pmoshs45b_sphv_10hv  = 0.0
+    rthlw_pmoshs45b_sphv_10hv = 0.0
+    strtho_pmoshs45b_sphv_10hv = 0.0
+    strthao_pmoshs45b_sphv_10hv = 0.0
+    ctho_pmoshs45b_sphv_10hv  = 0.0
+    cthl_pmoshs45b_sphv_10hv  = 0.0
+    cthw_pmoshs45b_sphv_10hv  = 0.0
+    cthlw_pmoshs45b_sphv_10hv = 0.0
+    rshldd_pmoshs45b_sphv_10hv = 24800.0
+    xw_pmoshs45b_sphv_10hv    = 1.6e-07
+    nwxw_pmoshs45b_sphv_10hv  = 0.0
+    xl_pmoshs45b_sphv_10hv    = 0.0
+    xlw_pmoshs45b_sphv_10hv   = 0.0
+    dxlsat_pmoshs45b_sphv_10hv = 0.0
+    nst_pmoshs45b_sphv_10hv   = 1.0
+    ats_pmoshs45b_sphv_10hv   = 0.0
+    dfinf_pmoshs45b_sphv_10hv = 0.07
+    dfw_pmoshs45b_sphv_10hv   = 9e-08
+    dfl_pmoshs45b_sphv_10hv   = 0.0
+    dflw_pmoshs45b_sphv_10hv  = 0.0
+    dp_pmoshs45b_sphv_10hv    = 2.0
+    ecrit_pmoshs45b_sphv_10hv = 7500000.0
+    ecorn_pmoshs45b_sphv_10hv = 50000.0
+    xvsat_pmoshs45b_sphv_10hv = 0.5
+    du_pmoshs45b_sphv_10hv    = 0.02
+    tc1_pmoshs45b_sphv_10hv   = 0.0052
+    tc2_pmoshs45b_sphv_10hv   = 6e-06
+    tc1l_pmoshs45b_sphv_10hv  = 0.0
+    tc2l_pmoshs45b_sphv_10hv  = 0.0
+    tc1w_pmoshs45b_sphv_10hv  = -7e-10
+    tc2w_pmoshs45b_sphv_10hv  = 0.0
+    theacc_pmoshs45b_sphv_10hv = 0.0
+    theacc2_pmoshs45b_sphv_10hv = 0.039
+    aacc_pmoshs45b_sphv_10hv  = 36.0
+    rva_pmoshs45b_sphv_10hv   = 10000.0
+    dta_pmoshs45b_sphv_10hv   = 0.0
+    trj_pmoshs45b_sphv_10hv   = 27.0
+    cjarea_pmoshs45b_sphv_10hv = 0.00168
+    cjlsti_pmoshs45b_sphv_10hv = 0.0
+    cjlgat_pmoshs45b_sphv_10hv = 5.375e-10
+    vbiarea_pmoshs45b_sphv_10hv = 0.7
+    vbisti_pmoshs45b_sphv_10hv = 0.75
+    vbigat_pmoshs45b_sphv_10hv = 0.75
+    parea_pmoshs45b_sphv_10hv = 0.29
+    psti_pmoshs45b_sphv_10hv  = 0.3
+    pgat_pmoshs45b_sphv_10hv  = 0.3
+    is1area_pmoshs45b_sphv_10hv = 3.8079e-07
+    ttarea_pmoshs45b_sphv_10hv = 3e-09
+    is2area_pmoshs45b_sphv_10hv = 7.2e-05
+    irarea_pmoshs45b_sphv_10hv = 0.0328
+    stis1area_pmoshs45b_sphv_10hv = 5.0
+    stis2area_pmoshs45b_sphv_10hv = 3.0
+    stirarea_pmoshs45b_sphv_10hv = 19000.0
+    n1area_pmoshs45b_sphv_10hv = 1.0
+    n2area_pmoshs45b_sphv_10hv = 1.6
+    nrarea_pmoshs45b_sphv_10hv = 1000.0
+    is1lsti_pmoshs45b_sphv_10hv = 1e-16
+    ttlsti_pmoshs45b_sphv_10hv = 3e-09
+    is2lsti_pmoshs45b_sphv_10hv = 1e-13
+    irlsti_pmoshs45b_sphv_10hv = 1e-15
+    stis1sti_pmoshs45b_sphv_10hv = 3.0
+    stis2sti_pmoshs45b_sphv_10hv = 3.0
+    stirsti_pmoshs45b_sphv_10hv = 3.0
+    n1sti_pmoshs45b_sphv_10hv = 1.02
+    n2sti_pmoshs45b_sphv_10hv = 2.0
+    nrsti_pmoshs45b_sphv_10hv = 20.0
+    is1lgat_pmoshs45b_sphv_10hv = 5e-14
+    ttlgat_pmoshs45b_sphv_10hv = 3e-09
+    is2lgat_pmoshs45b_sphv_10hv = 1e-10
+    irlgat_pmoshs45b_sphv_10hv = 1.5e-12
+    stis1gat_pmoshs45b_sphv_10hv = 3.0
+    stis2gat_pmoshs45b_sphv_10hv = 3.0
+    stirgat_pmoshs45b_sphv_10hv = 3.0
+    n1gat_pmoshs45b_sphv_10hv = 1.02
+    n2gat_pmoshs45b_sphv_10hv = 2.0
+    nrgat_pmoshs45b_sphv_10hv = 20.0
+    cjaread_pmoshs45b_sphv_10hv = 0.000128
+    cjlstid_pmoshs45b_sphv_10hv = 1.9e-10
+    cjlgatd_pmoshs45b_sphv_10hv = 0.0
+    vbiaread_pmoshs45b_sphv_10hv = 0.5
+    vbistid_pmoshs45b_sphv_10hv = 0.5
+    vbigatd_pmoshs45b_sphv_10hv = 0.5
+    paread_pmoshs45b_sphv_10hv = 0.4
+    pstid_pmoshs45b_sphv_10hv = 0.38
+    pgatd_pmoshs45b_sphv_10hv = 0.38
+    is1aread_pmoshs45b_sphv_10hv = 2.505e-08
+    ttaread_pmoshs45b_sphv_10hv = 2.4e-08
+    is2aread_pmoshs45b_sphv_10hv = 5.39e-06
+    iraread_pmoshs45b_sphv_10hv = 0.0017
+    stis1aread_pmoshs45b_sphv_10hv = 5.5
+    stis2aread_pmoshs45b_sphv_10hv = 0.0
+    stiraread_pmoshs45b_sphv_10hv = 170000.0
+    n1aread_pmoshs45b_sphv_10hv = 1.0
+    n2aread_pmoshs45b_sphv_10hv = 1.4
+    nraread_pmoshs45b_sphv_10hv = 8000.0
+    is1lstid_pmoshs45b_sphv_10hv = 0
+    ttlstid_pmoshs45b_sphv_10hv = 2.4e-08
+    is2lstid_pmoshs45b_sphv_10hv = 0.0
+    irlstid_pmoshs45b_sphv_10hv = 1.5e-15
+    stis1stid_pmoshs45b_sphv_10hv = 2.0
+    stis2stid_pmoshs45b_sphv_10hv = 10.0
+    stirstid_pmoshs45b_sphv_10hv = 8.0
+    n1stid_pmoshs45b_sphv_10hv = 1.02
+    n2stid_pmoshs45b_sphv_10hv = 2.0
+    nrstid_pmoshs45b_sphv_10hv = 8000.0
+    is1lgatd_pmoshs45b_sphv_10hv = 0
+    ttlgatd_pmoshs45b_sphv_10hv = 2.4e-08
+    is2lgatd_pmoshs45b_sphv_10hv = 0.0
+    irlgatd_pmoshs45b_sphv_10hv = 1e-09
+    stis1gatd_pmoshs45b_sphv_10hv = 2.0
+    stis2gatd_pmoshs45b_sphv_10hv = 10.0
+    stirgatd_pmoshs45b_sphv_10hv = 8.0
+    n1gatd_pmoshs45b_sphv_10hv = 1.02
+    n2gatd_pmoshs45b_sphv_10hv = 2.0
+    nrgatd_pmoshs45b_sphv_10hv = 8000.0
+    cjaread2_pmoshs45b_sphv_10hv = 1e-12
+    cjlstid2_pmoshs45b_sphv_10hv = 1e-18
+    vbiaread2_pmoshs45b_sphv_10hv = 0.5
+    vbistid2_pmoshs45b_sphv_10hv = 0.5
+    paread2_pmoshs45b_sphv_10hv = 0.38
+    pstid2_pmoshs45b_sphv_10hv = 0.38
+    is1aread2_pmoshs45b_sphv_10hv = 0
+    ttaread2_pmoshs45b_sphv_10hv = 2.4e-08
+    is2aread2_pmoshs45b_sphv_10hv = 0.0
+    iraread2_pmoshs45b_sphv_10hv = 0.0004
+    stis1aread2_pmoshs45b_sphv_10hv = 25
+    stis2aread2_pmoshs45b_sphv_10hv = 15
+    stiraread2_pmoshs45b_sphv_10hv = 8.0
+    n1aread2_pmoshs45b_sphv_10hv = 1.02
+    n2aread2_pmoshs45b_sphv_10hv = 2.0
+    nraread2_pmoshs45b_sphv_10hv = 8000.0
+    is1lstid2_pmoshs45b_sphv_10hv = 0
+    ttlstid2_pmoshs45b_sphv_10hv = 2.4e-08
+    is2lstid2_pmoshs45b_sphv_10hv = 0.0
+    irlstid2_pmoshs45b_sphv_10hv = 1.5e-15
+    stis1stid2_pmoshs45b_sphv_10hv = 2.0
+    stis2stid2_pmoshs45b_sphv_10hv = 10.0
+    stirstid2_pmoshs45b_sphv_10hv = 8.0
+    n1stid2_pmoshs45b_sphv_10hv = 1.02
+    n2stid2_pmoshs45b_sphv_10hv = 2.0
+    nrstid2_pmoshs45b_sphv_10hv = 8000.0
+    eais1area_pmoshs45b_sphv_10hv = 1.12
+    eais2area_pmoshs45b_sphv_10hv = 1.12
+    eairarea_pmoshs45b_sphv_10hv = 1.12
+    eais1sti_pmoshs45b_sphv_10hv = 1.12
+    eais2sti_pmoshs45b_sphv_10hv = 1.12
+    eairsti_pmoshs45b_sphv_10hv = 1.12
+    eais1gat_pmoshs45b_sphv_10hv = 1.12
+    eais2gat_pmoshs45b_sphv_10hv = 1.12
+    eairgat_pmoshs45b_sphv_10hv = 1.12
+    eais1aread_pmoshs45b_sphv_10hv = 1.12
+    eais2aread_pmoshs45b_sphv_10hv = 1.12
+    eairaread_pmoshs45b_sphv_10hv = 1.12
+    eais1stid_pmoshs45b_sphv_10hv = 1.12
+    eais2stid_pmoshs45b_sphv_10hv = 1.12
+    eairstid_pmoshs45b_sphv_10hv = 1.12
+    eais1gatd_pmoshs45b_sphv_10hv = 1.12
+    eais2gatd_pmoshs45b_sphv_10hv = 1.12
+    eairgatd_pmoshs45b_sphv_10hv = 1.12
+    eais1aread2_pmoshs45b_sphv_10hv = 1.12
+    eais2aread2_pmoshs45b_sphv_10hv = 1.12
+    eairaread2_pmoshs45b_sphv_10hv = 1.12
+    eais1stid2_pmoshs45b_sphv_10hv = 1.12
+    eais2stid2_pmoshs45b_sphv_10hv = 1.12
+    eairstid2_pmoshs45b_sphv_10hv = 1.12
+    vdscale_pmoshs45b_sphv_10hv = 1.01059542407
+    vdscalel_pmoshs45b_sphv_10hv = 0.129099503867
+    vdscalew_pmoshs45b_sphv_10hv = 0.0353995719021
+    vdscalelw_pmoshs45b_sphv_10hv = 0.0900805649322
+    vdscaleb_pmoshs45b_sphv_10hv = 0.0
+    vdscalebl_pmoshs45b_sphv_10hv = 0.07
+    mumb_pmoshs45b_sphv_10hv  = 0.0
+    mumbexp_pmoshs45b_sphv_10hv = 0.0
+    mumbvclmp_pmoshs45b_sphv_10hv = 0.0
+    stvdscale_pmoshs45b_sphv_10hv = 0.0
+    ctgo_pmoshs45b_sphv_10hv  = 0.0
+    ctbo_pmoshs45b_sphv_10hv  = 0.0
+    stcto_pmoshs45b_sphv_10hv = 0.0
+    ikfarea_pmoshs45b_sphv_10hv = 0.0
+    stikfarea_pmoshs45b_sphv_10hv = 0.0
+    ikfaread_pmoshs45b_sphv_10hv = 0.0
+    dwikfaread_pmoshs45b_sphv_10hv = 0.0
+    stikfaread_pmoshs45b_sphv_10hv = 0.0
+    nom_delr_tox_nmos10_sphv_10hv = 1.0
+    nom_delr_uch_nmos10_sphv_10hv = 1.0
+    nom_dela_vfb_nmos10_sphv_10hv = 0.0
+    nom_dela_vtl_nmos10_sphv_10hv = 0.0
+    nom_dela_vtw_nmos10_sphv_10hv = 0.0
+    nom_delr_thesatl_nmos10_sphv_10hv = 1.0
+    nom_delr_thesatlw_nmos10_sphv_10hv = 1.0
+    nom_dela_vdscale_nmos10_sphv_10hv = 0.0
+    nom_dela_lvaro_nmos10_sphv_10hv = 0.0
+    sig_delr_tox_nmos10_sphv_10hv = 0.012
+    sig_delr_uch_nmos10_sphv_10hv = 0.028
+    sig_dela_vfb_nmos10_sphv_10hv = 0.0418
+    sig_dela_vtl_nmos10_sphv_10hv = 0.02259
+    sig_dela_vtw_nmos10_sphv_10hv = 0.00525
+    sig_delr_thesatl_nmos10_sphv_10hv = 0.038
+    sig_delr_thesatlw_nmos10_sphv_10hv = 0.00202
+    sig_dela_vdscale_nmos10_sphv_10hv = 0.038
+    sig_dela_lvaro_nmos10_sphv_10hv = 6.6e-08
+    nom_delr_cj_nmos10_sphv_10hv = 1.0
+    nom_delr_is_nmos10_sphv_10hv = 1.0
+    nom_delr_is2_nmos10_sphv_10hv = 1.0
+    nom_delr_ir_nmos10_sphv_10hv = 1.0
+    sig_delr_cj_nmos10_sphv_10hv = 0.0333
+    sig_delr_is_nmos10_sphv_10hv = 0.055
+    sig_delr_is2_nmos10_sphv_10hv = 0.768
+    sig_delr_ir_nmos10_sphv_10hv = 0.768
+    fac_rth_ng_nmos10_sphv_10hv = 0.67
+    vfbo_ng_nmos10_sphv_10hv  = 0.01
+    uo_ng_nmos10_sphv_10hv    = 0.075
+    thesatl_ng_nmos10_sphv_10hv = 0.17
+    rshldd_ng_nmos10_sphv_10hv = -0.03
+    fac_rth_nmos10_sphv_10hv  = 0.5
+    xvsat_nmos10_sphv_10hv    = 0.0
+    dwrjundo_nmos10_sphv_10hv = 2.0
+    dwrjunso_nmos10_sphv_10hv = 1.5
+    qmc_nmos10_sphv_10hv      = 0.0
+    lvaro_nmos10_sphv_10hv    = 1.8e-07
+    lvarl_nmos10_sphv_10hv    = 0.0
+    lvarw_nmos10_sphv_10hv    = 0.0
+    lap_nmos10_sphv_10hv      = 0.0
+    wvaro_nmos10_sphv_10hv    = -1.65e-07
+    wvarl_nmos10_sphv_10hv    = 0.0
+    wvarw_nmos10_sphv_10hv    = 0.0
+    wot_nmos10_sphv_10hv      = 0.0
+    dlq_nmos10_sphv_10hv      = -1.13e-07
+    dwq_nmos10_sphv_10hv      = 2.24e-07
+    vfbo_nmos10_sphv_10hv     = -1.024
+    vfbl_nmos10_sphv_10hv     = -0.0217
+    vfbw_nmos10_sphv_10hv     = -0.018
+    vfblw_nmos10_sphv_10hv    = -0.0072
+    stvfbo_nmos10_sphv_10hv   = 0.0008808
+    stvfbl_nmos10_sphv_10hv   = -0.1
+    stvfbw_nmos10_sphv_10hv   = 0.0
+    stvfblw_nmos10_sphv_10hv  = 0.0
+    toxo_nmos10_sphv_10hv     = 1.345e-08
+    epsroxo_nmos10_sphv_10hv  = 3.9
+    nsubo_nmos10_sphv_10hv    = 1e+23
+    nsubw_nmos10_sphv_10hv    = -0.03
+    wseg_nmos10_sphv_10hv     = 1e-07
+    npck_nmos10_sphv_10hv     = 3e+22
+    npckw_nmos10_sphv_10hv    = -0.1
+    wsegp_nmos10_sphv_10hv    = 1e-07
+    lpck_nmos10_sphv_10hv     = 1e-07
+    lpckw_nmos10_sphv_10hv    = 0.0
+    fol1_nmos10_sphv_10hv     = 0.05
+    fol2_nmos10_sphv_10hv     = 0.0
+    facneffaco_nmos10_sphv_10hv = 1.0
+    facneffacl_nmos10_sphv_10hv = 0.0
+    facneffacw_nmos10_sphv_10hv = 0.0
+    facneffaclw_nmos10_sphv_10hv = 0.0
+    gfacnudo_nmos10_sphv_10hv = 1.0
+    gfacnudl_nmos10_sphv_10hv = 0.0
+    gfacnudlexp_nmos10_sphv_10hv = 1.0
+    gfacnudw_nmos10_sphv_10hv = 0.0
+    gfacnudlw_nmos10_sphv_10hv = 0.0
+    vsbnudo_nmos10_sphv_10hv  = 2.75
+    dvsbnudo_nmos10_sphv_10hv = 1.0
+    vnsubo_nmos10_sphv_10hv   = 0.0
+    nslpo_nmos10_sphv_10hv    = 0.05
+    dnsubo_nmos10_sphv_10hv   = 0.036
+    dphibo_nmos10_sphv_10hv   = 0.03
+    dphibl_nmos10_sphv_10hv   = 0.08
+    dphiblexp_nmos10_sphv_10hv = 0.5
+    dphibw_nmos10_sphv_10hv   = 0.016
+    dphiblw_nmos10_sphv_10hv  = -0.15
+    delvtaco_nmos10_sphv_10hv = -0.025
+    delvtacl_nmos10_sphv_10hv = 0.0
+    delvtaclexp_nmos10_sphv_10hv = 1.0
+    delvtacw_nmos10_sphv_10hv = 0.0
+    delvtaclw_nmos10_sphv_10hv = 0.0
+    npo_nmos10_sphv_10hv      = 1.648e+26
+    npl_nmos10_sphv_10hv      = -0.5
+    cto_nmos10_sphv_10hv      = 0.1
+    ctl_nmos10_sphv_10hv      = 0.0
+    ctlexp_nmos10_sphv_10hv   = 0.5
+    ctw_nmos10_sphv_10hv      = 0.21
+    ctlw_nmos10_sphv_10hv     = -0.01
+    toxovo_nmos10_sphv_10hv   = 1.345e-08
+    toxovdo_nmos10_sphv_10hv  = 1.345e-08
+    lov_nmos10_sphv_10hv      = 5.16e-08
+    dlovd_nmos10_sphv_10hv    = -1.439e-07
+    novo_nmos10_sphv_10hv     = 4.95e+23
+    novw_nmos10_sphv_10hv     = -0.02661
+    novdo_nmos10_sphv_10hv    = 5.42e+22
+    novdw_nmos10_sphv_10hv    = 0.0
+    cfl_nmos10_sphv_10hv      = 5e-05
+    cflexp_nmos10_sphv_10hv   = 2.0
+    cfw_nmos10_sphv_10hv      = 0.0
+    cfbo_nmos10_sphv_10hv     = 0.0
+    vdscale_nmos10_sphv_10hv  = 1.01
+    uo_nmos10_sphv_10hv       = 0.0565
+    fbet1_nmos10_sphv_10hv    = -0.57
+    fbet1w_nmos10_sphv_10hv   = 0.5
+    lp1_nmos10_sphv_10hv      = 1e-07
+    lp1w_nmos10_sphv_10hv     = 0.0
+    fbet2_nmos10_sphv_10hv    = 0.0
+    lp2_nmos10_sphv_10hv      = 0.0
+    betw1_nmos10_sphv_10hv    = 0.18
+    betw2_nmos10_sphv_10hv    = -0.075
+    wbet_nmos10_sphv_10hv     = 1e-07
+    stbeto_nmos10_sphv_10hv   = 1.3
+    stbetl_nmos10_sphv_10hv   = 0.0
+    stbetw_nmos10_sphv_10hv   = -0.0758
+    stbetlw_nmos10_sphv_10hv  = 0.06
+    mueo_nmos10_sphv_10hv     = 0.98
+    muew_nmos10_sphv_10hv     = -0.026
+    stmueo_nmos10_sphv_10hv   = 0.0
+    themuo_nmos10_sphv_10hv   = 2.0
+    stthemuo_nmos10_sphv_10hv = 1.5
+    cso_nmos10_sphv_10hv      = 0.0
+    csl_nmos10_sphv_10hv      = 0.0
+    cslexp_nmos10_sphv_10hv   = 1.0
+    csw_nmos10_sphv_10hv      = 0.0
+    cslw_nmos10_sphv_10hv     = 0.0
+    stcso_nmos10_sphv_10hv    = 0.0
+    xcoro_nmos10_sphv_10hv    = 0.045
+    xcorl_nmos10_sphv_10hv    = 0.4
+    xcorw_nmos10_sphv_10hv    = -0.2
+    xcorlw_nmos10_sphv_10hv   = 0.0
+    stxcoro_nmos10_sphv_10hv  = 1.4
+    fetao_nmos10_sphv_10hv    = 1.0
+    rsw1_nmos10_sphv_10hv     = 0.0
+    rsw2_nmos10_sphv_10hv     = 0.0
+    strso_nmos10_sphv_10hv    = 0.0
+    rsbo_nmos10_sphv_10hv     = 0.0
+    rsgo_nmos10_sphv_10hv     = 0.0
+    thesato_nmos10_sphv_10hv  = 0.086
+    thesatl_nmos10_sphv_10hv  = 0.63
+    thesatlexp_nmos10_sphv_10hv = 0.7
+    thesatw_nmos10_sphv_10hv  = -0.17
+    thesatlw_nmos10_sphv_10hv = -0.0155
+    stthesato_nmos10_sphv_10hv = 1.0
+    stthesatl_nmos10_sphv_10hv = 0.03
+    stthesatw_nmos10_sphv_10hv = 0.0
+    stthesatlw_nmos10_sphv_10hv = 0.16
+    thesatbo_nmos10_sphv_10hv = 0.0
+    thesatgo_nmos10_sphv_10hv = -0.063
+    thesatgl_nmos10_sphv_10hv = 0.134
+    thesatgw_nmos10_sphv_10hv = 0.007
+    axo_nmos10_sphv_10hv      = 16.0
+    axl_nmos10_sphv_10hv      = 3.5
+    alpl_nmos10_sphv_10hv     = 5.2e-05
+    alplexp_nmos10_sphv_10hv  = 1.0
+    alpw_nmos10_sphv_10hv     = 0.0
+    alp1l1_nmos10_sphv_10hv   = 2.3e-05
+    alp1lexp_nmos10_sphv_10hv = 0.5
+    alp1l2_nmos10_sphv_10hv   = -0.0054
+    alp1w_nmos10_sphv_10hv    = 0.0
+    alp2l1_nmos10_sphv_10hv   = 0.002
+    alp2lexp_nmos10_sphv_10hv = 0.5
+    alp2l2_nmos10_sphv_10hv   = -0.003
+    alp2w_nmos10_sphv_10hv    = 0.0
+    vpo_nmos10_sphv_10hv      = 0.05
+    a1o_nmos10_sphv_10hv      = 0.1
+    a1l_nmos10_sphv_10hv      = -0.24
+    a1w_nmos10_sphv_10hv      = -0.45
+    a2o_nmos10_sphv_10hv      = 41.0
+    sta2o_nmos10_sphv_10hv    = 0.3
+    a3o_nmos10_sphv_10hv      = 1.5
+    a3l_nmos10_sphv_10hv      = -0.15
+    a3w_nmos10_sphv_10hv      = 0.017
+    a4o_nmos10_sphv_10hv      = 0.0
+    a4l_nmos10_sphv_10hv      = 0.0
+    a4w_nmos10_sphv_10hv      = 0.0
+    gcoo_nmos10_sphv_10hv     = 0.0
+    iginvlw_nmos10_sphv_10hv  = 0.0
+    igovw_nmos10_sphv_10hv    = 0.0
+    igovdw_nmos10_sphv_10hv   = 0.0
+    stigo_nmos10_sphv_10hv    = 2.0
+    gc2o_nmos10_sphv_10hv     = 0.375
+    gc3o_nmos10_sphv_10hv     = 0.063
+    chibo_nmos10_sphv_10hv    = 3.1
+    agidlw_nmos10_sphv_10hv   = 9.5e-05
+    agidldw_nmos10_sphv_10hv  = 0.0
+    bgidlo_nmos10_sphv_10hv   = 8.0
+    bgidldo_nmos10_sphv_10hv  = 10.0
+    stbgidlo_nmos10_sphv_10hv = -0.0005
+    stbgidldo_nmos10_sphv_10hv = 0.0
+    cgidlo_nmos10_sphv_10hv   = 0.0
+    cgidldo_nmos10_sphv_10hv  = 0.0
+    cgbovlo_nmos10_sphv_10hv  = 2.5e-16
+    cgbovll_nmos10_sphv_10hv  = 1.5
+    cfrwo_nmos10_sphv_10hv    = 1.94e-16
+    cfrww_nmos10_sphv_10hv    = 1.05
+    cfrdwo_nmos10_sphv_10hv   = 3.324e-17
+    cfrdww_nmos10_sphv_10hv   = 4.0
+    fnto_nmos10_sphv_10hv     = 1.0
+    nfalw_nmos10_sphv_10hv    = 3e+25
+    nfblw_nmos10_sphv_10hv    = 100000000.0
+    nfclw_nmos10_sphv_10hv    = 2e-08
+    efo_nmos10_sphv_10hv      = 1.0
+    lintnoi_nmos10_sphv_10hv  = 0.0
+    alpnoi_nmos10_sphv_10hv   = 2.0
+    kvthoweo_nmos10_sphv_10hv = 0.0
+    kvthowel_nmos10_sphv_10hv = 0.0
+    kvthowew_nmos10_sphv_10hv = 0.0
+    kvthowelw_nmos10_sphv_10hv = 0.0
+    kuoweo_nmos10_sphv_10hv   = 0.0
+    kuowel_nmos10_sphv_10hv   = 0.0
+    kuowew_nmos10_sphv_10hv   = 0.0
+    kuowelw_nmos10_sphv_10hv  = 0.0
+    rgo_nmos10_sphv_10hv      = 0.0
+    rsh_nmos10_sphv_10hv      = 0.0
+    rbulko_nmos10_sphv_10hv   = 0.0
+    rwello_nmos10_sphv_10hv   = 0.0
+    rjunso_nmos10_sphv_10hv   = 200.0
+    rjundo_nmos10_sphv_10hv   = 1800.0
+    rint_nmos10_sphv_10hv     = 0.0
+    rvpoly_nmos10_sphv_10hv   = 0.0
+    rshg_nmos10_sphv_10hv     = 0.0
+    dlsil_nmos10_sphv_10hv    = 0.0
+    saref_nmos10_sphv_10hv    = 1e-06
+    sbref_nmos10_sphv_10hv    = 1e-06
+    wlod_nmos10_sphv_10hv     = 0.0
+    kuo_nmos10_sphv_10hv      = 0.0
+    kvsat_nmos10_sphv_10hv    = 0.0
+    tkuo_nmos10_sphv_10hv     = 0.0
+    lkuo_nmos10_sphv_10hv     = 0.0
+    wkuo_nmos10_sphv_10hv     = 0.0
+    pkuo_nmos10_sphv_10hv     = 0.0
+    llodkuo_nmos10_sphv_10hv  = 0.0
+    wlodkuo_nmos10_sphv_10hv  = 0.0
+    kvtho_nmos10_sphv_10hv    = 0.0
+    lkvtho_nmos10_sphv_10hv   = 0.0
+    wkvtho_nmos10_sphv_10hv   = 0.0
+    pkvtho_nmos10_sphv_10hv   = 0.0
+    llodvth_nmos10_sphv_10hv  = 0.0
+    wlodvth_nmos10_sphv_10hv  = 0.0
+    stetao_nmos10_sphv_10hv   = 0.0
+    lodetao_nmos10_sphv_10hv  = 1.0
+    scref_nmos10_sphv_10hv    = 1e-05
+    web_nmos10_sphv_10hv      = 0.0
+    wec_nmos10_sphv_10hv      = 0.0
+    adr1o_nmos10_sphv_10hv    = 15.0
+    adr1l_nmos10_sphv_10hv    = 0.0
+    adr1w_nmos10_sphv_10hv    = 40.0
+    adr2o_nmos10_sphv_10hv    = 70.0
+    stadr2o_nmos10_sphv_10hv  = 0.5
+    adr3o_nmos10_sphv_10hv    = 0.25
+    adr3l_nmos10_sphv_10hv    = 0.0
+    adr3w_nmos10_sphv_10hv    = 0.0
+    adr4o_nmos10_sphv_10hv    = 0.0
+    adr4l_nmos10_sphv_10hv    = 0.0
+    adr4w_nmos10_sphv_10hv    = 0.0
+    adr5o_nmos10_sphv_10hv    = 0.0
+    adr5l_nmos10_sphv_10hv    = 0.0
+    adr5w_nmos10_sphv_10hv    = 0.0
+    bidr1o_nmos10_sphv_10hv   = 0.0
+    bidr1l_nmos10_sphv_10hv   = 0.0
+    bidr1w_nmos10_sphv_10hv   = 0.0
+    bidr2o_nmos10_sphv_10hv   = 0.0
+    bidr2w_nmos10_sphv_10hv   = 0.0
+    rtho_nmos10_sphv_10hv     = 650.0
+    rthl_nmos10_sphv_10hv     = 0.0
+    rthw_nmos10_sphv_10hv     = 0.0
+    rthlw_nmos10_sphv_10hv    = 0.0
+    strtho_nmos10_sphv_10hv   = 0.5
+    ctho_nmos10_sphv_10hv     = 0.0
+    cthl_nmos10_sphv_10hv     = 0.0
+    cthw_nmos10_sphv_10hv     = 0.0
+    cthlw_nmos10_sphv_10hv    = 0.0
+    rshldd_nmos10_sphv_10hv   = 16050.0
+    xw_nmos10_sphv_10hv       = 1.3e-07
+    nwxw_nmos10_sphv_10hv     = 0.0
+    xl_nmos10_sphv_10hv       = 0.0
+    xlw_nmos10_sphv_10hv      = 0.0
+    dxlsat_nmos10_sphv_10hv   = 3e-07
+    nst_nmos10_sphv_10hv      = 1.0
+    ats_nmos10_sphv_10hv      = 0.0
+    dfinf_nmos10_sphv_10hv    = 0.06376
+    dfw_nmos10_sphv_10hv      = 0.0
+    dfl_nmos10_sphv_10hv      = 0.0
+    dflw_nmos10_sphv_10hv     = 0.0
+    dp_nmos10_sphv_10hv       = 2.0
+    ecrit_nmos10_sphv_10hv    = 6000000.0
+    ecorn_nmos10_sphv_10hv    = 100000.0
+    du_nmos10_sphv_10hv       = 0.25
+    tc1_nmos10_sphv_10hv      = 0.0038
+    tc2_nmos10_sphv_10hv      = 5.8e-06
+    tc1l_nmos10_sphv_10hv     = 0.0
+    tc2l_nmos10_sphv_10hv     = 0.0
+    tc1w_nmos10_sphv_10hv     = -1e-09
+    tc2w_nmos10_sphv_10hv     = 0.0
+    theacc_nmos10_sphv_10hv   = 0.0
+    theacc2_nmos10_sphv_10hv  = 0.2
+    aacc_nmos10_sphv_10hv     = 36.0
+    rva_nmos10_sphv_10hv      = 500.0
+    dta_nmos10_sphv_10hv      = 0.0
+    trj_nmos10_sphv_10hv      = 25.0
+    cjarea_nmos10_sphv_10hv   = 2.3e-08
+    cjlsti_nmos10_sphv_10hv   = 1.32e-10
+    cjlgat_nmos10_sphv_10hv   = 5.015e-10
+    vbiarea_nmos10_sphv_10hv  = 0.4
+    vbisti_nmos10_sphv_10hv   = 0.535
+    vbigat_nmos10_sphv_10hv   = 0.775
+    parea_nmos10_sphv_10hv    = 0.77
+    psti_nmos10_sphv_10hv     = 0.218
+    pgat_nmos10_sphv_10hv     = 0.333
+    is1area_nmos10_sphv_10hv  = 6e-08
+    ttarea_nmos10_sphv_10hv   = 0.0
+    is2area_nmos10_sphv_10hv  = 1e-06
+    irarea_nmos10_sphv_10hv   = 7.5e-06
+    stis1area_nmos10_sphv_10hv = 3.0
+    stis2area_nmos10_sphv_10hv = 3.0
+    stirarea_nmos10_sphv_10hv = 950.0
+    n1area_nmos10_sphv_10hv   = 1.0
+    n2area_nmos10_sphv_10hv   = 2.0
+    nrarea_nmos10_sphv_10hv   = 40.0
+    is1lsti_nmos10_sphv_10hv  = 1.2e-13
+    ttlsti_nmos10_sphv_10hv   = 7e-08
+    is2lsti_nmos10_sphv_10hv  = 3e-11
+    irlsti_nmos10_sphv_10hv   = 1.5e-11
+    stis1sti_nmos10_sphv_10hv = 3.0
+    stis2sti_nmos10_sphv_10hv = 3.0
+    stirsti_nmos10_sphv_10hv  = 950.0
+    n1sti_nmos10_sphv_10hv    = 1.0
+    n2sti_nmos10_sphv_10hv    = 2.0
+    nrsti_nmos10_sphv_10hv    = 40.0
+    is1lgat_nmos10_sphv_10hv  = 1.2e-13
+    ttlgat_nmos10_sphv_10hv   = 0.0
+    is2lgat_nmos10_sphv_10hv  = 3e-11
+    irlgat_nmos10_sphv_10hv   = 1.5e-11
+    stis1gat_nmos10_sphv_10hv = 3.0
+    stis2gat_nmos10_sphv_10hv = 3.0
+    stirgat_nmos10_sphv_10hv  = 950.0
+    n1gat_nmos10_sphv_10hv    = 1.0
+    n2gat_nmos10_sphv_10hv    = 2.0
+    nrgat_nmos10_sphv_10hv    = 40.0
+    cjaread_nmos10_sphv_10hv  = 0.000533
+    cjlstid_nmos10_sphv_10hv  = 2e-11
+    cjlgatd_nmos10_sphv_10hv  = 1.39e-10
+    vbiaread_nmos10_sphv_10hv = 0.63
+    vbistid_nmos10_sphv_10hv  = 0.818
+    vbigatd_nmos10_sphv_10hv  = 1.11
+    paread_nmos10_sphv_10hv   = 0.654
+    pstid_nmos10_sphv_10hv    = 0.9
+    pgatd_nmos10_sphv_10hv    = 0.39
+    is1aread_nmos10_sphv_10hv = 1e-07
+    ttaread_nmos10_sphv_10hv  = 8e-07
+    is2aread_nmos10_sphv_10hv = 1.4e-05
+    iraread_nmos10_sphv_10hv  = 2e-05
+    stis1aread_nmos10_sphv_10hv = 2.0
+    stis2aread_nmos10_sphv_10hv = 2.0
+    stiraread_nmos10_sphv_10hv = 11000.0
+    n1aread_nmos10_sphv_10hv  = 1.0
+    n2aread_nmos10_sphv_10hv  = 2.0
+    nraread_nmos10_sphv_10hv  = 500.0
+    is1lstid_nmos10_sphv_10hv = 0
+    ttlstid_nmos10_sphv_10hv  = 5e-08
+    is2lstid_nmos10_sphv_10hv = 0.0
+    irlstid_nmos10_sphv_10hv  = 5e-10
+    stis1stid_nmos10_sphv_10hv = 2.0
+    stis2stid_nmos10_sphv_10hv = 2.0
+    stirstid_nmos10_sphv_10hv = 11000.0
+    n1stid_nmos10_sphv_10hv   = 1.03
+    n2stid_nmos10_sphv_10hv   = 2.0
+    nrstid_nmos10_sphv_10hv   = 500.0
+    is1lgatd_nmos10_sphv_10hv = 0
+    ttlgatd_nmos10_sphv_10hv  = 0.0
+    is2lgatd_nmos10_sphv_10hv = 0.0
+    irlgatd_nmos10_sphv_10hv  = 1e-09
+    stis1gatd_nmos10_sphv_10hv = 2.0
+    stis2gatd_nmos10_sphv_10hv = 2.0
+    stirgatd_nmos10_sphv_10hv = 11000.0
+    n1gatd_nmos10_sphv_10hv   = 1.03
+    n2gatd_nmos10_sphv_10hv   = 2.0
+    nrgatd_nmos10_sphv_10hv   = 500.0
+    cjaread2_nmos10_sphv_10hv = 1e-12
+    cjlstid2_nmos10_sphv_10hv = 1e-18
+    vbiaread2_nmos10_sphv_10hv = 1.0
+    vbistid2_nmos10_sphv_10hv = 1.0
+    paread2_nmos10_sphv_10hv  = 0.55
+    pstid2_nmos10_sphv_10hv   = 0.48
+    is1aread2_nmos10_sphv_10hv = 0
+    ttaread2_nmos10_sphv_10hv = 0.0
+    is2aread2_nmos10_sphv_10hv = 0.0
+    iraread2_nmos10_sphv_10hv = 2e-05
+    stis1aread2_nmos10_sphv_10hv = 3.0
+    stis2aread2_nmos10_sphv_10hv = 3.0
+    stiraread2_nmos10_sphv_10hv = 11000.0
+    n1aread2_nmos10_sphv_10hv = 1.03
+    n2aread2_nmos10_sphv_10hv = 2.0
+    nraread2_nmos10_sphv_10hv = 500.0
+    is1lstid2_nmos10_sphv_10hv = 0
+    ttlstid2_nmos10_sphv_10hv = 0.0
+    is2lstid2_nmos10_sphv_10hv = 0.0
+    irlstid2_nmos10_sphv_10hv = 5e-10
+    stis1stid2_nmos10_sphv_10hv = 2.0
+    stis2stid2_nmos10_sphv_10hv = 2.0
+    stirstid2_nmos10_sphv_10hv = 11000.0
+    n1stid2_nmos10_sphv_10hv  = 1.03
+    n2stid2_nmos10_sphv_10hv  = 2.0
+    nrstid2_nmos10_sphv_10hv  = 500.0
+    eais1area_nmos10_sphv_10hv = 1.12
+    eais2area_nmos10_sphv_10hv = 1.12
+    eairarea_nmos10_sphv_10hv = 1.12
+    eais1sti_nmos10_sphv_10hv = 1.12
+    eais2sti_nmos10_sphv_10hv = 1.12
+    eairsti_nmos10_sphv_10hv  = 1.12
+    eais1gat_nmos10_sphv_10hv = 1.12
+    eais2gat_nmos10_sphv_10hv = 1.12
+    eairgat_nmos10_sphv_10hv  = 1.12
+    eais1aread_nmos10_sphv_10hv = 1.12
+    eais2aread_nmos10_sphv_10hv = 1.12
+    eairaread_nmos10_sphv_10hv = 1.12
+    eais1stid_nmos10_sphv_10hv = 1.12
+    eais2stid_nmos10_sphv_10hv = 1.12
+    eairstid_nmos10_sphv_10hv = 1.12
+    eais1gatd_nmos10_sphv_10hv = 1.12
+    eais2gatd_nmos10_sphv_10hv = 1.12
+    eairgatd_nmos10_sphv_10hv = 1.12
+    eais1aread2_nmos10_sphv_10hv = 1.12
+    eais2aread2_nmos10_sphv_10hv = 1.12
+    eairaread2_nmos10_sphv_10hv = 1.12
+    eais1stid2_nmos10_sphv_10hv = 1.12
+    eais2stid2_nmos10_sphv_10hv = 1.12
+    eairstid2_nmos10_sphv_10hv = 1.12
+    ikfarea_nmos10_sphv_10hv  = 8000000.0
+    stikfarea_nmos10_sphv_10hv = 0.0
+    ikfaread_nmos10_sphv_10hv = 6000000.0
+    dwikfaread_nmos10_sphv_10hv = 3.0
+    stikfaread_nmos10_sphv_10hv = 3.0
+    nom_delr_tox_pmos45b_sphv_10hv = 1.0
+    nom_delr_uch_pmos45b_sphv_10hv = 1.0
+    nom_delr_res_pmos45b_sphv_10hv = 1.0
+    nom_dela_vfb_pmos45b_sphv_10hv = 0.0
+    nom_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nom_dela_vtl_pmos45b_sphv_10hv = 0.0
+    nom_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nom_dela_dw_pmos45b_sphv_10hv = 0.0
+    nom_dela_dl_pmos45b_sphv_10hv = 0.0
+    nom_dela_dlw_pmos45b_sphv_10hv = 0.0
+    nom_delr_cjs_pmos45b_sphv_10hv = 1.0
+    nom_delr_cjd_pmos45b_sphv_10hv = 1.0
+    nom_delr_jsideal_pmos45b_sphv_10hv = 1.0
+    nom_delr_jdideal_pmos45b_sphv_10hv = 1.0
+    nom_delr_jsnonideal_pmos45b_sphv_10hv = 1.0
+    nom_delr_jdnonideal_pmos45b_sphv_10hv = 1.0
+    nom_delr_jsdideal_pmos45b_sphv_10hv = 1.0
+    sig_delr_tox_pmos45b_sphv_10hv = 0.012
+    sig_delr_uch_pmos45b_sphv_10hv = 0.01102
+    sig_delr_res_pmos45b_sphv_10hv = 0.02
+    sig_dela_vfb_pmos45b_sphv_10hv = 0.0187
+    sig_dela_vtw_pmos45b_sphv_10hv = 0.00063
+    sig_dela_vtl_pmos45b_sphv_10hv = 0.00593
+    sig_dela_vtm_pmos45b_sphv_10hv = 0.00622
+    sig_dela_dw_pmos45b_sphv_10hv = 0.0
+    sig_dela_dl_pmos45b_sphv_10hv = 0.0134
+    sig_dela_dlw_pmos45b_sphv_10hv = 0.0171
+    sig_delr_cjs_pmos45b_sphv_10hv = 0.033
+    sig_delr_cjd_pmos45b_sphv_10hv = 0.033
+    sig_delr_jsideal_pmos45b_sphv_10hv = 0.055
+    sig_delr_jdideal_pmos45b_sphv_10hv = 0.055
+    sig_delr_jsnonideal_pmos45b_sphv_10hv = 0.768
+    sig_delr_jdnonideal_pmos45b_sphv_10hv = 0.768
+    sig_delr_jsdideal_pmos45b_sphv_10hv = 0.055
+    fac_rth_pmos45b_sphv_10hv = 0.8
+    tc1_ecrit_pmos45b_sphv_10hv = 0.0
+    tc2_ecrit_pmos45b_sphv_10hv = 0.0
+    dwrjundo_pmos45b_sphv_10hv = 4.0
+    dwrjunso_pmos45b_sphv_10hv = 18.0
+    qmc_pmos45b_sphv_10hv     = 0.0
+    lvaro_pmos45b_sphv_10hv   = 3.19072185988e-08
+    lvarl_pmos45b_sphv_10hv   = 0.0
+    lvarw_pmos45b_sphv_10hv   = 6.0
+    lap_pmos45b_sphv_10hv     = 0.0
+    wvaro_pmos45b_sphv_10hv   = -2.21719734908e-07
+    wvarl_pmos45b_sphv_10hv   = 0.0
+    wvarw_pmos45b_sphv_10hv   = 0.0
+    wot_pmos45b_sphv_10hv     = 0.0
+    dlq_pmos45b_sphv_10hv     = 1.4e-07
+    dwq_pmos45b_sphv_10hv     = 0.0
+    vfbo_pmos45b_sphv_10hv    = -0.899989719846
+    vfbl_pmos45b_sphv_10hv    = -0.00688617490919
+    vfbw_pmos45b_sphv_10hv    = 0.00047737905195
+    vfblw_pmos45b_sphv_10hv   = 0.043919543021
+    stvfbo_pmos45b_sphv_10hv  = 0.0008808
+    stvfbl_pmos45b_sphv_10hv  = 0.0
+    stvfbw_pmos45b_sphv_10hv  = 5e-05
+    stvfblw_pmos45b_sphv_10hv = 0.0
+    toxo_pmos45b_sphv_10hv    = 1.3e-08
+    epsroxo_pmos45b_sphv_10hv = 3.9
+    nsubo_pmos45b_sphv_10hv   = 1.06e+23
+    nsubw_pmos45b_sphv_10hv   = 0.0
+    wseg_pmos45b_sphv_10hv    = 1e-09
+    npck_pmos45b_sphv_10hv    = 1e+23
+    npckw_pmos45b_sphv_10hv   = 0.0
+    wsegp_pmos45b_sphv_10hv   = 2.474e-06
+    lpck_pmos45b_sphv_10hv    = 0.0
+    lpckw_pmos45b_sphv_10hv   = 0.0
+    fol1_pmos45b_sphv_10hv    = 0.0
+    fol2_pmos45b_sphv_10hv    = 0.0
+    facneffaco_pmos45b_sphv_10hv = 1.0
+    facneffacl_pmos45b_sphv_10hv = 0.0
+    facneffacw_pmos45b_sphv_10hv = 0.0
+    facneffaclw_pmos45b_sphv_10hv = 0.0
+    gfacnudo_pmos45b_sphv_10hv = 1.0
+    gfacnudl_pmos45b_sphv_10hv = 0.0
+    gfacnudlexp_pmos45b_sphv_10hv = 1.0
+    gfacnudw_pmos45b_sphv_10hv = 0.0
+    gfacnudlw_pmos45b_sphv_10hv = 0.0
+    vsbnudo_pmos45b_sphv_10hv = 2.75
+    dvsbnudo_pmos45b_sphv_10hv = 1.0
+    vnsubo_pmos45b_sphv_10hv  = 0.0
+    nslpo_pmos45b_sphv_10hv   = 0.05
+    dnsubo_pmos45b_sphv_10hv  = 0.03
+    dphibo_pmos45b_sphv_10hv  = 0.008
+    dphibl_pmos45b_sphv_10hv  = 0.0
+    dphiblexp_pmos45b_sphv_10hv = 1.0
+    dphibw_pmos45b_sphv_10hv  = 0.0
+    dphiblw_pmos45b_sphv_10hv = 0.0
+    delvtaco_pmos45b_sphv_10hv = 0.0
+    delvtacl_pmos45b_sphv_10hv = 0.0
+    delvtaclexp_pmos45b_sphv_10hv = 1.0
+    delvtacw_pmos45b_sphv_10hv = 0.0
+    delvtaclw_pmos45b_sphv_10hv = 0.0
+    npo_pmos45b_sphv_10hv     = 9e+25
+    npl_pmos45b_sphv_10hv     = 0.0
+    cto_pmos45b_sphv_10hv     = 0.02
+    ctl_pmos45b_sphv_10hv     = 0.0
+    ctlexp_pmos45b_sphv_10hv  = 0.4772
+    ctw_pmos45b_sphv_10hv     = 0.0
+    ctlw_pmos45b_sphv_10hv    = 0.0
+    toxovo_pmos45b_sphv_10hv  = 1.3e-08
+    toxovdo_pmos45b_sphv_10hv = 1.3e-08
+    lov_pmos45b_sphv_10hv     = 6.5e-08
+    dlovd_pmos45b_sphv_10hv   = -2e-07
+    novo_pmos45b_sphv_10hv    = 5e+25
+    novdo_pmos45b_sphv_10hv   = 5e+21
+    cfl_pmos45b_sphv_10hv     = 0.0
+    cflexp_pmos45b_sphv_10hv  = 0.839
+    cfw_pmos45b_sphv_10hv     = 0.0
+    cfbo_pmos45b_sphv_10hv    = 2.22e-15
+    uo_pmos45b_sphv_10hv      = 0.0292
+    fbet1_pmos45b_sphv_10hv   = 0.0
+    fbet1w_pmos45b_sphv_10hv  = 0.0
+    lp1_pmos45b_sphv_10hv     = 1e-08
+    lp1w_pmos45b_sphv_10hv    = 0.0
+    fbet2_pmos45b_sphv_10hv   = 0.0
+    lp2_pmos45b_sphv_10hv     = 1e-08
+    betw1_pmos45b_sphv_10hv   = 0.0
+    betw2_pmos45b_sphv_10hv   = 0.0
+    wbet_pmos45b_sphv_10hv    = 0.0
+    stbeto_pmos45b_sphv_10hv  = 1.55
+    stbetl_pmos45b_sphv_10hv  = 0.0
+    stbetw_pmos45b_sphv_10hv  = -0.09
+    stbetlw_pmos45b_sphv_10hv = 0.0
+    mueo_pmos45b_sphv_10hv    = 5.8
+    muew_pmos45b_sphv_10hv    = -0.05
+    stmueo_pmos45b_sphv_10hv  = 0.8
+    themuo_pmos45b_sphv_10hv  = 0.82
+    stthemuo_pmos45b_sphv_10hv = 0.25
+    cso_pmos45b_sphv_10hv     = 0.0
+    csl_pmos45b_sphv_10hv     = 0.0
+    cslexp_pmos45b_sphv_10hv  = 0.0
+    csw_pmos45b_sphv_10hv     = 0.0
+    cslw_pmos45b_sphv_10hv    = 0.0
+    stcso_pmos45b_sphv_10hv   = 0.0
+    xcoro_pmos45b_sphv_10hv   = 0.01
+    xcorl_pmos45b_sphv_10hv   = 0.0
+    xcorw_pmos45b_sphv_10hv   = 0.0
+    xcorlw_pmos45b_sphv_10hv  = 0.0
+    stxcoro_pmos45b_sphv_10hv = 1.4
+    fetao_pmos45b_sphv_10hv   = 1.0
+    rsw1_pmos45b_sphv_10hv    = 0.0
+    rsw2_pmos45b_sphv_10hv    = 0.0
+    strso_pmos45b_sphv_10hv   = 0.0
+    rsbo_pmos45b_sphv_10hv    = 0.0
+    rsgo_pmos45b_sphv_10hv    = 0.0
+    thesato_pmos45b_sphv_10hv = 1e-09
+    thesatl_pmos45b_sphv_10hv = 0.23
+    thesatlexp_pmos45b_sphv_10hv = 2.0
+    thesatw_pmos45b_sphv_10hv = 0.0
+    thesatlw_pmos45b_sphv_10hv = -0.3
+    stthesato_pmos45b_sphv_10hv = 0.5
+    stthesatl_pmos45b_sphv_10hv = 1.0
+    stthesatw_pmos45b_sphv_10hv = 1.5
+    stthesatlw_pmos45b_sphv_10hv = -0.5
+    thesatbo_pmos45b_sphv_10hv = 0.3
+    thesatgo_pmos45b_sphv_10hv = 1.9
+    thesatgl_pmos45b_sphv_10hv = 0.0
+    thesatgw_pmos45b_sphv_10hv = 0.0
+    axo_pmos45b_sphv_10hv     = 10.0
+    axl_pmos45b_sphv_10hv     = 2.0
+    alpl_pmos45b_sphv_10hv    = 0.0
+    alplexp_pmos45b_sphv_10hv = 1.0
+    alpw_pmos45b_sphv_10hv    = 0.0
+    alp1l1_pmos45b_sphv_10hv  = 0.0
+    alp1lexp_pmos45b_sphv_10hv = 0.5
+    alp1l2_pmos45b_sphv_10hv  = 0.0
+    alp1w_pmos45b_sphv_10hv   = 0.0
+    alp2l1_pmos45b_sphv_10hv  = 0.0
+    alp2lexp_pmos45b_sphv_10hv = 1.0
+    alp2l2_pmos45b_sphv_10hv  = 0.0
+    alp2w_pmos45b_sphv_10hv   = 0.0
+    vpo_pmos45b_sphv_10hv     = 10.0
+    a1o_pmos45b_sphv_10hv     = 0.00014
+    a1l_pmos45b_sphv_10hv     = 5e-06
+    a1w_pmos45b_sphv_10hv     = 0.0
+    a2o_pmos45b_sphv_10hv     = 70.0
+    sta2o_pmos45b_sphv_10hv   = 0.8
+    a3o_pmos45b_sphv_10hv     = 1.4
+    a3l_pmos45b_sphv_10hv     = 0.0
+    a3w_pmos45b_sphv_10hv     = 0.0
+    a4o_pmos45b_sphv_10hv     = 0.0
+    a4l_pmos45b_sphv_10hv     = 0.0
+    a4w_pmos45b_sphv_10hv     = 0.0
+    gcoo_pmos45b_sphv_10hv    = 0.0
+    iginvlw_pmos45b_sphv_10hv = 0.0
+    igovw_pmos45b_sphv_10hv   = 0.0
+    igovdw_pmos45b_sphv_10hv  = 0.0
+    stigo_pmos45b_sphv_10hv   = 2.0
+    gc2o_pmos45b_sphv_10hv    = 0.375
+    gc3o_pmos45b_sphv_10hv    = 0.063
+    chibo_pmos45b_sphv_10hv   = 3.1
+    agidlw_pmos45b_sphv_10hv  = 1e-08
+    agidldw_pmos45b_sphv_10hv = 0.0
+    bgidlo_pmos45b_sphv_10hv  = 5.0
+    bgidldo_pmos45b_sphv_10hv = 10.0
+    stbgidlo_pmos45b_sphv_10hv = -0.0031
+    stbgidldo_pmos45b_sphv_10hv = 0.0
+    cgidlo_pmos45b_sphv_10hv  = 0.0
+    cgidldo_pmos45b_sphv_10hv = 1.0
+    cgbovl_pmos45b_sphv_10hv  = 1e-16
+    cfrw_pmos45b_sphv_10hv    = 0.0
+    cfrdw_pmos45b_sphv_10hv   = 0.0
+    fnto_pmos45b_sphv_10hv    = 1.0
+    nfalw_pmos45b_sphv_10hv   = 2e+23
+    nfblw_pmos45b_sphv_10hv   = 1500000000.0
+    nfclw_pmos45b_sphv_10hv   = 6.6e-08
+    efo_pmos45b_sphv_10hv     = 1.0
+    lintnoi_pmos45b_sphv_10hv = 0.0
+    alpnoi_pmos45b_sphv_10hv  = 2.0
+    kvthoweo_pmos45b_sphv_10hv = 0.0
+    kvthowel_pmos45b_sphv_10hv = 0.0
+    kvthowew_pmos45b_sphv_10hv = 0.0
+    kvthowelw_pmos45b_sphv_10hv = 0.0
+    kuoweo_pmos45b_sphv_10hv  = 0.0
+    kuowel_pmos45b_sphv_10hv  = 0.0
+    kuowew_pmos45b_sphv_10hv  = 0.0
+    kuowelw_pmos45b_sphv_10hv = 0.0
+    rgo_pmos45b_sphv_10hv     = 0.0
+    rsh_pmos45b_sphv_10hv     = 0.0
+    rbulko_pmos45b_sphv_10hv  = 0.0
+    rwello_pmos45b_sphv_10hv  = 0.0
+    rjunso_pmos45b_sphv_10hv  = 1200.0
+    rjundo_pmos45b_sphv_10hv  = 3500.0
+    rint_pmos45b_sphv_10hv    = 0.0
+    rvpoly_pmos45b_sphv_10hv  = 0.0
+    rshg_pmos45b_sphv_10hv    = 0.0
+    dlsil_pmos45b_sphv_10hv   = 0.0
+    saref_pmos45b_sphv_10hv   = 1e-06
+    sbref_pmos45b_sphv_10hv   = 1e-06
+    wlod_pmos45b_sphv_10hv    = 0.0
+    kuo_pmos45b_sphv_10hv     = 0.0
+    kvsat_pmos45b_sphv_10hv   = 0.0
+    tkuo_pmos45b_sphv_10hv    = 0.0
+    lkuo_pmos45b_sphv_10hv    = 0.0
+    wkuo_pmos45b_sphv_10hv    = 0.0
+    pkuo_pmos45b_sphv_10hv    = 0.0
+    llodkuo_pmos45b_sphv_10hv = 0.0
+    wlodkuo_pmos45b_sphv_10hv = 0.0
+    kvtho_pmos45b_sphv_10hv   = 0.0
+    lkvtho_pmos45b_sphv_10hv  = 0.0
+    wkvtho_pmos45b_sphv_10hv  = 0.0
+    pkvtho_pmos45b_sphv_10hv  = 0.0
+    llodvth_pmos45b_sphv_10hv = 0.0
+    wlodvth_pmos45b_sphv_10hv = 0.0
+    stetao_pmos45b_sphv_10hv  = 0.0
+    lodetao_pmos45b_sphv_10hv = 1.0
+    scref_pmos45b_sphv_10hv   = 1e-05
+    web_pmos45b_sphv_10hv     = 0.0
+    wec_pmos45b_sphv_10hv     = 0.0
+    adr1o_pmos45b_sphv_10hv   = 0.0003
+    adr1l_pmos45b_sphv_10hv   = 0.0
+    adr1w_pmos45b_sphv_10hv   = 0.0
+    adr2o_pmos45b_sphv_10hv   = 101.0
+    stadr2o_pmos45b_sphv_10hv = 0.5
+    adr3o_pmos45b_sphv_10hv   = 0.0
+    adr3l_pmos45b_sphv_10hv   = 0.0
+    adr3w_pmos45b_sphv_10hv   = 0.0
+    adr4o_pmos45b_sphv_10hv   = 0.0
+    adr4l_pmos45b_sphv_10hv   = 0.0
+    adr4w_pmos45b_sphv_10hv   = 0.0
+    adr5o_pmos45b_sphv_10hv   = 0.0
+    adr5l_pmos45b_sphv_10hv   = 0.0
+    adr5w_pmos45b_sphv_10hv   = 0.0
+    bidr1o_pmos45b_sphv_10hv  = 0.0
+    bidr1l_pmos45b_sphv_10hv  = 0.0
+    bidr1w_pmos45b_sphv_10hv  = 0.0
+    bidr2o_pmos45b_sphv_10hv  = 0.0
+    bidr2w_pmos45b_sphv_10hv  = 0.0
+    rtho_pmos45b_sphv_10hv    = 650.0
+    rthl_pmos45b_sphv_10hv    = 0.0
+    rthw_pmos45b_sphv_10hv    = 0.0
+    rthlw_pmos45b_sphv_10hv   = 0.0
+    strtho_pmos45b_sphv_10hv  = 0.0
+    strthao_pmos45b_sphv_10hv = 0.0
+    ctho_pmos45b_sphv_10hv    = 0.0
+    cthl_pmos45b_sphv_10hv    = 0.0
+    cthw_pmos45b_sphv_10hv    = 0.0
+    cthlw_pmos45b_sphv_10hv   = 0.0
+    rshldd_pmos45b_sphv_10hv  = 25800.0
+    xw_pmos45b_sphv_10hv      = 3.5e-07
+    nwxw_pmos45b_sphv_10hv    = 0.0
+    xl_pmos45b_sphv_10hv      = 0.0
+    xlw_pmos45b_sphv_10hv     = 0.0
+    dxlsat_pmos45b_sphv_10hv  = 0.0
+    nst_pmos45b_sphv_10hv     = 1.0
+    ats_pmos45b_sphv_10hv     = 0.0
+    dfinf_pmos45b_sphv_10hv   = 0.07
+    dfw_pmos45b_sphv_10hv     = 6e-08
+    dfl_pmos45b_sphv_10hv     = 0.0
+    dflw_pmos45b_sphv_10hv    = 0.0
+    dp_pmos45b_sphv_10hv      = 2.0
+    ecrit_pmos45b_sphv_10hv   = 7500000.0
+    ecorn_pmos45b_sphv_10hv   = 50000.0
+    xvsat_pmos45b_sphv_10hv   = 0.5
+    du_pmos45b_sphv_10hv      = 0.02
+    tc1_pmos45b_sphv_10hv     = 0.0052
+    tc2_pmos45b_sphv_10hv     = 6e-06
+    tc1l_pmos45b_sphv_10hv    = 0.0
+    tc2l_pmos45b_sphv_10hv    = 0.0
+    tc1w_pmos45b_sphv_10hv    = -7e-10
+    tc2w_pmos45b_sphv_10hv    = 0.0
+    theacc_pmos45b_sphv_10hv  = 0.0
+    theacc2_pmos45b_sphv_10hv = 0.039
+    aacc_pmos45b_sphv_10hv    = 36.0
+    rva_pmos45b_sphv_10hv     = 10000.0
+    dta_pmos45b_sphv_10hv     = 0.0
+    trj_pmos45b_sphv_10hv     = 27.0
+    cjarea_pmos45b_sphv_10hv  = 0.00168
+    cjlsti_pmos45b_sphv_10hv  = 0.0
+    cjlgat_pmos45b_sphv_10hv  = 5.375e-10
+    vbiarea_pmos45b_sphv_10hv = 0.7
+    vbisti_pmos45b_sphv_10hv  = 0.75
+    vbigat_pmos45b_sphv_10hv  = 0.75
+    parea_pmos45b_sphv_10hv   = 0.29
+    psti_pmos45b_sphv_10hv    = 0.3
+    pgat_pmos45b_sphv_10hv    = 0.3
+    is1area_pmos45b_sphv_10hv = 7e-07
+    ttarea_pmos45b_sphv_10hv  = 2.99e-09
+    is2area_pmos45b_sphv_10hv = 7.2e-05
+    irarea_pmos45b_sphv_10hv  = 0.0025
+    stis1area_pmos45b_sphv_10hv = 5.0
+    stis2area_pmos45b_sphv_10hv = 3.0
+    stirarea_pmos45b_sphv_10hv = 19000.0
+    n1area_pmos45b_sphv_10hv  = 1.0
+    n2area_pmos45b_sphv_10hv  = 1.6
+    nrarea_pmos45b_sphv_10hv  = 1000.0
+    is1lsti_pmos45b_sphv_10hv = 1e-16
+    ttlsti_pmos45b_sphv_10hv  = 2.99e-09
+    is2lsti_pmos45b_sphv_10hv = 1e-13
+    irlsti_pmos45b_sphv_10hv  = 1e-15
+    stis1sti_pmos45b_sphv_10hv = 3.0
+    stis2sti_pmos45b_sphv_10hv = 3.0
+    stirsti_pmos45b_sphv_10hv = 3.0
+    n1sti_pmos45b_sphv_10hv   = 1.02
+    n2sti_pmos45b_sphv_10hv   = 2.0
+    nrsti_pmos45b_sphv_10hv   = 20.0
+    is1lgat_pmos45b_sphv_10hv = 5e-14
+    ttlgat_pmos45b_sphv_10hv  = 2.99e-09
+    is2lgat_pmos45b_sphv_10hv = 1e-10
+    irlgat_pmos45b_sphv_10hv  = 1.5e-12
+    stis1gat_pmos45b_sphv_10hv = 3.0
+    stis2gat_pmos45b_sphv_10hv = 3.0
+    stirgat_pmos45b_sphv_10hv = 3.0
+    n1gat_pmos45b_sphv_10hv   = 1.02
+    n2gat_pmos45b_sphv_10hv   = 2.0
+    nrgat_pmos45b_sphv_10hv   = 20.0
+    cjaread_pmos45b_sphv_10hv = 0.000128
+    cjlstid_pmos45b_sphv_10hv = 1.2e-10
+    cjlgatd_pmos45b_sphv_10hv = 0.0
+    vbiaread_pmos45b_sphv_10hv = 0.5
+    vbistid_pmos45b_sphv_10hv = 0.5
+    vbigatd_pmos45b_sphv_10hv = 0.5
+    paread_pmos45b_sphv_10hv  = 0.4
+    pstid_pmos45b_sphv_10hv   = 0.38
+    pgatd_pmos45b_sphv_10hv   = 0.38
+    is1aread_pmos45b_sphv_10hv = 2.505e-08
+    ttaread_pmos45b_sphv_10hv = 2.401e-08
+    is2aread_pmos45b_sphv_10hv = 5.39e-06
+    iraread_pmos45b_sphv_10hv = 0.0017
+    stis1aread_pmos45b_sphv_10hv = 5.5
+    stis2aread_pmos45b_sphv_10hv = 0.0
+    stiraread_pmos45b_sphv_10hv = 160000.0
+    n1aread_pmos45b_sphv_10hv = 1.0
+    n2aread_pmos45b_sphv_10hv = 1.4
+    nraread_pmos45b_sphv_10hv = 8000.0
+    is1lstid_pmos45b_sphv_10hv = 0
+    ttlstid_pmos45b_sphv_10hv = 2.401e-08
+    is2lstid_pmos45b_sphv_10hv = 0.0
+    irlstid_pmos45b_sphv_10hv = 1.5e-15
+    stis1stid_pmos45b_sphv_10hv = 2.0
+    stis2stid_pmos45b_sphv_10hv = 10.0
+    stirstid_pmos45b_sphv_10hv = 8.0
+    n1stid_pmos45b_sphv_10hv  = 1.02
+    n2stid_pmos45b_sphv_10hv  = 2.0
+    nrstid_pmos45b_sphv_10hv  = 8000.0
+    is1lgatd_pmos45b_sphv_10hv = 0
+    ttlgatd_pmos45b_sphv_10hv = 2.401e-08
+    is2lgatd_pmos45b_sphv_10hv = 0.0
+    irlgatd_pmos45b_sphv_10hv = 1e-09
+    stis1gatd_pmos45b_sphv_10hv = 2.0
+    stis2gatd_pmos45b_sphv_10hv = 10.0
+    stirgatd_pmos45b_sphv_10hv = 8.0
+    n1gatd_pmos45b_sphv_10hv  = 1.02
+    n2gatd_pmos45b_sphv_10hv  = 2.0
+    nrgatd_pmos45b_sphv_10hv  = 8000.0
+    cjaread2_pmos45b_sphv_10hv = 1e-12
+    cjlstid2_pmos45b_sphv_10hv = 1e-18
+    vbiaread2_pmos45b_sphv_10hv = 0.5
+    vbistid2_pmos45b_sphv_10hv = 0.5
+    paread2_pmos45b_sphv_10hv = 0.38
+    pstid2_pmos45b_sphv_10hv  = 0.38
+    is1aread2_pmos45b_sphv_10hv = 0
+    ttaread2_pmos45b_sphv_10hv = 2.401e-08
+    is2aread2_pmos45b_sphv_10hv = 0.0
+    iraread2_pmos45b_sphv_10hv = 0.0004
+    stis1aread2_pmos45b_sphv_10hv = 25
+    stis2aread2_pmos45b_sphv_10hv = 15
+    stiraread2_pmos45b_sphv_10hv = 8.0
+    n1aread2_pmos45b_sphv_10hv = 1.02
+    n2aread2_pmos45b_sphv_10hv = 2.0
+    nraread2_pmos45b_sphv_10hv = 8000.0
+    is1lstid2_pmos45b_sphv_10hv = 0
+    ttlstid2_pmos45b_sphv_10hv = 2.401e-08
+    is2lstid2_pmos45b_sphv_10hv = 0.0
+    irlstid2_pmos45b_sphv_10hv = 1.5e-15
+    stis1stid2_pmos45b_sphv_10hv = 2.0
+    stis2stid2_pmos45b_sphv_10hv = 10.0
+    stirstid2_pmos45b_sphv_10hv = 8.0
+    n1stid2_pmos45b_sphv_10hv = 1.02
+    n2stid2_pmos45b_sphv_10hv = 2.0
+    nrstid2_pmos45b_sphv_10hv = 8000.0
+    eais1area_pmos45b_sphv_10hv = 1.12
+    eais2area_pmos45b_sphv_10hv = 1.12
+    eairarea_pmos45b_sphv_10hv = 1.12
+    eais1sti_pmos45b_sphv_10hv = 1.12
+    eais2sti_pmos45b_sphv_10hv = 1.12
+    eairsti_pmos45b_sphv_10hv = 1.12
+    eais1gat_pmos45b_sphv_10hv = 1.12
+    eais2gat_pmos45b_sphv_10hv = 1.12
+    eairgat_pmos45b_sphv_10hv = 1.12
+    eais1aread_pmos45b_sphv_10hv = 1.12
+    eais2aread_pmos45b_sphv_10hv = 1.12
+    eairaread_pmos45b_sphv_10hv = 1.12
+    eais1stid_pmos45b_sphv_10hv = 1.12
+    eais2stid_pmos45b_sphv_10hv = 1.12
+    eairstid_pmos45b_sphv_10hv = 1.12
+    eais1gatd_pmos45b_sphv_10hv = 1.12
+    eais2gatd_pmos45b_sphv_10hv = 1.12
+    eairgatd_pmos45b_sphv_10hv = 1.12
+    eais1aread2_pmos45b_sphv_10hv = 1.12
+    eais2aread2_pmos45b_sphv_10hv = 1.12
+    eairaread2_pmos45b_sphv_10hv = 1.12
+    eais1stid2_pmos45b_sphv_10hv = 1.12
+    eais2stid2_pmos45b_sphv_10hv = 1.12
+    eairstid2_pmos45b_sphv_10hv = 1.12
+    vdscale_pmos45b_sphv_10hv = 1.00992213053
+    vdscalel_pmos45b_sphv_10hv = 0.130661842988
+    vdscalew_pmos45b_sphv_10hv = 0.0421717309347
+    vdscalelw_pmos45b_sphv_10hv = 0.055
+    vdscaleb_pmos45b_sphv_10hv = 0.0
+    vdscalebl_pmos45b_sphv_10hv = 0.07
+    mumb_pmos45b_sphv_10hv    = 0.0
+    mumbexp_pmos45b_sphv_10hv = 0.0
+    mumbvclmp_pmos45b_sphv_10hv = 0.0
+    stvdscale_pmos45b_sphv_10hv = 0.0
+    ctgo_pmos45b_sphv_10hv    = 0.0
+    ctbo_pmos45b_sphv_10hv    = 0.0
+    stcto_pmos45b_sphv_10hv   = 0.0
+    ikfarea_pmos45b_sphv_10hv = 100000000.0
+    stikfarea_pmos45b_sphv_10hv = 0.0
+    ikfaread_pmos45b_sphv_10hv = 0.0
+    dwikfaread_pmos45b_sphv_10hv = 0.0
+    stikfaread_pmos45b_sphv_10hv = 0.0
+    nom_delr_tox_nmos45b_sphv_10hv = 1.0
+    nom_dela_dw_nmos45b_sphv_10hv = 0.0
+    nom_dela_dl_nmos45b_sphv_10hv = 0.0
+    nom_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nom_dela_vfb_nmos45b_sphv_10hv = 0.0
+    nom_dela_vtw_nmos45b_sphv_10hv = 0.0
+    nom_dela_vtl_nmos45b_sphv_10hv = 0.0
+    nom_dela_vtm_nmos45b_sphv_10hv = 0.0
+    nom_delr_mobref_nmos45b_sphv_10hv = 1.0
+    nom_delr_satl_nmos45b_sphv_10hv = 1.0
+    nom_delr_rshl_nmos45b_sphv_10hv = 1.0
+    nom_delr_cjs_nmos45b_sphv_10hv = 1.0
+    nom_delr_cjd_nmos45b_sphv_10hv = 1.0
+    nom_delr_jsideal_nmos45b_sphv_10hv = 1.0
+    nom_delr_jdideal_nmos45b_sphv_10hv = 1.0
+    nom_delr_jsnonideal_nmos45b_sphv_10hv = 1.0
+    nom_delr_jdnonideal_nmos45b_sphv_10hv = 1.0
+    sig_delr_tox_nmos45b_sphv_10hv = 0.012
+    sig_dela_dw_nmos45b_sphv_10hv = 0.0
+    sig_dela_dl_nmos45b_sphv_10hv = 0.0161
+    sig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    sig_dela_vfb_nmos45b_sphv_10hv = 0.04025
+    sig_dela_vtw_nmos45b_sphv_10hv = 0.001352
+    sig_dela_vtl_nmos45b_sphv_10hv = 0.002688
+    sig_dela_vtm_nmos45b_sphv_10hv = 0.003061
+    sig_delr_mobref_nmos45b_sphv_10hv = 0.02467
+    sig_delr_satl_nmos45b_sphv_10hv = 0.0
+    sig_delr_rshl_nmos45b_sphv_10hv = 0.02
+    sig_delr_cjs_nmos45b_sphv_10hv = 0.033
+    sig_delr_cjd_nmos45b_sphv_10hv = 0.033
+    sig_delr_jsideal_nmos45b_sphv_10hv = 0.055
+    sig_delr_jdideal_nmos45b_sphv_10hv = 0.055
+    sig_delr_jsnonideal_nmos45b_sphv_10hv = 0.768
+    sig_delr_jdnonideal_nmos45b_sphv_10hv = 0.768
+    fac_rth_nmos45b_sphv_10hv = 0.655
+    tc1_ecrit_nmos45b_sphv_10hv = 0.0
+    tc2_ecrit_nmos45b_sphv_10hv = 0.0
+    dwrjundo_nmos45b_sphv_10hv = 10.0
+    dwrjunso_nmos45b_sphv_10hv = 10.0
+    qmc_nmos45b_sphv_10hv     = 1.0
+    lvaro_nmos45b_sphv_10hv   = 1.9e-07
+    lvarl_nmos45b_sphv_10hv   = 0.0
+    lvarw_nmos45b_sphv_10hv   = 0.0
+    lap_nmos45b_sphv_10hv     = 0.0
+    wvaro_nmos45b_sphv_10hv   = -3.6e-07
+    wvarl_nmos45b_sphv_10hv   = 0.0
+    wvarw_nmos45b_sphv_10hv   = -0.56
+    wot_nmos45b_sphv_10hv     = 0.0
+    dlq_nmos45b_sphv_10hv     = 0.0
+    dwq_nmos45b_sphv_10hv     = 2.5e-07
+    vfbo_nmos45b_sphv_10hv    = -0.9994
+    vfbl_nmos45b_sphv_10hv    = 0.09562
+    vfbw_nmos45b_sphv_10hv    = -0.009274
+    vfblw_nmos45b_sphv_10hv   = 0.007513
+    stvfbo_nmos45b_sphv_10hv  = 0.001
+    stvfbl_nmos45b_sphv_10hv  = -0.1
+    stvfbw_nmos45b_sphv_10hv  = 0.0
+    stvfblw_nmos45b_sphv_10hv = 0.0
+    toxo_nmos45b_sphv_10hv    = 1.26e-08
+    epsroxo_nmos45b_sphv_10hv = 3.9
+    nsubo_nmos45b_sphv_10hv   = 1.381e+23
+    nsubw_nmos45b_sphv_10hv   = 0.0
+    wseg_nmos45b_sphv_10hv    = 1e-08
+    npck_nmos45b_sphv_10hv    = 7e+21
+    npckw_nmos45b_sphv_10hv   = 0.0
+    wsegp_nmos45b_sphv_10hv   = 1e-08
+    lpck_nmos45b_sphv_10hv    = 3e-06
+    lpckw_nmos45b_sphv_10hv   = 0.0
+    fol1_nmos45b_sphv_10hv    = 0.0
+    fol2_nmos45b_sphv_10hv    = 0.0
+    facneffaco_nmos45b_sphv_10hv = 0.85
+    facneffacl_nmos45b_sphv_10hv = 0.0
+    facneffacw_nmos45b_sphv_10hv = 0.0
+    facneffaclw_nmos45b_sphv_10hv = 0.0
+    gfacnudo_nmos45b_sphv_10hv = 1.035
+    gfacnudl_nmos45b_sphv_10hv = 0.03
+    gfacnudlexp_nmos45b_sphv_10hv = 1.0
+    gfacnudw_nmos45b_sphv_10hv = 0.0
+    gfacnudlw_nmos45b_sphv_10hv = 0.0
+    vsbnudo_nmos45b_sphv_10hv = 0.205
+    dvsbnudo_nmos45b_sphv_10hv = 0.2
+    vnsubo_nmos45b_sphv_10hv  = 0.0
+    nslpo_nmos45b_sphv_10hv   = 0.05
+    dnsubo_nmos45b_sphv_10hv  = 0.0
+    dphibo_nmos45b_sphv_10hv  = -0.068
+    dphibl_nmos45b_sphv_10hv  = 0.14
+    dphiblexp_nmos45b_sphv_10hv = 1.0
+    dphibw_nmos45b_sphv_10hv  = 0.0
+    dphiblw_nmos45b_sphv_10hv = 0.0
+    delvtaco_nmos45b_sphv_10hv = 0.02
+    delvtacl_nmos45b_sphv_10hv = 0.0
+    delvtaclexp_nmos45b_sphv_10hv = 1.0
+    delvtacw_nmos45b_sphv_10hv = 0.0
+    delvtaclw_nmos45b_sphv_10hv = 0.0
+    npo_nmos45b_sphv_10hv     = 1e+26
+    npl_nmos45b_sphv_10hv     = -0.5
+    cto_nmos45b_sphv_10hv     = 0.035
+    ctl_nmos45b_sphv_10hv     = 0.0
+    ctlexp_nmos45b_sphv_10hv  = 1.0
+    ctw_nmos45b_sphv_10hv     = 0.0
+    ctlw_nmos45b_sphv_10hv    = 0.0
+    toxovo_nmos45b_sphv_10hv  = 1.26e-08
+    toxovdo_nmos45b_sphv_10hv = 1.26e-08
+    lov_nmos45b_sphv_10hv     = 1.3e-07
+    dlovd_nmos45b_sphv_10hv   = -2.9e-07
+    novo_nmos45b_sphv_10hv    = 8e+23
+    novdo_nmos45b_sphv_10hv   = 6.8e+22
+    cfl_nmos45b_sphv_10hv     = 0.0001
+    cflexp_nmos45b_sphv_10hv  = 2.0
+    cfw_nmos45b_sphv_10hv     = 0.0
+    cfbo_nmos45b_sphv_10hv    = 0.0
+    uo_nmos45b_sphv_10hv      = 0.0525
+    fbet1_nmos45b_sphv_10hv   = 0.0
+    fbet1w_nmos45b_sphv_10hv  = 0.0
+    lp1_nmos45b_sphv_10hv     = 0.0
+    lp1w_nmos45b_sphv_10hv    = 0.0
+    fbet2_nmos45b_sphv_10hv   = 0.0
+    lp2_nmos45b_sphv_10hv     = 1e-08
+    betw1_nmos45b_sphv_10hv   = 0.0
+    betw2_nmos45b_sphv_10hv   = 0.0
+    wbet_nmos45b_sphv_10hv    = 1e-09
+    stbeto_nmos45b_sphv_10hv  = 1.43
+    stbetl_nmos45b_sphv_10hv  = -0.09
+    stbetw_nmos45b_sphv_10hv  = -0.17
+    stbetlw_nmos45b_sphv_10hv = 0.0
+    mueo_nmos45b_sphv_10hv    = 0.958
+    muew_nmos45b_sphv_10hv    = -0.17
+    stmueo_nmos45b_sphv_10hv  = -0.01
+    themuo_nmos45b_sphv_10hv  = 2.2
+    stthemuo_nmos45b_sphv_10hv = 1.0
+    cso_nmos45b_sphv_10hv     = 0.0
+    csl_nmos45b_sphv_10hv     = 0.0
+    cslexp_nmos45b_sphv_10hv  = 0.0
+    csw_nmos45b_sphv_10hv     = 0.0
+    cslw_nmos45b_sphv_10hv    = 0.0
+    stcso_nmos45b_sphv_10hv   = 0.0
+    xcoro_nmos45b_sphv_10hv   = 0.04
+    xcorl_nmos45b_sphv_10hv   = 0.0
+    xcorw_nmos45b_sphv_10hv   = -0.4
+    xcorlw_nmos45b_sphv_10hv  = 0.0
+    stxcoro_nmos45b_sphv_10hv = 0.95
+    fetao_nmos45b_sphv_10hv   = 1.0
+    rsw1_nmos45b_sphv_10hv    = 0.0
+    rsw2_nmos45b_sphv_10hv    = 0.0
+    strso_nmos45b_sphv_10hv   = 1.0
+    rsbo_nmos45b_sphv_10hv    = 0.0
+    rsgo_nmos45b_sphv_10hv    = 0.0
+    thesato_nmos45b_sphv_10hv = 0.0
+    thesatl_nmos45b_sphv_10hv = 0.38
+    thesatlexp_nmos45b_sphv_10hv = 1.0
+    thesatw_nmos45b_sphv_10hv = 0.0
+    thesatlw_nmos45b_sphv_10hv = 0.0
+    stthesato_nmos45b_sphv_10hv = 0.8
+    stthesatl_nmos45b_sphv_10hv = 0.0
+    stthesatw_nmos45b_sphv_10hv = 0.0
+    stthesatlw_nmos45b_sphv_10hv = 0.0
+    thesatbo_nmos45b_sphv_10hv = 0.0
+    thesatgo_nmos45b_sphv_10hv = 0.58
+    thesatgl_nmos45b_sphv_10hv = 0.12
+    thesatgw_nmos45b_sphv_10hv = -0.52
+    axo_nmos45b_sphv_10hv     = 20.0
+    axl_nmos45b_sphv_10hv     = 4.0
+    alpl_nmos45b_sphv_10hv    = 0.0001
+    alplexp_nmos45b_sphv_10hv = 4.997
+    alpw_nmos45b_sphv_10hv    = 4.667e-16
+    alp1l1_nmos45b_sphv_10hv  = 0.001196
+    alp1lexp_nmos45b_sphv_10hv = 0.865
+    alp1l2_nmos45b_sphv_10hv  = -0.02107
+    alp1w_nmos45b_sphv_10hv   = 0.1538
+    alp2l1_nmos45b_sphv_10hv  = 0.002954
+    alp2lexp_nmos45b_sphv_10hv = 0.252
+    alp2l2_nmos45b_sphv_10hv  = -0.06267
+    alp2w_nmos45b_sphv_10hv   = -0.2744
+    vpo_nmos45b_sphv_10hv     = 0.05
+    a1o_nmos45b_sphv_10hv     = 0.008
+    a1l_nmos45b_sphv_10hv     = 0.0
+    a1w_nmos45b_sphv_10hv     = 1.0
+    a2o_nmos45b_sphv_10hv     = 82.0
+    sta2o_nmos45b_sphv_10hv   = 0.5
+    a3o_nmos45b_sphv_10hv     = 1.2
+    a3l_nmos45b_sphv_10hv     = 0.0
+    a3w_nmos45b_sphv_10hv     = 3.0
+    a4o_nmos45b_sphv_10hv     = 0.0
+    a4l_nmos45b_sphv_10hv     = 0.0
+    a4w_nmos45b_sphv_10hv     = 0.0
+    gcoo_nmos45b_sphv_10hv    = 0.0
+    iginvlw_nmos45b_sphv_10hv = 0.0
+    igovw_nmos45b_sphv_10hv   = 0.0
+    igovdw_nmos45b_sphv_10hv  = 0.0
+    stigo_nmos45b_sphv_10hv   = 2.0
+    gc2o_nmos45b_sphv_10hv    = 0.375
+    gc3o_nmos45b_sphv_10hv    = 0.063
+    chibo_nmos45b_sphv_10hv   = 3.1
+    agidlw_nmos45b_sphv_10hv  = 0.19
+    agidldw_nmos45b_sphv_10hv = 0.0
+    bgidlo_nmos45b_sphv_10hv  = 14.0
+    bgidldo_nmos45b_sphv_10hv = 0.0
+    stbgidlo_nmos45b_sphv_10hv = -0.0005
+    stbgidldo_nmos45b_sphv_10hv = 0.0
+    cgidlo_nmos45b_sphv_10hv  = 0.0
+    cgidldo_nmos45b_sphv_10hv = 0.0
+    cgbovl_nmos45b_sphv_10hv  = 0.0
+    cfrw_nmos45b_sphv_10hv    = 1.597e-17
+    cfrdw_nmos45b_sphv_10hv   = 2.95e-17
+    fnto_nmos45b_sphv_10hv    = 1.0
+    nfalw_nmos45b_sphv_10hv   = 4.92e+25
+    nfblw_nmos45b_sphv_10hv   = 0.0
+    nfclw_nmos45b_sphv_10hv   = 0.0
+    efo_nmos45b_sphv_10hv     = 0.93
+    lintnoi_nmos45b_sphv_10hv = 0.0
+    alpnoi_nmos45b_sphv_10hv  = 2.0
+    kvthoweo_nmos45b_sphv_10hv = 0.0
+    kvthowel_nmos45b_sphv_10hv = 0.0
+    kvthowew_nmos45b_sphv_10hv = 0.0
+    kvthowelw_nmos45b_sphv_10hv = 0.0
+    kuoweo_nmos45b_sphv_10hv  = 0.0
+    kuowel_nmos45b_sphv_10hv  = 0.0
+    kuowew_nmos45b_sphv_10hv  = 0.0
+    kuowelw_nmos45b_sphv_10hv = 0.0
+    rgo_nmos45b_sphv_10hv     = 0.0
+    rsh_nmos45b_sphv_10hv     = 0.0
+    rbulko_nmos45b_sphv_10hv  = 0.0
+    rwello_nmos45b_sphv_10hv  = 0.0
+    rjunso_nmos45b_sphv_10hv  = 6000.0
+    rjundo_nmos45b_sphv_10hv  = 2500.0
+    rint_nmos45b_sphv_10hv    = 0.0
+    rvpoly_nmos45b_sphv_10hv  = 0.0
+    rshg_nmos45b_sphv_10hv    = 0.0
+    dlsil_nmos45b_sphv_10hv   = 0.0
+    saref_nmos45b_sphv_10hv   = 1e-06
+    sbref_nmos45b_sphv_10hv   = 1e-06
+    wlod_nmos45b_sphv_10hv    = 0.0
+    kuo_nmos45b_sphv_10hv     = 0.0
+    kvsat_nmos45b_sphv_10hv   = 0.0
+    tkuo_nmos45b_sphv_10hv    = 0.0
+    lkuo_nmos45b_sphv_10hv    = 0.0
+    wkuo_nmos45b_sphv_10hv    = 0.0
+    pkuo_nmos45b_sphv_10hv    = 0.0
+    llodkuo_nmos45b_sphv_10hv = 0.0
+    wlodkuo_nmos45b_sphv_10hv = 0.0
+    kvtho_nmos45b_sphv_10hv   = 0.0
+    lkvtho_nmos45b_sphv_10hv  = 0.0
+    wkvtho_nmos45b_sphv_10hv  = 0.0
+    pkvtho_nmos45b_sphv_10hv  = 0.0
+    llodvth_nmos45b_sphv_10hv = 0.0
+    wlodvth_nmos45b_sphv_10hv = 0.0
+    stetao_nmos45b_sphv_10hv  = 0.0
+    lodetao_nmos45b_sphv_10hv = 1.0
+    scref_nmos45b_sphv_10hv   = 1e-05
+    web_nmos45b_sphv_10hv     = 0.0
+    wec_nmos45b_sphv_10hv     = 0.0
+    adr1o_nmos45b_sphv_10hv   = 0.003
+    adr1l_nmos45b_sphv_10hv   = 0.0
+    adr1w_nmos45b_sphv_10hv   = 0.01
+    adr2o_nmos45b_sphv_10hv   = 70.0
+    stadr2o_nmos45b_sphv_10hv = 0.29
+    adr3o_nmos45b_sphv_10hv   = 0.2
+    adr3l_nmos45b_sphv_10hv   = 0.0
+    adr3w_nmos45b_sphv_10hv   = -0.2015
+    adr4o_nmos45b_sphv_10hv   = 0.0
+    adr4l_nmos45b_sphv_10hv   = 0.0
+    adr4w_nmos45b_sphv_10hv   = 0.0
+    adr5o_nmos45b_sphv_10hv   = 0.0
+    adr5l_nmos45b_sphv_10hv   = 0.0
+    adr5w_nmos45b_sphv_10hv   = 0.0
+    bidr1o_nmos45b_sphv_10hv  = 0.0
+    bidr1l_nmos45b_sphv_10hv  = 0.0
+    bidr1w_nmos45b_sphv_10hv  = 0.0
+    bidr2o_nmos45b_sphv_10hv  = 0.0
+    bidr2w_nmos45b_sphv_10hv  = 0.0
+    rtho_nmos45b_sphv_10hv    = 650.0
+    rthl_nmos45b_sphv_10hv    = 0.0
+    rthw_nmos45b_sphv_10hv    = 0.0
+    rthlw_nmos45b_sphv_10hv   = 0.0
+    strtho_nmos45b_sphv_10hv  = 0.5
+    ctho_nmos45b_sphv_10hv    = 0.0
+    cthl_nmos45b_sphv_10hv    = 0.0
+    cthw_nmos45b_sphv_10hv    = 0.0
+    cthlw_nmos45b_sphv_10hv   = 0.0
+    rshldd_nmos45b_sphv_10hv  = 7350.0
+    xw_nmos45b_sphv_10hv      = 8.879e-07
+    nwxw_nmos45b_sphv_10hv    = -2e-13
+    xl_nmos45b_sphv_10hv      = 0.0
+    xlw_nmos45b_sphv_10hv     = 0.0
+    dxlsat_nmos45b_sphv_10hv  = 3e-07
+    nst_nmos45b_sphv_10hv     = 0.0
+    ats_nmos45b_sphv_10hv     = 0.0
+    dfinf_nmos45b_sphv_10hv   = 0.063
+    dfw_nmos45b_sphv_10hv     = 3e-08
+    dfl_nmos45b_sphv_10hv     = 0.0
+    dflw_nmos45b_sphv_10hv    = 0.0
+    dp_nmos45b_sphv_10hv      = 2.0
+    ecrit_nmos45b_sphv_10hv   = 2200000.0
+    ecorn_nmos45b_sphv_10hv   = 10000.0
+    xvsat_nmos45b_sphv_10hv   = 0.0
+    du_nmos45b_sphv_10hv      = 0.02
+    tc1_nmos45b_sphv_10hv     = 0.0051
+    tc2_nmos45b_sphv_10hv     = 1.37e-05
+    tc1l_nmos45b_sphv_10hv    = 0.0
+    tc2l_nmos45b_sphv_10hv    = 0.0
+    tc1w_nmos45b_sphv_10hv    = -5e-10
+    tc2w_nmos45b_sphv_10hv    = 0.0
+    theacc_nmos45b_sphv_10hv  = 0.0
+    theacc2_nmos45b_sphv_10hv = 0.037
+    aacc_nmos45b_sphv_10hv    = 36.0
+    rva_nmos45b_sphv_10hv     = 1000.0
+    dta_nmos45b_sphv_10hv     = 0.0
+    cjarea_nmos45b_sphv_10hv  = 0.00023
+    cjlsti_nmos45b_sphv_10hv  = 4.785e-10
+    cjlgat_nmos45b_sphv_10hv  = 9.624e-11
+    vbiarea_nmos45b_sphv_10hv = 0.68
+    vbisti_nmos45b_sphv_10hv  = 0.6346
+    vbigat_nmos45b_sphv_10hv  = 0.2545
+    parea_nmos45b_sphv_10hv   = 0.39
+    psti_nmos45b_sphv_10hv    = 0.5
+    pgat_nmos45b_sphv_10hv    = 0.5
+    is1area_nmos45b_sphv_10hv = 8.4e-09
+    ttarea_nmos45b_sphv_10hv  = 5e-08
+    is2area_nmos45b_sphv_10hv = 1.54e-05
+    irarea_nmos45b_sphv_10hv  = 1e-05
+    stis1area_nmos45b_sphv_10hv = 3.0
+    stis2area_nmos45b_sphv_10hv = 3.0
+    stirarea_nmos45b_sphv_10hv = 1000.0
+    n1area_nmos45b_sphv_10hv  = 1.0
+    n2area_nmos45b_sphv_10hv  = 2.0
+    nrarea_nmos45b_sphv_10hv  = 45.0
+    is1lsti_nmos45b_sphv_10hv = 1e-18
+    ttlsti_nmos45b_sphv_10hv  = 5e-08
+    is2lsti_nmos45b_sphv_10hv = 0.0
+    irlsti_nmos45b_sphv_10hv  = 0.0
+    stis1sti_nmos45b_sphv_10hv = 25.0
+    stis2sti_nmos45b_sphv_10hv = 15.0
+    stirsti_nmos45b_sphv_10hv = 0.0
+    n1sti_nmos45b_sphv_10hv   = 1.0
+    n2sti_nmos45b_sphv_10hv   = 2.0
+    nrsti_nmos45b_sphv_10hv   = 100.0
+    is1lgat_nmos45b_sphv_10hv = 1e-18
+    ttlgat_nmos45b_sphv_10hv  = 5e-08
+    is2lgat_nmos45b_sphv_10hv = 0.0
+    irlgat_nmos45b_sphv_10hv  = 0.0
+    stis1gat_nmos45b_sphv_10hv = 25.0
+    stis2gat_nmos45b_sphv_10hv = 15.0
+    stirgat_nmos45b_sphv_10hv = 0.0
+    n1gat_nmos45b_sphv_10hv   = 1.0
+    n2gat_nmos45b_sphv_10hv   = 2.0
+    nrgat_nmos45b_sphv_10hv   = 100.0
+    cjaread_nmos45b_sphv_10hv = 0.0001258
+    cjlstid_nmos45b_sphv_10hv = 1e-18
+    cjlgatd_nmos45b_sphv_10hv = 1e-18
+    vbiaread_nmos45b_sphv_10hv = 0.5
+    vbistid_nmos45b_sphv_10hv = 1.12
+    vbigatd_nmos45b_sphv_10hv = 1.12
+    paread_nmos45b_sphv_10hv  = 0.43
+    pstid_nmos45b_sphv_10hv   = 0.5
+    pgatd_nmos45b_sphv_10hv   = 0.5
+    is1aread_nmos45b_sphv_10hv = 2e-07
+    ttaread_nmos45b_sphv_10hv = 1.11e-07
+    is2aread_nmos45b_sphv_10hv = 4e-05
+    iraread_nmos45b_sphv_10hv = 2e-05
+    stis1aread_nmos45b_sphv_10hv = 5.42
+    stis2aread_nmos45b_sphv_10hv = 3.0
+    stiraread_nmos45b_sphv_10hv = 23500.0
+    n1aread_nmos45b_sphv_10hv = 1.05
+    n2aread_nmos45b_sphv_10hv = 2.5
+    nraread_nmos45b_sphv_10hv = 950.0
+    is1lstid_nmos45b_sphv_10hv = 0
+    ttlstid_nmos45b_sphv_10hv = 2.21e-07
+    is2lstid_nmos45b_sphv_10hv = 0.0
+    irlstid_nmos45b_sphv_10hv = 0.0
+    stis1stid_nmos45b_sphv_10hv = 25.0
+    stis2stid_nmos45b_sphv_10hv = 15.0
+    stirstid_nmos45b_sphv_10hv = 0.0
+    n1stid_nmos45b_sphv_10hv  = 1.0
+    n2stid_nmos45b_sphv_10hv  = 2.0
+    nrstid_nmos45b_sphv_10hv  = 100.0
+    is1lgatd_nmos45b_sphv_10hv = 0
+    ttlgatd_nmos45b_sphv_10hv = 1.11e-07
+    is2lgatd_nmos45b_sphv_10hv = 0.0
+    irlgatd_nmos45b_sphv_10hv = 0.0
+    stis1gatd_nmos45b_sphv_10hv = 25.0
+    stis2gatd_nmos45b_sphv_10hv = 15.0
+    stirgatd_nmos45b_sphv_10hv = 0.0
+    n1gatd_nmos45b_sphv_10hv  = 1.0
+    n2gatd_nmos45b_sphv_10hv  = 2.0
+    nrgatd_nmos45b_sphv_10hv  = 100.0
+    cjaread2_nmos45b_sphv_10hv = 1e-12
+    cjlstid2_nmos45b_sphv_10hv = 1e-18
+    vbiaread2_nmos45b_sphv_10hv = 1.0
+    vbistid2_nmos45b_sphv_10hv = 1.0
+    paread2_nmos45b_sphv_10hv = 0.5
+    pstid2_nmos45b_sphv_10hv  = 0.5
+    is1aread2_nmos45b_sphv_10hv = 0
+    ttaread2_nmos45b_sphv_10hv = 1.11e-07
+    is2aread2_nmos45b_sphv_10hv = 0.0
+    iraread2_nmos45b_sphv_10hv = 0.0
+    stis1aread2_nmos45b_sphv_10hv = 25
+    stis2aread2_nmos45b_sphv_10hv = 15
+    stiraread2_nmos45b_sphv_10hv = 0.0
+    n1aread2_nmos45b_sphv_10hv = 1.0
+    n2aread2_nmos45b_sphv_10hv = 2.0
+    nraread2_nmos45b_sphv_10hv = 100.0
+    is1lstid2_nmos45b_sphv_10hv = 0
+    ttlstid2_nmos45b_sphv_10hv = 2.21e-07
+    is2lstid2_nmos45b_sphv_10hv = 0.0
+    irlstid2_nmos45b_sphv_10hv = 0.0
+    stis1stid2_nmos45b_sphv_10hv = 25.0
+    stis2stid2_nmos45b_sphv_10hv = 15.0
+    stirstid2_nmos45b_sphv_10hv = 0.0
+    n1stid2_nmos45b_sphv_10hv = 1.0
+    n2stid2_nmos45b_sphv_10hv = 2.0
+    nrstid2_nmos45b_sphv_10hv = 100.0
+    vfb1_nmos45b_sphv_10hv    = -1.0
+    stvfbo1_nmos45b_sphv_10hv = 0.0008898
+    nsub1_nmos45b_sphv_10hv   = 1.7e+23
+    dphib1_nmos45b_sphv_10hv  = -0.02344
+    ct1_nmos45b_sphv_10hv     = 0.0
+    u1_nmos45b_sphv_10hv      = 0.052
+    mue1_nmos45b_sphv_10hv    = 0.94
+    themu1_nmos45b_sphv_10hv  = 1.661
+    cs1_nmos45b_sphv_10hv     = 0.0
+    eais1area_nmos45b_sphv_10hv = 1.12
+    eais2area_nmos45b_sphv_10hv = 1.12
+    eairarea_nmos45b_sphv_10hv = 1.12
+    eais1sti_nmos45b_sphv_10hv = 1.12
+    eais2sti_nmos45b_sphv_10hv = 1.12
+    eairsti_nmos45b_sphv_10hv = 1.12
+    eais1gat_nmos45b_sphv_10hv = 1.12
+    eais2gat_nmos45b_sphv_10hv = 1.12
+    eairgat_nmos45b_sphv_10hv = 1.12
+    eais1aread_nmos45b_sphv_10hv = 0.98
+    eais2aread_nmos45b_sphv_10hv = 1.12
+    eairaread_nmos45b_sphv_10hv = 1.12
+    eais1stid_nmos45b_sphv_10hv = 1.12
+    eais2stid_nmos45b_sphv_10hv = 1.12
+    eairstid_nmos45b_sphv_10hv = 1.12
+    eais1gatd_nmos45b_sphv_10hv = 1.12
+    eais2gatd_nmos45b_sphv_10hv = 1.12
+    eairgatd_nmos45b_sphv_10hv = 1.12
+    eais1aread2_nmos45b_sphv_10hv = 1.12
+    eais2aread2_nmos45b_sphv_10hv = 1.12
+    eairaread2_nmos45b_sphv_10hv = 1.12
+    eais1stid2_nmos45b_sphv_10hv = 1.12
+    eais2stid2_nmos45b_sphv_10hv = 1.12
+    eairstid2_nmos45b_sphv_10hv = 1.12
+    ikfarea_nmos45b_sphv_10hv = 0.0
+    stikfarea_nmos45b_sphv_10hv = 0.0
+    ikfaread_nmos45b_sphv_10hv = 100000000.0
+    dwikfaread_nmos45b_sphv_10hv = 40.0
+    stikfaread_nmos45b_sphv_10hv = 0.0
+    nom_delr_tox_pmos10_sphv_10hv = 1.0
+    nom_delr_uch_pmos10_sphv_10hv = 1.002
+    nom_delr_res_pmos10_sphv_10hv = 1.0
+    nom_dela_vfb_pmos10_sphv_10hv = -0.005775
+    nom_dela_vtl_pmos10_sphv_10hv = 0.00305
+    nom_dela_vtw_pmos10_sphv_10hv = -0.0132
+    nom_dela_vtlw_pmos10_sphv_10hv = 0.0109
+    nom_dela_dl_pmos10_sphv_10hv = -3.82e-08
+    nom_dela_dw_pmos10_sphv_10hv = 4.81e-08
+    nom_dela_dlw_pmos10_sphv_10hv = -0.055
+    nom_dela_thesato_pmos10_sphv_10hv = 0.0
+    nom_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nom_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nom_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nom_dela_vdscalel_pmos10_sphv_10hv = -0.02
+    nom_dela_vdscaleo_pmos10_sphv_10hv = 0.02
+    sig_delr_tox_pmos10_sphv_10hv = 0.012
+    sig_delr_uch_pmos10_sphv_10hv = 2.842E-02
+    sig_delr_res_pmos10_sphv_10hv = 0
+    sig_dela_vfb_pmos10_sphv_10hv = 1.974E-02
+    sig_dela_vtl_pmos10_sphv_10hv = 2.289E-03
+    sig_dela_vtw_pmos10_sphv_10hv = 3.053E-04
+    sig_dela_vtlw_pmos10_sphv_10hv = 5.037E-04
+    sig_dela_dl_pmos10_sphv_10hv = 5.800E-08
+    sig_dela_dw_pmos10_sphv_10hv = 7.632E-09
+    sig_dela_dlw_pmos10_sphv_10hv = 9.158E-02
+    sig_dela_thesato_pmos10_sphv_10hv = 0
+    sig_dela_thesatl_pmos10_sphv_10hv = 0
+    sig_dela_thesatw_pmos10_sphv_10hv = 0
+    sig_dela_thesatlw_pmos10_sphv_10hv = 0
+    sig_dela_vdscalel_pmos10_sphv_10hv = 0
+    sig_dela_vdscaleo_pmos10_sphv_10hv = 1.211E-02
+    nom_delr_cj_pmos10_sphv_10hv = 1.0
+    nom_delr_is_pmos10_sphv_10hv = 1.0
+    nom_delr_is2_pmos10_sphv_10hv = 1.0
+    nom_delr_ir_pmos10_sphv_10hv = 1.0
+    sig_delr_cj_pmos10_sphv_10hv = 0.0333
+    sig_delr_is_pmos10_sphv_10hv = 0.055
+    sig_delr_is2_pmos10_sphv_10hv = 0.768
+    sig_delr_ir_pmos10_sphv_10hv = 0.768
+    fac_rth_pmos10_sphv_10hv  = 0.9
+    tc1_ecrit_pmos10_sphv_10hv = 0.0
+    tc2_ecrit_pmos10_sphv_10hv = 0.0
+    dwrjundo_pmos10_sphv_10hv = 1.8
+    dwrjunso_pmos10_sphv_10hv = 3.2
+    qmc_pmos10_sphv_10hv      = 1.0
+    lvaro_pmos10_sphv_10hv    = -3.8e-07
+    lvarl_pmos10_sphv_10hv    = -0.27
+    lvarw_pmos10_sphv_10hv    = -0.2
+    lap_pmos10_sphv_10hv      = 0.0
+    wvaro_pmos10_sphv_10hv    = -3.396e-07
+    wvarl_pmos10_sphv_10hv    = 0.0
+    wvarw_pmos10_sphv_10hv    = -0.29
+    wot_pmos10_sphv_10hv      = 0.0
+    dlq_pmos10_sphv_10hv      = 1.78e-07
+    dwq_pmos10_sphv_10hv      = 2.6e-07
+    vfbo_pmos10_sphv_10hv     = -0.9
+    vfbl_pmos10_sphv_10hv     = 0.0
+    vfbw_pmos10_sphv_10hv     = 0.0
+    vfblw_pmos10_sphv_10hv    = 0.02
+    stvfbo_pmos10_sphv_10hv   = 0.0011
+    stvfbl_pmos10_sphv_10hv   = -0.1
+    stvfbw_pmos10_sphv_10hv   = 0.0
+    stvfblw_pmos10_sphv_10hv  = 0.0
+    toxo_pmos10_sphv_10hv     = 1.27e-08
+    epsroxo_pmos10_sphv_10hv  = 3.9
+    nsubo_pmos10_sphv_10hv    = 9.71e+22
+    nsubw_pmos10_sphv_10hv    = -0.006
+    wseg_pmos10_sphv_10hv     = 1e-08
+    npck_pmos10_sphv_10hv     = 1e+23
+    npckw_pmos10_sphv_10hv    = 0.0
+    wsegp_pmos10_sphv_10hv    = 1e-08
+    lpck_pmos10_sphv_10hv     = 0.0
+    lpckw_pmos10_sphv_10hv    = 0.0
+    fol1_pmos10_sphv_10hv     = -0.17
+    fol2_pmos10_sphv_10hv     = 0.12
+    facneffaco_pmos10_sphv_10hv = 1.0
+    facneffacl_pmos10_sphv_10hv = 0.0
+    facneffacw_pmos10_sphv_10hv = 0.0
+    facneffaclw_pmos10_sphv_10hv = 0.0
+    gfacnudo_pmos10_sphv_10hv = 1.0
+    gfacnudl_pmos10_sphv_10hv = 0.0
+    gfacnudlexp_pmos10_sphv_10hv = 1.0
+    gfacnudw_pmos10_sphv_10hv = 0.0
+    gfacnudlw_pmos10_sphv_10hv = 0.0
+    vsbnudo_pmos10_sphv_10hv  = 0.0
+    dvsbnudo_pmos10_sphv_10hv = 1.0
+    vnsubo_pmos10_sphv_10hv   = 0.0
+    nslpo_pmos10_sphv_10hv    = 0.05
+    dnsubo_pmos10_sphv_10hv   = 0.035
+    dphibo_pmos10_sphv_10hv   = -0.015
+    dphibl_pmos10_sphv_10hv   = 0.016
+    dphiblexp_pmos10_sphv_10hv = 1.0
+    dphibw_pmos10_sphv_10hv   = 0.15
+    dphiblw_pmos10_sphv_10hv  = 0.0
+    delvtaco_pmos10_sphv_10hv = 0.0
+    delvtacl_pmos10_sphv_10hv = 0.0
+    delvtaclexp_pmos10_sphv_10hv = 1.0
+    delvtacw_pmos10_sphv_10hv = 0.0
+    delvtaclw_pmos10_sphv_10hv = 0.0
+    npo_pmos10_sphv_10hv      = 1e+26
+    npl_pmos10_sphv_10hv      = 0.0
+    cto_pmos10_sphv_10hv      = 0.0
+    ctl_pmos10_sphv_10hv      = 0.0
+    ctlexp_pmos10_sphv_10hv   = 1.0
+    ctw_pmos10_sphv_10hv      = 0.0
+    ctlw_pmos10_sphv_10hv     = 0.0
+    toxovo_pmos10_sphv_10hv   = 1.27e-08
+    toxovdo_pmos10_sphv_10hv  = 1.27e-08
+    lov_pmos10_sphv_10hv      = 7.4e-08
+    dlovd_pmos10_sphv_10hv    = 0.0
+    novo_pmos10_sphv_10hv     = 4.7e+23
+    novdo_pmos10_sphv_10hv    = 6e+22
+    cfl_pmos10_sphv_10hv      = 0.0
+    cflexp_pmos10_sphv_10hv   = 2.0
+    cfw_pmos10_sphv_10hv      = 0.0
+    cfbo_pmos10_sphv_10hv     = 0.0
+    uo_pmos10_sphv_10hv       = 0.0235
+    fbet1_pmos10_sphv_10hv    = 0.0
+    fbet1w_pmos10_sphv_10hv   = 0.0
+    lp1_pmos10_sphv_10hv      = 1e-08
+    lp1w_pmos10_sphv_10hv     = 0.0
+    fbet2_pmos10_sphv_10hv    = 0.0
+    lp2_pmos10_sphv_10hv      = 1e-08
+    betw1_pmos10_sphv_10hv    = 0.0
+    betw2_pmos10_sphv_10hv    = 0.0
+    wbet_pmos10_sphv_10hv     = 1e-09
+    stbeto_pmos10_sphv_10hv   = 1.0
+    stbetl_pmos10_sphv_10hv   = 0.21
+    stbetw_pmos10_sphv_10hv   = -0.11
+    stbetlw_pmos10_sphv_10hv  = -0.025
+    mueo_pmos10_sphv_10hv     = 3.45
+    muew_pmos10_sphv_10hv     = -0.195
+    stmueo_pmos10_sphv_10hv   = -0.2
+    themuo_pmos10_sphv_10hv   = 0.83
+    stthemuo_pmos10_sphv_10hv = 0.45
+    cso_pmos10_sphv_10hv      = 0.1
+    csl_pmos10_sphv_10hv      = 0.0
+    cslexp_pmos10_sphv_10hv   = 0.0
+    csw_pmos10_sphv_10hv      = 0.0
+    cslw_pmos10_sphv_10hv     = 0.0
+    stcso_pmos10_sphv_10hv    = 0.0
+    xcoro_pmos10_sphv_10hv    = 0.0
+    xcorl_pmos10_sphv_10hv    = 0.0
+    xcorw_pmos10_sphv_10hv    = 0.0
+    xcorlw_pmos10_sphv_10hv   = 0.0
+    stxcoro_pmos10_sphv_10hv  = 0.2
+    fetao_pmos10_sphv_10hv    = 1.32
+    rsw1_pmos10_sphv_10hv     = 0.0
+    rsw2_pmos10_sphv_10hv     = 0.0
+    strso_pmos10_sphv_10hv    = 0.0
+    rsbo_pmos10_sphv_10hv     = 0.0
+    rsgo_pmos10_sphv_10hv     = 0.0
+    thesato_pmos10_sphv_10hv  = 0.0
+    thesatl_pmos10_sphv_10hv  = 0.034
+    thesatlexp_pmos10_sphv_10hv = 2.0
+    thesatw_pmos10_sphv_10hv  = 0.0
+    thesatlw_pmos10_sphv_10hv = -0.12
+    stthesato_pmos10_sphv_10hv = 2.5
+    stthesatl_pmos10_sphv_10hv = 0.0
+    stthesatw_pmos10_sphv_10hv = 0.0
+    stthesatlw_pmos10_sphv_10hv = -0.2
+    thesatbo_pmos10_sphv_10hv = 0.25
+    thesatgo_pmos10_sphv_10hv = 5.6
+    thesatgl_pmos10_sphv_10hv = 0.0
+    thesatgw_pmos10_sphv_10hv = 0.0
+    axo_pmos10_sphv_10hv      = 13.0
+    axl_pmos10_sphv_10hv      = 1.5
+    alpl_pmos10_sphv_10hv     = 0.01
+    alplexp_pmos10_sphv_10hv  = 0.8
+    alpw_pmos10_sphv_10hv     = 0.0
+    alp1l1_pmos10_sphv_10hv   = 0.0
+    alp1lexp_pmos10_sphv_10hv = 1.0
+    alp1l2_pmos10_sphv_10hv   = 0.0
+    alp1w_pmos10_sphv_10hv    = 0.0
+    alp2l1_pmos10_sphv_10hv   = 0.0
+    alp2lexp_pmos10_sphv_10hv = 1.0
+    alp2l2_pmos10_sphv_10hv   = 0.0
+    alp2w_pmos10_sphv_10hv    = 0.0
+    vpo_pmos10_sphv_10hv      = 3.0
+    a1o_pmos10_sphv_10hv      = 0.0075
+    a1l_pmos10_sphv_10hv      = -0.1
+    a1w_pmos10_sphv_10hv      = -0.4
+    a2o_pmos10_sphv_10hv      = 57.0
+    sta2o_pmos10_sphv_10hv    = 0.15
+    a3o_pmos10_sphv_10hv      = 1.4
+    a3l_pmos10_sphv_10hv      = -0.12
+    a3w_pmos10_sphv_10hv      = 0.0
+    a4o_pmos10_sphv_10hv      = 0.0
+    a4l_pmos10_sphv_10hv      = 0.0
+    a4w_pmos10_sphv_10hv      = 0.0
+    gcoo_pmos10_sphv_10hv     = 0.0
+    iginvlw_pmos10_sphv_10hv  = 0.0
+    igovw_pmos10_sphv_10hv    = 0.0
+    igovdw_pmos10_sphv_10hv   = 0.0
+    stigo_pmos10_sphv_10hv    = 2.0
+    gc2o_pmos10_sphv_10hv     = 0.375
+    gc3o_pmos10_sphv_10hv     = 0.063
+    chibo_pmos10_sphv_10hv    = 3.1
+    agidlw_pmos10_sphv_10hv   = 1.9e-05
+    agidldw_pmos10_sphv_10hv  = 0.0
+    bgidlo_pmos10_sphv_10hv   = 5.2
+    bgidldo_pmos10_sphv_10hv  = 41.0
+    stbgidlo_pmos10_sphv_10hv = -0.0013
+    stbgidldo_pmos10_sphv_10hv = 0.0
+    cgidlo_pmos10_sphv_10hv   = 0.0
+    cgidldo_pmos10_sphv_10hv  = 0.0
+    cgbovl_pmos10_sphv_10hv   = 0.0
+    cfrw_pmos10_sphv_10hv     = 1.05e-16
+    cfrdw_pmos10_sphv_10hv    = 3e-17
+    fnto_pmos10_sphv_10hv     = 1.0
+    nfalw_pmos10_sphv_10hv    = 2e+25
+    nfblw_pmos10_sphv_10hv    = 30000000.0
+    nfclw_pmos10_sphv_10hv    = 4e-07
+    efo_pmos10_sphv_10hv      = 1.1
+    lintnoi_pmos10_sphv_10hv  = -2.5e-07
+    alpnoi_pmos10_sphv_10hv   = 2.0
+    kvthoweo_pmos10_sphv_10hv = 0.0
+    kvthowel_pmos10_sphv_10hv = 0.0
+    kvthowew_pmos10_sphv_10hv = 0.0
+    kvthowelw_pmos10_sphv_10hv = 0.0
+    kuoweo_pmos10_sphv_10hv   = 0.0
+    kuowel_pmos10_sphv_10hv   = 0.0
+    kuowew_pmos10_sphv_10hv   = 0.0
+    kuowelw_pmos10_sphv_10hv  = 0.0
+    rgo_pmos10_sphv_10hv      = 0.0
+    rsh_pmos10_sphv_10hv      = 0.0
+    rbulko_pmos10_sphv_10hv   = 0.0
+    rwello_pmos10_sphv_10hv   = 0.0
+    rjunso_pmos10_sphv_10hv   = 400.0
+    rjundo_pmos10_sphv_10hv   = 2250.0
+    rint_pmos10_sphv_10hv     = 0.0
+    rvpoly_pmos10_sphv_10hv   = 0.0
+    rshg_pmos10_sphv_10hv     = 0.0
+    dlsil_pmos10_sphv_10hv    = 0.0
+    saref_pmos10_sphv_10hv    = 1e-06
+    sbref_pmos10_sphv_10hv    = 1e-06
+    wlod_pmos10_sphv_10hv     = 0.0
+    kuo_pmos10_sphv_10hv      = 0.0
+    kvsat_pmos10_sphv_10hv    = 0.0
+    tkuo_pmos10_sphv_10hv     = 0.0
+    lkuo_pmos10_sphv_10hv     = 0.0
+    wkuo_pmos10_sphv_10hv     = 0.0
+    pkuo_pmos10_sphv_10hv     = 0.0
+    llodkuo_pmos10_sphv_10hv  = 0.0
+    wlodkuo_pmos10_sphv_10hv  = 0.0
+    kvtho_pmos10_sphv_10hv    = 0.0
+    lkvtho_pmos10_sphv_10hv   = 0.0
+    wkvtho_pmos10_sphv_10hv   = 0.0
+    pkvtho_pmos10_sphv_10hv   = 0.0
+    llodvth_pmos10_sphv_10hv  = 0.0
+    wlodvth_pmos10_sphv_10hv  = 0.0
+    stetao_pmos10_sphv_10hv   = 0.0
+    lodetao_pmos10_sphv_10hv  = 1.0
+    scref_pmos10_sphv_10hv    = 1e-05
+    web_pmos10_sphv_10hv      = 0.0
+    wec_pmos10_sphv_10hv      = 0.0
+    adr1o_pmos10_sphv_10hv    = 0.0
+    adr1l_pmos10_sphv_10hv    = 0.0
+    adr1w_pmos10_sphv_10hv    = 0.0
+    adr2o_pmos10_sphv_10hv    = 10.0
+    stadr2o_pmos10_sphv_10hv  = 0.0
+    adr3o_pmos10_sphv_10hv    = 0.0
+    adr3l_pmos10_sphv_10hv    = 0.0
+    adr3w_pmos10_sphv_10hv    = 0.0
+    adr4o_pmos10_sphv_10hv    = 0.0
+    adr4l_pmos10_sphv_10hv    = 0.0
+    adr4w_pmos10_sphv_10hv    = 0.0
+    adr5o_pmos10_sphv_10hv    = 0.0
+    adr5l_pmos10_sphv_10hv    = 0.0
+    adr5w_pmos10_sphv_10hv    = 0.0
+    bidr1o_pmos10_sphv_10hv   = 0.0
+    bidr1l_pmos10_sphv_10hv   = 0.0
+    bidr1w_pmos10_sphv_10hv   = 0.0
+    bidr2o_pmos10_sphv_10hv   = 0.0
+    bidr2w_pmos10_sphv_10hv   = 0.0
+    strtho_pmos10_sphv_10hv   = 0.0
+    rshldd_pmos10_sphv_10hv   = 24600.0
+    xw_pmos10_sphv_10hv       = -2.2e-07
+    nwxw_pmos10_sphv_10hv     = 2e-13
+    xl_pmos10_sphv_10hv       = 0.0
+    xlw_pmos10_sphv_10hv      = 0.0
+    dxlsat_pmos10_sphv_10hv   = 0.0
+    nst_pmos10_sphv_10hv      = 1.0
+    ats_pmos10_sphv_10hv      = 0.0
+    dfinf_pmos10_sphv_10hv    = 0.03
+    dfw_pmos10_sphv_10hv      = 1e-08
+    dfl_pmos10_sphv_10hv      = 0.0
+    dflw_pmos10_sphv_10hv     = 1.3e-14
+    dp_pmos10_sphv_10hv       = 2.0
+    ecrit_pmos10_sphv_10hv    = 22000000.0
+    ecorn_pmos10_sphv_10hv    = 500000.0
+    du_pmos10_sphv_10hv       = 0.02
+    tc1_pmos10_sphv_10hv      = 0.0036
+    tc2_pmos10_sphv_10hv      = 4.1e-06
+    tc1l_pmos10_sphv_10hv     = 0.0
+    tc2l_pmos10_sphv_10hv     = 0.0
+    tc1w_pmos10_sphv_10hv     = 0.0
+    tc2w_pmos10_sphv_10hv     = 0.0
+    theacc_pmos10_sphv_10hv   = 0.0
+    theacc2_pmos10_sphv_10hv  = 0.055
+    aacc_pmos10_sphv_10hv     = 36.0
+    rva_pmos10_sphv_10hv      = 1000.0
+    dta_pmos10_sphv_10hv      = 0.0
+    trj_pmos10_sphv_10hv      = 27.0
+    cjarea_pmos10_sphv_10hv   = 0.00093
+    cjlsti_pmos10_sphv_10hv   = 1.3e-10
+    cjlgat_pmos10_sphv_10hv   = 1.5e-10
+    vbiarea_pmos10_sphv_10hv  = 0.8
+    vbisti_pmos10_sphv_10hv   = 0.8
+    vbigat_pmos10_sphv_10hv   = 0.8
+    parea_pmos10_sphv_10hv    = 0.38
+    psti_pmos10_sphv_10hv     = 0.2
+    pgat_pmos10_sphv_10hv     = 0.38
+    is1area_pmos10_sphv_10hv  = 5.5e-08
+    ttarea_pmos10_sphv_10hv   = 2.35e-08
+    is2area_pmos10_sphv_10hv  = 1e-18
+    irarea_pmos10_sphv_10hv   = 1e-07
+    stis1area_pmos10_sphv_10hv = 4.0
+    stis2area_pmos10_sphv_10hv = 1.0
+    stirarea_pmos10_sphv_10hv = 1000.0
+    n1area_pmos10_sphv_10hv   = 1.0
+    n2area_pmos10_sphv_10hv   = 1.87
+    nrarea_pmos10_sphv_10hv   = 60.0
+    is1lsti_pmos10_sphv_10hv  = 1.5e-13
+    ttlsti_pmos10_sphv_10hv   = 2.35e-08
+    is2lsti_pmos10_sphv_10hv  = 2e-11
+    irlsti_pmos10_sphv_10hv   = 6e-11
+    stis1sti_pmos10_sphv_10hv = 5.0
+    stis2sti_pmos10_sphv_10hv = 1.0
+    stirsti_pmos10_sphv_10hv  = 1400.0
+    n1sti_pmos10_sphv_10hv    = 1.0
+    n2sti_pmos10_sphv_10hv    = 1.6
+    nrsti_pmos10_sphv_10hv    = 60.0
+    is1lgat_pmos10_sphv_10hv  = 1.9e-13
+    ttlgat_pmos10_sphv_10hv   = 2.35e-08
+    is2lgat_pmos10_sphv_10hv  = 1.6e-10
+    irlgat_pmos10_sphv_10hv   = 6e-11
+    stis1gat_pmos10_sphv_10hv = 5.0
+    stis2gat_pmos10_sphv_10hv = 1.0
+    stirgat_pmos10_sphv_10hv  = 1400.0
+    n1gat_pmos10_sphv_10hv    = 1.0
+    n2gat_pmos10_sphv_10hv    = 2.0
+    nrgat_pmos10_sphv_10hv    = 55.0
+    cjaread_pmos10_sphv_10hv  = 0.00015
+    cjlstid_pmos10_sphv_10hv  = 3.3e-10
+    cjlgatd_pmos10_sphv_10hv  = 6.2e-10
+    vbiaread_pmos10_sphv_10hv = 0.3
+    vbistid_pmos10_sphv_10hv  = 1.0
+    vbigatd_pmos10_sphv_10hv  = 0.49
+    paread_pmos10_sphv_10hv   = 0.23
+    pstid_pmos10_sphv_10hv    = 0.4
+    pgatd_pmos10_sphv_10hv    = 0.35
+    is1aread_pmos10_sphv_10hv = 2.5e-08
+    ttaread_pmos10_sphv_10hv  = 5.4e-08
+    is2aread_pmos10_sphv_10hv = 1e-09
+    iraread_pmos10_sphv_10hv  = 4e-05
+    stis1aread_pmos10_sphv_10hv = 4.0
+    stis2aread_pmos10_sphv_10hv = 1.0
+    stiraread_pmos10_sphv_10hv = 100000.0
+    n1aread_pmos10_sphv_10hv  = 1.0
+    n2aread_pmos10_sphv_10hv  = 1.5
+    nraread_pmos10_sphv_10hv  = 4500.0
+    ttlstid_pmos10_sphv_10hv  = 7e-08
+    irlstid_pmos10_sphv_10hv  = 4e-09
+    stis1stid_pmos10_sphv_10hv = 3.2
+    stis2stid_pmos10_sphv_10hv = 1.0
+    stirstid_pmos10_sphv_10hv = 100000.0
+    n1stid_pmos10_sphv_10hv   = 1.0
+    n2stid_pmos10_sphv_10hv   = 1.5
+    nrstid_pmos10_sphv_10hv   = 4500.0
+    ttlgatd_pmos10_sphv_10hv  = 5.4e-08
+    irlgatd_pmos10_sphv_10hv  = 2e-08
+    stis1gatd_pmos10_sphv_10hv = 5.0
+    stis2gatd_pmos10_sphv_10hv = 1.0
+    stirgatd_pmos10_sphv_10hv = 110000.0
+    n1gatd_pmos10_sphv_10hv   = 1.0
+    n2gatd_pmos10_sphv_10hv   = 1.5
+    nrgatd_pmos10_sphv_10hv   = 5000.0
+    vbiaread2_pmos10_sphv_10hv = 0.3
+    vbistid2_pmos10_sphv_10hv = 1.0
+    paread2_pmos10_sphv_10hv  = 0.23
+    pstid2_pmos10_sphv_10hv   = 0.4
+    ttaread2_pmos10_sphv_10hv = 5.4e-08
+    iraread2_pmos10_sphv_10hv = 4e-05
+    stiraread2_pmos10_sphv_10hv = 100000.0
+    n1aread2_pmos10_sphv_10hv = 1.0
+    n2aread2_pmos10_sphv_10hv = 1.6
+    nraread2_pmos10_sphv_10hv = 4500.0
+    ttlstid2_pmos10_sphv_10hv = 7e-08
+    irlstid2_pmos10_sphv_10hv = 4e-09
+    stis1stid2_pmos10_sphv_10hv = 3.2
+    stis2stid2_pmos10_sphv_10hv = 1.0
+    stirstid2_pmos10_sphv_10hv = 110000.0
+    n1stid2_pmos10_sphv_10hv  = 1.0
+    n2stid2_pmos10_sphv_10hv  = 1.7
+    nrstid2_pmos10_sphv_10hv  = 4500.0
+    eais1area_pmos10_sphv_10hv = 1.12
+    eais2area_pmos10_sphv_10hv = 1.12
+    eairarea_pmos10_sphv_10hv = 1.12
+    eais1sti_pmos10_sphv_10hv = 1.12
+    eais2sti_pmos10_sphv_10hv = 1.12
+    eairsti_pmos10_sphv_10hv  = 1.12
+    eais1gat_pmos10_sphv_10hv = 1.12
+    eais2gat_pmos10_sphv_10hv = 1.12
+    eairgat_pmos10_sphv_10hv  = 1.12
+    eais1aread_pmos10_sphv_10hv = 1.12
+    eais2aread_pmos10_sphv_10hv = 1.12
+    eairaread_pmos10_sphv_10hv = 1.12
+    eais1stid_pmos10_sphv_10hv = 1.12
+    eais2stid_pmos10_sphv_10hv = 1.12
+    eairstid_pmos10_sphv_10hv = 1.12
+    eais1gatd_pmos10_sphv_10hv = 1.12
+    eais2gatd_pmos10_sphv_10hv = 1.12
+    eairgatd_pmos10_sphv_10hv = 1.12
+    eais1aread2_pmos10_sphv_10hv = 1.12
+    eais2aread2_pmos10_sphv_10hv = 1.12
+    eairaread2_pmos10_sphv_10hv = 1.12
+    eais1stid2_pmos10_sphv_10hv = 1.12
+    eais2stid2_pmos10_sphv_10hv = 1.12
+    eairstid2_pmos10_sphv_10hv = 1.12
+    xvsat_pmos10_sphv_10hv    = -1.0
+    ikfarea_pmos10_sphv_10hv  = 5800000.0
+    stikfarea_pmos10_sphv_10hv = 0.0
+    ikfaread_pmos10_sphv_10hv = 1800000.0
+    dwikfaread_pmos10_sphv_10hv = 1.5
+    stikfaread_pmos10_sphv_10hv = 0.0
+    vdscalebo_pmos10_sphv_10hv = 0.005
+    vdscalebl_pmos10_sphv_10hv = 10.0
+    dwecrit_pmos10_sphv_10hv  = 0.0
+    dwecritw_pmos10_sphv_10hv = 0.0
+    is1lstid_pmos10_sphv_10hv = 5e-08
+    is1lgatd_pmos10_sphv_10hv = 6e-08
+    cjaread2_pmos10_sphv_10hv = 0.00015
+    cjlstid2_pmos10_sphv_10hv = 3.3e-10
+    is1aread2_pmos10_sphv_10hv = 4.5e-08
+    vdscale_pmos10_sphv_10hv  = 0.97
+    vdscalel_pmos10_sphv_10hv = 0.095
+    vdscaleo_pmos10_sphv_10hv = 0.0
+    is1lstid2_pmos10_sphv_10hv = 5e-08
+    is2lstid_pmos10_sphv_10hv = 2e-06
+    is2lgatd_pmos10_sphv_10hv = 3.5e-06
+    nom_delr_tox_nmos90b_sphv_10hv = 1.0
+    nom_delr_uch_nmos90b_sphv_10hv = 1.0
+    nom_delr_res_nmos90b_sphv_10hv = 1.0
+    nom_dela_vfb_nmos90b_sphv_10hv = 0.0
+    nom_dela_vtw_nmos90b_sphv_10hv = 0.0
+    nom_dela_vtl_nmos90b_sphv_10hv = 0.0
+    nom_dela_dw_nmos90b_sphv_10hv = 0.0
+    nom_dela_thesato_nmos90b_sphv_10hv = 0.0
+    nom_dela_lvaro_nmos90b_sphv_10hv = 0.0
+    nom_dela_vdscalel_nmos90b_sphv_10hv = 0.0
+    nom_delr_cj_nmos90b_sphv_10hv = 1.0
+    nom_delr_is_nmos90b_sphv_10hv = 1.0
+    nom_delr_is2_nmos90b_sphv_10hv = 1.0
+    nom_delr_ir_nmos90b_sphv_10hv = 1.0
+    sig_delr_tox_nmos90b_sphv_10hv = 0.012
+    sig_delr_uch_nmos90b_sphv_10hv = 0.034
+    sig_delr_res_nmos90b_sphv_10hv = 0.02
+    sig_dela_vfb_nmos90b_sphv_10hv = 0.0384
+    sig_dela_vtw_nmos90b_sphv_10hv = 0.0031
+    sig_dela_vtl_nmos90b_sphv_10hv = 0.001
+    sig_dela_dw_nmos90b_sphv_10hv = 0.0036667
+    sig_dela_thesato_nmos90b_sphv_10hv = 0.06
+    sig_dela_lvaro_nmos90b_sphv_10hv = 0.018
+    sig_dela_vdscalel_nmos90b_sphv_10hv = 0.015
+    sig_delr_cj_nmos90b_sphv_10hv = 0.0333
+    sig_delr_is_nmos90b_sphv_10hv = 0.055
+    sig_delr_is2_nmos90b_sphv_10hv = 0.768
+    sig_delr_ir_nmos90b_sphv_10hv = 0.768
+    fac_rth_nmos90b_sphv_10hv = 0.6
+    tc1_ecrit_nmos90b_sphv_10hv = 0.0
+    tc2_ecrit_nmos90b_sphv_10hv = 0.0
+    dwrjundo_nmos90b_sphv_10hv = 14.0
+    dwrjunso_nmos90b_sphv_10hv = 30.0
+    qmc_nmos90b_sphv_10hv     = 0.0
+    lvaro_nmos90b_sphv_10hv   = 2e-07
+    lvarl_nmos90b_sphv_10hv   = 0.0
+    lvarw_nmos90b_sphv_10hv   = -0.1
+    lap_nmos90b_sphv_10hv     = 0.0
+    wvaro_nmos90b_sphv_10hv   = -2.5e-07
+    wvarl_nmos90b_sphv_10hv   = 0.0
+    wvarw_nmos90b_sphv_10hv   = 0.0
+    wot_nmos90b_sphv_10hv     = 0.0
+    dlq_nmos90b_sphv_10hv     = -1.7e-07
+    dwq_nmos90b_sphv_10hv     = 4.6e-07
+    vfbo_nmos90b_sphv_10hv    = -0.96
+    vfbl_nmos90b_sphv_10hv    = 0.025
+    vfbw_nmos90b_sphv_10hv    = -0.016
+    vfblw_nmos90b_sphv_10hv   = 0.0
+    stvfbo_nmos90b_sphv_10hv  = 0.0008808
+    stvfbl_nmos90b_sphv_10hv  = 0.0
+    stvfbw_nmos90b_sphv_10hv  = 0.0
+    stvfblw_nmos90b_sphv_10hv = 1.0
+    toxo_nmos90b_sphv_10hv    = 1.346e-08
+    epsroxo_nmos90b_sphv_10hv = 3.9
+    nsubo_nmos90b_sphv_10hv   = 1.1e+23
+    nsubw_nmos90b_sphv_10hv   = 0.0
+    wseg_nmos90b_sphv_10hv    = 1e-09
+    npck_nmos90b_sphv_10hv    = 1e+23
+    npckw_nmos90b_sphv_10hv   = 0.0
+    wsegp_nmos90b_sphv_10hv   = 2.474e-06
+    lpck_nmos90b_sphv_10hv    = 0.0
+    lpckw_nmos90b_sphv_10hv   = 0.0
+    fol1_nmos90b_sphv_10hv    = -0.08
+    fol2_nmos90b_sphv_10hv    = 0.0
+    facneffaco_nmos90b_sphv_10hv = 1.0
+    facneffacl_nmos90b_sphv_10hv = 0.0
+    facneffacw_nmos90b_sphv_10hv = 0.0
+    facneffaclw_nmos90b_sphv_10hv = 0.0
+    gfacnudo_nmos90b_sphv_10hv = 1.0
+    gfacnudl_nmos90b_sphv_10hv = 0.0
+    gfacnudlexp_nmos90b_sphv_10hv = 1.0
+    gfacnudw_nmos90b_sphv_10hv = 0.0
+    gfacnudlw_nmos90b_sphv_10hv = 0.0
+    vsbnudo_nmos90b_sphv_10hv = 2.75
+    dvsbnudo_nmos90b_sphv_10hv = 1.0
+    vnsubo_nmos90b_sphv_10hv  = 0.0
+    nslpo_nmos90b_sphv_10hv   = 0.05
+    dnsubo_nmos90b_sphv_10hv  = 0.036
+    dphibo_nmos90b_sphv_10hv  = 0.0
+    dphibl_nmos90b_sphv_10hv  = 0.08
+    dphiblexp_nmos90b_sphv_10hv = 1.0
+    dphibw_nmos90b_sphv_10hv  = 0.0
+    dphiblw_nmos90b_sphv_10hv = 0.0
+    delvtaco_nmos90b_sphv_10hv = 0.0
+    delvtacl_nmos90b_sphv_10hv = 0.0
+    delvtaclexp_nmos90b_sphv_10hv = 1.0
+    delvtacw_nmos90b_sphv_10hv = 0.0
+    delvtaclw_nmos90b_sphv_10hv = 0.0
+    npo_nmos90b_sphv_10hv     = 1e+26
+    npl_nmos90b_sphv_10hv     = 0.0
+    cto_nmos90b_sphv_10hv     = 0.03
+    ctl_nmos90b_sphv_10hv     = 0.07
+    ctlexp_nmos90b_sphv_10hv  = 0.4772
+    ctw_nmos90b_sphv_10hv     = -0.09186
+    ctlw_nmos90b_sphv_10hv    = 0.0
+    toxovo_nmos90b_sphv_10hv  = 1.346e-08
+    toxovdo_nmos90b_sphv_10hv = 1.346e-08
+    lov_nmos90b_sphv_10hv     = 1.5e-07
+    dlovd_nmos90b_sphv_10hv   = 0.0
+    novo_nmos90b_sphv_10hv    = 2e+24
+    novdo_nmos90b_sphv_10hv   = 3e+22
+    cfl_nmos90b_sphv_10hv     = 0.0
+    cflexp_nmos90b_sphv_10hv  = 0.839
+    cfw_nmos90b_sphv_10hv     = 0.0
+    cfbo_nmos90b_sphv_10hv    = 2.22e-15
+    uo_nmos90b_sphv_10hv      = 0.0599
+    fbet1_nmos90b_sphv_10hv   = 0.0
+    fbet1w_nmos90b_sphv_10hv  = 0.0
+    lp1_nmos90b_sphv_10hv     = 1e-08
+    lp1w_nmos90b_sphv_10hv    = 0.0
+    fbet2_nmos90b_sphv_10hv   = 0.0
+    lp2_nmos90b_sphv_10hv     = 1e-08
+    betw1_nmos90b_sphv_10hv   = 0.0
+    betw2_nmos90b_sphv_10hv   = 0.0
+    wbet_nmos90b_sphv_10hv    = 0.0
+    stbeto_nmos90b_sphv_10hv  = 1.26
+    stbetl_nmos90b_sphv_10hv  = 0.0
+    stbetw_nmos90b_sphv_10hv  = -0.15
+    stbetlw_nmos90b_sphv_10hv = 0.35
+    mueo_nmos90b_sphv_10hv    = 1.23
+    muew_nmos90b_sphv_10hv    = -0.05
+    stmueo_nmos90b_sphv_10hv  = -0.2
+    themuo_nmos90b_sphv_10hv  = 1.85
+    stthemuo_nmos90b_sphv_10hv = 1.4
+    cso_nmos90b_sphv_10hv     = 0.0
+    csl_nmos90b_sphv_10hv     = 0.0
+    cslexp_nmos90b_sphv_10hv  = 0.0
+    csw_nmos90b_sphv_10hv     = 0.0
+    cslw_nmos90b_sphv_10hv    = 0.0
+    stcso_nmos90b_sphv_10hv   = 0.0
+    xcoro_nmos90b_sphv_10hv   = 0.065
+    xcorl_nmos90b_sphv_10hv   = 0.0
+    xcorw_nmos90b_sphv_10hv   = 0.0
+    xcorlw_nmos90b_sphv_10hv  = 0.0
+    stxcoro_nmos90b_sphv_10hv = 1.4
+    fetao_nmos90b_sphv_10hv   = 0.8
+    rsw1_nmos90b_sphv_10hv    = 0.0
+    rsw2_nmos90b_sphv_10hv    = 0.0
+    strso_nmos90b_sphv_10hv   = 0.0
+    rsbo_nmos90b_sphv_10hv    = 0.0
+    rsgo_nmos90b_sphv_10hv    = 0.0
+    thesato_nmos90b_sphv_10hv = 0.0
+    thesatl_nmos90b_sphv_10hv = 0.98
+    thesatlexp_nmos90b_sphv_10hv = 1.0
+    thesatw_nmos90b_sphv_10hv = -0.7
+    thesatlw_nmos90b_sphv_10hv = 0.15
+    stthesato_nmos90b_sphv_10hv = 0.5
+    stthesatl_nmos90b_sphv_10hv = 0.0
+    stthesatw_nmos90b_sphv_10hv = 0.0
+    stthesatlw_nmos90b_sphv_10hv = 12.0
+    thesatbo_nmos90b_sphv_10hv = 0.0
+    thesatgo_nmos90b_sphv_10hv = 0.02
+    thesatgl_nmos90b_sphv_10hv = 0.0
+    thesatgw_nmos90b_sphv_10hv = 0.0
+    axo_nmos90b_sphv_10hv     = 7.0
+    axl_nmos90b_sphv_10hv     = 0.0
+    alpl_nmos90b_sphv_10hv    = 0.0
+    alplexp_nmos90b_sphv_10hv = 1.0
+    alpw_nmos90b_sphv_10hv    = 0.0
+    alp1l1_nmos90b_sphv_10hv  = 0.0
+    alp1lexp_nmos90b_sphv_10hv = 0.5
+    alp1l2_nmos90b_sphv_10hv  = 0.0
+    alp1w_nmos90b_sphv_10hv   = 0.0
+    alp2l1_nmos90b_sphv_10hv  = 0.0
+    alp2lexp_nmos90b_sphv_10hv = 1.0
+    alp2l2_nmos90b_sphv_10hv  = 0.0
+    alp2w_nmos90b_sphv_10hv   = 0.0
+    vpo_nmos90b_sphv_10hv     = 10.0
+    a1o_nmos90b_sphv_10hv     = 0.006
+    a1l_nmos90b_sphv_10hv     = -0.3
+    a1w_nmos90b_sphv_10hv     = 0.0
+    a2o_nmos90b_sphv_10hv     = 56.0
+    sta2o_nmos90b_sphv_10hv   = 0.4
+    a3o_nmos90b_sphv_10hv     = 1.3
+    a3l_nmos90b_sphv_10hv     = 3.0
+    a3w_nmos90b_sphv_10hv     = 0.0
+    a4o_nmos90b_sphv_10hv     = 0.0
+    a4l_nmos90b_sphv_10hv     = 0.0
+    a4w_nmos90b_sphv_10hv     = 0.0
+    gcoo_nmos90b_sphv_10hv    = 0.0
+    iginvlw_nmos90b_sphv_10hv = 0.0
+    igovw_nmos90b_sphv_10hv   = 0.0
+    igovdw_nmos90b_sphv_10hv  = 0.0
+    stigo_nmos90b_sphv_10hv   = 2.0
+    gc2o_nmos90b_sphv_10hv    = 0.375
+    gc3o_nmos90b_sphv_10hv    = 0.063
+    chibo_nmos90b_sphv_10hv   = 3.1
+    agidlw_nmos90b_sphv_10hv  = 0.0005
+    agidldw_nmos90b_sphv_10hv = 0.0
+    bgidlo_nmos90b_sphv_10hv  = 14.0
+    bgidldo_nmos90b_sphv_10hv = 10.0
+    stbgidlo_nmos90b_sphv_10hv = -0.0005
+    stbgidldo_nmos90b_sphv_10hv = 0.0
+    cgidlo_nmos90b_sphv_10hv  = 0.0
+    cgidldo_nmos90b_sphv_10hv = 0.0
+    cgbovl_nmos90b_sphv_10hv  = 0.0
+    cfrw_nmos90b_sphv_10hv    = 0.0
+    cfrdw_nmos90b_sphv_10hv   = 0.0
+    fnto_nmos90b_sphv_10hv    = 1.0
+    nfalw_nmos90b_sphv_10hv   = 2.5e+25
+    nfblw_nmos90b_sphv_10hv   = 0.0
+    nfclw_nmos90b_sphv_10hv   = 7e-08
+    efo_nmos90b_sphv_10hv     = 1.0
+    lintnoi_nmos90b_sphv_10hv = 0.0
+    alpnoi_nmos90b_sphv_10hv  = 2.0
+    kvthoweo_nmos90b_sphv_10hv = 0.0
+    kvthowel_nmos90b_sphv_10hv = 0.0
+    kvthowew_nmos90b_sphv_10hv = 0.0
+    kvthowelw_nmos90b_sphv_10hv = 0.0
+    kuoweo_nmos90b_sphv_10hv  = 0.0
+    kuowel_nmos90b_sphv_10hv  = 0.0
+    kuowew_nmos90b_sphv_10hv  = 0.0
+    kuowelw_nmos90b_sphv_10hv = 0.0
+    rgo_nmos90b_sphv_10hv     = 0.0
+    rsh_nmos90b_sphv_10hv     = 0.0
+    rbulko_nmos90b_sphv_10hv  = 0.0
+    rwello_nmos90b_sphv_10hv  = 0.0
+    rjunso_nmos90b_sphv_10hv  = 1800.0
+    rjundo_nmos90b_sphv_10hv  = 2300.0
+    rint_nmos90b_sphv_10hv    = 0.0
+    rvpoly_nmos90b_sphv_10hv  = 0.0
+    rshg_nmos90b_sphv_10hv    = 0.0
+    dlsil_nmos90b_sphv_10hv   = 0.0
+    saref_nmos90b_sphv_10hv   = 1e-06
+    sbref_nmos90b_sphv_10hv   = 1e-06
+    wlod_nmos90b_sphv_10hv    = 0.0
+    kuo_nmos90b_sphv_10hv     = 0.0
+    kvsat_nmos90b_sphv_10hv   = 0.0
+    tkuo_nmos90b_sphv_10hv    = 0.0
+    lkuo_nmos90b_sphv_10hv    = 0.0
+    wkuo_nmos90b_sphv_10hv    = 0.0
+    pkuo_nmos90b_sphv_10hv    = 0.0
+    llodkuo_nmos90b_sphv_10hv = 0.0
+    wlodkuo_nmos90b_sphv_10hv = 0.0
+    kvtho_nmos90b_sphv_10hv   = 0.0
+    lkvtho_nmos90b_sphv_10hv  = 0.0
+    wkvtho_nmos90b_sphv_10hv  = 0.0
+    pkvtho_nmos90b_sphv_10hv  = 0.0
+    llodvth_nmos90b_sphv_10hv = 0.0
+    wlodvth_nmos90b_sphv_10hv = 0.0
+    stetao_nmos90b_sphv_10hv  = 0.0
+    lodetao_nmos90b_sphv_10hv = 1.0
+    scref_nmos90b_sphv_10hv   = 1e-05
+    web_nmos90b_sphv_10hv     = 0.0
+    wec_nmos90b_sphv_10hv     = 0.0
+    adr1o_nmos90b_sphv_10hv   = 0.005
+    adr1l_nmos90b_sphv_10hv   = 0.0
+    adr1w_nmos90b_sphv_10hv   = 0.0
+    adr2o_nmos90b_sphv_10hv   = 11.0
+    stadr2o_nmos90b_sphv_10hv = 1.0
+    adr3o_nmos90b_sphv_10hv   = 0.0
+    adr3l_nmos90b_sphv_10hv   = 0.0
+    adr3w_nmos90b_sphv_10hv   = 0.0
+    adr4o_nmos90b_sphv_10hv   = 0.0
+    adr4l_nmos90b_sphv_10hv   = 0.0
+    adr4w_nmos90b_sphv_10hv   = 0.0
+    adr5o_nmos90b_sphv_10hv   = 0.0
+    adr5l_nmos90b_sphv_10hv   = 0.0
+    adr5w_nmos90b_sphv_10hv   = 0.0
+    bidr1o_nmos90b_sphv_10hv  = 0.0
+    bidr1l_nmos90b_sphv_10hv  = 0.0
+    bidr1w_nmos90b_sphv_10hv  = 0.0
+    bidr2o_nmos90b_sphv_10hv  = 0.0
+    bidr2w_nmos90b_sphv_10hv  = 0.0
+    rtho_nmos90b_sphv_10hv    = 650.0
+    rthl_nmos90b_sphv_10hv    = 0.0
+    rthw_nmos90b_sphv_10hv    = 0.0
+    rthlw_nmos90b_sphv_10hv   = 0.0
+    strtho_nmos90b_sphv_10hv  = 0.6
+    ctho_nmos90b_sphv_10hv    = 0.0
+    cthl_nmos90b_sphv_10hv    = 0.0
+    cthw_nmos90b_sphv_10hv    = 0.0
+    cthlw_nmos90b_sphv_10hv   = 0.0
+    rshldd_nmos90b_sphv_10hv  = 4550.0
+    xw_nmos90b_sphv_10hv      = 1.8e-06
+    nwxw_nmos90b_sphv_10hv    = 0.0
+    xl_nmos90b_sphv_10hv      = 0.0
+    xlw_nmos90b_sphv_10hv     = 0.0
+    dxlsat_nmos90b_sphv_10hv  = 3e-07
+    nst_nmos90b_sphv_10hv     = 1.0
+    ats_nmos90b_sphv_10hv     = 0.0
+    dfinf_nmos90b_sphv_10hv   = 0.055
+    dfw_nmos90b_sphv_10hv     = 5e-08
+    dfl_nmos90b_sphv_10hv     = 0.0
+    dflw_nmos90b_sphv_10hv    = 0.0
+    dp_nmos90b_sphv_10hv      = 2.0
+    ecrit_nmos90b_sphv_10hv   = 1300000.0
+    ecorn_nmos90b_sphv_10hv   = 350000.0
+    xvsat_nmos90b_sphv_10hv   = -0.3
+    du_nmos90b_sphv_10hv      = 0.25
+    tc1_nmos90b_sphv_10hv     = 0.0054
+    tc2_nmos90b_sphv_10hv     = 1.37e-05
+    tc1l_nmos90b_sphv_10hv    = 0.0
+    tc2l_nmos90b_sphv_10hv    = 0.0
+    tc1w_nmos90b_sphv_10hv    = -3e-09
+    tc2w_nmos90b_sphv_10hv    = 0.0
+    theacc_nmos90b_sphv_10hv  = 0.0
+    theacc2_nmos90b_sphv_10hv = 0.055
+    aacc_nmos90b_sphv_10hv    = 36.0
+    rva_nmos90b_sphv_10hv     = 500.0
+    dta_nmos90b_sphv_10hv     = 0.0
+    trj_nmos90b_sphv_10hv     = 27.0
+    cjarea_nmos90b_sphv_10hv  = 0.00035
+    cjlsti_nmos90b_sphv_10hv  = 0.0
+    cjlgat_nmos90b_sphv_10hv  = 6e-10
+    vbiarea_nmos90b_sphv_10hv = 0.7
+    vbisti_nmos90b_sphv_10hv  = 0.7
+    vbigat_nmos90b_sphv_10hv  = 0.7
+    parea_nmos90b_sphv_10hv   = 0.3
+    psti_nmos90b_sphv_10hv    = 0.3
+    pgat_nmos90b_sphv_10hv    = 0.3
+    is1area_nmos90b_sphv_10hv = 4.8e-08
+    ttarea_nmos90b_sphv_10hv  = 1e-08
+    is2area_nmos90b_sphv_10hv = 0.0001
+    irarea_nmos90b_sphv_10hv  = 5e-05
+    stis1area_nmos90b_sphv_10hv = 3.0
+    stis2area_nmos90b_sphv_10hv = 5.0
+    stirarea_nmos90b_sphv_10hv = 1000.0
+    n1area_nmos90b_sphv_10hv  = 1.03
+    n2area_nmos90b_sphv_10hv  = 2.0
+    nrarea_nmos90b_sphv_10hv  = 47.0
+    is1lsti_nmos90b_sphv_10hv = 1.2e-13
+    ttlsti_nmos90b_sphv_10hv  = 1e-08
+    is2lsti_nmos90b_sphv_10hv = 5e-11
+    irlsti_nmos90b_sphv_10hv  = 2e-11
+    stis1sti_nmos90b_sphv_10hv = 3.0
+    stis2sti_nmos90b_sphv_10hv = 5.0
+    stirsti_nmos90b_sphv_10hv = 1000.0
+    n1sti_nmos90b_sphv_10hv   = 1.03
+    n2sti_nmos90b_sphv_10hv   = 2.0
+    nrsti_nmos90b_sphv_10hv   = 47.0
+    is1lgat_nmos90b_sphv_10hv = 1.2e-13
+    ttlgat_nmos90b_sphv_10hv  = 1e-08
+    is2lgat_nmos90b_sphv_10hv = 5e-11
+    irlgat_nmos90b_sphv_10hv  = 4e-11
+    stis1gat_nmos90b_sphv_10hv = 3.0
+    stis2gat_nmos90b_sphv_10hv = 5.0
+    stirgat_nmos90b_sphv_10hv = 1000.0
+    n1gat_nmos90b_sphv_10hv   = 1.03
+    n2gat_nmos90b_sphv_10hv   = 2.0
+    nrgat_nmos90b_sphv_10hv   = 47.0
+    cjaread_nmos90b_sphv_10hv = 0.000127
+    cjlstid_nmos90b_sphv_10hv = 1e-10
+    cjlgatd_nmos90b_sphv_10hv = 2.5e-10
+    vbiaread_nmos90b_sphv_10hv = 0.5
+    vbistid_nmos90b_sphv_10hv = 0.5
+    vbigatd_nmos90b_sphv_10hv = 0.5
+    paread_nmos90b_sphv_10hv  = 0.37
+    pstid_nmos90b_sphv_10hv   = 0.37
+    pgatd_nmos90b_sphv_10hv   = 0.37
+    is1aread_nmos90b_sphv_10hv = 3e-08
+    ttaread_nmos90b_sphv_10hv = 1e-07
+    is2aread_nmos90b_sphv_10hv = 1e-05
+    iraread_nmos90b_sphv_10hv = 1e-06
+    stis1aread_nmos90b_sphv_10hv = 3.0
+    stis2aread_nmos90b_sphv_10hv = 10.0
+    stiraread_nmos90b_sphv_10hv = 15000.0
+    n1aread_nmos90b_sphv_10hv = 1.03
+    n2aread_nmos90b_sphv_10hv = 2.0
+    nraread_nmos90b_sphv_10hv = 700.0
+    is1lstid_nmos90b_sphv_10hv = 0
+    ttlstid_nmos90b_sphv_10hv = 1e-07
+    is2lstid_nmos90b_sphv_10hv = 0.0
+    irlstid_nmos90b_sphv_10hv = 2e-12
+    stis1stid_nmos90b_sphv_10hv = 3.0
+    stis2stid_nmos90b_sphv_10hv = 10.0
+    stirstid_nmos90b_sphv_10hv = 15000.0
+    n1stid_nmos90b_sphv_10hv  = 1.03
+    n2stid_nmos90b_sphv_10hv  = 2.0
+    nrstid_nmos90b_sphv_10hv  = 700.0
+    is1lgatd_nmos90b_sphv_10hv = 0
+    ttlgatd_nmos90b_sphv_10hv = 1e-07
+    is2lgatd_nmos90b_sphv_10hv = 0.0
+    irlgatd_nmos90b_sphv_10hv = 2e-12
+    stis1gatd_nmos90b_sphv_10hv = 3.0
+    stis2gatd_nmos90b_sphv_10hv = 10.0
+    stirgatd_nmos90b_sphv_10hv = 15000.0
+    n1gatd_nmos90b_sphv_10hv  = 1.03
+    n2gatd_nmos90b_sphv_10hv  = 2.0
+    nrgatd_nmos90b_sphv_10hv  = 700.0
+    cjaread2_nmos90b_sphv_10hv = 1e-12
+    cjlstid2_nmos90b_sphv_10hv = 1e-18
+    vbiaread2_nmos90b_sphv_10hv = 0.5
+    vbistid2_nmos90b_sphv_10hv = 0.5
+    paread2_nmos90b_sphv_10hv = 0.37
+    pstid2_nmos90b_sphv_10hv  = 0.37
+    is1aread2_nmos90b_sphv_10hv = 0
+    ttaread2_nmos90b_sphv_10hv = 1e-07
+    is2aread2_nmos90b_sphv_10hv = 0.0
+    iraread2_nmos90b_sphv_10hv = 1e-06
+    stis1aread2_nmos90b_sphv_10hv = 25
+    stis2aread2_nmos90b_sphv_10hv = 15
+    stiraread2_nmos90b_sphv_10hv = 15000.0
+    n1aread2_nmos90b_sphv_10hv = 1.03
+    n2aread2_nmos90b_sphv_10hv = 2.0
+    nraread2_nmos90b_sphv_10hv = 700.0
+    is1lstid2_nmos90b_sphv_10hv = 0
+    ttlstid2_nmos90b_sphv_10hv = 1e-07
+    is2lstid2_nmos90b_sphv_10hv = 0.0
+    irlstid2_nmos90b_sphv_10hv = 2e-12
+    stis1stid2_nmos90b_sphv_10hv = 3.0
+    stis2stid2_nmos90b_sphv_10hv = 10.0
+    stirstid2_nmos90b_sphv_10hv = 15000.0
+    n1stid2_nmos90b_sphv_10hv = 1.03
+    n2stid2_nmos90b_sphv_10hv = 2.0
+    nrstid2_nmos90b_sphv_10hv = 700.0
+    eais1area_nmos90b_sphv_10hv = 1.12
+    eais2area_nmos90b_sphv_10hv = 1.12
+    eairarea_nmos90b_sphv_10hv = 1.12
+    eais1sti_nmos90b_sphv_10hv = 1.12
+    eais2sti_nmos90b_sphv_10hv = 1.12
+    eairsti_nmos90b_sphv_10hv = 1.12
+    eais1gat_nmos90b_sphv_10hv = 1.12
+    eais2gat_nmos90b_sphv_10hv = 1.12
+    eairgat_nmos90b_sphv_10hv = 1.12
+    eais1aread_nmos90b_sphv_10hv = 1.12
+    eais2aread_nmos90b_sphv_10hv = 1.12
+    eairaread_nmos90b_sphv_10hv = 1.12
+    eais1stid_nmos90b_sphv_10hv = 1.12
+    eais2stid_nmos90b_sphv_10hv = 1.12
+    eairstid_nmos90b_sphv_10hv = 1.12
+    eais1gatd_nmos90b_sphv_10hv = 1.12
+    eais2gatd_nmos90b_sphv_10hv = 1.12
+    eairgatd_nmos90b_sphv_10hv = 1.12
+    eais1aread2_nmos90b_sphv_10hv = 1.12
+    eais2aread2_nmos90b_sphv_10hv = 1.12
+    eairaread2_nmos90b_sphv_10hv = 1.12
+    eais1stid2_nmos90b_sphv_10hv = 1.12
+    eais2stid2_nmos90b_sphv_10hv = 1.12
+    eairstid2_nmos90b_sphv_10hv = 1.12
+    vdscale_nmos90b_sphv_10hv = 0.9
+    vdscalel_nmos90b_sphv_10hv = 0.22
+    vdscalew_nmos90b_sphv_10hv = 0.0
+    vdscalelw_nmos90b_sphv_10hv = 0.0
+    vdscaleb_nmos90b_sphv_10hv = 0.0
+    vdscalebl_nmos90b_sphv_10hv = 0.0
+    stvdscale_nmos90b_sphv_10hv = 0.0
+    ikfarea_nmos90b_sphv_10hv = 1000000000.0
+    stikfarea_nmos90b_sphv_10hv = 0.0
+    ikfaread_nmos90b_sphv_10hv = 5800000.0
+    dwikfaread_nmos90b_sphv_10hv = 14.0
+    stikfaread_nmos90b_sphv_10hv = 0.0
+    dwecrit_nmos90b_sphv_10hv = -0.65
+    dwecritw_nmos90b_sphv_10hv = 0.0
+    nom_delr_tox_nmos120_sphv_10hv = 1.0
+    nom_delr_uch_nmos120_sphv_10hv = 1.0
+    nom_delr_res_nmos120_sphv_10hv = 0.994
+    nom_dela_vfb_nmos120_sphv_10hv = -0.0017
+    nom_dela_vtw_nmos120_sphv_10hv = 0.014
+    nom_dela_vtl_nmos120_sphv_10hv = -0.0047
+    nom_dela_vtlw_nmos120_sphv_10hv = -0.004
+    nom_dela_dw_nmos120_sphv_10hv = 0.0
+    nom_dela_thesato_nmos120_sphv_10hv = 0.0
+    nom_dela_lvaro_nmos120_sphv_10hv = 0.02
+    nom_dela_vdscale_nmos120_sphv_10hv = -0.034
+    nom_dela_vdscalel_nmos120_sphv_10hv = 0.115
+    nom_dela_vdscalew_nmos120_sphv_10hv = -0.123
+    nom_dela_vdscalelw_nmos120_sphv_10hv = -0.49
+    nom_dela_xw_nmos120_sphv_10hv = -1.97e-07
+    nom_dela_lvarw_nmos120_sphv_10hv = -1.8
+    nom_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nom_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nom_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nom_delr_cj_nmos120_sphv_10hv = 1.0
+    nom_delr_is_nmos120_sphv_10hv = 1.0
+    nom_delr_is2_nmos120_sphv_10hv = 1.0
+    nom_delr_ir_nmos120_sphv_10hv = 1.0
+    sig_delr_tox_nmos120_sphv_10hv = 0.012
+    sig_delr_uch_nmos120_sphv_10hv = 0.02
+    sig_delr_res_nmos120_sphv_10hv = 0.05
+    sig_dela_vfb_nmos120_sphv_10hv = 0.015
+    sig_dela_vtw_nmos120_sphv_10hv = 0.0015
+    sig_dela_vtl_nmos120_sphv_10hv = 0.007
+    sig_dela_vtlw_nmos120_sphv_10hv = 0.003
+    sig_dela_dw_nmos120_sphv_10hv = 0.013
+    sig_dela_thesato_nmos120_sphv_10hv = 0.1
+    sig_dela_lvaro_nmos120_sphv_10hv = 0.012
+    sig_dela_vdscale_nmos120_sphv_10hv = 0.015
+    sig_dela_vdscalel_nmos120_sphv_10hv = 0.08
+    sig_dela_vdscalew_nmos120_sphv_10hv = 0.02
+    sig_dela_vdscalelw_nmos120_sphv_10hv = 0.055
+    sig_dela_xw_nmos120_sphv_10hv = 1.5e-7
+    sig_dela_lvarw_nmos120_sphv_10hv = 0.025
+    sig_dela_thesatw_nmos120_sphv_10hv = 0
+    sig_dela_thesatl_nmos120_sphv_10hv = 0
+    sig_dela_thesatlw_nmos120_sphv_10hv = 0
+    sig_delr_cj_nmos120_sphv_10hv = 0.0333
+    sig_delr_is_nmos120_sphv_10hv = 0.055
+    sig_delr_is2_nmos120_sphv_10hv = 0.768
+    sig_delr_ir_nmos120_sphv_10hv = 0.768
+    fac_rth_nmos120_sphv_10hv = 0.5
+    tc1_ecrit_nmos120_sphv_10hv = 0.0003
+    tc2_ecrit_nmos120_sphv_10hv = 0.0
+    dwrjundo_nmos120_sphv_10hv = 15
+    dwrjunso_nmos120_sphv_10hv = 23.0
+    qmc_nmos120_sphv_10hv     = 0.0
+    lvaro_nmos120_sphv_10hv   = 2.0000000000000002e-07
+    lvarl_nmos120_sphv_10hv   = 0.0
+    lvarw_nmos120_sphv_10hv   = 2.0
+    lap_nmos120_sphv_10hv     = 0.0
+    wvaro_nmos120_sphv_10hv   = -2.5000000000000004e-07
+    wvarl_nmos120_sphv_10hv   = 0.0
+    wvarw_nmos120_sphv_10hv   = 0.0
+    wot_nmos120_sphv_10hv     = 0.0
+    dlq_nmos120_sphv_10hv     = -1.2e-07
+    dwq_nmos120_sphv_10hv     = 2.2e-07
+    vfbo_nmos120_sphv_10hv    = -0.898
+    vfbl_nmos120_sphv_10hv    = -0.045
+    vfbw_nmos120_sphv_10hv    = -0.02
+    vfblw_nmos120_sphv_10hv   = -0.005
+    stvfbo_nmos120_sphv_10hv  = 0.0008808
+    stvfbl_nmos120_sphv_10hv  = 0.05
+    stvfbw_nmos120_sphv_10hv  = 0.0
+    stvfblw_nmos120_sphv_10hv = 0.6
+    toxo_nmos120_sphv_10hv    = 1.346e-08
+    epsroxo_nmos120_sphv_10hv = 3.9
+    nsubo_nmos120_sphv_10hv   = 1.1e+23
+    nsubw_nmos120_sphv_10hv   = 0.0
+    wseg_nmos120_sphv_10hv    = 1e-09
+    npck_nmos120_sphv_10hv    = 1e+23
+    npckw_nmos120_sphv_10hv   = 0.0
+    wsegp_nmos120_sphv_10hv   = 2.474e-06
+    lpck_nmos120_sphv_10hv    = 0.0
+    lpckw_nmos120_sphv_10hv   = 0.0
+    fol1_nmos120_sphv_10hv    = -0.08
+    fol2_nmos120_sphv_10hv    = 0.0
+    facneffaco_nmos120_sphv_10hv = 1.0
+    facneffacl_nmos120_sphv_10hv = 0.0
+    facneffacw_nmos120_sphv_10hv = 0.0
+    facneffaclw_nmos120_sphv_10hv = 0.0
+    gfacnudo_nmos120_sphv_10hv = 1.0
+    gfacnudl_nmos120_sphv_10hv = 0.0
+    gfacnudlexp_nmos120_sphv_10hv = 1.0
+    gfacnudw_nmos120_sphv_10hv = 0.0
+    gfacnudlw_nmos120_sphv_10hv = 0.0
+    vsbnudo_nmos120_sphv_10hv = 2.75
+    dvsbnudo_nmos120_sphv_10hv = 1.0
+    vnsubo_nmos120_sphv_10hv  = 0.0
+    nslpo_nmos120_sphv_10hv   = 0.05
+    dnsubo_nmos120_sphv_10hv  = 0.036
+    dphibo_nmos120_sphv_10hv  = 0.0
+    dphibl_nmos120_sphv_10hv  = 0.01
+    dphiblexp_nmos120_sphv_10hv = 1.0
+    dphibw_nmos120_sphv_10hv  = 0.0
+    dphiblw_nmos120_sphv_10hv = 0.0
+    delvtaco_nmos120_sphv_10hv = 0.0
+    delvtacl_nmos120_sphv_10hv = 0.0
+    delvtaclexp_nmos120_sphv_10hv = 1.0
+    delvtacw_nmos120_sphv_10hv = 0.0
+    delvtaclw_nmos120_sphv_10hv = 0.0
+    npo_nmos120_sphv_10hv     = 3.5e+25
+    npl_nmos120_sphv_10hv     = 0.0
+    cto_nmos120_sphv_10hv     = 0.03
+    ctl_nmos120_sphv_10hv     = 0.07
+    ctlexp_nmos120_sphv_10hv  = 0.4772
+    ctw_nmos120_sphv_10hv     = -0.09186
+    ctlw_nmos120_sphv_10hv    = 0.0
+    toxovo_nmos120_sphv_10hv  = 1.346e-08
+    toxovdo_nmos120_sphv_10hv = 1.346e-08
+    lov_nmos120_sphv_10hv     = 1.1500000000000001e-07
+    dlovd_nmos120_sphv_10hv   = -1.0000000000000001e-07
+    novo_nmos120_sphv_10hv    = 2e+24
+    novdo_nmos120_sphv_10hv   = 3e+22
+    cfl_nmos120_sphv_10hv     = 0.0
+    cflexp_nmos120_sphv_10hv  = 0.839
+    cfw_nmos120_sphv_10hv     = 0.0
+    cfbo_nmos120_sphv_10hv    = 2.22e-15
+    uo_nmos120_sphv_10hv      = 0.061
+    fbet1_nmos120_sphv_10hv   = 0.0
+    fbet1w_nmos120_sphv_10hv  = 0.0
+    lp1_nmos120_sphv_10hv     = 1e-08
+    lp1w_nmos120_sphv_10hv    = 0.0
+    fbet2_nmos120_sphv_10hv   = 0.0
+    lp2_nmos120_sphv_10hv     = 1e-08
+    betw1_nmos120_sphv_10hv   = 0.0
+    betw2_nmos120_sphv_10hv   = 0.0
+    wbet_nmos120_sphv_10hv    = 0.0
+    stbeto_nmos120_sphv_10hv  = 1.16
+    stbetl_nmos120_sphv_10hv  = -0.1
+    stbetw_nmos120_sphv_10hv  = -0.35000000000000003
+    stbetlw_nmos120_sphv_10hv = 0.35000000000000003
+    mueo_nmos120_sphv_10hv    = 1.42
+    muew_nmos120_sphv_10hv    = -0.05
+    stmueo_nmos120_sphv_10hv  = -0.6
+    themuo_nmos120_sphv_10hv  = 1.85
+    stthemuo_nmos120_sphv_10hv = 1.4
+    cso_nmos120_sphv_10hv     = 0.0
+    csl_nmos120_sphv_10hv     = 0.0
+    cslexp_nmos120_sphv_10hv  = 0.0
+    csw_nmos120_sphv_10hv     = 0.0
+    cslw_nmos120_sphv_10hv    = 0.0
+    stcso_nmos120_sphv_10hv   = 0.0
+    xcoro_nmos120_sphv_10hv   = 0.115
+    xcorl_nmos120_sphv_10hv   = 0.0
+    xcorw_nmos120_sphv_10hv   = 0.0
+    xcorlw_nmos120_sphv_10hv  = -0.6
+    stxcoro_nmos120_sphv_10hv = 0.7
+    fetao_nmos120_sphv_10hv   = 0.8
+    rsw1_nmos120_sphv_10hv    = 0.0
+    rsw2_nmos120_sphv_10hv    = 0.0
+    strso_nmos120_sphv_10hv   = 0.0
+    rsbo_nmos120_sphv_10hv    = 0.0
+    rsgo_nmos120_sphv_10hv    = 0.0
+    thesato_nmos120_sphv_10hv = 0.25
+    thesatl_nmos120_sphv_10hv = 1.73
+    thesatlexp_nmos120_sphv_10hv = 1.0
+    thesatw_nmos120_sphv_10hv = -0.7
+    thesatlw_nmos120_sphv_10hv = 0.15
+    stthesato_nmos120_sphv_10hv = 0.45
+    stthesatl_nmos120_sphv_10hv = 0.1
+    stthesatw_nmos120_sphv_10hv = 0.3
+    stthesatlw_nmos120_sphv_10hv = -0.2
+    thesatbo_nmos120_sphv_10hv = -0.22
+    thesatgo_nmos120_sphv_10hv = -0.58
+    thesatgl_nmos120_sphv_10hv = 0.5
+    thesatgw_nmos120_sphv_10hv = -1.0
+    axo_nmos120_sphv_10hv     = 7.0
+    axl_nmos120_sphv_10hv     = 2.5
+    alpl_nmos120_sphv_10hv    = 0.0
+    alplexp_nmos120_sphv_10hv = 1.0
+    alpw_nmos120_sphv_10hv    = 0.0
+    alp1l1_nmos120_sphv_10hv  = 0.0
+    alp1lexp_nmos120_sphv_10hv = 0.5
+    alp1l2_nmos120_sphv_10hv  = 0.0
+    alp1w_nmos120_sphv_10hv   = 0.0
+    alp2l1_nmos120_sphv_10hv  = 0.0
+    alp2lexp_nmos120_sphv_10hv = 1.0
+    alp2l2_nmos120_sphv_10hv  = 0.0
+    alp2w_nmos120_sphv_10hv   = 0.0
+    vpo_nmos120_sphv_10hv     = 10.0
+    a1o_nmos120_sphv_10hv     = 0.005
+    a1l_nmos120_sphv_10hv     = 0.03
+    a1w_nmos120_sphv_10hv     = 1.0
+    a2o_nmos120_sphv_10hv     = 50.0
+    sta2o_nmos120_sphv_10hv   = 0.4
+    a3o_nmos120_sphv_10hv     = 1.3
+    a3l_nmos120_sphv_10hv     = 2.0
+    a3w_nmos120_sphv_10hv     = 0.0
+    a4o_nmos120_sphv_10hv     = 0.0
+    a4l_nmos120_sphv_10hv     = 0.0
+    a4w_nmos120_sphv_10hv     = 0.0
+    gcoo_nmos120_sphv_10hv    = 0.0
+    iginvlw_nmos120_sphv_10hv = 0.0
+    igovw_nmos120_sphv_10hv   = 0.0
+    igovdw_nmos120_sphv_10hv  = 0.0
+    stigo_nmos120_sphv_10hv   = 2.0
+    gc2o_nmos120_sphv_10hv    = 0.375
+    gc3o_nmos120_sphv_10hv    = 0.063
+    chibo_nmos120_sphv_10hv   = 3.1
+    agidlw_nmos120_sphv_10hv  = 0.0005
+    agidldw_nmos120_sphv_10hv = 0.0
+    bgidlo_nmos120_sphv_10hv  = 14.0
+    bgidldo_nmos120_sphv_10hv = 10.0
+    stbgidlo_nmos120_sphv_10hv = -0.0005
+    stbgidldo_nmos120_sphv_10hv = 0.0
+    cgidlo_nmos120_sphv_10hv  = 0.0
+    cgidldo_nmos120_sphv_10hv = 0.0
+    cgbovl_nmos120_sphv_10hv  = 9e-16
+    cfrw_nmos120_sphv_10hv    = 25e-18
+    cfrdw_nmos120_sphv_10hv   = 0.0
+    fnto_nmos120_sphv_10hv    = 1.0
+    nfalw_nmos120_sphv_10hv   = 2.5e+25
+    nfblw_nmos120_sphv_10hv   = 0.0
+    nfclw_nmos120_sphv_10hv   = 7e-08
+    efo_nmos120_sphv_10hv     = 1.0
+    lintnoi_nmos120_sphv_10hv = 0.0
+    alpnoi_nmos120_sphv_10hv  = 2.0
+    kvthoweo_nmos120_sphv_10hv = 0.0
+    kvthowel_nmos120_sphv_10hv = 0.0
+    kvthowew_nmos120_sphv_10hv = 0.0
+    kvthowelw_nmos120_sphv_10hv = 0.0
+    kuoweo_nmos120_sphv_10hv  = 0.0
+    kuowel_nmos120_sphv_10hv  = 0.0
+    kuowew_nmos120_sphv_10hv  = 0.0
+    kuowelw_nmos120_sphv_10hv = 0.0
+    rgo_nmos120_sphv_10hv     = 0.0
+    rsh_nmos120_sphv_10hv     = 0.0
+    rbulko_nmos120_sphv_10hv  = 0.0
+    rwello_nmos120_sphv_10hv  = 0.0
+    rjunso_nmos120_sphv_10hv  = 1300.0
+    rjundo_nmos120_sphv_10hv  = 2450.0
+    rint_nmos120_sphv_10hv    = 0.0
+    rvpoly_nmos120_sphv_10hv  = 0.0
+    rshg_nmos120_sphv_10hv    = 0.0
+    dlsil_nmos120_sphv_10hv   = 0.0
+    saref_nmos120_sphv_10hv   = 1e-06
+    sbref_nmos120_sphv_10hv   = 1e-06
+    wlod_nmos120_sphv_10hv    = 0.0
+    kuo_nmos120_sphv_10hv     = 0.0
+    kvsat_nmos120_sphv_10hv   = 0.0
+    tkuo_nmos120_sphv_10hv    = 0.0
+    lkuo_nmos120_sphv_10hv    = 0.0
+    wkuo_nmos120_sphv_10hv    = 0.0
+    pkuo_nmos120_sphv_10hv    = 0.0
+    llodkuo_nmos120_sphv_10hv = 0.0
+    wlodkuo_nmos120_sphv_10hv = 0.0
+    kvtho_nmos120_sphv_10hv   = 0.0
+    lkvtho_nmos120_sphv_10hv  = 0.0
+    wkvtho_nmos120_sphv_10hv  = 0.0
+    pkvtho_nmos120_sphv_10hv  = 0.0
+    llodvth_nmos120_sphv_10hv = 0.0
+    wlodvth_nmos120_sphv_10hv = 0.0
+    stetao_nmos120_sphv_10hv  = 0.0
+    lodetao_nmos120_sphv_10hv = 1.0
+    scref_nmos120_sphv_10hv   = 1e-05
+    web_nmos120_sphv_10hv     = 0.0
+    wec_nmos120_sphv_10hv     = 0.0
+    adr1o_nmos120_sphv_10hv   = 0.0
+    adr1l_nmos120_sphv_10hv   = 0.00013
+    adr1w_nmos120_sphv_10hv   = 0.0
+    adr2o_nmos120_sphv_10hv   = 11.0
+    stadr2o_nmos120_sphv_10hv = 1.0
+    adr3o_nmos120_sphv_10hv   = 0.0
+    adr3l_nmos120_sphv_10hv   = 0.0
+    adr3w_nmos120_sphv_10hv   = 0.0
+    adr4o_nmos120_sphv_10hv   = 0.0
+    adr4l_nmos120_sphv_10hv   = 0.0
+    adr4w_nmos120_sphv_10hv   = 0.0
+    adr5o_nmos120_sphv_10hv   = 0.0
+    adr5l_nmos120_sphv_10hv   = 0.0
+    adr5w_nmos120_sphv_10hv   = 0.0
+    bidr1o_nmos120_sphv_10hv  = 1.7
+    bidr1l_nmos120_sphv_10hv  = 0.0
+    bidr1w_nmos120_sphv_10hv  = 0.0
+    bidr2o_nmos120_sphv_10hv  = 1.0
+    bidr2w_nmos120_sphv_10hv  = 0.0
+    rtho_nmos120_sphv_10hv    = 650.0
+    rthl_nmos120_sphv_10hv    = 0.0
+    rthw_nmos120_sphv_10hv    = 0.0
+    rthlw_nmos120_sphv_10hv   = 0.0
+    strtho_nmos120_sphv_10hv  = 2.4999999999999998e-05
+    ctho_nmos120_sphv_10hv    = 0.0
+    cthl_nmos120_sphv_10hv    = 0.0
+    cthw_nmos120_sphv_10hv    = 0.0
+    cthlw_nmos120_sphv_10hv   = 0.0
+    rshldd_nmos120_sphv_10hv  = 4000.0
+    xw_nmos120_sphv_10hv      = 2.85e-06
+    nwxw_nmos120_sphv_10hv    = -5e-13
+    xl_nmos120_sphv_10hv      = 0.0
+    xlw_nmos120_sphv_10hv     = 3.0000000000000003e-13
+    dxlsat_nmos120_sphv_10hv  = 3e-07
+    nst_nmos120_sphv_10hv     = 1.0
+    ats_nmos120_sphv_10hv     = 0.0
+    dfinf_nmos120_sphv_10hv   = 0.055
+    dfw_nmos120_sphv_10hv     = 1.1e-07
+    dfl_nmos120_sphv_10hv     = 0.0
+    dflw_nmos120_sphv_10hv    = 4.5000000000000005e-13
+    dp_nmos120_sphv_10hv      = 2.0
+    ecrit_nmos120_sphv_10hv   = 1150000.0
+    ecorn_nmos120_sphv_10hv   = 350000.0
+    xvsat_nmos120_sphv_10hv   = -0.3
+    du_nmos120_sphv_10hv      = 0.25
+    tc1_nmos120_sphv_10hv     = 0.0054
+    tc2_nmos120_sphv_10hv     = 1.4199999999999998e-05
+    tc1l_nmos120_sphv_10hv    = 1e-09
+    tc2l_nmos120_sphv_10hv    = 8e-12
+    tc1w_nmos120_sphv_10hv    = -2e-09
+    tc2w_nmos120_sphv_10hv    = 1e-11
+    theacc_nmos120_sphv_10hv  = 0.0
+    theacc2_nmos120_sphv_10hv = 0.05
+    aacc_nmos120_sphv_10hv    = 36.0
+    rva_nmos120_sphv_10hv     = 500.0
+    dta_nmos120_sphv_10hv     = 0.0
+    trj_nmos120_sphv_10hv     = 27.0
+    cjarea_nmos120_sphv_10hv  = 0.00127
+    cjlsti_nmos120_sphv_10hv  = 19.5e-11
+    cjlgat_nmos120_sphv_10hv  = 0.0
+    vbiarea_nmos120_sphv_10hv = 0.7
+    vbisti_nmos120_sphv_10hv  = 0.7
+    vbigat_nmos120_sphv_10hv  = 0.7
+    parea_nmos120_sphv_10hv   = 0.37
+    psti_nmos120_sphv_10hv    = 0.14
+    pgat_nmos120_sphv_10hv    = 0.37
+    is1area_nmos120_sphv_10hv = 1.2000000000000002e-08
+    ttarea_nmos120_sphv_10hv  = 0.8e-08
+    is2area_nmos120_sphv_10hv = 2.4999999999999998e-05
+    irarea_nmos120_sphv_10hv  = 5e-05
+    stis1area_nmos120_sphv_10hv = 3.0
+    stis2area_nmos120_sphv_10hv = 5.0
+    stirarea_nmos120_sphv_10hv = 1000.0
+    n1area_nmos120_sphv_10hv  = 1.03
+    n2area_nmos120_sphv_10hv  = 2.0
+    nrarea_nmos120_sphv_10hv  = 47.0
+    is1lsti_nmos120_sphv_10hv = 3.0000000000000005e-14
+    ttlsti_nmos120_sphv_10hv  = 0.8e-08
+    is2lsti_nmos120_sphv_10hv = 1.25e-11
+    irlsti_nmos120_sphv_10hv  = 2e-11
+    stis1sti_nmos120_sphv_10hv = 3.0
+    stis2sti_nmos120_sphv_10hv = 5.0
+    stirsti_nmos120_sphv_10hv = 1000.0
+    n1sti_nmos120_sphv_10hv   = 1.03
+    n2sti_nmos120_sphv_10hv   = 2.0
+    nrsti_nmos120_sphv_10hv   = 47.0
+    is1lgat_nmos120_sphv_10hv = 3.0000000000000005e-14
+    ttlgat_nmos120_sphv_10hv  = 0.8e-08
+    is2lgat_nmos120_sphv_10hv = 1.25e-11
+    irlgat_nmos120_sphv_10hv  = 4e-11
+    stis1gat_nmos120_sphv_10hv = 3.0
+    stis2gat_nmos120_sphv_10hv = 5.0
+    stirgat_nmos120_sphv_10hv = 1000.0
+    n1gat_nmos120_sphv_10hv   = 1.03
+    n2gat_nmos120_sphv_10hv   = 2.0
+    nrgat_nmos120_sphv_10hv   = 47.0
+    cjaread_nmos120_sphv_10hv = 0.00010999999999999999
+    cjlstid_nmos120_sphv_10hv = 1.3e-10
+    cjlgatd_nmos120_sphv_10hv = 0.0
+    vbiaread_nmos120_sphv_10hv = 0.95
+    vbistid_nmos120_sphv_10hv = 1.55
+    vbigatd_nmos120_sphv_10hv = 0.95
+    paread_nmos120_sphv_10hv  = 0.72
+    pstid_nmos120_sphv_10hv   = 0.87
+    pgatd_nmos120_sphv_10hv   = 0.72
+    is1aread_nmos120_sphv_10hv = 2.5000000000000002e-08
+    ttaread_nmos120_sphv_10hv = 3.500000000000001e-08
+    is2aread_nmos120_sphv_10hv = 4.2e-05
+    iraread_nmos120_sphv_10hv = 1e-06
+    stis1aread_nmos120_sphv_10hv = 4.0
+    stis2aread_nmos120_sphv_10hv = 10.0
+    stiraread_nmos120_sphv_10hv = 15000.0
+    n1aread_nmos120_sphv_10hv = 1.09
+    n2aread_nmos120_sphv_10hv = 2.0
+    nraread_nmos120_sphv_10hv = 1400.0
+    is1lstid_nmos120_sphv_10hv = 0
+    ttlstid_nmos120_sphv_10hv = 1.15e-06
+    is2lstid_nmos120_sphv_10hv = 7e-06
+    irlstid_nmos120_sphv_10hv = 2e-12
+    stis1stid_nmos120_sphv_10hv = 4.0
+    stis2stid_nmos120_sphv_10hv = 10.0
+    stirstid_nmos120_sphv_10hv = 15000.0
+    n1stid_nmos120_sphv_10hv  = 1.3
+    n2stid_nmos120_sphv_10hv  = 2.0
+    nrstid_nmos120_sphv_10hv  = 1400.0
+    is1lgatd_nmos120_sphv_10hv = 0
+    ttlgatd_nmos120_sphv_10hv = 3.500000000000001e-08
+    is2lgatd_nmos120_sphv_10hv = 4.2e-05
+    irlgatd_nmos120_sphv_10hv = 2e-12
+    stis1gatd_nmos120_sphv_10hv = 4.0
+    stis2gatd_nmos120_sphv_10hv = 10.0
+    stirgatd_nmos120_sphv_10hv = 15000.0
+    n1gatd_nmos120_sphv_10hv  = 1.09
+    n2gatd_nmos120_sphv_10hv  = 2.0
+    nrgatd_nmos120_sphv_10hv  = 1400.0
+    cjaread2_nmos120_sphv_10hv = 1e-12
+    cjlstid2_nmos120_sphv_10hv = 1e-18
+    vbiaread2_nmos120_sphv_10hv = 0.95
+    vbistid2_nmos120_sphv_10hv = 1.55
+    paread2_nmos120_sphv_10hv = 0.72
+    pstid2_nmos120_sphv_10hv  = 0.87
+    is1aread2_nmos120_sphv_10hv = 0
+    ttaread2_nmos120_sphv_10hv = 3.500000000000001e-08
+    is2aread2_nmos120_sphv_10hv = 4.2e-05
+    iraread2_nmos120_sphv_10hv = 1e-06
+    stis1aread2_nmos120_sphv_10hv = 25
+    stis2aread2_nmos120_sphv_10hv = 15
+    stiraread2_nmos120_sphv_10hv = 15000.0
+    n1aread2_nmos120_sphv_10hv = 1.09
+    n2aread2_nmos120_sphv_10hv = 2.0
+    nraread2_nmos120_sphv_10hv = 1400.0
+    is1lstid2_nmos120_sphv_10hv = 0
+    ttlstid2_nmos120_sphv_10hv = 1.15e-06
+    is2lstid2_nmos120_sphv_10hv = 7e-06
+    irlstid2_nmos120_sphv_10hv = 2e-12
+    stis1stid2_nmos120_sphv_10hv = 4.0
+    stis2stid2_nmos120_sphv_10hv = 10.0
+    stirstid2_nmos120_sphv_10hv = 15000.0
+    n1stid2_nmos120_sphv_10hv = 1.09
+    n2stid2_nmos120_sphv_10hv = 2.0
+    nrstid2_nmos120_sphv_10hv = 1400.0
+    eais1area_nmos120_sphv_10hv = 1.12
+    eais2area_nmos120_sphv_10hv = 1.12
+    eairarea_nmos120_sphv_10hv = 1.12
+    eais1sti_nmos120_sphv_10hv = 1.12
+    eais2sti_nmos120_sphv_10hv = 1.12
+    eairsti_nmos120_sphv_10hv = 1.12
+    eais1gat_nmos120_sphv_10hv = 1.12
+    eais2gat_nmos120_sphv_10hv = 1.12
+    eairgat_nmos120_sphv_10hv = 1.12
+    eais1aread_nmos120_sphv_10hv = 1.12
+    eais2aread_nmos120_sphv_10hv = 1.12
+    eairaread_nmos120_sphv_10hv = 1.12
+    eais1stid_nmos120_sphv_10hv = 1.12
+    eais2stid_nmos120_sphv_10hv = 1.12
+    eairstid_nmos120_sphv_10hv = 1.12
+    eais1gatd_nmos120_sphv_10hv = 1.12
+    eais2gatd_nmos120_sphv_10hv = 1.12
+    eairgatd_nmos120_sphv_10hv = 1.12
+    eais1aread2_nmos120_sphv_10hv = 1.12
+    eais2aread2_nmos120_sphv_10hv = 1.12
+    eairaread2_nmos120_sphv_10hv = 1.12
+    eais1stid2_nmos120_sphv_10hv = 1.12
+    eais2stid2_nmos120_sphv_10hv = 1.12
+    eairstid2_nmos120_sphv_10hv = 1.12
+    vdscale_nmos120_sphv_10hv = 1.02
+    vdscalel_nmos120_sphv_10hv = 0.22
+    vdscalew_nmos120_sphv_10hv = 0.08
+    vdscalelw_nmos120_sphv_10hv = 0.25
+    vdscaleb_nmos120_sphv_10hv = 0.0
+    vdscalebl_nmos120_sphv_10hv = 0.0
+    stvdscale_nmos120_sphv_10hv = 0.0
+    ikfarea_nmos120_sphv_10hv = 1000000000.0
+    stikfarea_nmos120_sphv_10hv = 0.0
+    ikfaread_nmos120_sphv_10hv = 1000000000.0
+    dwikfaread_nmos120_sphv_10hv = 14.0
+    stikfaread_nmos120_sphv_10hv = 0.0
+    dwecrit_nmos120_sphv_10hv = -0.9500000000000001
+    dwecritw_nmos120_sphv_10hv = 0.5
+    thesatbl_nmos120_sphv_10hv = 0.3
+    thesatbw_nmos120_sphv_10hv = 0.0
+    thesatblw_nmos120_sphv_10hv = 0.5
+    thesatglw_nmos120_sphv_10hv = 1.75
+    tc1lw_nmos120_sphv_10hv   = 9.999999999999999e-05
+    tc2lw_nmos120_sphv_10hv   = -4.9999999999999996e-06
+    tc1w_ecrit_nmos120_sphv_10hv = 0.016
+    tc1lw_ecrit_nmos120_sphv_10hv = -0.022
+    tc1l_ecrit_nmos120_sphv_10hv = -0.0005
+    tc2l_ecrit_nmos120_sphv_10hv = 2.2e-05
+    adr1lw_nmos120_sphv_10hv  = 0.0015
+    tc2lw_ecrit_nmos120_sphv_10hv = -5.4999999999999995e-05
+    stthesatgo_nmos120_sphv_10hv = 0.001
+    stthesatgl_nmos120_sphv_10hv = -0.0015
+    stthesatgw_nmos120_sphv_10hv = 0.025
+    stthesatglw_nmos120_sphv_10hv = -0.03
+    nom_delr_tox_nld45b_sphv_10hv = 1.0
+    nom_dela_xw_nld45b_sphv_10hv = -0.07747
+    nom_dela_vfb_nld45b_sphv_10hv = -0.04474
+    nom_delr_mobref_nld45b_sphv_10hv = 0.9558
+    nom_delr_rsh_nld45b_sphv_10hv = 0.99
+    nom_delr_vdscale_nld45b_sphv_10hv = 0.9195
+    nom_dela_vtw_nld45b_sphv_10hv = -0.219
+    nom_delr_cj_nld45b_sphv_10hv = 1.0
+    nom_delr_is_nld45b_sphv_10hv = 1.0
+    nom_delr_is2_nld45b_sphv_10hv = 1.0
+    nom_delr_ir_nld45b_sphv_10hv = 1.0
+    sig_delr_tox_nld45b_sphv_10hv = 0.012
+    sig_dela_xw_nld45b_sphv_10hv = 0.03829
+    sig_dela_vfb_nld45b_sphv_10hv = 0.07968
+    sig_delr_mobref_nld45b_sphv_10hv = 0.01329
+    sig_delr_rsh_nld45b_sphv_10hv = 0.04459
+    sig_delr_vdscale_nld45b_sphv_10hv = 0.01543
+    sig_dela_vtw_nld45b_sphv_10hv = 0.03439
+    sig_delr_cj_nld45b_sphv_10hv = 0.0333
+    sig_delr_is_nld45b_sphv_10hv = 0.055
+    sig_delr_is2_nld45b_sphv_10hv = 0.768
+    sig_delr_ir_nld45b_sphv_10hv = 0.768
+    fac_rth_nld45b_sphv_10hv  = 1.5
+    tc1_ecrit_nld45b_sphv_10hv = 0.0
+    tc2_ecrit_nld45b_sphv_10hv = 0.0
+    dwrjundo_nld45b_sphv_10hv = 1.2
+    dwrjunso_nld45b_sphv_10hv = 0.0
+    qmc_nld45b_sphv_10hv      = 0.0
+    lvaro_nld45b_sphv_10hv    = 0.0
+    lvarl_nld45b_sphv_10hv    = 0.0
+    lvarw_nld45b_sphv_10hv    = 0.0
+    lap_nld45b_sphv_10hv      = 0.0
+    wvaro_nld45b_sphv_10hv    = 8.084e-07
+    wvarl_nld45b_sphv_10hv    = 0.0
+    wvarw_nld45b_sphv_10hv    = -1.0
+    wot_nld45b_sphv_10hv      = 0.0
+    dlq_nld45b_sphv_10hv      = 0.0
+    dwq_nld45b_sphv_10hv      = -5.54e-07
+    vfbo_nld45b_sphv_10hv     = -0.7
+    vfbl_nld45b_sphv_10hv     = 0.0
+    vfbw_nld45b_sphv_10hv     = 0.0
+    vfblw_nld45b_sphv_10hv    = 0.0
+    stvfbo_nld45b_sphv_10hv   = 0.001277
+    stvfbl_nld45b_sphv_10hv   = 0.0
+    stvfbw_nld45b_sphv_10hv   = 0.1668
+    stvfblw_nld45b_sphv_10hv  = 0.0
+    toxo_nld45b_sphv_10hv     = 1.32e-08
+    epsroxo_nld45b_sphv_10hv  = 3.9
+    nsubo_nld45b_sphv_10hv    = 1e+23
+    nsubw_nld45b_sphv_10hv    = 0.03
+    wseg_nld45b_sphv_10hv     = 1e-08
+    npck_nld45b_sphv_10hv     = 1e+23
+    npckw_nld45b_sphv_10hv    = 0.0
+    wsegp_nld45b_sphv_10hv    = 1e-08
+    lpck_nld45b_sphv_10hv     = 0.0
+    lpckw_nld45b_sphv_10hv    = 0.0
+    fol1_nld45b_sphv_10hv     = 0.0
+    fol2_nld45b_sphv_10hv     = 0.0
+    facneffaco_nld45b_sphv_10hv = 0.3
+    facneffacl_nld45b_sphv_10hv = 0.0
+    facneffacw_nld45b_sphv_10hv = -0.3
+    facneffaclw_nld45b_sphv_10hv = 0.0
+    gfacnudo_nld45b_sphv_10hv = 1.0
+    gfacnudl_nld45b_sphv_10hv = 0.0
+    gfacnudlexp_nld45b_sphv_10hv = 1.0
+    gfacnudw_nld45b_sphv_10hv = 0.0
+    gfacnudlw_nld45b_sphv_10hv = 0.0
+    vsbnudo_nld45b_sphv_10hv  = 0.0
+    dvsbnudo_nld45b_sphv_10hv = 1.0
+    vnsubo_nld45b_sphv_10hv   = 0.0
+    nslpo_nld45b_sphv_10hv    = 0.05
+    dnsubo_nld45b_sphv_10hv   = 0.3046
+    dphibo_nld45b_sphv_10hv   = 0.0
+    dphibl_nld45b_sphv_10hv   = -0.006442
+    dphiblexp_nld45b_sphv_10hv = 1.0
+    dphibw_nld45b_sphv_10hv   = 0.0
+    dphiblw_nld45b_sphv_10hv  = 0.0
+    delvtaco_nld45b_sphv_10hv = 0.29
+    delvtacl_nld45b_sphv_10hv = 0.0
+    delvtaclexp_nld45b_sphv_10hv = 1.0
+    delvtacw_nld45b_sphv_10hv = 0.5
+    delvtaclw_nld45b_sphv_10hv = -0.05
+    npo_nld45b_sphv_10hv      = 4.5e+25
+    npl_nld45b_sphv_10hv      = 0.0
+    cto_nld45b_sphv_10hv      = 0.04
+    ctl_nld45b_sphv_10hv      = 0.0
+    ctlexp_nld45b_sphv_10hv   = 1.0
+    ctw_nld45b_sphv_10hv      = 0.0
+    ctlw_nld45b_sphv_10hv     = 0.0
+    toxovo_nld45b_sphv_10hv   = 1.32e-08
+    toxovdo_nld45b_sphv_10hv  = 1.32e-08
+    lov_nld45b_sphv_10hv      = 0.0
+    dlovd_nld45b_sphv_10hv    = 0.0
+    novo_nld45b_sphv_10hv     = 1e+24
+    novdo_nld45b_sphv_10hv    = 5e+22
+    cfl_nld45b_sphv_10hv      = 0.0
+    cflexp_nld45b_sphv_10hv   = 2.0
+    cfw_nld45b_sphv_10hv      = 0.0
+    cfbo_nld45b_sphv_10hv     = 1.0
+    uo_nld45b_sphv_10hv       = 0.05052
+    fbet1_nld45b_sphv_10hv    = 0.0
+    fbet1w_nld45b_sphv_10hv   = 0.0
+    lp1_nld45b_sphv_10hv      = 1e-10
+    lp1w_nld45b_sphv_10hv     = 0.0
+    fbet2_nld45b_sphv_10hv    = 0.0
+    lp2_nld45b_sphv_10hv      = 1e-10
+    betw1_nld45b_sphv_10hv    = -0.4
+    betw2_nld45b_sphv_10hv    = 0.02
+    wbet_nld45b_sphv_10hv     = 1e-09
+    stbeto_nld45b_sphv_10hv   = 1.309
+    stbetl_nld45b_sphv_10hv   = 0.0
+    stbetw_nld45b_sphv_10hv   = -0.03493
+    stbetlw_nld45b_sphv_10hv  = 0.0
+    mueo_nld45b_sphv_10hv     = 1.551
+    muew_nld45b_sphv_10hv     = 0.0
+    stmueo_nld45b_sphv_10hv   = 0.2775
+    themuo_nld45b_sphv_10hv   = 1.798
+    stthemuo_nld45b_sphv_10hv = 0.09956
+    cso_nld45b_sphv_10hv      = 0.0
+    csl_nld45b_sphv_10hv      = 0.0
+    cslexp_nld45b_sphv_10hv   = 0.0
+    csw_nld45b_sphv_10hv      = 0.0
+    cslw_nld45b_sphv_10hv     = 0.0
+    stcso_nld45b_sphv_10hv    = 0.0
+    xcoro_nld45b_sphv_10hv    = 0.0
+    xcorl_nld45b_sphv_10hv    = 0.0
+    xcorw_nld45b_sphv_10hv    = 0.0
+    xcorlw_nld45b_sphv_10hv   = 0.0
+    stxcoro_nld45b_sphv_10hv  = 0.0
+    fetao_nld45b_sphv_10hv    = 1.0
+    rsw1_nld45b_sphv_10hv     = 0.0
+    rsw2_nld45b_sphv_10hv     = 0.0
+    strso_nld45b_sphv_10hv    = 0.0
+    rsbo_nld45b_sphv_10hv     = 0.0
+    rsgo_nld45b_sphv_10hv     = 1.0
+    thesato_nld45b_sphv_10hv  = 0.0521
+    thesatl_nld45b_sphv_10hv  = 0.0
+    thesatlexp_nld45b_sphv_10hv = 1.0
+    thesatw_nld45b_sphv_10hv  = 0.0
+    thesatlw_nld45b_sphv_10hv = 0.0
+    stthesato_nld45b_sphv_10hv = 0.0
+    stthesatl_nld45b_sphv_10hv = 0.0
+    stthesatw_nld45b_sphv_10hv = 0.0
+    stthesatlw_nld45b_sphv_10hv = 0.0
+    thesatbo_nld45b_sphv_10hv = 0.0
+    thesatgo_nld45b_sphv_10hv = 0.0
+    thesatgl_nld45b_sphv_10hv = 0.0
+    thesatgw_nld45b_sphv_10hv = 0.0
+    axo_nld45b_sphv_10hv      = 3.0
+    axl_nld45b_sphv_10hv      = 0.0
+    alpl_nld45b_sphv_10hv     = 0.009
+    alplexp_nld45b_sphv_10hv  = 1.0
+    alpw_nld45b_sphv_10hv     = 0.0
+    alp1l1_nld45b_sphv_10hv   = 1e-06
+    alp1lexp_nld45b_sphv_10hv = 1.0
+    alp1l2_nld45b_sphv_10hv   = 0.0
+    alp1w_nld45b_sphv_10hv    = 0.0
+    alp2l1_nld45b_sphv_10hv   = 0.0
+    alp2lexp_nld45b_sphv_10hv = 1.0
+    alp2l2_nld45b_sphv_10hv   = 0.0
+    alp2w_nld45b_sphv_10hv    = 0.0
+    vpo_nld45b_sphv_10hv      = 0.1
+    a1o_nld45b_sphv_10hv      = 0.085
+    a1l_nld45b_sphv_10hv      = 0.0
+    a1w_nld45b_sphv_10hv      = -1.455
+    a2o_nld45b_sphv_10hv      = 28.57
+    sta2o_nld45b_sphv_10hv    = 1.65
+    a3o_nld45b_sphv_10hv      = 101.7
+    a3l_nld45b_sphv_10hv      = 0.0
+    a3w_nld45b_sphv_10hv      = 0.0
+    a4o_nld45b_sphv_10hv      = 0.0
+    a4l_nld45b_sphv_10hv      = 0.0
+    a4w_nld45b_sphv_10hv      = 0.0
+    gcoo_nld45b_sphv_10hv     = 0.0
+    iginvlw_nld45b_sphv_10hv  = 0.0
+    igovw_nld45b_sphv_10hv    = 0.0
+    igovdw_nld45b_sphv_10hv   = 0.0
+    stigo_nld45b_sphv_10hv    = 2.0
+    gc2o_nld45b_sphv_10hv     = 0.375
+    gc3o_nld45b_sphv_10hv     = 0.063
+    chibo_nld45b_sphv_10hv    = 3.1
+    agidlw_nld45b_sphv_10hv   = 0.0
+    agidldw_nld45b_sphv_10hv  = 0.0
+    bgidlo_nld45b_sphv_10hv   = 41.0
+    bgidldo_nld45b_sphv_10hv  = 41.0
+    stbgidlo_nld45b_sphv_10hv = 0.0
+    stbgidldo_nld45b_sphv_10hv = 0.0
+    cgidlo_nld45b_sphv_10hv   = 0.0
+    cgidldo_nld45b_sphv_10hv  = 0.0
+    cgbovl_nld45b_sphv_10hv   = 1e-15
+    cfrw_nld45b_sphv_10hv     = 2.35e-16
+    cfrdw_nld45b_sphv_10hv    = 0.0
+    fnto_nld45b_sphv_10hv     = 1.0
+    nfalw_nld45b_sphv_10hv    = 2e+26
+    nfblw_nld45b_sphv_10hv    = 0.0
+    nfclw_nld45b_sphv_10hv    = 0.0
+    efo_nld45b_sphv_10hv      = 1.0
+    lintnoi_nld45b_sphv_10hv  = 0.0
+    alpnoi_nld45b_sphv_10hv   = 2.0
+    kvthoweo_nld45b_sphv_10hv = 0.0
+    kvthowel_nld45b_sphv_10hv = 0.0
+    kvthowew_nld45b_sphv_10hv = 0.0
+    kvthowelw_nld45b_sphv_10hv = 0.0
+    kuoweo_nld45b_sphv_10hv   = 0.0
+    kuowel_nld45b_sphv_10hv   = 0.0
+    kuowew_nld45b_sphv_10hv   = 0.0
+    kuowelw_nld45b_sphv_10hv  = 0.0
+    rgo_nld45b_sphv_10hv      = 0.0
+    rsh_nld45b_sphv_10hv      = 0.0
+    rbulko_nld45b_sphv_10hv   = 0.0
+    rwello_nld45b_sphv_10hv   = 0.0
+    rjunso_nld45b_sphv_10hv   = 0.006
+    rjundo_nld45b_sphv_10hv   = 162.0
+    rint_nld45b_sphv_10hv     = 0.0
+    rvpoly_nld45b_sphv_10hv   = 0.0
+    rshg_nld45b_sphv_10hv     = 0.0
+    dlsil_nld45b_sphv_10hv    = 0.0
+    saref_nld45b_sphv_10hv    = 1e-06
+    sbref_nld45b_sphv_10hv    = 1e-06
+    wlod_nld45b_sphv_10hv     = 0.0
+    kuo_nld45b_sphv_10hv      = 0.0
+    kvsat_nld45b_sphv_10hv    = 0.0
+    tkuo_nld45b_sphv_10hv     = 0.0
+    lkuo_nld45b_sphv_10hv     = 0.0
+    wkuo_nld45b_sphv_10hv     = 0.0
+    pkuo_nld45b_sphv_10hv     = 0.0
+    llodkuo_nld45b_sphv_10hv  = 0.0
+    wlodkuo_nld45b_sphv_10hv  = 0.0
+    kvtho_nld45b_sphv_10hv    = 0.0
+    lkvtho_nld45b_sphv_10hv   = 0.0
+    wkvtho_nld45b_sphv_10hv   = 0.0
+    pkvtho_nld45b_sphv_10hv   = 0.0
+    llodvth_nld45b_sphv_10hv  = 0.0
+    wlodvth_nld45b_sphv_10hv  = 0.0
+    stetao_nld45b_sphv_10hv   = 0.0
+    lodetao_nld45b_sphv_10hv  = 1.0
+    scref_nld45b_sphv_10hv    = 1e-05
+    web_nld45b_sphv_10hv      = 0.0
+    wec_nld45b_sphv_10hv      = 0.0
+    adr1o_nld45b_sphv_10hv    = 0.0
+    adr1l_nld45b_sphv_10hv    = 0.0
+    adr1w_nld45b_sphv_10hv    = 2.0
+    adr2o_nld45b_sphv_10hv    = 26.0
+    stadr2o_nld45b_sphv_10hv  = 0.0
+    stadr2o1_nld45b_sphv_10hv = 1.35
+    adr3o_nld45b_sphv_10hv    = 0.0
+    adr3l_nld45b_sphv_10hv    = 0.0
+    adr3w_nld45b_sphv_10hv    = 0.0
+    adr4o_nld45b_sphv_10hv    = 0.0
+    adr4l_nld45b_sphv_10hv    = 0.0
+    adr4w_nld45b_sphv_10hv    = 0.0
+    adr5o_nld45b_sphv_10hv    = 0.0
+    adr5l_nld45b_sphv_10hv    = 0.0
+    adr5w_nld45b_sphv_10hv    = 0.0
+    bidr1o_nld45b_sphv_10hv   = 0.0
+    bidr1l_nld45b_sphv_10hv   = 0.0
+    bidr1w_nld45b_sphv_10hv   = 0.4
+    bidr2o_nld45b_sphv_10hv   = 0.0
+    bidr2w_nld45b_sphv_10hv   = 0.0
+    rtho_nld45b_sphv_10hv     = 750.0
+    rthl_nld45b_sphv_10hv     = 0.0
+    rthw_nld45b_sphv_10hv     = 0.0
+    rthlw_nld45b_sphv_10hv    = 0.0
+    strtho_nld45b_sphv_10hv   = 0.0
+    ctho_nld45b_sphv_10hv     = 0.0
+    cthl_nld45b_sphv_10hv     = 0.0
+    cthw_nld45b_sphv_10hv     = 0.0
+    cthlw_nld45b_sphv_10hv    = 0.0
+    rshldd_nld45b_sphv_10hv   = 4990.0
+    xw_nld45b_sphv_10hv       = 1e-06
+    nwxw_nld45b_sphv_10hv     = 2.5e-13
+    xl_nld45b_sphv_10hv       = 0.0
+    xlw_nld45b_sphv_10hv      = 0.0
+    dxlsat_nld45b_sphv_10hv   = 0.0
+    nst_nld45b_sphv_10hv      = 1.0
+    ats_nld45b_sphv_10hv      = 0.0
+    dfinf_nld45b_sphv_10hv    = 0.01
+    dfw_nld45b_sphv_10hv      = 2e-08
+    dfl_nld45b_sphv_10hv      = 0.0
+    dflw_nld45b_sphv_10hv     = 0.0
+    dp_nld45b_sphv_10hv       = 2.0
+    ecrit_nld45b_sphv_10hv    = 1600000.0
+    ecorn_nld45b_sphv_10hv    = 600000.0
+    xvsat_nld45b_sphv_10hv    = -0.28
+    du_nld45b_sphv_10hv       = 0.02
+    tc1_nld45b_sphv_10hv      = 0.0062
+    tc2_nld45b_sphv_10hv      = 2e-05
+    tc1l_nld45b_sphv_10hv     = 0.0
+    tc2l_nld45b_sphv_10hv     = 0.0
+    tc1w_nld45b_sphv_10hv     = -8e-10
+    tc2w_nld45b_sphv_10hv     = -1e-12
+    theacc_nld45b_sphv_10hv   = 0.0
+    theacc2_nld45b_sphv_10hv  = 0.03071
+    rva_nld45b_sphv_10hv      = 1000.0
+    dta_nld45b_sphv_10hv      = 0.0
+    trj_nld45b_sphv_10hv      = 25.0
+    cjarea_nld45b_sphv_10hv   = 0.00014
+    cjlsti_nld45b_sphv_10hv   = 1e-10
+    cjlgat_nld45b_sphv_10hv   = 5e-08
+    vbiarea_nld45b_sphv_10hv  = 0.7
+    vbisti_nld45b_sphv_10hv   = 0.7
+    vbigat_nld45b_sphv_10hv   = 0.7
+    parea_nld45b_sphv_10hv    = 0.2
+    psti_nld45b_sphv_10hv     = 0.2
+    pgat_nld45b_sphv_10hv     = 0.35
+    is1area_nld45b_sphv_10hv  = 0.0
+    ttarea_nld45b_sphv_10hv   = 0.0
+    is2area_nld45b_sphv_10hv  = 0.0
+    irarea_nld45b_sphv_10hv   = 0.0
+    stis1area_nld45b_sphv_10hv = 3.0
+    stis2area_nld45b_sphv_10hv = 3.0
+    stirarea_nld45b_sphv_10hv = 1.0
+    n1area_nld45b_sphv_10hv   = 1.0
+    n2area_nld45b_sphv_10hv   = 2.0
+    nrarea_nld45b_sphv_10hv   = 200.0
+    is1lsti_nld45b_sphv_10hv  = 0.0
+    ttlsti_nld45b_sphv_10hv   = 0.0
+    is2lsti_nld45b_sphv_10hv  = 0.0
+    irlsti_nld45b_sphv_10hv   = 0.0
+    stis1sti_nld45b_sphv_10hv = 3.0
+    stis2sti_nld45b_sphv_10hv = 3.0
+    stirsti_nld45b_sphv_10hv  = 1.0
+    n1sti_nld45b_sphv_10hv    = 1.0
+    n2sti_nld45b_sphv_10hv    = 2.0
+    nrsti_nld45b_sphv_10hv    = 200.0
+    is1lgat_nld45b_sphv_10hv  = 0.0
+    ttlgat_nld45b_sphv_10hv   = 0.0
+    is2lgat_nld45b_sphv_10hv  = 0.0
+    irlgat_nld45b_sphv_10hv   = 0.0
+    stis1gat_nld45b_sphv_10hv = 3.0
+    stis2gat_nld45b_sphv_10hv = 3.0
+    stirgat_nld45b_sphv_10hv  = 1.0
+    n1gat_nld45b_sphv_10hv    = 1.0
+    n2gat_nld45b_sphv_10hv    = 2.0
+    nrgat_nld45b_sphv_10hv    = 200.0
+    cjaread_nld45b_sphv_10hv  = 0.000142
+    cjlstid_nld45b_sphv_10hv  = 1e-18
+    cjlgatd_nld45b_sphv_10hv  = 1e-18
+    vbiaread_nld45b_sphv_10hv = 0.9055
+    vbistid_nld45b_sphv_10hv  = 0.8725
+    vbigatd_nld45b_sphv_10hv  = 0.866
+    paread_nld45b_sphv_10hv   = 0.3305
+    pstid_nld45b_sphv_10hv    = 0.9
+    pgatd_nld45b_sphv_10hv    = 0.5628
+    is1aread_nld45b_sphv_10hv = 9.331e-08
+    ttaread_nld45b_sphv_10hv  = 3.78e-08
+    is2aread_nld45b_sphv_10hv = 1e-05
+    iraread_nld45b_sphv_10hv  = 0.00016
+    stis1aread_nld45b_sphv_10hv = 6.0
+    stis2aread_nld45b_sphv_10hv = 3.0
+    stiraread_nld45b_sphv_10hv = 35000.0
+    n1aread_nld45b_sphv_10hv  = 1.066
+    n2aread_nld45b_sphv_10hv  = 2.0
+    nraread_nld45b_sphv_10hv  = 2500.0
+    is1lstid_nld45b_sphv_10hv = 6.624e-09
+    ttlstid_nld45b_sphv_10hv  = 3.78e-08
+    is2lstid_nld45b_sphv_10hv = 0.0
+    irlstid_nld45b_sphv_10hv  = 3e-10
+    stis1stid_nld45b_sphv_10hv = 6.0
+    stis2stid_nld45b_sphv_10hv = 3.0
+    stirstid_nld45b_sphv_10hv = 35000.0
+    n1stid_nld45b_sphv_10hv   = 1.155
+    n2stid_nld45b_sphv_10hv   = 2.0
+    nrstid_nld45b_sphv_10hv   = 2500.0
+    is1lgatd_nld45b_sphv_10hv = 1.576e-07
+    ttlgatd_nld45b_sphv_10hv  = 3.78e-08
+    is2lgatd_nld45b_sphv_10hv = 0.0
+    irlgatd_nld45b_sphv_10hv  = 3e-10
+    stis1gatd_nld45b_sphv_10hv = 6.0
+    stis2gatd_nld45b_sphv_10hv = 3.0
+    stirgatd_nld45b_sphv_10hv = 35000.0
+    n1gatd_nld45b_sphv_10hv   = 1.00717111355
+    n2gatd_nld45b_sphv_10hv   = 2.0
+    nrgatd_nld45b_sphv_10hv   = 2500.0
+    cjaread2_nld45b_sphv_10hv = 0.000178
+    cjlstid2_nld45b_sphv_10hv = 1e-18
+    vbiaread2_nld45b_sphv_10hv = 0.7
+    vbistid2_nld45b_sphv_10hv = 0.7
+    paread2_nld45b_sphv_10hv  = 0.5
+    pstid2_nld45b_sphv_10hv   = 0.5
+    is1aread2_nld45b_sphv_10hv = 3e-08
+    ttaread2_nld45b_sphv_10hv = 3.78e-08
+    is2aread2_nld45b_sphv_10hv = 3e-06
+    iraread2_nld45b_sphv_10hv = 0.00016
+    stis1aread2_nld45b_sphv_10hv = 3.0
+    stis2aread2_nld45b_sphv_10hv = 3.0
+    stiraread2_nld45b_sphv_10hv = 35000.0
+    n1aread2_nld45b_sphv_10hv = 1.0
+    n2aread2_nld45b_sphv_10hv = 2.0
+    nraread2_nld45b_sphv_10hv = 2500.0
+    is1lstid2_nld45b_sphv_10hv = 0
+    ttlstid2_nld45b_sphv_10hv = 3.78e-08
+    is2lstid2_nld45b_sphv_10hv = 0.0
+    irlstid2_nld45b_sphv_10hv = 0.0
+    stis1stid2_nld45b_sphv_10hv = 3.0
+    stis2stid2_nld45b_sphv_10hv = 5.5
+    stirstid2_nld45b_sphv_10hv = 35000.0
+    n1stid2_nld45b_sphv_10hv  = 1.0
+    n2stid2_nld45b_sphv_10hv  = 2.0
+    nrstid2_nld45b_sphv_10hv  = 2500.0
+    eais1area_nld45b_sphv_10hv = 1.12
+    eais2area_nld45b_sphv_10hv = 1.12
+    eairarea_nld45b_sphv_10hv = 1.12
+    eais1sti_nld45b_sphv_10hv = 1.12
+    eais2sti_nld45b_sphv_10hv = 1.12
+    eairsti_nld45b_sphv_10hv  = 1.12
+    eais1gat_nld45b_sphv_10hv = 1.12
+    eais2gat_nld45b_sphv_10hv = 1.12
+    eairgat_nld45b_sphv_10hv  = 1.12
+    eais1aread_nld45b_sphv_10hv = 1.12
+    eais2aread_nld45b_sphv_10hv = 1.12
+    eairaread_nld45b_sphv_10hv = 1.12
+    eais1stid_nld45b_sphv_10hv = 1.12
+    eais2stid_nld45b_sphv_10hv = 1.12
+    eairstid_nld45b_sphv_10hv = 1.12
+    eais1gatd_nld45b_sphv_10hv = 1.12
+    eais2gatd_nld45b_sphv_10hv = 1.12
+    eairgatd_nld45b_sphv_10hv = 1.12
+    eais1aread2_nld45b_sphv_10hv = 1.12
+    eais2aread2_nld45b_sphv_10hv = 1.12
+    eairaread2_nld45b_sphv_10hv = 1.12
+    eais1stid2_nld45b_sphv_10hv = 1.12
+    eais2stid2_nld45b_sphv_10hv = 1.12
+    eairstid2_nld45b_sphv_10hv = 1.12
+    aacc_nld45b_sphv_10hv     = 36.0
+    vdscale_nld45b_sphv_10hv  = 1.32
+    dwvdscale_nld45b_sphv_10hv = -0.41
+    dwvdscalew_nld45b_sphv_10hv = 0.7988
+    dwecrit_nld45b_sphv_10hv  = -1.0
+    dwecritw_nld45b_sphv_10hv = 0.6
+    stvdscale_nld45b_sphv_10hv = 0.0
+    stvdscale1_nld45b_sphv_10hv = 0.29
+    ctgo_nld45b_sphv_10hv     = 0.005508
+    strthao_nld45b_sphv_10hv  = 1.1
+    dwtt_nld45b_sphv_10hv     = 2.0
+    ikfarea_nld45b_sphv_10hv  = 0
+    stikfarea_nld45b_sphv_10hv = 0
+    ikfaread_nld45b_sphv_10hv = 15300000.0
+    dwikfaread_nld45b_sphv_10hv = 2.0
+    stikfaread_nld45b_sphv_10hv = 0.8
+    dphibo_nld45b_pspmoscap_10hv = -0.2
+    vfbo_nld45b_pspmoscap_10hv = -1.1
+    w_nld45b_mosb_10hv        = 1.78
+    ldrift_nld45b_mosb_10hv   = 9.7
+    delvto_nld45b_mosb_10hv   = 1.39
+    factuo_nld45b_mosb_10hv   = 1.1
+    stdelvto_nld45b_mosb_10hv = -0.3
+    stfactuo_nld45b_mosb_10hv = 1.2
+    nom_delr_tox_pld65_sphv_10hv = 1.0
+    nom_dela_vfb_pld65_sphv_10hv = 0.01795
+    nom_dela_vtw_pld65_sphv_10hv = 0.0169
+    nom_delr_uch_pld65_sphv_10hv = 0.9895
+    nom_delr_res_pld65_sphv_10hv = 0.985
+    nom_dela_dwox_pld65_sphv_10hv = -4.5e-08
+    nom_delr_cj_pld65_sphv_10hv = 1.0
+    nom_delr_is_pld65_sphv_10hv = 1.0
+    nom_delr_is2_pld65_sphv_10hv = 1.0
+    nom_delr_ir_pld65_sphv_10hv = 1.0
+    sig_delr_tox_pld65_sphv_10hv = 0.012
+    sig_dela_vfb_pld65_sphv_10hv = 0.017
+    sig_dela_vtw_pld65_sphv_10hv = 0.00325
+    sig_delr_uch_pld65_sphv_10hv = 0.04
+    sig_delr_res_pld65_sphv_10hv = 0.065
+    sig_dela_dwox_pld65_sphv_10hv = 7.0e-08
+    sig_delr_cj_pld65_sphv_10hv = 0.0333
+    sig_delr_is_pld65_sphv_10hv = 0.055
+    sig_delr_is2_pld65_sphv_10hv = 0.768
+    sig_delr_ir_pld65_sphv_10hv = 0.768
+    fac_rth_pld65_sphv_10hv   = 0.45
+    dwrjundo_pld65_sphv_10hv  = 0.5
+    dwrjunso_pld65_sphv_10hv  = 8e-06
+    qmc_pld65_sphv_10hv       = 0.0
+    lvaro_pld65_sphv_10hv     = 0.0
+    lvarl_pld65_sphv_10hv     = 0.0
+    lvarw_pld65_sphv_10hv     = 0.0
+    lap_pld65_sphv_10hv       = 0.0
+    wvaro_pld65_sphv_10hv     = -2.2e-07
+    wvarl_pld65_sphv_10hv     = 0.0
+    wvarw_pld65_sphv_10hv     = -0.0009
+    wot_pld65_sphv_10hv       = 0.0
+    dlq_pld65_sphv_10hv       = 0.0
+    dwq_pld65_sphv_10hv       = 1.55e-07
+    vfbo_pld65_sphv_10hv      = -0.803
+    vfbl_pld65_sphv_10hv      = 0.1
+    vfbw_pld65_sphv_10hv      = 0.053
+    vfblw_pld65_sphv_10hv     = 0.0
+    stvfbo_pld65_sphv_10hv    = 0.00105
+    stvfbl_pld65_sphv_10hv    = 0.0
+    stvfbw_pld65_sphv_10hv    = -0.0413
+    stvfblw_pld65_sphv_10hv   = 0.0
+    toxo_pld65_sphv_10hv      = 1.3e-08
+    epsroxo_pld65_sphv_10hv   = 3.9
+    nsubo_pld65_sphv_10hv     = 1.5e+23
+    nsubw_pld65_sphv_10hv     = 0.0
+    wseg_pld65_sphv_10hv      = 1e-08
+    npck_pld65_sphv_10hv      = 1e+23
+    npckw_pld65_sphv_10hv     = 0.0
+    wsegp_pld65_sphv_10hv     = 1e-08
+    lpck_pld65_sphv_10hv      = 0.0
+    lpckw_pld65_sphv_10hv     = 0.0
+    fol1_pld65_sphv_10hv      = 0.0
+    fol2_pld65_sphv_10hv      = 0.0
+    facneffaco_pld65_sphv_10hv = 1.1
+    facneffacl_pld65_sphv_10hv = 0.0
+    facneffacw_pld65_sphv_10hv = -1.0
+    facneffaclw_pld65_sphv_10hv = 0.0
+    gfacnudo_pld65_sphv_10hv  = 1.0
+    gfacnudl_pld65_sphv_10hv  = 0.0
+    gfacnudlexp_pld65_sphv_10hv = 1.0
+    gfacnudw_pld65_sphv_10hv  = 0.0
+    gfacnudlw_pld65_sphv_10hv = 0.0
+    vsbnudo_pld65_sphv_10hv   = 0.0
+    dvsbnudo_pld65_sphv_10hv  = 1.0
+    vnsubo_pld65_sphv_10hv    = 0.0
+    nslpo_pld65_sphv_10hv     = 0.05
+    dnsubo_pld65_sphv_10hv    = -0.01068
+    dphibo_pld65_sphv_10hv    = -0.03
+    dphibl_pld65_sphv_10hv    = 0.0
+    dphiblexp_pld65_sphv_10hv = 1.0
+    dphibw_pld65_sphv_10hv    = 0.0
+    dphiblw_pld65_sphv_10hv   = 0.0
+    delvtaco_pld65_sphv_10hv  = -0.03
+    delvtacl_pld65_sphv_10hv  = 0.0
+    delvtaclexp_pld65_sphv_10hv = 1.0
+    delvtacw_pld65_sphv_10hv  = 0.25
+    delvtaclw_pld65_sphv_10hv = 0.0
+    npo_pld65_sphv_10hv       = 5.7e+25
+    npl_pld65_sphv_10hv       = 0.0
+    cto_pld65_sphv_10hv       = 0.0
+    ctl_pld65_sphv_10hv       = 0.0
+    ctlexp_pld65_sphv_10hv    = 1.0
+    ctw_pld65_sphv_10hv       = 0.2929
+    ctlw_pld65_sphv_10hv      = 0.0
+    ctgo_pld65_sphv_10hv      = 0.0
+    ctbo_pld65_sphv_10hv      = 0.0
+    stcto_pld65_sphv_10hv     = 1.0
+    toxovo_pld65_sphv_10hv    = 1.3e-08
+    toxovdo_pld65_sphv_10hv   = 1.3e-08
+    lov_pld65_sphv_10hv       = 4e-08
+    dlovd_pld65_sphv_10hv     = -1.05e-07
+    novo_pld65_sphv_10hv      = 8e+25
+    novdo_pld65_sphv_10hv     = 3e+21
+    cfl_pld65_sphv_10hv       = 0.0
+    cflexp_pld65_sphv_10hv    = 2.0
+    cfw_pld65_sphv_10hv       = 0.0
+    cfbo_pld65_sphv_10hv      = 1.0
+    uo_pld65_sphv_10hv        = 0.024
+    fbet1_pld65_sphv_10hv     = 0.0
+    fbet1w_pld65_sphv_10hv    = 0.0
+    lp1_pld65_sphv_10hv       = 1e-10
+    lp1w_pld65_sphv_10hv      = 0.0
+    fbet2_pld65_sphv_10hv     = 0.0
+    lp2_pld65_sphv_10hv       = 1e-10
+    betw1_pld65_sphv_10hv     = -0.4
+    betw2_pld65_sphv_10hv     = 0.02
+    wbet_pld65_sphv_10hv      = 1e-09
+    stbeto_pld65_sphv_10hv    = 1.4
+    stbetl_pld65_sphv_10hv    = 0.0
+    stbetw_pld65_sphv_10hv    = -0.1
+    stbetlw_pld65_sphv_10hv   = 0.0
+    mueo_pld65_sphv_10hv      = 11.0
+    muew_pld65_sphv_10hv      = 0.03
+    stmueo_pld65_sphv_10hv    = 0.0
+    themuo_pld65_sphv_10hv    = 0.3
+    stthemuo_pld65_sphv_10hv  = 1.0
+    cso_pld65_sphv_10hv       = 0.0
+    csl_pld65_sphv_10hv       = 0.0
+    cslexp_pld65_sphv_10hv    = 0.0
+    csw_pld65_sphv_10hv       = 0.0
+    cslw_pld65_sphv_10hv      = 0.0
+    stcso_pld65_sphv_10hv     = 0.0
+    xcoro_pld65_sphv_10hv     = 0.0
+    xcorl_pld65_sphv_10hv     = 0.0
+    xcorw_pld65_sphv_10hv     = 0.0
+    xcorlw_pld65_sphv_10hv    = 0.0
+    stxcoro_pld65_sphv_10hv   = 0.0
+    fetao_pld65_sphv_10hv     = 1.0
+    rsw1_pld65_sphv_10hv      = 0.0
+    rsw2_pld65_sphv_10hv      = 0.0
+    strso_pld65_sphv_10hv     = 1.0
+    rsbo_pld65_sphv_10hv      = 0.0
+    rsgo_pld65_sphv_10hv      = 1.0
+    thesato_pld65_sphv_10hv   = 1.6
+    thesatl_pld65_sphv_10hv   = 0.0
+    thesatlexp_pld65_sphv_10hv = 1.0
+    thesatw_pld65_sphv_10hv   = 1.75
+    thesatlw_pld65_sphv_10hv  = 0.0
+    stthesato_pld65_sphv_10hv = 1.15
+    stthesatl_pld65_sphv_10hv = 0.0
+    stthesatw_pld65_sphv_10hv = -0.05
+    stthesatlw_pld65_sphv_10hv = 0.0
+    thesatbo_pld65_sphv_10hv  = -0.065
+    thesatgo_pld65_sphv_10hv  = 1.0
+    thesatgl_pld65_sphv_10hv  = 0.0
+    thesatgw_pld65_sphv_10hv  = -2.5
+    thesatgw2_pld65_sphv_10hv = 1.35
+    vdscale_pld65_sphv_10hv   = 1.37
+    vdscaleb_pld65_sphv_10hv  = 0.0
+    stvdscale_pld65_sphv_10hv = 0.0
+    axo_pld65_sphv_10hv       = 2.0
+    axl_pld65_sphv_10hv       = 0.0
+    alpl_pld65_sphv_10hv      = 0.012
+    alplexp_pld65_sphv_10hv   = 1.0
+    alpw_pld65_sphv_10hv      = 0.0
+    alp1l1_pld65_sphv_10hv    = 1e-06
+    alp1lexp_pld65_sphv_10hv  = 1.0
+    alp1l2_pld65_sphv_10hv    = 0.0
+    alp1w_pld65_sphv_10hv     = 0.0
+    alp2l1_pld65_sphv_10hv    = 0.0
+    alp2lexp_pld65_sphv_10hv  = 1.0
+    alp2l2_pld65_sphv_10hv    = 0.0
+    alp2w_pld65_sphv_10hv     = 0.0
+    vpo_pld65_sphv_10hv       = 0.1
+    a1o_pld65_sphv_10hv       = 0.000535
+    a1l_pld65_sphv_10hv       = 0.0
+    a1w_pld65_sphv_10hv       = -0.485
+    a2o_pld65_sphv_10hv       = 73.75
+    sta2o_pld65_sphv_10hv     = 0.45
+    a3o_pld65_sphv_10hv       = 1.2
+    a3l_pld65_sphv_10hv       = 0.0
+    a3w_pld65_sphv_10hv       = 0.0
+    a4o_pld65_sphv_10hv       = 0.0
+    a4l_pld65_sphv_10hv       = 0.0
+    a4w_pld65_sphv_10hv       = 0.0
+    gcoo_pld65_sphv_10hv      = 0.0
+    iginvlw_pld65_sphv_10hv   = 0.0
+    igovw_pld65_sphv_10hv     = 0.0
+    igovdw_pld65_sphv_10hv    = 0.0
+    stigo_pld65_sphv_10hv     = 2.0
+    gc2o_pld65_sphv_10hv      = 0.375
+    gc3o_pld65_sphv_10hv      = 0.063
+    chibo_pld65_sphv_10hv     = 3.1
+    agidlw_pld65_sphv_10hv    = 0.0
+    agidldw_pld65_sphv_10hv   = 0.0
+    bgidlo_pld65_sphv_10hv    = 41.0
+    bgidldo_pld65_sphv_10hv   = 41.0
+    stbgidlo_pld65_sphv_10hv  = 0.0
+    stbgidldo_pld65_sphv_10hv = 0.0
+    cgidlo_pld65_sphv_10hv    = 0.0
+    cgidldo_pld65_sphv_10hv   = 0.0
+    cgbovl_pld65_sphv_10hv    = 1e-15
+    cfrw_pld65_sphv_10hv      = 2.4e-16
+    cfrdw_pld65_sphv_10hv     = 0.0
+    fnto_pld65_sphv_10hv      = 1.0
+    nfalw_pld65_sphv_10hv     = 2e+25
+    nfblw_pld65_sphv_10hv     = 0.0
+    nfclw_pld65_sphv_10hv     = 2e-07
+    efo_pld65_sphv_10hv       = 1.05
+    lintnoi_pld65_sphv_10hv   = 0.0
+    alpnoi_pld65_sphv_10hv    = 2.0
+    kvthoweo_pld65_sphv_10hv  = 0.0
+    kvthowel_pld65_sphv_10hv  = 0.0
+    kvthowew_pld65_sphv_10hv  = 0.0
+    kvthowelw_pld65_sphv_10hv = 0.0
+    kuoweo_pld65_sphv_10hv    = 0.0
+    kuowel_pld65_sphv_10hv    = 0.0
+    kuowew_pld65_sphv_10hv    = 0.0
+    kuowelw_pld65_sphv_10hv   = 0.0
+    rgo_pld65_sphv_10hv       = 0.0
+    rsh_pld65_sphv_10hv       = 0.0
+    rbulko_pld65_sphv_10hv    = 0.0
+    rwello_pld65_sphv_10hv    = 0.0
+    rjunso_pld65_sphv_10hv    = 1000.0
+    rjundo_pld65_sphv_10hv    = 380.0
+    rint_pld65_sphv_10hv      = 0.0
+    rvpoly_pld65_sphv_10hv    = 0.0
+    rshg_pld65_sphv_10hv      = 0.0
+    dlsil_pld65_sphv_10hv     = 0.0
+    saref_pld65_sphv_10hv     = 1e-06
+    sbref_pld65_sphv_10hv     = 1e-06
+    wlod_pld65_sphv_10hv      = 0.0
+    kuo_pld65_sphv_10hv       = 0.0
+    kvsat_pld65_sphv_10hv     = 0.0
+    tkuo_pld65_sphv_10hv      = 0.0
+    lkuo_pld65_sphv_10hv      = 0.0
+    wkuo_pld65_sphv_10hv      = 0.0
+    pkuo_pld65_sphv_10hv      = 0.0
+    llodkuo_pld65_sphv_10hv   = 0.0
+    wlodkuo_pld65_sphv_10hv   = 0.0
+    kvtho_pld65_sphv_10hv     = 0.0
+    lkvtho_pld65_sphv_10hv    = 0.0
+    wkvtho_pld65_sphv_10hv    = 0.0
+    pkvtho_pld65_sphv_10hv    = 0.0
+    llodvth_pld65_sphv_10hv   = 0.0
+    wlodvth_pld65_sphv_10hv   = 0.0
+    stetao_pld65_sphv_10hv    = 0.0
+    lodetao_pld65_sphv_10hv   = 1.0
+    scref_pld65_sphv_10hv     = 1e-05
+    web_pld65_sphv_10hv       = 0.0
+    wec_pld65_sphv_10hv       = 0.0
+    adr1o_pld65_sphv_10hv     = 2.5e-05
+    adr1l_pld65_sphv_10hv     = 0.0
+    adr1w_pld65_sphv_10hv     = 0.0002
+    adr2o_pld65_sphv_10hv     = 160.0
+    stadr2o_pld65_sphv_10hv   = -0.3
+    adr3o_pld65_sphv_10hv     = 1.2
+    adr3l_pld65_sphv_10hv     = 0.0
+    adr3w_pld65_sphv_10hv     = 0.0
+    adr4o_pld65_sphv_10hv     = 0.0
+    adr4l_pld65_sphv_10hv     = 0.0
+    adr4w_pld65_sphv_10hv     = 0.0
+    adr5o_pld65_sphv_10hv     = 0.0
+    adr5l_pld65_sphv_10hv     = 0.0
+    adr5w_pld65_sphv_10hv     = 0.0
+    bidr1o_pld65_sphv_10hv    = 0.0
+    bidr1l_pld65_sphv_10hv    = 0.0
+    bidr1w_pld65_sphv_10hv    = 0.0
+    bidr2o_pld65_sphv_10hv    = 0.0
+    bidr2w_pld65_sphv_10hv    = 0.0
+    rtho_pld65_sphv_10hv      = 750.0
+    rthl_pld65_sphv_10hv      = 0.0
+    rthw_pld65_sphv_10hv      = 0.0
+    rthlw_pld65_sphv_10hv     = 0.0
+    strtho_pld65_sphv_10hv    = 0.0
+    strthao_pld65_sphv_10hv   = 0.0
+    ctho_pld65_sphv_10hv      = 0.0
+    cthl_pld65_sphv_10hv      = 0.0
+    cthw_pld65_sphv_10hv      = 0.0
+    cthlw_pld65_sphv_10hv     = 0.0
+    rshldd_pld65_sphv_10hv    = 16700.0
+    xw_pld65_sphv_10hv        = 6.6e-07
+    nwxw_pld65_sphv_10hv      = 0.0
+    xl_pld65_sphv_10hv        = 0.0
+    xlw_pld65_sphv_10hv       = 0.0
+    dxlsat_pld65_sphv_10hv    = -5e-08
+    nst_pld65_sphv_10hv       = 2.0
+    ats_pld65_sphv_10hv       = 0.0
+    dfinf_pld65_sphv_10hv     = 0.075
+    dfw_pld65_sphv_10hv       = -1e-08
+    dfl_pld65_sphv_10hv       = 0.0
+    dflw_pld65_sphv_10hv      = 0.0
+    dp_pld65_sphv_10hv        = 2.0
+    ecrit_pld65_sphv_10hv     = 5400000.0
+    ecorn_pld65_sphv_10hv     = 280000.0
+    xvsat_pld65_sphv_10hv     = 0.0
+    du_pld65_sphv_10hv        = 0.01
+    tc1_pld65_sphv_10hv       = 0.0052
+    tc2_pld65_sphv_10hv       = 6.2e-06
+    tc1l_pld65_sphv_10hv      = 0.0
+    tc2l_pld65_sphv_10hv      = 0.0
+    tc1w_pld65_sphv_10hv      = -1e-09
+    tc2w_pld65_sphv_10hv      = -8e-12
+    theacc_pld65_sphv_10hv    = 0.0
+    theacc2_pld65_sphv_10hv   = 0.03
+    rva_pld65_sphv_10hv       = 450.0
+    dta_pld65_sphv_10hv       = 0.0
+    trj_pld65_sphv_10hv       = 27.0
+    cjarea_pld65_sphv_10hv    = 0.00014
+    cjlsti_pld65_sphv_10hv    = 1e-10
+    cjlgat_pld65_sphv_10hv    = 5e-08
+    vbiarea_pld65_sphv_10hv   = 0.7
+    vbisti_pld65_sphv_10hv    = 0.7
+    vbigat_pld65_sphv_10hv    = 0.7
+    parea_pld65_sphv_10hv     = 0.2
+    psti_pld65_sphv_10hv      = 0.2
+    pgat_pld65_sphv_10hv      = 0.35
+    is1area_pld65_sphv_10hv   = 1e-08
+    ttarea_pld65_sphv_10hv    = 3e-09
+    is2area_pld65_sphv_10hv   = 0.0
+    irarea_pld65_sphv_10hv    = 3e-09
+    stis1area_pld65_sphv_10hv = 3.0
+    stis2area_pld65_sphv_10hv = 3.0
+    stirarea_pld65_sphv_10hv  = 3.0
+    n1area_pld65_sphv_10hv    = 1.0
+    n2area_pld65_sphv_10hv    = 2.0
+    nrarea_pld65_sphv_10hv    = 200.0
+    is1lsti_pld65_sphv_10hv   = 0.0
+    ttlsti_pld65_sphv_10hv    = 3e-09
+    is2lsti_pld65_sphv_10hv   = 0.0
+    irlsti_pld65_sphv_10hv    = 3e-09
+    stis1sti_pld65_sphv_10hv  = 3.0
+    stis2sti_pld65_sphv_10hv  = 3.0
+    stirsti_pld65_sphv_10hv   = 3.0
+    n1sti_pld65_sphv_10hv     = 1.0
+    n2sti_pld65_sphv_10hv     = 2.0
+    nrsti_pld65_sphv_10hv     = 200.0
+    is1lgat_pld65_sphv_10hv   = 0.0
+    ttlgat_pld65_sphv_10hv    = 3e-09
+    is2lgat_pld65_sphv_10hv   = 0.0
+    irlgat_pld65_sphv_10hv    = 0.0
+    stis1gat_pld65_sphv_10hv  = 3.0
+    stis2gat_pld65_sphv_10hv  = 3.0
+    stirgat_pld65_sphv_10hv   = 3.0
+    n1gat_pld65_sphv_10hv     = 1.0
+    n2gat_pld65_sphv_10hv     = 2.0
+    nrgat_pld65_sphv_10hv     = 200.0
+    cjaread_pld65_sphv_10hv   = 0.00012
+    cjlstid_pld65_sphv_10hv   = 1.4e-10
+    cjlgatd_pld65_sphv_10hv   = 1.75e-10
+    vbiaread_pld65_sphv_10hv  = 0.8
+    vbistid_pld65_sphv_10hv   = 1.0
+    vbigatd_pld65_sphv_10hv   = 0.5
+    paread_pld65_sphv_10hv    = 0.65
+    pstid_pld65_sphv_10hv     = 0.38
+    pgatd_pld65_sphv_10hv     = 0.2
+    is1aread_pld65_sphv_10hv  = 3e-07
+    ttaread_pld65_sphv_10hv   = 7e-09
+    is2aread_pld65_sphv_10hv  = 3e-07
+    iraread_pld65_sphv_10hv   = 1e-09
+    stis1aread_pld65_sphv_10hv = 4.0
+    stis2aread_pld65_sphv_10hv = 3.0
+    stiraread_pld65_sphv_10hv = 460000.0
+    n1aread_pld65_sphv_10hv   = 1.2
+    n2aread_pld65_sphv_10hv   = 1.5
+    nraread_pld65_sphv_10hv   = 20000.0
+    is1lstid_pld65_sphv_10hv  = 5e-15
+    ttlstid_pld65_sphv_10hv   = 1.4e-07
+    is2lstid_pld65_sphv_10hv  = 6.5e-13
+    irlstid_pld65_sphv_10hv   = 4e-09
+    stis1stid_pld65_sphv_10hv = 4.0
+    stis2stid_pld65_sphv_10hv = 3.0
+    stirstid_pld65_sphv_10hv  = 460000.0
+    n1stid_pld65_sphv_10hv    = 1.0
+    n2stid_pld65_sphv_10hv    = 1.5
+    nrstid_pld65_sphv_10hv    = 20000.0
+    ttlgatd_pld65_sphv_10hv   = 1e-08
+    irlgatd_pld65_sphv_10hv   = 2e-08
+    stis1gatd_pld65_sphv_10hv = 4.5
+    stis2gatd_pld65_sphv_10hv = 3.0
+    stirgatd_pld65_sphv_10hv  = 460000.0
+    n1gatd_pld65_sphv_10hv    = 1.0
+    n2gatd_pld65_sphv_10hv    = 1.5
+    nrgatd_pld65_sphv_10hv    = 20000.0
+    cjaread2_pld65_sphv_10hv  = 0.00024
+    cjlstid2_pld65_sphv_10hv  = 0.0
+    vbiaread2_pld65_sphv_10hv = 0.5
+    vbistid2_pld65_sphv_10hv  = 0.5
+    paread2_pld65_sphv_10hv   = 0.4
+    pstid2_pld65_sphv_10hv    = 0.4
+    is1aread2_pld65_sphv_10hv = 3e-07
+    ttaread2_pld65_sphv_10hv  = 7e-09
+    is2aread2_pld65_sphv_10hv = 3e-07
+    iraread2_pld65_sphv_10hv  = 1e-09
+    stis1aread2_pld65_sphv_10hv = 4.0
+    stis2aread2_pld65_sphv_10hv = 3.0
+    stiraread2_pld65_sphv_10hv = 460000.0
+    n1aread2_pld65_sphv_10hv  = 1.2
+    n2aread2_pld65_sphv_10hv  = 1.5
+    nraread2_pld65_sphv_10hv  = 20000.0
+    is1lstid2_pld65_sphv_10hv = 5e-15
+    ttlstid2_pld65_sphv_10hv  = 1.4e-07
+    is2lstid2_pld65_sphv_10hv = 6.5e-13
+    irlstid2_pld65_sphv_10hv  = 4e-09
+    stis1stid2_pld65_sphv_10hv = 4.0
+    stis2stid2_pld65_sphv_10hv = 3.0
+    stirstid2_pld65_sphv_10hv = 460000.0
+    n1stid2_pld65_sphv_10hv   = 1.0
+    n2stid2_pld65_sphv_10hv   = 1.5
+    nrstid2_pld65_sphv_10hv   = 20000.0
+    aacc_pld65_sphv_10hv      = 36.0
+    eais1area_pld65_sphv_10hv = 1.12
+    eais2area_pld65_sphv_10hv = 1.12
+    eairarea_pld65_sphv_10hv  = 1.12
+    eais1sti_pld65_sphv_10hv  = 1.12
+    eais2sti_pld65_sphv_10hv  = 1.12
+    eairsti_pld65_sphv_10hv   = 1.12
+    eais1gat_pld65_sphv_10hv  = 1.12
+    eais2gat_pld65_sphv_10hv  = 1.12
+    eairgat_pld65_sphv_10hv   = 1.12
+    eais1aread_pld65_sphv_10hv = 1.12
+    eais2aread_pld65_sphv_10hv = 1.12
+    eairaread_pld65_sphv_10hv = 1.12
+    eais1stid_pld65_sphv_10hv = 1.12
+    eais2stid_pld65_sphv_10hv = 1.12
+    eairstid_pld65_sphv_10hv  = 1.12
+    eais1gatd_pld65_sphv_10hv = 1.12
+    eais2gatd_pld65_sphv_10hv = 1.12
+    eairgatd_pld65_sphv_10hv  = 1.12
+    eais1aread2_pld65_sphv_10hv = 1.12
+    eais2aread2_pld65_sphv_10hv = 1.12
+    eairaread2_pld65_sphv_10hv = 1.12
+    eais1stid2_pld65_sphv_10hv = 1.12
+    eais2stid2_pld65_sphv_10hv = 1.12
+    eairstid2_pld65_sphv_10hv = 1.12
+    mumb_pld65_sphv_10hv      = 0.0
+    ecritw_pld65_sphv_10hv    = -0.8
+    ecritw2_pld65_sphv_10hv   = 2.0
+    ecornw_pld65_sphv_10hv    = 20.0
+    vdscalew_pld65_sphv_10hv  = 0.4
+    tc1_ecrit_pld65_sphv_10hv = -0.0002
+    tc2_ecrit_pld65_sphv_10hv = -1e-09
+    tc1_ecorn_pld65_sphv_10hv = 0.0015
+    tc2_ecorn_pld65_sphv_10hv = 0.0
+    is1lgatd_pld65_sphv_10hv  = 1e-07
+    is2lgatd_pld65_sphv_10hv  = 8e-06
+    ikfaread_pld65_sphv_10hv  = 20000000.0
+    ikfaread2_pld65_sphv_10hv = 20000000.0
+    ikflgatd_pld65_sphv_10hv  = 20000000.0
+    ikflstid_pld65_sphv_10hv  = 20000000.0
+    ikflstid2_pld65_sphv_10hv = 20000000.0
+    nom_delr_tox_nld90b_sphv_10hv = 1.0
+    nom_dela_dw_nld90b_sphv_10hv = -0.0556698248844
+    nom_dela_xw_nld90b_sphv_10hv = -0.0602308460335
+    nom_dela_vfb_nld90b_sphv_10hv = 0.0511095158808
+    nom_delr_mobref_nld90b_sphv_10hv = 1.0
+    nom_delr_ids_nld90b_sphv_10hv = 1.0
+    nom_delr_rshl_nld90b_sphv_10hv = 1.03343772149
+    nom_dela_vtwl_nld90b_sphv_10hv = 0.0139243092467
+    nom_delr_cj_nld90b_sphv_10hv = 1.0
+    nom_delr_is_nld90b_sphv_10hv = 1.0
+    nom_delr_is2_nld90b_sphv_10hv = 1.0
+    nom_delr_ir_nld90b_sphv_10hv = 1.0
+    nom_cfr_s_ply_met_nld90b_sphv_10hv = 7.97e-17
+    nom_cfr_d_ply_met_nld90b_sphv_10hv = 1.04e-17
+    nom_cfr_s_ply_m1ct_nld90b_sphv_10hv = 1.15e-16
+    nom_cfr_d_ply_m1ct_nld90b_sphv_10hv = 1.06e-17
+    nom_delr_cfr_s_ply_met_nld90b_sphv_10hv = 1.0
+    nom_delr_cfr_d_ply_met_nld90b_sphv_10hv = 1.0
+    nom_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = 1.0
+    nom_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = 1.0
