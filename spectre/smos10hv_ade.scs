+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-06
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = 0
+    ldmu0_dte                      = 1.6e-07*0.7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 3.0//um
+    wdvth_dte                      = 0
+    wdmu0_dte                      = 1.0e-07*1.5
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+(temp-27)*(-1.2e-3))
+    dela_cd_nmos_ull_10hv_bsim4    = (nom_dela_cd_nmos_ull_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_nmos_ull_10hv_bsim4)
+    delr_tox_nmos_ull_10hv_bsim4   = (nom_delr_tox_nmos_ull_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_nmos_ull_10hv_bsim4+nsmm_delr_gox_nmos_ull_10hv_bsim4*smm_delr_gox_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_nmos_ull_10hv_bsim4  = (nom_dela_dwox_nmos_ull_10hv_bsim4+nsig_dela_dwox_nmos_ull_10hv_bsim4*sig_dela_dwox_nmos_ull_10hv_bsim4+nsmm_dela_dwox_nmos_ull_10hv_bsim4*smm_dela_dwox_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vfb_nmos_ull_10hv_bsim4   = (nom_dela_vfb_nmos_ull_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_nmos_ull_10hv_bsim4*sig_dela_vfb_nmos_ull_10hv_bsim4+tc_vth_mm*nsmm_dela_vfb_nmos_ull_10hv_bsim4*smm_dela_vfb_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_ubref_nmos_ull_10hv_bsim4 = (nom_delr_ubref_nmos_ull_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_nmos_ull_10hv_bsim4*sig_delr_ubref_nmos_ull_10hv_bsim4+nsmm_delr_ubref_nmos_ull_10hv_bsim4*smm_delr_ubref_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_a0_nmos_ull_10hv_bsim4    = (nom_dela_a0_nmos_ull_10hv_bsim4+nsig_dela_a0_nmos_ull_10hv_bsim4*sig_dela_a0_nmos_ull_10hv_bsim4)
+    dela_b0_nmos_ull_10hv_bsim4    = (nom_dela_b0_nmos_ull_10hv_bsim4+nsig_dela_b0_nmos_ull_10hv_bsim4*sig_dela_b0_nmos_ull_10hv_bsim4)
+    dela_vtl_nmos_ull_10hv_bsim4   = (nom_dela_vtl_nmos_ull_10hv_bsim4+nsig_dela_vtl_nmos_ull_10hv_bsim4*sig_dela_vtl_nmos_ull_10hv_bsim4+nsmm_dela_vtl_nmos_ull_10hv_bsim4*smm_dela_vtl_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_od_nmos_ull_10hv_bsim4    = (nom_dela_od_nmos_ull_10hv_bsim4+nsig_dela_od_nmos_ull_10hv_bsim4*sig_dela_od_nmos_ull_10hv_bsim4+nsmm_dela_dl_nmos_ull_10hv_bsim4*smm_dela_dl_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_nmos_ull_10hv_bsim4    = (dela_cd_nmos_ull_10hv_bsim4+dela_od_nmos_ull_10hv_bsim4)
+    delr_wvsat_nmos_ull_10hv_bsim4 = (nom_delr_wvsat_nmos_ull_10hv_bsim4*(1.0+nsig_delr_wvsat_nmos_ull_10hv_bsim4*sig_delr_wvsat_nmos_ull_10hv_bsim4))
+    delr_vsat_nmos_ull_10hv_bsim4  = ((nom_delr_vsat_nmos_ull_10hv_bsim4+(0.21/w)*delr_wvsat_nmos_ull_10hv_bsim4)*(1.0+nsig_delr_vsat_nmos_ull_10hv_bsim4*sig_delr_vsat_nmos_ull_10hv_bsim4))
+    dela_vtw_nmos_ull_10hv_bsim4   = (nom_dela_vtw_nmos_ull_10hv_bsim4+nsig_dela_vtw_nmos_ull_10hv_bsim4*sig_dela_vtw_nmos_ull_10hv_bsim4+nsmm_dela_vtw_nmos_ull_10hv_bsim4*smm_dela_vtw_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtm_nmos_ull_10hv_bsim4   = (nom_dela_vtm_nmos_ull_10hv_bsim4+nsig_dela_vtm_nmos_ull_10hv_bsim4*sig_dela_vtm_nmos_ull_10hv_bsim4)
+    dela_wwl_nmos_ull_10hv_bsim4   = (nom_dela_wwl_nmos_ull_10hv_bsim4+nsig_dela_wwl_nmos_ull_10hv_bsim4*sig_dela_wwl_nmos_ull_10hv_bsim4)
+    dela_lu0_nmos_ull_10hv_bsim4   = (nom_dela_lu0_nmos_ull_10hv_bsim4+nsig_dela_lu0_nmos_ull_10hv_bsim4*sig_dela_lu0_nmos_ull_10hv_bsim4)
+    delr_rsh_nmos_ull_10hv_bsim4   = (1+nsmm_delr_rsh_nmos_ull_10hv_bsim4*smm_delr_rsh_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_nmos_ull_10hv_bsim4  = (fac_nsub_sti_final*(1+nsmm_delr_nsub_nmos_ull_10hv_bsim4*smm_delr_nsub_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_jtss_nmos_ull_10hv_bsim4  = (exp(nom_dela_jtss_nmos_ull_10hv_bsim4+nsig_dela_jtss_nmos_ull_10hv_bsim4*sig_dela_jtss_nmos_ull_10hv_bsim4))
+    delr_agidl_nmos_ull_10hv_bsim4 = (exp(nom_dela_agidl_nmos_ull_10hv_bsim4+nsig_dela_agidl_nmos_ull_10hv_bsim4*sig_dela_agidl_nmos_ull_10hv_bsim4))
+    delr_wagidl_nmos_ull_10hv_bsim4 = (exp(nom_dela_wagidl_nmos_ull_10hv_bsim4+nsig_dela_wagidl_nmos_ull_10hv_bsim4*sig_dela_wagidl_nmos_ull_10hv_bsim4))
+    delr_voff_nmos_ull_10hv_bsim4  = (1.0+nsmm_delr_voff_nmos_ull_10hv_bsim4*smm_delr_voff_nmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_pvoff_nmos_ull_10hv_bsim4 = (exp(nom_dela_pvoff_nmos_ull_10hv_bsim4+nsig_dela_pvoff_nmos_ull_10hv_bsim4*sig_dela_pvoff_nmos_ull_10hv_bsim4))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.082e-09*delr_tox_nmos_ull_10hv_bsim4)
+    cox                            = (epsox/tox)
+    cfr_gs_nmos_ull                = (1-lpe)*(cfr_nmos_ull_s_ply_met*w+cfr_nmos_ull_s_ply_met_end*2+cfr_nmos_ull_s_ply_ct*w+cfr_nmos_ull_s_ply_ct_end*2)*np+lpe*1e-18
+    cfr_gd_nmos_ull                = (1-lpe)*(cfr_nmos_ull_d_ply_met*w+cfr_nmos_ull_d_ply_met_end*2+cfr_nmos_ull_d_ply_ct*w+cfr_nmos_ull_d_ply_ct_end*2)*np+lpe*1e-18

model nmos_ull_10hv bsim4 type=n version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.082e-09*delr_tox_nmos_ull_10hv_bsim4)
+ toxm     = (3.082e-09)
+ toxp     = (((3.082e-09*delr_tox_nmos_ull_10hv_bsim4))-((0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.3e+17)
+ lndep    = (1e+18)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (1.87e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (9.8)
+ rshg     = (0.1)
+ lint     = (-4.95165448035e-08-0.5e-06*dela_dl_nmos_ull_10hv_bsim4)
+ wint     = (3.078e-08-0.5e-06*dela_dwox_nmos_ull_10hv_bsim4)
+ wl       = (-1.35e-14)
+ lwl      = (-6e-22)
+ wwl      = (1.352e-21+1e-18*dela_wwl_nmos_ull_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (-2.15e-15)
+ wwn      = (1.0)
+ ll       = (1.91777244368e-15)
+ lln      = (1.07388923134)
+ lw       = (6.527e-15)
+ lwn      = (1.0)
+ dwg      = (-1.50035089582e-08)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (8e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (0.42+dela_vfb_nmos_ull_10hv_bsim4+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos_ull_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos_ull_10hv-relimo_ratio1_b_hci_nmos_ull_10hv))
+ lvth0    = (-0.107)
+ wvth0    = (0.0+dela_vtw_nmos_ull_10hv_bsim4)
+ pvth0    = (0.0+dela_vtm_nmos_ull_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.29)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.335*sqrt(delr_nsub_nmos_ull_10hv_bsim4)*(0.6+0.4/delr_tox_nmos_ull_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.0*sqrt(delr_nsub_nmos_ull_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (20.0)
+ lk3      = (0.0)
+ wk3      = (-7.0)
+ pk3      = (0.0)
+ k3b      = (-17.0)
+ lk3b     = (0.0)
+ wk3b     = (6.5)
+ pk3b     = (0.0)
+ w0       = (2.5e-06)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (1.68e-06+1e-06*dela_vtl_nmos_ull_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (4e-08)
+ lpeb     = (0.0)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (3e-09)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (25.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.2*sqrt(delr_tox_nmos_ull_10hv_bsim4))
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.065)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (-7.38766777036e-08)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (-6.676e-13)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.2)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.07)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.89753772595+dela_a0_nmos_ull_10hv_bsim4)*delr_a0_relimo)
+ la0      = (-0.3)
+ wa0      = (4.232e-10)
+ pa0      = (0.0)
+ ags      = (1.18-0.75*((temp+273.15)/(tnom+273.15)-1))
+ lags     = (0.5)
+ wags     = (0.0)
+ pags     = (0.0)
+ b0       = (1.3e-05+1e-4*dela_b0_nmos_ull_10hv_bsim4)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (2.2e-05)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.08)
+ lketa    = (0.0)
+ wketa    = (0.01)
+ pketa    = (0.0018)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((1050.0*delr_ubref_nmos_ull_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.2268+dela_lu0_nmos_ull_10hv_bsim4)
+ wu0      = (0.0)
+ pu0      = (2.88450907608)
+ ua       = (7e-10)
+ lua      = (-2.15479223878e-11)
+ wua      = (5e-12)
+ pua      = (0.0)
+ ub       = (4.25e-18)
+ lub      = (-8.56881342686e-20)
+ wub      = (1.98267604742e-19)
+ pub      = (-3.99994142883e-20)
+ uc       = (0.13)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e+14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (150300.0*delr_vsat_nmos_ull_10hv_bsim4)
+ lvsat    = (-10070.0*delr_vsat_nmos_ull_10hv_bsim4)
+ wvsat    = (0.0)
+ pvsat    = (0.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.1*delr_voff_nmos_ull_10hv_bsim4)
+ lvoff    = (-0.006)
+ wvoff    = (-0.005)
+ pvoff    = (-0.0026*delr_pvoff_nmos_ull_10hv_bsim4)
+ tvoff    = (0.0055)
+ ltvoff   = (-0.00065)
+ wtvoff   = (0.0)
+ ptvoff   = (-8e-05)
+ voffl    = (0.0)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.8)
+ lnfactor = (-0.22)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.108)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-0.03)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.11)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0018)
+ lcit     = (0.0)
+ wcit     = (-0.0003)
+ pcit     = (-1e-06)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.3694)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (-0.01)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.04)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.02)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.03)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-10)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.0)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.007868)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((179.016*delr_rsh_nmos_ull_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (6.29254232196)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (7.27613708465)
+ lprwg    = (-0.148844311162)
+ wprwg    = (0.0)
+ pprwg    = (0.05)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (-0.1)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (2.2e-07*pow((temp+273.15)/(tnom+273.15),-2.5*1))
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (2.95*pow((temp+273.15)/(tnom+273.15),-1.0*0))
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (14.0957114495*pow((temp+273.15)/(tnom+273.15),-0.47))
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (3.8e-08*pow((temp+273.15)/(tnom+273.15),3.0)*delr_agidl_nmos_ull_10hv_bsim4)
+ lagidl   = (2.5e-09*delr_agidl_nmos_ull_10hv_bsim4)
+ wagidl   = (7e-09*delr_wagidl_nmos_ull_10hv_bsim4)
+ pagidl   = (3e-09*delr_wagidl_nmos_ull_10hv_bsim4)
+ bgidl    = (1100000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1300.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.42)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (0.01245*pow((temp+273.15)/(tnom+273.15),-0.25))
+ laigbacc = (0.00042)
+ waigbacc = (-3e-05*pow((temp+273.15)/(tnom+273.15),-0.25))
+ paigbacc = (6e-05)
+ bigbacc  = (0.0024*pow((temp+273.15)/(tnom+273.15),-1.0))
+ lbigbacc = (7e-05)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.06)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (2.5)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.01213*pow((temp+273.15)/(tnom+273.15),0.03))
+ laigbinv = (-0.00011*pow((temp+273.15)/(tnom+273.15),0.03))
+ waigbinv = (2e-05*pow((temp+273.15)/(tnom+273.15),0.03))
+ paigbinv = (-1e-06*pow((temp+273.15)/(tnom+273.15),0.03))
+ bigbinv  = (0.00215)
+ lbigbinv = (-3e-05)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.1)
+ leigbinv = (-0.07)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (0.01143*pow((temp+273.15)/(tnom+273.15),0.03))
+ laigc    = (-2.8e-05*pow((temp+273.15)/(tnom+273.15),0.03))
+ waigc    = (1e-05)
+ paigc    = (1.2e-05*pow((temp+273.15)/(tnom+273.15),0.03))
+ bigc     = (0.001511)
+ lbigc    = (4.440892e-15)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05031)
+ lcigc    = (0.0015476)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.01471*pow((temp+273.15)/(tnom+273.15),-0.1))
+ laigsd   = (-0.00029*pow((temp+273.15)/(tnom+273.15),-0.5))
+ waigsd   = (7.5e-05*pow((temp+273.15)/(tnom+273.15),-0.1))
+ paigsd   = (-5.8e-05*pow((temp+273.15)/(tnom+273.15),-0.1))
+ bigsd    = (0.0032305)
+ lbigsd   = (-0.00034)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.019518)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.005)
+ dlcig    = (2e-08)
+ nigc     = (3.2*pow((temp+273.15)/(tnom+273.15),-0.35))
+ lnigc    = (0.2*pow((temp+273.15)/(tnom+273.15),-0.35))
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (6.15e-09*cox)
+ cgdo     = (6.15e-09*cox)
+ cgbo     = (0.0)
+ cgsl     = (6.5e-11)
+ cgdl     = (6.5e-11)
+ ckappas  = (3.0)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.08e-08)
+ dwc      = (-1.4e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (0.6)
+ lnoff    = (0.4)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.17)
+ lvoffcv  = (-0.0055)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.33)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (3.8e-15)
+ lwc      = (-2.6e-15)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_nmos_ull_sd_body)
+ jsws     = (1.0e6*pjs_junc_nmos_ull_sd_body)
+ jswgs    = (1.0e6*chjs_junc_nmos_ull_sd_body)
+ jtss     = (2e-07*delr_jtss_nmos_ull_10hv_bsim4)
+ jtssws   = (1e-11*delr_jtss_nmos_ull_10hv_bsim4)
+ jtsswgs  = (2e-14*delr_jtss_nmos_ull_10hv_bsim4)
+ njts     = (7.0)
+ njtssw   = (7.0)
+ njtsswg  = (5.0)
+ xtss     = (0.1)
+ xtssws   = (0.1)
+ xtsswgs  = (0.1)
+ vtss     = (15.0)
+ vtssws   = (15.0)
+ vtsswgs  = (15.0)
+ tnjts    = (0.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (0.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_nmos_ull_sd_body)
+ mjs      = (aexm_junc_nmos_ull_sd_body)
+ pbs      = (aphi_junc_nmos_ull_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_nmos_ull_sd_body)
+ mjsws    = (pexm_junc_nmos_ull_sd_body)
+ pbsws    = (pphi_junc_nmos_ull_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_nmos_ull_sd_body)
+ mjswgs   = (chexm_junc_nmos_ull_sd_body)
+ pbswgs   = (chphi_junc_nmos_ull_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.4)
+ lute     = (0.05)
+ wute     = (0.055)
+ pute     = (0.017)
+ kt1      = (-0.28)
+ lkt1     = (0.0)
+ wkt1     = (0.0085)
+ pkt1     = (0.0015)
+ kt1l     = (1.3e-08)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.035)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.03)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.0049)
+ lub1     = (0.0)
+ wub1     = (0.00027)
+ pub1     = (0.0)
+ uc1      = (-0.0011)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0006)
+ lat      = (0.0)
+ wat      = (3e-05)
+ pat      = (0.0)
+ prt      = (0.0)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_nmos_ull_sd_body)
+ xtis     = (1.0)
+ tpb      = (0.0018)
+ tpbsw    = (0.0018)
+ tpbswg   = (0.0018)
+ tcj      = (0.0009)
+ tcjsw    = (0.0009)
+ tcjswg   = (0.0009)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (5.5e-03)
+ lkvth0we = (-0.2e-03)
+ wkvth0we = (-0.2e-03)
+ pkvth0we = (0.15e-03)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (-6.0e-03)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.6e-03)
+ scref    = (1e-06)
+ noia     = (noia_nmos_ull_10hv_bsim4)
+ noib     = (noib_nmos_ull_10hv_bsim4)
+ noic     = (noic_nmos_ull_10hv_bsim4)
+ ef       = (ef_nmos_ull_10hv_bsim4)
+ em       = (em_nmos_ull_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (-6e-07)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

mnmos_ull_10hv_i (d g s b) nmos_ull_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
cfr_gs (g s) capacitor c=(cfr_gs_nmos_ull)
cfr_gd (g d) capacitor c=(cfr_gd_nmos_ull)

include "./smos10hv_ade_dfrt.scs" section=nmos_ull_10hv_dfrt
ends

subckt nmos_ana_10hv (d g s b sub)

parameters
+    l                              = 0.5
+    w                              = 0.69
+    ng                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 0
+    ring                           = 1
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    fault_injection_nmos_ana_leakage_outlier = fault_injection_nmos_ana_leakage_outlier_global
+    nsmm_delr_gox_nmos_ana_10hv_bsim4 = tmp_nsmm_delr_gox_nmos_ana_10hv_bsim4
+    nsmm_dela_vfb_nmos_ana_10hv_bsim4 = tmp_nsmm_dela_vfb_nmos_ana_10hv_bsim4
+    nsmm_delr_nsub_nmos_ana_10hv_bsim4 = tmp_nsmm_delr_nsub_nmos_ana_10hv_bsim4
+    nsmm_dela_vtl_nmos_ana_10hv_bsim4 = tmp_nsmm_dela_vtl_nmos_ana_10hv_bsim4
+    nsmm_dela_dl_nmos_ana_10hv_bsim4 = tmp_nsmm_dela_dl_nmos_ana_10hv_bsim4
+    nsmm_dela_dwox_nmos_ana_10hv_bsim4 = tmp_nsmm_dela_dwox_nmos_ana_10hv_bsim4
+    nsmm_delr_ubref_nmos_ana_10hv_bsim4 = tmp_nsmm_delr_ubref_nmos_ana_10hv_bsim4
+    nsmm_delr_rdsw_nmos_ana_10hv_bsim4 = tmp_nsmm_delr_rdsw_nmos_ana_10hv_bsim4
+    nsmm_dela_vtw_nmos_ana_10hv_bsim4 = tmp_nsmm_dela_vtw_nmos_ana_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos_ana_vthratio       = (1.0)
+    presto_nmos_ana_betaratio      = (2.0)
+    relimo_ratio1_a_hci_nmos_ana_10hv = (0.121870883)
+    relimo_ratio1_b_hci_nmos_ana_10hv = (-0.643836627)
+    nde                            = (mod(ng,2))
+    nse                            = (2-nde)
+    nd                             = ((ng+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    as_i                           = ((as/ng)+(as==0)*(1-lpe)*((lg2aa_nmos_ana_10hv*nse+lg2g_nmos_ana_10hv*nsi)*w/ng))
+    ps_i                           = ((ps/ng)+(ps==0)*(1-lpe)*((2*(lg2aa_nmos_ana_10hv*nse+lg2g_nmos_ana_10hv*nsi)+2*ns*w)/ng))
+    ad_i                           = ((ad/ng)+(ad==0)*(1-lpe)*((lg2aa_nmos_ana_10hv*nde+lg2g_nmos_ana_10hv*ndi)*w/ng))
+    pd_i                           = ((pd/ng)+(pd==0)*(1-lpe)*((2*(lg2aa_nmos_ana_10hv*nde+lg2g_nmos_ana_10hv*ndi)+2*nd*w)/ng))
+    nrs_i                          = (lg2ct_nmos_ana_10hv/w)
+    nrd_i                          = (lg2ct_nmos_ana_10hv/w)
+    liso                           = (laa2iso_left_nmos_ana_10hv+lg2aa_nmos_ana_10hv*(nse+nde)+lg2g_nmos_ana_10hv*(nsi+ndi)+l*ng+laa2iso_right_nmos_ana_10hv)
+    wiso_i                         = (wg2iso_nmos_ana_10hv*2+w)
+    wiso                           = (3*(wiso_i<=3)+wiso_i*(wiso_i>3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    rleak_nmos_ana                 = (5692400)
+    lchmin_nmos_ana                = (0.5)
+    dela_dwox_nmos_ana_wdist       = (0+(wdist==1)*0.157888+(wdist==2)*0.0364142)
+    delr_ubref_nmos_ana_wdist      = (1+(wdist==1)*(0.946105-1)+(wdist==2)*(0.976488-1))
+    dela_dl_nmos_ana_wdist         = (0+(wdist==1)*(-0.21496)+(wdist==2)*(-0.417192))
+    dela_wl_nmos_ana_wdist         = (0+(wdist==1)*(-0.00342809)+(wdist==2)*0.00499454)
+    nmos_ana_astivfb               = (0.005075)
+    nmos_ana_bstivfb               = (-2.28e-3)
+    nmos_ana_astinsub              = (-7.4e-3)
+    nmos_ana_astiubref             = (-0.042)
+    nmos_ana_bstiubref             = (-0.0095)
+    nmos_ana_cstiubref             = (0.0249)
+    nmos_ana_sapar0                = (0.195+0.265*l)
+    nmos_ana_sapar1                = (-0.051-0.02675*l)
+    sa_i                           = (sa+(sa==0)*(0.375+nmos_ana_sapar0*(ng-1)+nmos_ana_sapar1*(ng-1)*log(ng)))
+    sb_i                           = (sb+(sb==0)*(0.375+nmos_ana_sapar0*(ng-1)+nmos_ana_sapar1*(ng-1)*log(ng)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.375)+1/(0.5*l+0.375))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((nmos_ana_astivfb+nmos_ana_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+nmos_ana_astinsub*stress)/(1+nmos_ana_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti_final               = ((stimod_on)*(((1+(nmos_ana_astiubref+l*nmos_ana_bstiubref)*stress+(nmos_ana_cstiubref/sqrt(w)))/(1+(nmos_ana_astiubref+l*nmos_ana_bstiubref)*stress0+(nmos_ana_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = -9.5e-09
+    ldmu0_dte                      = 1.8e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,ng,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,ng,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = -1.8e-08
+    wdmu0_dte                      = 2.2e-7
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    dela_cd_nmos_ana_10hv_bsim4    = (nom_dela_cd_nmos_ana_10hv_bsim4+nsig_dela_cd_cmos_ana_10hv_bsim4*sig_dela_cd_nmos_ana_10hv_bsim4)
+    delr_tox_nmos_ana_10hv_bsim4   = (nom_delr_tox_nmos_ana_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_nmos_ana_10hv_bsim4+nsmm_delr_gox_nmos_ana_10hv_bsim4*smm_delr_gox_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_od_nmos_ana_10hv_bsim4    = (nom_dela_od_nmos_ana_10hv_bsim4+nsig_dela_od_nmos_ana_10hv_bsim4*sig_dela_od_nmos_ana_10hv_bsim4+nsmm_dela_dl_nmos_ana_10hv_bsim4*smm_dela_dl_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_dl_nmos_ana_10hv_bsim4    = (dela_cd_nmos_ana_10hv_bsim4+dela_od_nmos_ana_10hv_bsim4)
+    dela_dwox_nmos_ana_10hv_bsim4  = (nom_dela_dwox_nmos_ana_10hv_bsim4+nsig_dela_dwox_nmos_ana_10hv_bsim4*sig_dela_dwox_nmos_ana_10hv_bsim4+nsmm_dela_dwox_nmos_ana_10hv_bsim4*smm_dela_dwox_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    delr_ubref_nmos_ana_10hv_bsim4 = (nom_delr_ubref_nmos_ana_10hv_bsim4*fac_ub_sti_final*delr_mu0_dte*(1.0+nsig_delr_ubref_nmos_ana_10hv_bsim4*sig_delr_ubref_nmos_ana_10hv_bsim4+nsmm_delr_ubref_nmos_ana_10hv_bsim4*smm_delr_ubref_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_vfb_nmos_ana_10hv_bsim4   = (nom_dela_vfb_nmos_ana_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_nmos_ana_10hv_bsim4*sig_dela_vfb_nmos_ana_10hv_bsim4+nsmm_dela_vfb_nmos_ana_10hv_bsim4*smm_dela_vfb_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)+nsmm_dela_vtl_nmos_ana_10hv_bsim4*smm_dela_vtl_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_nmos_ana_10hv_bsim4*smm_dela_vtw_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)/w)
+    dela_vtl_nmos_ana_10hv_bsim4   = (nom_dela_vtl_nmos_ana_10hv_bsim4+nsig_dela_vtl_nmos_ana_10hv_bsim4*sig_dela_vtl_nmos_ana_10hv_bsim4)
+    delr_rdsw_nmos_ana_10hv_bsim4  = (1.0+nsmm_delr_rdsw_nmos_ana_10hv_bsim4*smm_delr_rdsw_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_vtw_nmos_ana_10hv_bsim4   = (nom_dela_vtw_nmos_ana_10hv_bsim4+nsig_dela_vtw_nmos_ana_10hv_bsim4*sig_dela_vtw_nmos_ana_10hv_bsim4)
+    dela_vtm_nmos_ana_10hv_bsim4   = (nom_dela_vtm_nmos_ana_10hv_bsim4+nsig_dela_vtm_nmos_ana_10hv_bsim4*sig_dela_vtm_nmos_ana_10hv_bsim4)
+    delr_nsub_nmos_ana_10hv_bsim4  = (fac_nsub_sti_final*(1+nsmm_delr_nsub_nmos_ana_10hv_bsim4*smm_delr_nsub_nmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_wwl_nmos_ana_10hv_bsim4   = (nom_dela_wwl_nmos_ana_10hv_bsim4+nsig_dela_wwl_nmos_ana_10hv_bsim4*sig_dela_wwl_nmos_ana_10hv_bsim4)
+    delr_vsat_nmos_ana_10hv_bsim4  = (nom_delr_vsat_nmos_ana_10hv_bsim4*(1.0+nsig_delr_vsat_nmos_ana_10hv_bsim4*sig_delr_vsat_nmos_ana_10hv_bsim4))
+    delr_pvsat_nmos_ana_10hv_bsim4 = (nom_delr_pvsat_nmos_ana_10hv_bsim4*(1.0+nsig_delr_pvsat_nmos_ana_10hv_bsim4*sig_delr_pvsat_nmos_ana_10hv_bsim4))
+    dela_voff_nmos_ana_10hv_bsim4  = (nom_dela_voff_nmos_ana_10hv_bsim4+nsig_dela_voff_nmos_ana_10hv_bsim4*sig_dela_voff_nmos_ana_10hv_bsim4)
+    dela_lvoff_nmos_ana_10hv_bsim4 = (nom_dela_lvoff_nmos_ana_10hv_bsim4+nsig_dela_lvoff_nmos_ana_10hv_bsim4*sig_dela_lvoff_nmos_ana_10hv_bsim4)
+    dela_pvoff_nmos_ana_10hv_bsim4 = (nom_dela_pvoff_nmos_ana_10hv_bsim4+nsig_dela_pvoff_nmos_ana_10hv_bsim4*sig_dela_pvoff_nmos_ana_10hv_bsim4)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.072e-09*delr_tox_nmos_ana_10hv_bsim4)
+    cox                            = (epsox/tox)
+    kboq                           = 8.617087e-5
+    vtm                            = kboq*(temp+273.15)
+    eg                             = 1.16-7.02e-4*(temp+273.15)*(temp+273.15)/((temp+273.15)+1108.0)
+    nit                            = 1.45e10*((temp+273.15)/300.15)*sqrt((temp+273.15)/300.15)*exp(21.5565981-eg/(2.0*vtm))
+    phis                           = vtm*log(1.55e+17/nit)+0.12+0.4
+    tags_nmos_ana_10hv_bsim4       = (-0.414)

model nmos_ana_10hv bsim4 type=n version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.072e-09*delr_tox_nmos_ana_10hv_bsim4)
+ toxm     = (3.072e-09)
+ toxp     = (((3.072e-09*delr_tox_nmos_ana_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.55e+17*delr_nsub_nmos_ana_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (1.37e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ xt       = (1.55e-07)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (-3.702e-08-0.5e-7*dela_dl_nmos_ana_wdist-0.5e-7*dela_dl_nmos_ana_10hv_bsim4)
+ wint     = (6.02e-08-0.5e-7*dela_dwox_nmos_ana_wdist-0.5e-7*dela_dwox_nmos_ana_10hv_bsim4)
+ wl       = (-1.341e-14+1e-12*dela_wl_nmos_ana_wdist)
+ lwl      = (-8.211e-22)
+ wwl      = (9.355e-21+1e-18*dela_wwl_nmos_ana_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (0.0)
+ wwn      = (1.0)
+ ll       = (3.575e-14)
+ lln      = (1.0)
+ lw       = (1e-15)
+ lwn      = (1.0)
+ dwg      = (-1.75e-08)
+ ldwg     = (-2.8e-08)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (-2.6e-08)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (0.22+dela_vfb_nmos_ana_10hv_bsim4+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos_ana_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos_ana_10hv-relimo_ratio1_b_hci_nmos_ana_10hv)+(sqrt(delr_nsub_nmos_ana_10hv_bsim4)-1)*0.8*(28/53)*sqrt(phis))
+ lvth0    = (0.006)
+ wvth0    = (0.0)
+ pvth0    = (0.007+dela_vtm_nmos_ana_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.12)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.24)
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.016)
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (35.0+80*dela_vtw_nmos_ana_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (-40.0)
+ pk3      = (0.0)
+ k3b      = (-28.0)
+ lk3b     = (0.0)
+ wk3b     = (6.38)
+ pk3b     = (0.0)
+ w0       = (1.2e-05)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (4.5e-08+1e-6*dela_vtl_nmos_ana_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (-1.1e-07)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (0.0032)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.011)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.032)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (0.0)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (3.5e-14)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.035)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (-0.05)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = (2.27)
+ la0      = (-0.5581)
+ wa0      = (0.0)
+ pa0      = (-0.331)
+ ags      = (0.81+((temp+273.15)/(tnom+273.15)-1)*tags_nmos_ana_10hv_bsim4)
+ lags     = (0.2858)
+ wags     = (0.0)
+ pags     = (0.4325)
+ b0       = (2e-07)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.07885)
+ lketa    = (0.002)
+ wketa    = (0.01)
+ pketa    = (0.01015)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((340.0*delr_ubref_nmos_ana_wdist*delr_ubref_nmos_ana_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (4.0)
+ ua       = (-1.075e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (2.28e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.1336)
+ luc      = (-0.01)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e+14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (215000.0*delr_vsat_nmos_ana_10hv_bsim4)
+ lvsat    = (-39630.0)
+ wvsat    = (0.0)
+ pvsat    = (5992.0*delr_pvsat_nmos_ana_10hv_bsim4)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.128+dela_voff_nmos_ana_10hv_bsim4)
+ lvoff    = (0.0+dela_lvoff_nmos_ana_10hv_bsim4)
+ wvoff    = (-0.009)
+ pvoff    = (-0.008+dela_pvoff_nmos_ana_10hv_bsim4)
+ tvoff    = (0.001308)
+ ltvoff   = (0.0001296)
+ wtvoff   = (0.001)
+ ptvoff   = (-0.0007)
+ voffl    = (9e-09)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (11.78)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (-1.0)
+ etab     = (-0.07)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.066)
+ dsub     = (0.7)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (-0.0001672)
+ lcit     = (0.0)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.01)
+ lpclm    = (1.5)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.0001)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.0002)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (-1.0)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (1e-15)
+ drout    = (0.056)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.5)
+ lpvag    = (20.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.005)
+ ldelta   = (0.0)
+ wdelta   = (0.001)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((935.2*delr_rdsw_nmos_ana_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (50.94)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.06)
+ prwb     = (0.02087)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.01)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (4.7e-07)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (2.85)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.5)
+ beta0    = (19.0)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (1e-11)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (2502000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (10.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (1.03)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.28e-02*pow((temp+273.15)/(tnom+273.15),-0.25))
+ laigbacc = (5.78e-04)
+ waigbacc = (0.0)
+ paigbacc = (0.0)
+ bigbacc  = (1.91e-03*pow((temp+273.15)/(tnom+273.15),-1.5))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.0)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (1.12e-02)
+ laigbinv = (0.0)
+ waigbinv = (0.0)
+ paigbinv = (0.0)
+ bigbinv  = (1.6e-03)
+ lbigbinv = (0.0)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.3)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (1.188e-02)
+ laigc    = (0.0)
+ waigc    = (0.0)
+ paigc    = (0.0)
+ bigc     = (1.31e-03)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.005)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (1.25e-02*pow((temp+273.15)/(tnom+273.15),-0.12))
+ laigsd   = (4.25e-04*pow((temp+273.15)/(tnom+273.15),0.25))
+ waigsd   = (0.0)
+ paigsd   = (0.0)
+ bigsd    = (1.81e-03*0.15)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (1.0e-08)
+ nigc     = (2.2)
+ lnigc    = (0.0)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (1.3e-10*cox+0.5*cfr_nmos_ana_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos_ana_s_ply_met*1e6-0.5*cfr_nmos_ana_s_ply_met*1e6)
+ cgdo     = (1.3e-10*cox+0.5*cfr_nmos_ana_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos_ana_d_ply_met*1e6-0.5*cfr_nmos_ana_d_ply_met*1e6)
+ cgbo     = (0.0)
+ cgsl     = (4.4e-10)
+ lcgsl    = (0.0)
+ wcgsl    = (0.0)
+ pcgsl    = (0.0)
+ cgdl     = (4.4e-10)
+ lcgdl    = (0.0)
+ wcgdl    = (0.0)
+ pcgdl    = (0.0)
+ ckappas  = (0.06)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (8e-08)
+ dwc      = (-2.2e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.85)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.06)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (-0.005)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.375)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (10.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (-4e-15)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_nmos_ana_sd_body)
+ jsws     = (1.0e6*pjs_junc_nmos_ana_sd_body)
+ jswgs    = (1.0e6*chjs_junc_nmos_ana_sd_body)
+ jtss     = (5e-05)
+ jtssws   = (1e-12)
+ jtsswgs  = (5e-11)
+ njts     = (17.0)
+ njtssw   = (17.0)
+ njtsswg  = (17.0)
+ xtss     = (0.35)
+ xtssws   = (0.8)
+ xtsswgs  = (0.45)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (0.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (0.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_nmos_ana_sd_body)
+ pbs      = (aphi_junc_nmos_ana_sd_body)
+ mjs      = (aexm_junc_nmos_ana_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_nmos_ana_sd_body)
+ pbsws    = (pphi_junc_nmos_ana_sd_body)
+ mjsws    = (pexm_junc_nmos_ana_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_nmos_ana_sd_body)
+ pbswgs   = (chphi_junc_nmos_ana_sd_body)
+ mjswgs   = (chexm_junc_nmos_ana_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.485)
+ lute     = (0.0)
+ wute     = (0.09842)
+ pute     = (0.0)
+ kt1      = (-0.1948)
+ lkt1     = (0.0)
+ wkt1     = (0.01111)
+ pkt1     = (0.0007577)
+ kt1l     = (4.438e-09)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.03006)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (-0.005551)
+ lua1     = (0.00018)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.003401)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.0007994)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.001183)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.0006)
+ lprt     = (0.0)
+ wprt     = (0.0006742)
+ pprt     = (-0.0001)
+ njs      = (ajnd_junc_nmos_ana_sd_body)
+ xtis     = (0.0)
+ tpb      = (0.001364)
+ tpbsw    = (0.0007342)
+ tpbswg   = (0.001403)
+ tcj      = (0.0009162)
+ tcjsw    = (0.0004907)
+ tcjswg   = (0.001088)
+ saref    = (3.75e-07)
+ sbref    = (3.75e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (0.02)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (0.02)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)
+ noia     = (noia_nmos_ana_10hv_bsim4)
+ noib     = (noib_nmos_ana_10hv_bsim4)
+ noic     = (noic_nmos_ana_10hv_bsim4)
+ ef       = (ef_nmos_ana_10hv_bsim4)
+ em       = (em_nmos_ana_10hv_bsim4)

bileak (d s) bsource i=((fault_injection_nmos_ana_leakage_outlier==1)*v(d,s)/(rleak_nmos_ana*l/lchmin_nmos_ana)) tc1=-2e-05 tc2=0
mnmos_ana_10hv_i (d g s b) nmos_ana_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ng sca=sca_f scb=scb_f scc=scc_f
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
aprint_function print_function
+ device="nmos_ana_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_injection_nmos_ana_leakage_outlier

include "./smos10hv_ade_dfrt.scs" section=nmos_ana_10hv_dfrt
ends

subckt pmos_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.195
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrs                            = 0
+    nrd                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    fault_injection_pmos_leakage_outlier = fault_injection_pmos_leakage_outlier_global
+    nsmm_delr_gox_pmos_10hv_bsim4  = tmp_nsmm_delr_gox_pmos_10hv_bsim4
+    nsmm_dela_vfb_pmos_10hv_bsim4  = tmp_nsmm_dela_vfb_pmos_10hv_bsim4
+    nsmm_delr_nsub_pmos_10hv_bsim4 = tmp_nsmm_delr_nsub_pmos_10hv_bsim4
+    nsmm_dela_vtl_pmos_10hv_bsim4  = tmp_nsmm_dela_vtl_pmos_10hv_bsim4
+    nsmm_dela_dl_pmos_10hv_bsim4   = tmp_nsmm_dela_dl_pmos_10hv_bsim4
+    nsmm_dela_dwox_pmos_10hv_bsim4 = tmp_nsmm_dela_dwox_pmos_10hv_bsim4
+    nsmm_delr_ubref_pmos_10hv_bsim4 = tmp_nsmm_delr_ubref_pmos_10hv_bsim4
+    nsmm_delr_rsh_pmos_10hv_bsim4  = tmp_nsmm_delr_rsh_pmos_10hv_bsim4
+    nsmm_dela_vtw_pmos_10hv_bsim4  = tmp_nsmm_dela_vtw_pmos_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos_vthratio           = (1.0)
+    presto_pmos_betaratio          = (0.93)
+    relimo_ratio1_a_hci_pmos_10hv  = (0.057535642)
+    relimo_ratio1_b_hci_pmos_10hv  = (-0.180020672)
+    we                             = (0.5*(wemin_pmos_10hv+w+sqrt((w-wemin_pmos_10hv)*(w-wemin_pmos_10hv))))
+    as_i                           = (as+(as==0)*(1-lpe)*(lg2aa_pmos_10hv*we))
+    ps_i                           = (ps+(ps==0)*(1-lpe)*(2*(lg2aa_pmos_10hv+we)))
+    ad_i                           = (ad+(ad==0)*(1-lpe)*(lg2aa_pmos_10hv*we))
+    pd_i                           = (pd+(pd==0)*(1-lpe)*(2*(lg2aa_pmos_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_pmos_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_pmos_10hv/w))
+    liso                           = (laa2iso_left_pmos_10hv+lg2aa_pmos_10hv+l+lg2aa_pmos_10hv+laa2iso_right_pmos_10hv)
+    wiso                           = (wg2iso_pmos_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    rleak_pmos                     = (437525)
+    lchmin_pmos                    = (0.15)
+    pmos_astivfb                   = (-0.001012)*(-0.4)
+    pmos_bstivfb                   = (1.951e-3)*0.4
+    pmos_astinsub                  = (1.84e-3)*1.3
+    pmos_astiubref                 = (-0.0038)
+    pmos_bstiubref                 = (0.042)
+    pmos_cstiubref                 = (0.012)
+    pmos_sapar0                    = (0.023+0.035*l)
+    pmos_sapar1                    = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+pmos_sapar0*(np-1)+pmos_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+pmos_sapar0*(np-1)+pmos_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pmos_astivfb+pmos_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pmos_astinsub*stress)/(1+pmos_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(pmos_astiubref+l*pmos_bstiubref)*stress+(pmos_cstiubref/sqrt(w)))/(1+(pmos_astiubref+l*pmos_bstiubref)*stress0+(pmos_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-06
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = 2.5e-08
+    ldmu0_dte                      = -1.6e-07
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = 2.5e-08
+    wdmu0_dte                      = 1.6e-07
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    dela_cd_pmos_10hv_bsim4        = (nom_dela_cd_pmos_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_pmos_10hv_bsim4)
+    delr_tox_pmos_10hv_bsim4       = (nom_delr_tox_pmos_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_pmos_10hv_bsim4+nsmm_delr_gox_pmos_10hv_bsim4*smm_delr_gox_pmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_pmos_10hv_bsim4      = (nom_dela_dwox_pmos_10hv_bsim4+nsig_dela_dwox_pmos_10hv_bsim4*sig_dela_dwox_pmos_10hv_bsim4+nsmm_dela_dwox_pmos_10hv_bsim4*smm_dela_dwox_pmos_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vfb_pmos_10hv_bsim4       = (nom_dela_vfb_pmos_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_pmos_10hv_bsim4*sig_dela_vfb_pmos_10hv_bsim4+nsmm_dela_vfb_pmos_10hv_bsim4*smm_dela_vfb_pmos_10hv_bsim4(l,w)/sqrt(1*np)+nsmm_dela_vtl_pmos_10hv_bsim4*smm_dela_vtl_pmos_10hv_bsim4(l,w)/sqrt(1*np)/l+nsmm_dela_vtw_pmos_10hv_bsim4*smm_dela_vtw_pmos_10hv_bsim4(l,w)/sqrt(1*np)/w)
+    delr_ubref_pmos_10hv_bsim4     = (nom_delr_ubref_pmos_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_pmos_10hv_bsim4*sig_delr_ubref_pmos_10hv_bsim4+nsmm_delr_ubref_pmos_10hv_bsim4*smm_delr_ubref_pmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_od_pmos_10hv_bsim4        = (nom_dela_od_pmos_10hv_bsim4+nsig_dela_od_pmos_10hv_bsim4*sig_dela_od_pmos_10hv_bsim4+nsmm_dela_dl_pmos_10hv_bsim4*smm_dela_dl_pmos_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_pmos_10hv_bsim4        = (dela_cd_pmos_10hv_bsim4+dela_od_pmos_10hv_bsim4)
+    dela_vtl_pmos_10hv_bsim4       = (nom_dela_vtl_pmos_10hv_bsim4+nsig_dela_vtl_pmos_10hv_bsim4*sig_dela_vtl_pmos_10hv_bsim4)
+    dela_vtw_pmos_10hv_bsim4       = (nom_dela_vtw_pmos_10hv_bsim4+nsig_dela_vtw_pmos_10hv_bsim4*sig_dela_vtw_pmos_10hv_bsim4)
+    dela_vtm_pmos_10hv_bsim4       = (nom_dela_vtm_pmos_10hv_bsim4+nsig_dela_vtm_pmos_10hv_bsim4*sig_dela_vtm_pmos_10hv_bsim4)
+    dela_a0_pmos_10hv_bsim4        = (nom_dela_a0_pmos_10hv_bsim4+nsig_dela_a0_pmos_10hv_bsim4*sig_dela_a0_pmos_10hv_bsim4)
+    dela_pu0_pmos_10hv_bsim4       = (nom_dela_pu0_pmos_10hv_bsim4+nsig_dela_pu0_pmos_10hv_bsim4*sig_dela_pu0_pmos_10hv_bsim4)
+    delr_rsh_pmos_10hv_bsim4       = (1+nsmm_delr_rsh_pmos_10hv_bsim4*smm_delr_rsh_pmos_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_pmos_10hv_bsim4      = (fac_nsub_sti_final*(1+nsmm_delr_nsub_pmos_10hv_bsim4*smm_delr_nsub_pmos_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_agidl_pmos_10hv_bsim4     = (exp(nom_dela_agidl_pmos_10hv_bsim4+nsig_dela_agidl_pmos_10hv_bsim4*sig_dela_agidl_pmos_10hv_bsim4))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3e-09*delr_tox_pmos_10hv_bsim4)
+    cox                            = (epsox/tox)
+    kboq                           = (8.617087e-5)
+    vtm                            = (kboq*(temp+273.15))
+    eg                             = (1.16-7.02e-4*(temp+273.15)*(temp+273.15)/(temp+1108.0))
+    nit                            = (1.45e10*((temp+273.15)/300.15)*sqrt((temp+273.15)/300.15)*exp(21.5565981-eg/(2.0*vtm)))
+    phis                           = (0.4+vtm*log(1.7e+17/nit)+0.13)

model pmos_10hv bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3e-09*delr_tox_pmos_10hv_bsim4)
+ toxm     = (3e-09)
+ toxp     = (((3e-09*delr_tox_pmos_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.7e+17*delr_nsub_pmos_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (1.57e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ rsh      = (8.3)
+ rshg     = (0.1)
+ lint     = (1.79e-08-0.5e-06*dela_dl_pmos_10hv_bsim4)
+ wint     = (2.82e-08*1.033-0.5e-06*dela_dwox_pmos_10hv_bsim4)
+ wl       = (4e-15)*(-2.15e-06)
+ lwl      = (-6.15e-22)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (-1.082e-14)
+ wwn      = (1.0)
+ ll       = (-5e-16)
+ lln      = (1.0)
+ lw       = (0.0)
+ lwn      = (1.0)
+ dwg      = (-1.0e-08)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (3.37e-10)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (-0.334-dela_vfb_pmos_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_10hv-relimo_ratio1_b_hci_pmos_10hv)-(sqrt(delr_nsub_pmos_10hv_bsim4)-1)*0.3674*(18/5)*sqrt(phis))
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (-0.0007*0.7+dela_vtm_pmos_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.13)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.3674*sqrt(delr_nsub_pmos_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.01816*sqrt(delr_nsub_pmos_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (-49.06+80*dela_vtw_pmos_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (-2.398)
+ pk3      = (0.5)
+ k3b      = (-12.572)
+ lk3b     = (0.0)
+ wk3b     = (14.22)
+ pk3b     = (-0.5)
+ w0       = (2e-06)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (6e-08+1e-06*dela_vtl_pmos_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (4e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (0.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.53)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.32)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (2e-06)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.18)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (500000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.532)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.85+dela_a0_pmos_10hv_bsim4)*delr_a0_relimo)
+ la0      = (0.2222)
+ wa0      = (0.0)
+ pa0      = (0.2)
+ ags      = (0.5315)
+ lags     = (0.3167)
+ wags     = (0.0)
+ pags     = (-0.01)
+ b0       = (0.0)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = ((-0.25e-06)*0.025)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.0201)
+ lketa    = (-0.008)
+ wketa    = (0.015)
+ pketa    = (0.004)
+ a1       = (5.549e-08)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (0.2103)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((113.9*delr_ubref_pmos_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (-0.2)
+ wu0      = (0.3)
+ pu0      = (0.0+dela_pu0_pmos_10hv_bsim4)
+ ua       = (6.784e-10)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (8.572e-19)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (-0.0001042)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (-2e+16)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = ((298500.0)*0.9)
+ lvsat    = (0.0)
+ wvsat    = (0.0)
+ pvsat    = (9000)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.1317)
+ lvoff    = (-0.005)
+ wvoff    = (-0.005)
+ pvoff    = (0.001)
+ tvoff    = (0.003)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (0.0)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.1398)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-0.18)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.56)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.001)
+ lcit     = (0.0003)
+ wcit     = (0.0)
+ pcit     = (-3e-05)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (1.199)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.05563)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.008586)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.5)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (1.0)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (5e-11)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (8.6)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.01)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.00885)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.1099)
+ pditsd   = (0.01375)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((298.342*delr_rsh_pmos_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.5)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (0.0)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (0.9)
+ lalpha1  = (0.0)
+ walpha1  = (3.0)
+ palpha1  = (0.255)
+ beta0    = (18.2)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.1317)
+ agidl    = (2.295e-10*delr_agidl_pmos_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (1000000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (200.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (-0.2)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.3563e-02*pow((temp+273.15)/(tnom+273.15),-0.25))
+ laigbacc = (1.025325e-04*pow((temp+273.15)/(tnom+273.15),-0.5))
+ waigbacc = (0.0e-05*pow((temp+273.15)/(tnom+273.15),-0.25))
+ paigbacc = (7.0e-06)
+ bigbacc  = (2.76785e-03*pow((temp+273.15)/(tnom+273.15),-1.0))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.0)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (1.01505e-02*pow((temp+273.15)/(tnom+273.15),0.1))
+ laigbinv = (-1.5e-04*pow((temp+273.15)/(tnom+273.15),0.1))
+ waigbinv = (8.5e-05*pow((temp+273.15)/(tnom+273.15),0.1))
+ paigbinv = (1.5e-06*pow((temp+273.15)/(tnom+273.15),0.1))
+ bigbinv  = (1e-03*pow((temp+273.15)/(tnom+273.15),0.5))
+ lbigbinv = (-7.875e-05*pow((temp+273.15)/(tnom+273.15),0.5))
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.4)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.03)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (7.9992e-03)
+ laigc    = (6.336e-06)
+ waigc    = (3.752e-05*pow((temp+273.15)/(tnom+273.15),-0.5))
+ paigc    = (3.92e-06*pow((temp+273.15)/(tnom+273.15),-0.5))
+ bigc     = (7.0e-04)
+ lbigc    = (-5.0e-06)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (8.16e-03*pow((temp+273.15)/(tnom+273.15),-0.05))
+ laigsd   = (1.00e-05*pow((temp+273.15)/(tnom+273.15),-0.05))
+ waigsd   = (-3.50e-05)
+ paigsd   = (1.25e-05*pow((temp+273.15)/(tnom+273.15),-0.05))
+ bigsd    = (1.44e-04)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2e-08)
+ nigc     = (3.0)
+ lnigc    = (0.0)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (3e-11*cox+(1-lpe)*0.5*cfr_pmos_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos_s_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_s_ply_met*1e6)
+ cgdo     = (3e-11*cox+(1-lpe)*0.5*cfr_pmos_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos_d_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_d_ply_met*1e6)
+ cgbo     = (1.25e-10)
+ cgsl     = (2.3e-10)
+ cgdl     = (2.3e-10)
+ ckappas  = (1.8)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.55e-08)
+ dwc      = (-3.38e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.8)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.055)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.5)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_sd_body)
+ jtss     = (3e-06)
+ jtssws   = (2.5e-11)
+ jtsswgs  = (4.715e-12)
+ njts     = (30.0)
+ njtssw   = (25.0)
+ njtsswg  = (2.0)
+ xtss     = (0.2)
+ xtssws   = (0.2)
+ xtsswgs  = (0.2)
+ vtss     = (10.0)
+ vtssws   = (3.0)
+ vtsswgs  = (1.0)
+ tnjts    = (0.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (0.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_sd_body)
+ mjs      = (aexm_junc_pmos_sd_body)
+ pbs      = (aphi_junc_pmos_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_sd_body)
+ mjsws    = (pexm_junc_pmos_sd_body)
+ pbsws    = (pphi_junc_pmos_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_sd_body)
+ mjswgs   = (chexm_junc_pmos_sd_body)
+ pbswgs   = (chphi_junc_pmos_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.28)
+ lute     = (0.0)
+ wute     = (-0.03986)
+ pute     = (0.015)
+ kt1      = (-0.207)
+ lkt1     = (0.0)
+ wkt1     = (0.01)
+ pkt1     = (0.0)
+ kt1l     = (-1.027e-08)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.02286)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.001353)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.00507)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (0.038)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.001)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (-0.005)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0002)
+ njs      = (ajnd_junc_pmos_sd_body)
+ xtis     = (3.0)
+ tpb      = (0.001171)
+ tpbsw    = (0.000651)
+ tpbswg   = (0.0004)
+ tcj      = (0.00082)
+ tcjsw    = (0.00022)
+ tcjswg   = (0.001)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (1.0)
+ wlodku0  = (1.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (1.0)
+ wlodvth  = (1.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-5.0e-03)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (-5.0e-03)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ noia     = (noia_pmos_10hv_bsim4)
+ noib     = (noib_pmos_10hv_bsim4)
+ noic     = (noic_pmos_10hv_bsim4)
+ ef       = (ef_pmos_10hv_bsim4)
+ em       = (em_pmos_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.04e-9)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

bileak (d s) bsource i=((fault_injection_pmos_leakage_outlier==1)*v(d,s)/(rleak_pmos*l/lchmin_pmos)) tc1=-2e-05 tc2=0
mpmos_10hv_i (d g s b) pmos_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
xcnwtub_sub (b sub) cnwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
aprint_function print_function
+ device="pmos_10hv"
+ modelfunction="fault_model_leakage_outlier"
+ enableflag=fault_injection_pmos_leakage_outlier

include "./smos10hv_ade_dfrt.scs" section=pmos_10hv_dfrt
ends

subckt pmos_ll_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.195
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrs                            = 0
+    nrd                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_gox_pmos_ll_10hv_bsim4
+    nsmm_dela_vfb_pmos_ll_10hv_bsim4 = tmp_nsmm_dela_vfb_pmos_ll_10hv_bsim4
+    nsmm_delr_nsub_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_nsub_pmos_ll_10hv_bsim4
+    nsmm_dela_vtl_pmos_ll_10hv_bsim4 = tmp_nsmm_dela_vtl_pmos_ll_10hv_bsim4
+    nsmm_dela_dl_pmos_ll_10hv_bsim4 = tmp_nsmm_dela_dl_pmos_ll_10hv_bsim4
+    nsmm_dela_dwox_pmos_ll_10hv_bsim4 = tmp_nsmm_dela_dwox_pmos_ll_10hv_bsim4
+    nsmm_delr_ubref_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_ubref_pmos_ll_10hv_bsim4
+    nsmm_delr_rsh_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_rsh_pmos_ll_10hv_bsim4
+    nsmm_dela_vtw_pmos_ll_10hv_bsim4 = tmp_nsmm_dela_vtw_pmos_ll_10hv_bsim4
+    nsmm_delr_k1_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_k1_pmos_ll_10hv_bsim4
+    nsmm_delr_jtss_pmos_ll_10hv_bsim4 = tmp_nsmm_delr_jtss_pmos_ll_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos_ll_vthratio        = 1.0
+    presto_pmos_ll_betaratio       = 1.1
+    relimo_ratio1_a_hci_pmos_ll_10hv = (0.061845387)
+    relimo_ratio1_b_hci_pmos_ll_10hv = (-0.173335162)
+    we                             = (0.5*(wemin_pmos_ll_10hv+w+sqrt((w-wemin_pmos_ll_10hv)*(w-wemin_pmos_ll_10hv))))
+    as_i                           = ((as)+(as==0)*(1-lpe)*(lg2aa_pmos_ll_10hv*we))
+    ps_i                           = ((ps)+(ps==0)*(1-lpe)*(2*(lg2aa_pmos_ll_10hv+we)))
+    ad_i                           = ((ad)+(ad==0)*(1-lpe)*(lg2aa_pmos_ll_10hv*we))
+    pd_i                           = ((pd)+(pd==0)*(1-lpe)*(2*(lg2aa_pmos_ll_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_pmos_ll_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_pmos_ll_10hv/w))
+    liso                           = (laa2iso_left_pmos_ll_10hv+lg2aa_pmos_ll_10hv+l+lg2aa_pmos_ll_10hv+laa2iso_right_pmos_ll_10hv)
+    wiso                           = (wg2iso_pmos_ll_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    pmos_ll_astivfb                = (0.001012)
+    pmos_ll_bstivfb                = (-1.951e-3)
+    pmos_ll_astinsub               = (1.84e-3)
+    pmos_ll_astiubref              = (-0.0038)
+    pmos_ll_bstiubref              = (0.042*1.3)
+    pmos_ll_cstiubref              = (0.012)
+    pmos_ll_sapar0                 = (0.023+0.035*l)
+    pmos_ll_sapar1                 = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+pmos_ll_sapar0*(np-1)+pmos_ll_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+pmos_ll_sapar0*(np-1)+pmos_ll_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pmos_ll_astivfb+pmos_ll_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pmos_ll_astinsub*stress)/(1+pmos_ll_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(pmos_ll_astiubref+l*pmos_ll_bstiubref)*stress+(pmos_ll_cstiubref/sqrt(w)))/(1+(pmos_ll_astiubref+l*pmos_ll_bstiubref)*stress0+(pmos_ll_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = -2.5e-08
+    ldmu0_dte                      = -1.6e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = -3.5e-08
+    wdmu0_dte                      = 1.1e-7
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+(temp-27)*(-1.2e-3))
+    dela_cd_pmos_ll_10hv_bsim4     = (nom_dela_cd_pmos_ll_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_pmos_ll_10hv_bsim4)
+    delr_tox_pmos_ll_10hv_bsim4    = (nom_delr_tox_pmos_ll_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_pmos_ll_10hv_bsim4+nsmm_delr_gox_pmos_ll_10hv_bsim4*smm_delr_gox_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_pmos_ll_10hv_bsim4   = (nom_dela_dwox_pmos_ll_10hv_bsim4+nsig_dela_dwox_pmos_ll_10hv_bsim4*sig_dela_dwox_pmos_ll_10hv_bsim4+nsmm_dela_dwox_pmos_ll_10hv_bsim4*smm_dela_dwox_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vfb_pmos_ll_10hv_bsim4    = (nom_dela_vfb_pmos_ll_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_pmos_ll_10hv_bsim4*sig_dela_vfb_pmos_ll_10hv_bsim4+tc_vth_mm*nsmm_dela_vfb_pmos_ll_10hv_bsim4*smm_dela_vfb_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_ubref_pmos_ll_10hv_bsim4  = (nom_delr_ubref_pmos_ll_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_pmos_ll_10hv_bsim4*sig_delr_ubref_pmos_ll_10hv_bsim4+nsmm_delr_ubref_pmos_ll_10hv_bsim4*smm_delr_ubref_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_od_pmos_ll_10hv_bsim4     = (nom_dela_od_pmos_ll_10hv_bsim4+nsig_dela_od_pmos_ll_10hv_bsim4*sig_dela_od_pmos_ll_10hv_bsim4+nsmm_dela_dl_pmos_ll_10hv_bsim4*smm_dela_dl_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_pmos_ll_10hv_bsim4     = (dela_cd_pmos_ll_10hv_bsim4+dela_od_pmos_ll_10hv_bsim4)
+    dela_vtl_pmos_ll_10hv_bsim4    = (nom_dela_vtl_pmos_ll_10hv_bsim4+nsig_dela_vtl_pmos_ll_10hv_bsim4*sig_dela_vtl_pmos_ll_10hv_bsim4+nsmm_dela_vtl_pmos_ll_10hv_bsim4*smm_dela_vtl_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtw_pmos_ll_10hv_bsim4    = (nom_dela_vtw_pmos_ll_10hv_bsim4+nsig_dela_vtw_pmos_ll_10hv_bsim4*sig_dela_vtw_pmos_ll_10hv_bsim4+nsmm_dela_vtw_pmos_ll_10hv_bsim4*smm_dela_vtw_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtm_pmos_ll_10hv_bsim4    = (nom_dela_vtm_pmos_ll_10hv_bsim4+nsig_dela_vtm_pmos_ll_10hv_bsim4*sig_dela_vtm_pmos_ll_10hv_bsim4)
+    dela_ags_pmos_ll_10hv_bsim4    = (nom_dela_ags_pmos_ll_10hv_bsim4+nsig_dela_ags_pmos_ll_10hv_bsim4*sig_dela_ags_pmos_ll_10hv_bsim4)
+    delr_rsh_pmos_ll_10hv_bsim4    = (1+nsmm_delr_rsh_pmos_ll_10hv_bsim4*smm_delr_rsh_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_pmos_ll_10hv_bsim4   = (fac_nsub_sti_final*(1+nsmm_delr_nsub_pmos_ll_10hv_bsim4*smm_delr_nsub_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_jtss_pmos_ll_10hv_bsim4   = (exp(nom_dela_jtss_pmos_ll_10hv_bsim4+nsig_dela_jtss_pmos_ll_10hv_bsim4*sig_dela_jtss_pmos_ll_10hv_bsim4)*(1+nsmm_delr_jtss_pmos_ll_10hv_bsim4*smm_delr_jtss_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_k1_pmos_ll_10hv_bsim4     = (1+nsmm_delr_k1_pmos_ll_10hv_bsim4*smm_delr_k1_pmos_ll_10hv_bsim4(l,w)/sqrt(1*np))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.12e-09*delr_tox_pmos_ll_10hv_bsim4)
+    cox                            = (epsox/tox)

model pmos_ll_10hv bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.12e-09*delr_tox_pmos_ll_10hv_bsim4)
+ toxm     = (3.12e-09)
+ toxp     = (((3.12e-09*delr_tox_pmos_ll_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.2e+17)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (2.4e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (6e-09-0.5e-06*dela_dl_pmos_ll_10hv_bsim4)
+ wint     = (4e-09-0.5e-06*dela_dwox_pmos_ll_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (0.0)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (-4.5e-15)
+ wwn      = (1.0)
+ ll       = (0.0)
+ lln      = (1.0)
+ lw       = (-8.068e-16)
+ lwn      = (1.0)
+ dwg      = (-1.3e-08+6.0e-9*((temp+273.15)/(tnom+273.15)-1))
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (6e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (-0.426+dela_vfb_pmos_ll_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_ll_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_ll_10hv-relimo_ratio1_b_hci_pmos_ll_10hv))
+ lvth0    = (0.0365)
+ wvth0    = (0.0)
+ pvth0    = (-0.0001+dela_vtm_pmos_ll_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (-1.5)
+ phin     = (0.1)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.53*sqrt(delr_nsub_pmos_ll_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (-0.01*sqrt(delr_nsub_pmos_ll_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (-11.0+80*dela_vtw_pmos_ll_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (0.3)
+ pk3      = (0.0)
+ k3b      = (4.0)
+ lk3b     = (0.0)
+ wk3b     = (-0.14)
+ pk3b     = (0.0)
+ w0       = (0.0)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (3.18e-07+1e-06*dela_vtl_pmos_ll_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (3e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (1.8e-06)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.0005809)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.9967)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (1.55e-06)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.0)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = (2.1*delr_a0_relimo)
+ la0      = (-0.0562)
+ wa0      = (0.0)
+ pa0      = (0.4)
+ ags      = (0.5-0.3*((temp+273.15)/(tnom+273.15)-1)+dela_ags_pmos_ll_10hv_bsim4)
+ lags     = (0.3751)
+ wags     = (0.0)
+ pags     = (-0.0503)
+ b0       = (7.151e-07)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (6.832e-06)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (0.01)
+ lketa    = (-0.0107)
+ wketa    = (0.001525)
+ pketa    = (0.006283)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((136.4*delr_ubref_pmos_ll_10hv_bsim4)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pmos_ll_betaratio))
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (1.421e-14)
+ ua       = (1.411e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (7.752e-19)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.012)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (-2e+16)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.0)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (560600.0)
+ lvsat    = (11810.0)
+ wvsat    = (0.0)
+ pvsat    = (0.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.0)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.15)
+ lvoff    = (0.0)
+ wvoff    = (0.005)
+ pvoff    = (0.0)
+ tvoff    = (0.002)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (-3e-09)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.0)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (0.0)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.45)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0015)
+ lcit     = (0.0)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.005)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (1.0)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.002786)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (-1.5)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.9)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (0.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-18)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (554900.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.7081)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.04)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = (250.0*delr_rsh_pmos_ll_10hv_bsim4*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (2.6)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (0.0)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (42.73)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (24.1)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (8.6e-11*delr_jtss_pmos_ll_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (870000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1000.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.1)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.2997e-02*pow((temp+273.15)/(tnom+273.15),-0.28))
+ laigbacc = (1.1081e-04*pow((temp+273.15)/(tnom+273.15),-0.29))
+ waigbacc = (6.0e-05*pow((temp+273.15)/(tnom+273.15),-1.0))
+ paigbacc = (-1.75e-05)
+ bigbacc  = (2.746775e-03*pow((temp+273.15)/(tnom+273.15),-1.0))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.0)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (9.999e-03*pow((temp+273.15)/(tnom+273.15),0.125))
+ laigbinv = (-2.100e-04)
+ waigbinv = (2.2125e-04)
+ paigbinv = (4.0e-06)
+ bigbinv  = (1e-03*pow((temp+273.15)/(tnom+273.15),0.5))
+ lbigbinv = (-1.05e-04)
+ wbigbinv = (1.0e-04)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.42)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.03)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (7.6700e-03)
+ laigc    = (0.65e-05)
+ waigc    = (3.0e-05*pow((temp+273.15)/(tnom+273.15),-1.5))
+ paigc    = (5.8e-06*pow((temp+273.15)/(tnom+273.15),1.0))
+ bigc     = (6.79e-04)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (7.8625e-03*pow((temp+273.15)/(tnom+273.15),-0.05))
+ laigsd   = (1.0e-05*pow((temp+273.15)/(tnom+273.15),-0.05))
+ waigsd   = (0.0)
+ paigsd   = (6.0e-06)
+ bigsd    = (1.47e-04)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2e-08)
+ nigc     = (3.0*pow((temp+273.15)/(tnom+273.15),-0.5))
+ lnigc    = (0.3)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (2.808e-10*cox+(1-lpe)*0.5*cfr_pmos_ll_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ll_s_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_ll_s_ply_met*1e6)
+ cgdo     = (2.808e-10*cox+(1-lpe)*0.5*cfr_pmos_ll_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ll_d_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_ll_d_ply_met*1e6)
+ cgbo     = (0.0)
+ cgsl     = (2.1e-10)
+ cgdl     = (2.1e-10)
+ ckappas  = (1.6)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = ((3.8e-08)*1.026)
+ dwc      = ((-1.9e-08)*0.808)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.7)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.07)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (1.0)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (7.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_ll_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_ll_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_ll_sd_body)
+ jtss     = (0.0001*delr_jtss_pmos_ll_10hv_bsim4)
+ jtssws   = (0.0)
+ jtsswgs  = (3e-09*delr_jtss_pmos_ll_10hv_bsim4)
+ njts     = (12.0)
+ njtssw   = (12.0)
+ njtsswg  = (10.0)
+ xtss     = (0.38)
+ xtssws   = (0.0)
+ xtsswgs  = (0.38)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (1.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (1.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_ll_sd_body)
+ mjs      = (aexm_junc_pmos_ll_sd_body)
+ pbs      = (aphi_junc_pmos_ll_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_ll_sd_body)
+ mjsws    = (pexm_junc_pmos_ll_sd_body)
+ pbsws    = (pphi_junc_pmos_ll_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_ll_sd_body)
+ mjswgs   = (chexm_junc_pmos_ll_sd_body)
+ pbswgs   = (chphi_junc_pmos_ll_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.1)
+ lute     = (0.03)
+ wute     = (-0.01599)
+ pute     = (0.0)
+ kt1      = (-0.28)
+ lkt1     = (0.0)
+ wkt1     = (0.02)
+ pkt1     = (-0.004873)
+ kt1l     = (-5e-09)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.01699)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.003)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.01045)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.0516)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (-0.00192)
+ lat      = (0.0)
+ wat      = (0.0002379)
+ pat      = (0.0)
+ prt      = (0.001)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos_ll_sd_body)
+ xtis     = (1.0)
+ tpb      = (0.0035)
+ tpbsw    = (0.004)
+ tpbswg   = (0.003)
+ tcj      = (0.0009)
+ tcjsw    = (0.0009)
+ tcjswg   = (0.001)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-5e-3)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (-5e-4)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ noia     = (noia_pmos_ll_10hv_bsim4)
+ noib     = (noib_pmos_ll_10hv_bsim4)
+ noic     = (noic_pmos_ll_10hv_bsim4)
+ ef       = (ef_pmos_ll_10hv_bsim4)
+ em       = (em_pmos_ll_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

model pmos_ll_10hv_edge bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.12e-09*delr_tox_pmos_ll_10hv_bsim4)
+ toxm     = (3.12e-09)
+ toxp     = (((3.12e-09*delr_tox_pmos_ll_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.2e+17)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (2.4e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.0)
+ lint     = (6e-09-0.5e-06*dela_dl_pmos_ll_10hv_bsim4)
+ wint     = (0.0-0.5e-06*dela_dwox_pmos_ll_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (0.0)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (0.0)
+ wwn      = (1.0)
+ ll       = (0.0)
+ lln      = (1.0)
+ lw       = (0.0)
+ lwn      = (1.0)
+ dwg      = (-1.3e-08+6.0e-9*((temp+273.15)/(tnom+273.15)-1))
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (6e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (-0.426+dela_vfb_pmos_ll_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_ll_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_ll_10hv-relimo_ratio1_b_hci_pmos_ll_10hv))
+ lvth0    = (0.0365)
+ wvth0    = (0.0)
+ pvth0    = (0.0+sqrt(0.195/w)*dela_vtm_pmos_ll_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (-1.5)
+ phin     = (0.1)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.53*sqrt(delr_nsub_pmos_ll_10hv_bsim4)*0.4*delr_k1_pmos_ll_10hv_bsim4)
+ lk1      = ((0.0+0.0168)*sqrt(delr_nsub_pmos_ll_10hv_bsim4))
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (-0.01*sqrt(delr_nsub_pmos_ll_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (0.0+sqrt(0.195/w)*80*dela_vtw_pmos_ll_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (0.0)
+ pk3      = (0.0)
+ k3b      = (0.0)
+ lk3b     = (0.0)
+ wk3b     = (0.0)
+ pk3b     = (0.0)
+ w0       = (0.0)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (3.18e-07+1e-06*dela_vtl_pmos_ll_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (3e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (1.8e-06)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.0005809)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.9967)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (1.55e-06)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.0)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = (2.1*delr_a0_relimo)
+ la0      = (-0.0562)
+ wa0      = (0.0)
+ pa0      = (0.0)
+ ags      = (0.5-0.3*((temp+273.15)/(tnom+273.15)-1)+dela_ags_pmos_ll_10hv_bsim4)
+ lags     = (0.3751)
+ wags     = (0.0)
+ pags     = (0.0)
+ b0       = (7.151e-07)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (6.832e-06)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (0.01)
+ lketa    = (-0.0107)
+ wketa    = (0.0)
+ pketa    = (0.0)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((136.4*delr_ubref_pmos_ll_10hv_bsim4)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pmos_ll_betaratio))
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (0.0)
+ ua       = (1.411e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (7.752e-19)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.012)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (-2e+16)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.0)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (560600.0)
+ lvsat    = (11810.0)
+ wvsat    = (0.0)
+ pvsat    = (0.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.0)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.15)
+ lvoff    = (0.0)
+ wvoff    = (0.0)
+ pvoff    = (0.0)
+ tvoff    = (0.002)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (-3e-09)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0*2.5)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.0)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (0.0)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.45)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0015)
+ lcit     = (0.0)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.005)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (1.0)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.002786)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (-1.5)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.9)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (0.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-18)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (554900.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.7081)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.04)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = (250.0*delr_rsh_pmos_ll_10hv_bsim4*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (0.0)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (42.73)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (24.1)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (8.6e-11*delr_jtss_pmos_ll_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (870000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1000.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.1)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.2997e-02*pow((temp+273.15)/(tnom+273.15),-0.28))
+ laigbacc = (1.1081e-04*pow((temp+273.15)/(tnom+273.15),-0.29))
+ waigbacc = (6.0e-05*pow((temp+273.15)/(tnom+273.15),-1.0))
+ paigbacc = (0.0)
+ bigbacc  = (2.746775e-03*pow((temp+273.15)/(tnom+273.15),-1.0))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.0)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (9.999e-03*pow((temp+273.15)/(tnom+273.15),0.125))
+ laigbinv = (-2.100e-04)
+ waigbinv = (0.0)
+ paigbinv = (0.0)
+ bigbinv  = (1e-03*pow((temp+273.15)/(tnom+273.15),0.5))
+ lbigbinv = (-1.05e-04)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.42)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.03)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (7.6700e-03)
+ laigc    = (0.65e-05)
+ waigc    = (0.0)
+ paigc    = (0.0)
+ bigc     = (6.79e-04)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (7.8625e-03*pow((temp+273.15)/(tnom+273.15),-0.05))
+ laigsd   = (1.0e-05*pow((temp+273.15)/(tnom+273.15),-0.05))
+ waigsd   = (0.0)
+ paigsd   = (0.0)
+ bigsd    = (1.47e-04)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2e-08)
+ nigc     = (3.0*pow((temp+273.15)/(tnom+273.15),-0.5))
+ lnigc    = (0.3)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (2.808e-10*cox+(1-lpe)*0.5*cfr_pmos_ll_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ll_s_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_ll_s_ply_met*1e6)
+ cgdo     = (2.808e-10*cox+(1-lpe)*0.5*cfr_pmos_ll_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ll_d_ply_met*1e6-(1-lpe)*0.5*cfr_pmos_ll_d_ply_met*1e6)
+ cgbo     = (0.0)
+ cgsl     = (2.1e-10)
+ cgdl     = (2.1e-10)
+ ckappas  = (1.6)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0)
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (3.8e-08)
+ dwc      = (-1.9e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.7)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.16)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (1.0)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (7.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_ll_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_ll_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_ll_sd_body)
+ jtss     = (0.0001*delr_jtss_pmos_ll_10hv_bsim4)
+ jtssws   = (0.0)
+ jtsswgs  = (3e-09*delr_jtss_pmos_ll_10hv_bsim4)
+ njts     = (12.0)
+ njtssw   = (12.0)
+ njtsswg  = (10.0)
+ xtss     = (0.38)
+ xtssws   = (0.0)
+ xtsswgs  = (0.38)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (1.0)
+ tnjtssw  = (0.0)
+ tnjtsswg = (1.0)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_ll_sd_body)
+ mjs      = (aexm_junc_pmos_ll_sd_body)
+ pbs      = (aphi_junc_pmos_ll_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_ll_sd_body)
+ mjsws    = (pexm_junc_pmos_ll_sd_body)
+ pbsws    = (pphi_junc_pmos_ll_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_ll_sd_body)
+ mjswgs   = (chexm_junc_pmos_ll_sd_body)
+ pbswgs   = (chphi_junc_pmos_ll_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.1)
+ lute     = (0.03)
+ wute     = (0.0)
+ pute     = (0.0)
+ kt1      = (-0.28)
+ lkt1     = (0.0)
+ wkt1     = (0.0)
+ pkt1     = (0.0)
+ kt1l     = (0.0)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.01699)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.003)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.01045)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.0516)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (-0.00192)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.001)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos_ll_sd_body)
+ xtis     = (1.0)
+ tpb      = (0.0035)
+ tpbsw    = (0.004)
+ tpbswg   = (0.003)
+ tcj      = (0.0009)
+ tcjsw    = (0.0009)
+ tcjswg   = (0.001)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-5e-3)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (-5e-4)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ noia     = (noia_pmos_ll_10hv_bsim4)
+ noib     = (noib_pmos_ll_10hv_bsim4)
+ noic     = (noic_pmos_ll_10hv_bsim4)
+ ef       = (ef_pmos_ll_10hv_bsim4)
+ em       = (em_pmos_ll_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

mpmos_ll_10hv_i (d g s b) pmos_ll_10hv l=l w=w-0.1 ad=ad_i as=as_i pd=pd_i-0.1 ps=ps_i-0.1 nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
mpmos_ll_10hv_edge (d g s b) pmos_ll_10hv_edge l=l w=0.1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 m=np sca=sca_f scb=scb_f scc=scc_f
xcnwtub_sub (b sub) cnwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmos_ll_10hv_dfrt
ends

subckt pmos_ull_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.195
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrs                            = 0
+    nrd                            = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 1
+    ring                           = 0
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_gox_pmos_ull_10hv_bsim4
+    nsmm_dela_vfb_pmos_ull_10hv_bsim4 = tmp_nsmm_dela_vfb_pmos_ull_10hv_bsim4
+    nsmm_delr_nsub_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_nsub_pmos_ull_10hv_bsim4
+    nsmm_dela_vtl_pmos_ull_10hv_bsim4 = tmp_nsmm_dela_vtl_pmos_ull_10hv_bsim4
+    nsmm_dela_dl_pmos_ull_10hv_bsim4 = tmp_nsmm_dela_dl_pmos_ull_10hv_bsim4
+    nsmm_dela_dwox_pmos_ull_10hv_bsim4 = tmp_nsmm_dela_dwox_pmos_ull_10hv_bsim4
+    nsmm_delr_ubref_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_ubref_pmos_ull_10hv_bsim4
+    nsmm_delr_rsh_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_rsh_pmos_ull_10hv_bsim4
+    nsmm_dela_vtw_pmos_ull_10hv_bsim4 = tmp_nsmm_dela_vtw_pmos_ull_10hv_bsim4
+    nsmm_delr_k1_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_k1_pmos_ull_10hv_bsim4
+    nsmm_delr_jtss_pmos_ull_10hv_bsim4 = tmp_nsmm_delr_jtss_pmos_ull_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos_ull_vthratio       = 1.0
+    presto_pmos_ull_betaratio      = 1.1
+    relimo_ratio1_a_hci_pmos_ull_10hv = (0.061845387)
+    relimo_ratio1_b_hci_pmos_ull_10hv = (-0.173335162)
+    we                             = (0.5*(wemin_pmos_ull_10hv+w+sqrt((w-wemin_pmos_ull_10hv)*(w-wemin_pmos_ull_10hv))))
+    as_i                           = ((as)+(as==0)*(1-lpe)*(lg2aa_pmos_ull_10hv*we))
+    ps_i                           = ((ps)+(ps==0)*(1-lpe)*(2*(lg2aa_pmos_ull_10hv+we)))
+    ad_i                           = ((ad)+(ad==0)*(1-lpe)*(lg2aa_pmos_ull_10hv*we))
+    pd_i                           = ((pd)+(pd==0)*(1-lpe)*(2*(lg2aa_pmos_ull_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_pmos_ull_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_pmos_ull_10hv/w))
+    liso                           = (laa2iso_left_pmos_ull_10hv+lg2aa_pmos_ull_10hv+l+lg2aa_pmos_ull_10hv+laa2iso_right_pmos_ull_10hv)
+    wiso                           = (wg2iso_pmos_ull_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    pmos_ull_astivfb               = (0.002112)
+    pmos_ull_bstivfb               = (-1.951e-3*1.5)
+    pmos_ull_astinsub              = (1.84e-3)
+    pmos_ull_astiubref             = (0.038)
+    pmos_ull_bstiubref             = (0.042*1.3)
+    pmos_ull_cstiubref             = (0.3)
+    pmos_ull_sapar0                = (0.023+0.035*l)
+    pmos_ull_sapar1                = (0.052+0.0975*l)
+    sa_i                           = (sa+(sa==0)*(0.345+pmos_ull_sapar0*(np-1)+pmos_ull_sapar1*(np-1)*log(np)))
+    sb_i                           = (sb+(sb==0)*(0.345+pmos_ull_sapar0*(np-1)+pmos_ull_sapar1*(np-1)*log(np)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.345)+1/(0.5*l+0.345))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pmos_ull_astivfb+pmos_ull_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pmos_ull_astinsub*stress)/(1+pmos_ull_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(pmos_ull_astiubref+l*pmos_ull_bstiubref)*stress+(pmos_ull_cstiubref/sqrt(w)))/(1+(pmos_ull_astiubref+l*pmos_ull_bstiubref)*stress0+(pmos_ull_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,np,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,np,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = -2.5e-08*0
+    ldmu0_dte                      = -1.6e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,np,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,np,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = -3.5e-08*0
+    wdmu0_dte                      = 1.1e-7*0.5
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+(temp-27)*(-1.2e-3))
+    dela_cd_pmos_ull_10hv_bsim4    = (nom_dela_cd_pmos_ull_10hv_bsim4+nsig_dela_cd_cmos_10hv_bsim4*sig_dela_cd_pmos_ull_10hv_bsim4)
+    delr_tox_pmos_ull_10hv_bsim4   = (nom_delr_tox_pmos_ull_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_pmos_ull_10hv_bsim4+nsmm_delr_gox_pmos_ull_10hv_bsim4*smm_delr_gox_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_dwox_pmos_ull_10hv_bsim4  = (nom_dela_dwox_pmos_ull_10hv_bsim4+nsig_dela_dwox_pmos_ull_10hv_bsim4*sig_dela_dwox_pmos_ull_10hv_bsim4+nsmm_dela_dwox_pmos_ull_10hv_bsim4*smm_dela_dwox_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    sig_dela_vfbl_pmos_ull_10hv_bsim4 = sig_dela_vfb_pmos_ull_10hv_bsim4*(lm/(lm+0.105*fscale))
+    dela_vfb_pmos_ull_10hv_bsim4   = (nom_dela_vfb_pmos_ull_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_pmos_ull_10hv_bsim4*sig_dela_vfbl_pmos_ull_10hv_bsim4+tc_vth_mm*nsmm_dela_vfb_pmos_ull_10hv_bsim4*smm_dela_vfb_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_ubref_pmos_ull_10hv_bsim4 = (nom_delr_ubref_pmos_ull_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1.0+nsig_delr_ubref_pmos_ull_10hv_bsim4*sig_delr_ubref_pmos_ull_10hv_bsim4+nsmm_delr_ubref_pmos_ull_10hv_bsim4*smm_delr_ubref_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    dela_od_pmos_ull_10hv_bsim4    = (nom_dela_od_pmos_ull_10hv_bsim4+nsig_dela_od_pmos_ull_10hv_bsim4*sig_dela_od_pmos_ull_10hv_bsim4+nsmm_dela_dl_pmos_ull_10hv_bsim4*smm_dela_dl_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_dl_pmos_ull_10hv_bsim4    = (dela_cd_pmos_ull_10hv_bsim4+dela_od_pmos_ull_10hv_bsim4)
+    dela_vtl_pmos_ull_10hv_bsim4   = (nom_dela_vtl_pmos_ull_10hv_bsim4+nsig_dela_vtl_pmos_ull_10hv_bsim4*sig_dela_vtl_pmos_ull_10hv_bsim4+nsmm_dela_vtl_pmos_ull_10hv_bsim4*smm_dela_vtl_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtw_pmos_ull_10hv_bsim4   = (nom_dela_vtw_pmos_ull_10hv_bsim4+nsig_dela_vtw_pmos_ull_10hv_bsim4*sig_dela_vtw_pmos_ull_10hv_bsim4+nsmm_dela_vtw_pmos_ull_10hv_bsim4*smm_dela_vtw_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    dela_vtm_pmos_ull_10hv_bsim4   = (nom_dela_vtm_pmos_ull_10hv_bsim4+nsig_dela_vtm_pmos_ull_10hv_bsim4*sig_dela_vtm_pmos_ull_10hv_bsim4)
+    dela_a0_pmos_ull_10hv_bsim4    = (nom_dela_a0_pmos_ull_10hv_bsim4+nsig_dela_a0_pmos_ull_10hv_bsim4*sig_dela_a0_pmos_ull_10hv_bsim4)
+    dela_b0_pmos_ull_10hv_bsim4    = (nom_dela_b0_pmos_ull_10hv_bsim4+nsig_dela_b0_pmos_ull_10hv_bsim4*sig_dela_b0_pmos_ull_10hv_bsim4)
+    dela_la0_pmos_ull_10hv_bsim4   = (nom_dela_la0_pmos_ull_10hv_bsim4+nsig_dela_la0_pmos_ull_10hv_bsim4*sig_dela_la0_pmos_ull_10hv_bsim4)
+    dela_pa0_pmos_ull_10hv_bsim4   = (nom_dela_pa0_pmos_ull_10hv_bsim4+nsig_dela_pa0_pmos_ull_10hv_bsim4*sig_dela_pa0_pmos_ull_10hv_bsim4)
+    dela_wwl_pmos_ull_10hv_bsim4   = (nom_dela_wwl_pmos_ull_10hv_bsim4+nsig_dela_wwl_pmos_ull_10hv_bsim4*sig_dela_wwl_pmos_ull_10hv_bsim4)
+    delr_rsh_pmos_ull_10hv_bsim4   = (1+nsmm_delr_rsh_pmos_ull_10hv_bsim4*smm_delr_rsh_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    delr_nsub_pmos_ull_10hv_bsim4  = (fac_nsub_sti_final*(1+nsmm_delr_nsub_pmos_ull_10hv_bsim4*smm_delr_nsub_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_jtss_pmos_ull_10hv_bsim4  = (exp(nom_dela_jtss_pmos_ull_10hv_bsim4+nsig_dela_jtss_pmos_ull_10hv_bsim4*sig_dela_jtss_pmos_ull_10hv_bsim4)*(1+nsmm_delr_jtss_pmos_ull_10hv_bsim4*smm_delr_jtss_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np)))
+    delr_agidl_pmos_ull_10hv_bsim4 = (exp(nom_dela_agidl_pmos_ull_10hv_bsim4+nsig_dela_agidl_pmos_ull_10hv_bsim4*sig_dela_agidl_pmos_ull_10hv_bsim4))
+    delr_wagidl_pmos_ull_10hv_bsim4 = (exp(nom_dela_wagidl_pmos_ull_10hv_bsim4+nsig_dela_wagidl_pmos_ull_10hv_bsim4*sig_dela_wagidl_pmos_ull_10hv_bsim4))
+    delr_k1_pmos_ull_10hv_bsim4    = (1+nsmm_delr_k1_pmos_ull_10hv_bsim4*smm_delr_k1_pmos_ull_10hv_bsim4(l,w)/sqrt(1*np))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.08e-09*delr_tox_pmos_ull_10hv_bsim4)
+    cox                            = (epsox/tox)
+    cfr_gs_pmos_ull                = (1-lpe)*(cfr_pmos_ull_s_ply_met*w+cfr_pmos_ull_s_ply_met_end*2+cfr_pmos_ull_s_ply_ct*w+cfr_pmos_ull_s_ply_ct_end*2)*np+lpe*1e-18
+    cfr_gd_pmos_ull                = (1-lpe)*(cfr_pmos_ull_d_ply_met*w+cfr_pmos_ull_d_ply_met_end*2+cfr_pmos_ull_d_ply_ct*w+cfr_pmos_ull_d_ply_ct_end*2)*np+lpe*1e-18

model pmos_ull_10hv bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.08e-09*delr_tox_pmos_ull_10hv_bsim4)
+ toxm     = (3.08e-09)
+ toxp     = (((3.08e-09*delr_tox_pmos_ull_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (2.8e+16)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (2.4e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (3.3e-08-0.5e-06*dela_dl_pmos_ull_10hv_bsim4)
+ wint     = (7e-09-0.5e-06*dela_dwox_pmos_ull_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (0.0)
+ wwl      = (0.0+1e-18*dela_wwl_pmos_ull_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (-2.5e-15)
+ wwn      = (1.0)
+ ll       = (-3.3e-15)
+ lln      = (1.0)
+ lw       = (0)
+ lwn      = (1.0)
+ dwg      = (-1.4e-08)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (1.2e-08)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (-0.393+dela_vfb_pmos_ull_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_ull_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_ull_10hv-relimo_ratio1_b_hci_pmos_ull_10hv))
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (-0.0025+dela_vtm_pmos_ull_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (-1.5)
+ phin     = (0.05)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.55*sqrt(delr_nsub_pmos_ull_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.013*sqrt(delr_nsub_pmos_ull_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (-7.3+80*dela_vtw_pmos_ull_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (0.0)
+ pk3      = (0.0)
+ k3b      = (4.0)
+ lk3b     = (0.0)
+ wk3b     = (0.0)
+ pk3b     = (0.0)
+ w0       = (0.0)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (1.15e-07+1e-06*dela_vtl_pmos_ull_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (9.0e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (0.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.4)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.0)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (9.555e-06)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.0)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.83228+dela_a0_pmos_ull_10hv_bsim4)*delr_a0_relimo)
+ la0      = (0.0+dela_la0_pmos_ull_10hv_bsim4)
+ wa0      = (0.0)
+ pa0      = (0.02+dela_pa0_pmos_ull_10hv_bsim4)
+ ags      = (0.586966-0.5*((temp+273.15)/(tnom+273.15)-1))
+ lags     = (0.2)
+ wags     = (0.0)
+ pags     = (0.0)
+ b0       = (4e-08+1e-6*dela_b0_pmos_ull_10hv_bsim4)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.09)
+ lketa    = (-0.003)
+ wketa    = (0.022)
+ pketa    = (0.006)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((300*delr_ubref_pmos_ull_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (-2.2)
+ ua       = (3.392e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (3.5e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.15)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (0.0)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.0)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (130000.0)
+ lvsat    = (0.0)
+ wvsat    = (0.0)
+ pvsat    = (0.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.0)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.152)
+ lvoff    = (0.0)
+ wvoff    = (0.009)
+ pvoff    = (0.0)
+ tvoff    = (0.0025)
+ ltvoff   = (0.0)
+ wtvoff   = (0.001)
+ ptvoff   = (0.0)
+ voffl    = (-1.2e-08)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.0)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (0.0)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.5)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0045)
+ lcit     = (0.0001)
+ wcit     = (-0.0003)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.4)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.015)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.01884)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (-0.15)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.56)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.0)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.02)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = (170.0*delr_rsh_pmos_ull_10hv_bsim4*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (-1.02e-6)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (13.0)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (20.96)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (2e-9*delr_agidl_pmos_ull_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (2e-9*delr_wagidl_pmos_ull_10hv_bsim4)
+ pagidl   = (0.0)
+ bgidl    = (1200000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1700.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.3)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (0.0135*pow((temp+273.15)/(tnom+273.15),-0.3))
+ laigbacc = (0.000155*pow((temp+273.15)/(tnom+273.15),-0.5))
+ waigbacc = (0.0001*pow((temp+273.15)/(tnom+273.15),-0.8))
+ paigbacc = (-5.5e-06*pow((temp+273.15)/(tnom+273.15),-1.0))
+ bigbacc  = (0.003056*pow((temp+273.15)/(tnom+273.15),-0.9))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.006505)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.0118*pow((temp+273.15)/(tnom+273.15),0.06))
+ laigbinv = (-5.8e-5*pow((temp+273.15)/(tnom+273.15),0.08))
+ waigbinv = (2.8e-05*pow((temp+273.15)/(tnom+273.15),-1.5))
+ paigbinv = (-5e-06*pow((temp+273.15)/(tnom+273.15),0.0))
+ bigbinv  = (0.002)
+ lbigbinv = (-7.075e-06)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.006)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.3)
+ leigbinv = (-0.03853)
+ weigbinv = (0.02186)
+ peigbinv = (-0.0022)
+ nigbinv  = (1.5)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (0.007506*pow((temp+273.15)/(tnom+273.15),0.05))
+ laigc    = (8e-6)
+ waigc    = (2.14e-05*pow((temp+273.15)/(tnom+273.15),-1.0))
+ paigc    = (-5e-7)
+ bigc     = (0.0005201)*pow((temp+273.15)/(tnom+273.15),0.4)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.00865*pow((temp+273.15)/(tnom+273.15),-0.05))
+ laigsd   = (4.5e-05*pow((temp+273.15)/(tnom+273.15),0.0))
+ waigsd   = (4.3e-05*pow((temp+273.15)/(tnom+273.15),0.0))
+ paigsd   = (-3e-6)
+ bigsd    = (0.00115)
+ lbigsd   = (-4e-05)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0125)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (3.65e-08)
+ nigc     = (3.0)
+ lnigc    = (0.458)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cf       = (0.0)
+ cgso     = (6.6e-9*cox)
+ cgdo     = (6.6e-9*cox)
+ cgbo     = (0.0)
+ cgsl     = (1.65e-10)
+ cgdl     = (1.65e-10)
+ ckappas  = (1.4)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.05e-08)
+ dwc      = (-8.0e-09)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.0)
+ lnoff    = (0.3)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.08)
+ lvoffcv  = (-0.01)
+ wvoffcv  = (-0.003)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.55)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (2.0e-15)
+ lwc      = (-1.5e-15)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_ull_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_ull_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_ull_sd_body)
+ jtss     = (2e-12*delr_jtss_pmos_ull_10hv_bsim4)
+ jtssws   = (3e-10*delr_jtss_pmos_ull_10hv_bsim4)
+ jtsswgs  = (2e-10*delr_jtss_pmos_ull_10hv_bsim4)
+ njts     = (12.0)
+ njtssw   = (7.8)
+ njtsswg  = (7.0)
+ xtss     = (0.0)
+ xtssws   = (0.38)
+ xtsswgs  = (0.45)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (0.0)
+ tnjtssw  = (1.0)
+ tnjtsswg = (1.3)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_ull_sd_body)
+ mjs      = (aexm_junc_pmos_ull_sd_body)
+ pbs      = (aphi_junc_pmos_ull_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_ull_sd_body)
+ mjsws    = (pexm_junc_pmos_ull_sd_body)
+ pbsws    = (pphi_junc_pmos_ull_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_ull_sd_body)
+ mjswgs   = (chexm_junc_pmos_ull_sd_body)
+ pbswgs   = (chphi_junc_pmos_ull_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-0.9)
+ lute     = (0.01)
+ wute     = (-0.005)
+ pute     = (0.005)
+ kt1      = (-0.41)
+ lkt1     = (0.0)
+ wkt1     = (0.016)
+ pkt1     = (-0.0008)
+ kt1l     = (-5e-9)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.03)
+ lkt2     = (-0.005)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.007)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.0065)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.0015)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.0)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos_ull_sd_body)
+ xtis     = (0.419)
+ tpb      = (0.0012)
+ tpbsw    = (0.0013-0.0002)
+ tpbswg   = (0.0011)
+ tcj      = (0.0007)
+ tcjsw    = (0.0006)
+ tcjswg   = (0.0006+0.0002)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-0.011)
+ lkvth0we = (-0.125e-03)
+ wkvth0we = (0.6e-03)
+ pkvth0we = (0.04e-03)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (6.0e-03)
+ lku0we   = (0.6e-03)
+ wku0we   = (-0.8e-03)
+ pku0we   = (-0.1e-03)
+ scref    = (1e-06)
+ noia     = (noia_pmos_ull_10hv_bsim4)
+ noib     = (noib_pmos_ull_10hv_bsim4)
+ noic     = (noic_pmos_ull_10hv_bsim4)
+ ef       = (ef_pmos_ull_10hv_bsim4)
+ em       = (em_pmos_ull_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

model pmos_ull_10hv_edge bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ wpemod   = (1.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.08e-09*delr_tox_pmos_ull_10hv_bsim4)
+ toxm     = (3.08e-09)
+ toxp     = (((3.08e-09*delr_tox_pmos_ull_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (2.8e+16)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ lnsub    = (0.0)
+ wnsub    = (0.0)
+ pnsub    = (0.0)
+ ngate    = (2.4e+20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.0)
+ lint     = (3.3e-08-0.5e-06*dela_dl_pmos_ull_10hv_bsim4)
+ wint     = (0.0-0.5e-06*dela_dwox_pmos_ull_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (0.0)
+ wwl      = (0.0+1e-18*dela_wwl_pmos_ull_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (0.0)
+ wwn      = (1.0)
+ ll       = (-3.3e-15)
+ lln      = (1.0)
+ lw       = (0.0)
+ lwn      = (1.0)
+ dwg      = (-1.4e-08)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (1.2e-08)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = ((-0.393+dela_vfb_pmos_ull_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_ull_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_ull_10hv-relimo_ratio1_b_hci_pmos_ull_10hv))+0.03)
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (0.0+sqrt(0.195/w)*dela_vtm_pmos_ull_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (-1.5)
+ phin     = (0.05)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.55*sqrt(delr_nsub_pmos_ull_10hv_bsim4)*0.27*delr_k1_pmos_ull_10hv_bsim4)
+ lk1      = ((0.0+0.0168*1.2)*sqrt(delr_nsub_pmos_ull_10hv_bsim4))
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.013*sqrt(delr_nsub_pmos_ull_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (0.0+sqrt(0.195/w)*80*dela_vtw_pmos_ull_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (0.0)
+ pk3      = (0.0)
+ k3b      = (0.0)
+ lk3b     = (0.0)
+ wk3b     = (0.0)
+ pk3b     = (0.0)
+ w0       = (0.0)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (1.15e-07+1e-06*dela_vtl_pmos_ull_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (9.0e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (0.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.4)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (0.0)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (9.555e-06)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (0.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.0)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.83228+dela_a0_pmos_ull_10hv_bsim4)*delr_a0_relimo)
+ la0      = (0.0+dela_la0_pmos_ull_10hv_bsim4)
+ wa0      = (0.0)
+ pa0      = (0.0+(0.1/0.195)*dela_pa0_pmos_ull_10hv_bsim4)
+ ags      = (0.586966-0.5*((temp+273.15)/(tnom+273.15)-1))
+ lags     = (0.2)
+ wags     = (0.0)
+ pags     = (0.0)
+ b0       = (4e-08+1e-6*(0.1/0.195)*dela_b0_pmos_ull_10hv_bsim4)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.09)
+ lketa    = (-0.003)
+ wketa    = (0.0)
+ pketa    = (0.0)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((300*delr_ubref_pmos_ull_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (0.0)
+ ua       = (3.392e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (3.5e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.15)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (0.0)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.0)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (130000.0)
+ lvsat    = (0.0)
+ wvsat    = (0.0)
+ pvsat    = (0.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.0)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = ((-0.152)*0.6)
+ lvoff    = (0.0)
+ wvoff    = (0.0)
+ pvoff    = (0.0)
+ tvoff    = (0.0025)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (-1.2e-08)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.0)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (0.0)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.5)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = ((0.0045)*0.55)
+ lcit     = (0.0001)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.4)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.015)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.01884)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (-0.15)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.56)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.0)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.02)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = (170.0*delr_rsh_pmos_ull_10hv_bsim4*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (-1.02e-6)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (13.0)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (20.96)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (2e-9*delr_agidl_pmos_ull_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (1200000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (1700.0)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.3)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (0.0135*pow((temp+273.15)/(tnom+273.15),-0.3))
+ laigbacc = (0.000155*pow((temp+273.15)/(tnom+273.15),-0.5))
+ waigbacc = (0.0001*pow((temp+273.15)/(tnom+273.15),-0.8))
+ paigbacc = (-5.5e-06*pow((temp+273.15)/(tnom+273.15),-1.0))
+ bigbacc  = (0.003056*pow((temp+273.15)/(tnom+273.15),-0.9))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.006505)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.0118*pow((temp+273.15)/(tnom+273.15),0.06))
+ laigbinv = (-5.8e-05*pow((temp+273.15)/(tnom+273.15),0.08))
+ waigbinv = (2.8e-05*pow((temp+273.15)/(tnom+273.15),-1.5))
+ paigbinv = (-5e-06*pow((temp+273.15)/(tnom+273.15),0.0))
+ bigbinv  = (0.002)
+ lbigbinv = (-7.075e-06)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.006)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.3)
+ leigbinv = (-0.03853)
+ weigbinv = (0.02186)
+ peigbinv = (-0.0022)
+ nigbinv  = (1.5)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (0.007506*pow((temp+273.15)/(tnom+273.15),0.05))
+ laigc    = (8e-6)
+ waigc    = (2.14e-05*pow((temp+273.15)/(tnom+273.15),-1.0))
+ paigc    = (-5e-7)
+ bigc     = (0.0005201)*pow((temp+273.15)/(tnom+273.15),0.4)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.05)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.00865*pow((temp+273.15)/(tnom+273.15),-0.05))
+ laigsd   = (4.5e-05*pow((temp+273.15)/(tnom+273.15),0.0))
+ waigsd   = (4.3e-05*pow((temp+273.15)/(tnom+273.15),0.0))
+ paigsd   = (-3e-6)
+ bigsd    = (0.00115)
+ lbigsd   = (-4e-05)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0125)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (3.65e-08)
+ nigc     = (3.0)
+ lnigc    = (0.458)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cf       = (0.0)
+ cgso     = (6.6e-9*cox)
+ cgdo     = (6.6e-9*cox)
+ cgbo     = (0.0)
+ cgsl     = (1.65e-10)
+ cgdl     = (1.65e-10)
+ ckappas  = (1.4)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.05e-08)
+ dwc      = (-8.0e-09)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.0)
+ lnoff    = (0.3)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.08)
+ lvoffcv  = (-0.01)
+ wvoffcv  = (-0.003)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.55)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (2.0e-15)
+ lwc      = (-1.5e-15)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_ull_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_ull_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_ull_sd_body)
+ jtss     = (2e-12*delr_jtss_pmos_ull_10hv_bsim4)
+ jtssws   = (3e-10*delr_jtss_pmos_ull_10hv_bsim4)
+ jtsswgs  = (2e-10*delr_jtss_pmos_ull_10hv_bsim4)
+ njts     = (12.0)
+ njtssw   = (7.8)
+ njtsswg  = (7.0)
+ xtss     = (0.0)
+ xtssws   = (0.38)
+ xtsswgs  = (0.45)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (0.0)
+ tnjtssw  = (1.0)
+ tnjtsswg = (1.3)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_ull_sd_body)
+ mjs      = (aexm_junc_pmos_ull_sd_body)
+ pbs      = (aphi_junc_pmos_ull_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_ull_sd_body)
+ mjsws    = (pexm_junc_pmos_ull_sd_body)
+ pbsws    = (pphi_junc_pmos_ull_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_ull_sd_body)
+ mjswgs   = (chexm_junc_pmos_ull_sd_body)
+ pbswgs   = (chphi_junc_pmos_ull_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-0.9)
+ lute     = (0.01)
+ wute     = (0.0)
+ pute     = (0.0)
+ kt1      = (-0.41)
+ lkt1     = (0.0)
+ wkt1     = (0.0)
+ pkt1     = (0.0)
+ kt1l     = (-5e-9)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.03)
+ lkt2     = (-0.005)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.007)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.0065)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.0015)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.0)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos_ull_sd_body)
+ xtis     = (0.419)
+ tpb      = (0.0012)
+ tpbsw    = (0.0013-0.0002)
+ tpbswg   = (0.0011)
+ tcj      = (0.0007)
+ tcjsw    = (0.0006)
+ tcjswg   = (0.0006+0.0002)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-0.011)
+ lkvth0we = (-0.125e-03)
+ wkvth0we = (0.6e-03)
+ pkvth0we = (0.04e-03)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (6.0e-03)
+ lku0we   = (0.6e-03)
+ wku0we   = (-0.8e-03)
+ pku0we   = (-0.1e-03)
+ scref    = (1e-06)
+ noia     = (noia_pmos_ull_10hv_bsim4)
+ noib     = (noib_pmos_ull_10hv_bsim4)
+ noic     = (noic_pmos_ull_10hv_bsim4)
+ ef       = (ef_pmos_ull_10hv_bsim4)
+ em       = (em_pmos_ull_10hv_bsim4)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)

mpmos_ull_10hv_i (d g s b) pmos_ull_10hv l=l w=w-0.1 ad=ad_i as=as_i pd=pd_i-0.1 ps=ps_i-0.1 nrd=nrd_i nrs=nrs_i m=np sca=sca_f scb=scb_f scc=scc_f
mpmos_ull_10hv_edge (d g s b) pmos_ull_10hv_edge l=l w=0.1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 m=np sca=sca_f scb=scb_f scc=scc_f
xcnwtub_sub (b sub) cnwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)
cfr_gs (g s) capacitor c=(cfr_gs_pmos_ull)
cfr_gd (g d) capacitor c=(cfr_gd_pmos_ull)

include "./smos10hv_ade_dfrt.scs" section=pmos_ull_10hv_dfrt
ends

subckt pmos_ana_10hv (d g s b sub)

parameters
+    l                              = 0.5
+    w                              = 0.69
+    ng                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 0
+    ring                           = 1
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_pmos_ana_10hv_bsim4 = tmp_nsmm_delr_gox_pmos_ana_10hv_bsim4
+    nsmm_dela_vfb_pmos_ana_10hv_bsim4 = tmp_nsmm_dela_vfb_pmos_ana_10hv_bsim4
+    nsmm_delr_nsub_pmos_ana_10hv_bsim4 = tmp_nsmm_delr_nsub_pmos_ana_10hv_bsim4
+    nsmm_dela_vtl_pmos_ana_10hv_bsim4 = tmp_nsmm_dela_vtl_pmos_ana_10hv_bsim4
+    nsmm_dela_dl_pmos_ana_10hv_bsim4 = tmp_nsmm_dela_dl_pmos_ana_10hv_bsim4
+    nsmm_dela_dwox_pmos_ana_10hv_bsim4 = tmp_nsmm_dela_dwox_pmos_ana_10hv_bsim4
+    nsmm_delr_ubref_pmos_ana_10hv_bsim4 = tmp_nsmm_delr_ubref_pmos_ana_10hv_bsim4
+    nsmm_delr_rsh_pmos_ana_10hv_bsim4 = tmp_nsmm_delr_rsh_pmos_ana_10hv_bsim4
+    nsmm_dela_vtw_pmos_ana_10hv_bsim4 = tmp_nsmm_dela_vtw_pmos_ana_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos_ana_vthratio       = 1.0
+    presto_pmos_ana_betaratio      = 1.19
+    relimo_ratio1_a_hci_pmos_ana_10hv = (0.163957799)
+    relimo_ratio1_b_hci_pmos_ana_10hv = (-0.547171286)
+    nde                            = (mod(ng,2))
+    nse                            = (2-nde)
+    nd                             = ((ng+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    as_i                           = ((as/ng)+(as==0)*(1-lpe)*((lg2aa_pmos_ana_10hv*nse+lg2g_pmos_ana_10hv*nsi)*w/ng))
+    ps_i                           = ((ps/ng)+(ps==0)*(1-lpe)*((2*(lg2aa_pmos_ana_10hv*nse+lg2g_pmos_ana_10hv*nsi)+2*ns*w)/ng))
+    ad_i                           = ((ad/ng)+(ad==0)*(1-lpe)*((lg2aa_pmos_ana_10hv*nde+lg2g_pmos_ana_10hv*ndi)*w/ng))
+    pd_i                           = ((pd/ng)+(pd==0)*(1-lpe)*((2*(lg2aa_pmos_ana_10hv*nde+lg2g_pmos_ana_10hv*ndi)+2*nd*w)/ng))
+    nrs_i                          = (lg2ct_pmos_ana_10hv/w)
+    nrd_i                          = (lg2ct_pmos_ana_10hv/w)
+    liso                           = (laa2iso_left_pmos_ana_10hv+lg2aa_pmos_ana_10hv*(nse+nde)+lg2g_pmos_ana_10hv*(nsi+ndi)+l*ng+laa2iso_right_pmos_ana_10hv)
+    wiso_i                         = (wg2iso_pmos_ana_10hv*2+w)
+    wiso                           = (3*(wiso_i<=3)+wiso_i*(wiso_i>3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    delr_ubref_pmos_ana_wdist      = (1+(wdist==1)*(1.01578-1)+(wdist==2)*(1.01413-1))
+    dela_dl_pmos_ana_wdist         = (0+(wdist==1)*0.170453+(wdist==2)*0.100632)
+    pmos_ana_astivfb               = (-0.00105)
+    pmos_ana_bstivfb               = (5.528e-4)
+    pmos_ana_astinsub              = (-1.034e-3)
+    pmos_ana_astiubref             = (0.085)
+    pmos_ana_bstiubref             = (0.0155)
+    pmos_ana_cstiubref             = (0.0119)
+    pmos_ana_sapar0                = (0.195+0.265*l)
+    pmos_ana_sapar1                = (-0.051-0.02675*l)
+    sa_i                           = (sa+(sa==0)*(0.375+pmos_ana_sapar0*(ng-1)+pmos_ana_sapar1*(ng-1)*log(ng)))
+    sb_i                           = (sb+(sb==0)*(0.375+pmos_ana_sapar0*(ng-1)+pmos_ana_sapar1*(ng-1)*log(ng)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.375)+1/(0.5*l+0.375))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pmos_ana_astivfb+pmos_ana_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pmos_ana_astinsub*stress)/(1+pmos_ana_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti_final               = ((stimod_on)*(((1+(pmos_ana_astiubref+l*pmos_ana_bstiubref)*stress+(pmos_ana_cstiubref/sqrt(w)))/(1+(pmos_ana_astiubref+l*pmos_ana_bstiubref)*stress0+(pmos_ana_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    corner_dte                     = 1e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = 1.0e-8
+    ldmu0_dte                      = -5.2e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,ng,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,ng,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+18*corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = 3.5e-08
+    wdmu0_dte                      = 5.6e-7
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+20*corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    dela_cd_pmos_ana_10hv_bsim4    = (nom_dela_cd_pmos_ana_10hv_bsim4+nsig_dela_cd_cmos_ana_10hv_bsim4*sig_dela_cd_pmos_ana_10hv_bsim4)
+    delr_tox_pmos_ana_10hv_bsim4   = (nom_delr_tox_pmos_ana_10hv_bsim4*(1.0+nsig_delr_mosfet_thin_tox_bsim4*sig_delr_tox_pmos_ana_10hv_bsim4+nsmm_delr_gox_pmos_ana_10hv_bsim4*smm_delr_gox_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_dwox_pmos_ana_10hv_bsim4  = (nom_dela_dwox_pmos_ana_10hv_bsim4+nsig_dela_dwox_pmos_ana_10hv_bsim4*sig_dela_dwox_pmos_ana_10hv_bsim4+nsmm_dela_dwox_pmos_ana_10hv_bsim4*smm_dela_dwox_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_vfb_pmos_ana_10hv_bsim4   = (nom_dela_vfb_pmos_ana_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_pmos_ana_10hv_bsim4*sig_dela_vfb_pmos_ana_10hv_bsim4+nsmm_dela_vfb_pmos_ana_10hv_bsim4*smm_dela_vfb_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)+nsmm_dela_vtl_pmos_ana_10hv_bsim4*smm_dela_vtl_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_pmos_ana_10hv_bsim4*smm_dela_vtw_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)/w)
+    dela_vtl_pmos_ana_10hv_bsim4   = (nom_dela_vtl_pmos_ana_10hv_bsim4+nsig_dela_vtl_pmos_ana_10hv_bsim4*sig_dela_vtl_pmos_ana_10hv_bsim4)
+    dela_od_pmos_ana_10hv_bsim4    = (nom_dela_od_pmos_ana_10hv_bsim4+nsig_dela_od_pmos_ana_10hv_bsim4*sig_dela_od_pmos_ana_10hv_bsim4+nsmm_dela_dl_pmos_ana_10hv_bsim4*smm_dela_dl_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_dl_pmos_ana_10hv_bsim4    = (dela_cd_pmos_ana_10hv_bsim4+dela_od_pmos_ana_10hv_bsim4)
+    delr_ubref_pmos_ana_10hv_bsim4 = (nom_delr_ubref_pmos_ana_10hv_bsim4*fac_ub_sti_final*delr_mu0_dte*(1.0+nsig_delr_ubref_pmos_ana_10hv_bsim4*sig_delr_ubref_pmos_ana_10hv_bsim4+nsmm_delr_ubref_pmos_ana_10hv_bsim4*smm_delr_ubref_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_vtw_pmos_ana_10hv_bsim4   = (nom_dela_vtw_pmos_ana_10hv_bsim4+nsig_dela_vtw_pmos_ana_10hv_bsim4*sig_dela_vtw_pmos_ana_10hv_bsim4)
+    dela_vtm_pmos_ana_10hv_bsim4   = (nom_dela_vtm_pmos_ana_10hv_bsim4+nsig_dela_vtm_pmos_ana_10hv_bsim4*sig_dela_vtm_pmos_ana_10hv_bsim4)
+    dela_lwl_pmos_ana_10hv_bsim4   = (nom_dela_lwl_pmos_ana_10hv_bsim4+nsig_dela_lwl_pmos_ana_10hv_bsim4*sig_dela_lwl_pmos_ana_10hv_bsim4)
+    dela_wvoff_pmos_ana_10hv_bsim4 = (nom_dela_wvoff_pmos_ana_10hv_bsim4+nsig_dela_wvoff_pmos_ana_10hv_bsim4*sig_dela_wvoff_pmos_ana_10hv_bsim4)
+    dela_pvoff_pmos_ana_10hv_bsim4 = (nom_dela_pvoff_pmos_ana_10hv_bsim4+nsig_dela_pvoff_pmos_ana_10hv_bsim4*sig_dela_pvoff_pmos_ana_10hv_bsim4)
+    dela_a0_pmos_ana_10hv_bsim4    = (nom_dela_a0_pmos_ana_10hv_bsim4+nsig_dela_a0_pmos_ana_10hv_bsim4*sig_dela_a0_pmos_ana_10hv_bsim4)
+    delr_rsh_pmos_ana_10hv_bsim4   = (1+nsmm_delr_rsh_pmos_ana_10hv_bsim4*smm_delr_rsh_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng))
+    delr_nsub_pmos_ana_10hv_bsim4  = (fac_nsub_sti_final*(1+nsmm_delr_nsub_pmos_ana_10hv_bsim4*smm_delr_nsub_pmos_ana_10hv_bsim4(l,w)/sqrt(1*ng)))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.2e-09*delr_tox_pmos_ana_10hv_bsim4)
+    cox                            = (epsox/tox)
+    kboq                           = 8.617087e-5
+    vtm                            = kboq*(temp+273.15)
+    eg                             = 1.16-7.02e-4*(temp+273.15)*(temp+273.15)/((temp+273.15)+1108.0)
+    nit                            = 1.45e10*((temp+273.15)/300.15)*sqrt((temp+273.15)/300.15)*exp(21.5565981-eg/(2.0*vtm))
+    phis                           = vtm*log(1.7e+17/nit)+0.14+0.4
+    talpha0_pmos_ana_10hv_bsim4    = (1.8)

model pmos_ana_10hv bsim4 type=p version=4.70
+ minr     = (1e-4)
+ vbox     = (500)
+ diomod   = (1.0)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ igcmod   = (2.0)
+ igbmod   = (1.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (3.2e-09*delr_tox_pmos_ana_10hv_bsim4)
+ toxm     = (3.2e-09)
+ toxp     = (((3.2e-09*delr_tox_pmos_ana_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1.7e+17*delr_nsub_pmos_ana_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (1.57e+21)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ xt       = (1.55e-07)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (8.3)
+ rshg     = (0.1)
+ lint     = (-1e-08-0.5e-7*dela_dl_pmos_ana_wdist-0.5e-7*dela_dl_pmos_ana_10hv_bsim4)
+ wint     = (-4.5e-08-0.5e-7*dela_dwox_pmos_ana_10hv_bsim4)
+ wl       = (-1e-14)
+ lwl      = (-6.15e-22+1e-18*dela_lwl_pmos_ana_10hv_bsim4)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (-4.5e-14)
+ wwn      = (1.0)
+ ll       = (-1.8e-14)
+ lln      = (1.0)
+ lw       = (-1e-14)
+ lwn      = (1.0)
+ dwg      = (1e-08)
+ ldwg     = (0.0)
+ wdwg     = (-2.3e-08)
+ pdwg     = (0.0)
+ dwb      = (1e-08)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = (-0.322-dela_vfb_pmos_ana_10hv_bsim4-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos_ana_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos_ana_10hv-relimo_ratio1_b_hci_pmos_ana_10hv)-(sqrt(delr_nsub_pmos_ana_10hv_bsim4)-1)*0.8*(95/53)*sqrt(phis))
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (0.007+dela_vtm_pmos_ana_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.14)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.373*sqrt(delr_nsub_pmos_ana_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.016*sqrt(delr_nsub_pmos_ana_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (-5.0+80*dela_vtw_pmos_ana_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (-16.0)
+ pk3      = (0.0)
+ k3b      = (3.0)
+ lk3b     = (0.0)
+ wk3b     = (11.0)
+ pk3b     = (1.0)
+ w0       = (1.5e-06)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (7e-08+1.0e-06*dela_vtl_pmos_ana_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (5e-09)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (2.0)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.115)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.07)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (0.0)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.18)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (500000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.532)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = (1.3+dela_a0_pmos_ana_10hv_bsim4)
+ la0      = (-0.432)
+ wa0      = (0.0)
+ pa0      = (0.0)
+ ags      = (0.4205)
+ lags     = (0.405)
+ wags     = (0.0)
+ pags     = (0.1)
+ b0       = (0.0)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.01)
+ lketa    = (-0.02)
+ wketa    = (-0.005)
+ pketa    = (0.0)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((114.0*delr_ubref_pmos_ana_wdist*delr_ubref_pmos_ana_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (50.0)
+ wu0      = (-30.0)
+ pu0      = (-26.0)
+ ua       = (6.64e-10)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (1e-18)
+ lub      = (1.25e-19)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (-0.025)
+ luc      = (0.02)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (-2e+16)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (90000.0)
+ lvsat    = (20000.0)
+ wvsat    = (0.0)
+ pvsat    = (10000.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.145)
+ lvoff    = (0)
+ wvoff    = (-0.025+dela_wvoff_pmos_ana_10hv_bsim4)
+ pvoff    = (0.001+dela_pvoff_pmos_ana_10hv_bsim4)
+ tvoff    = (0.0018)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (0.0)
+ minv     = (-0.35)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.12)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-0.18)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (0.30)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.001)
+ lcit     = (0.0)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.2)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.1)
+ pdiblc1  = (0.3)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (3e-05)
+ lpdiblc2 = (0.0003)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.5)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.30)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-11)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (6.0)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.01)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.003)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.01375)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((900.0*delr_rsh_pmos_ana_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (0.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (0.0)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (1e-05*pow((temp+273.15)/(tnom+273.15),talpha0_pmos_ana_10hv_bsim4))
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (5e-06)
+ alpha1   = (9.0)
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (27.0)
+ lbeta0   = (1.0)
+ wbeta0   = (1.0)
+ pbeta0   = (0.0)
+ agidl    = (4e-11)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (1950000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (0.5)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.8)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (1.25e-02*pow((temp+273.15)/(tnom+273.15),-0.27))
+ laigbacc = (1.5e-04)
+ waigbacc = (0.0)
+ paigbacc = (0.0)
+ bigbacc  = (2.51e-03*pow((temp+273.15)/(tnom+273.15),-1.2))
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.0)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (3.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.95e-02)
+ laigbinv = (0.0)
+ waigbinv = (0.0)
+ paigbinv = (0.0)
+ bigbinv  = (9.0e-04)
+ lbigbinv = (0.0)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.0)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.45)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (7.45e-03)
+ laigc    = (5.55e-05)
+ waigc    = (0.0)
+ paigc    = (0.0)
+ bigc     = (3.8e-04)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.005)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.0083*pow((temp+273.15)/(tnom+273.15),-0.20))
+ laigsd   = (3.3e-04*pow((temp+273.15)/(tnom+273.15),-0.20))
+ waigsd   = (0.0)
+ paigsd   = (0.0)
+ bigsd    = (0.00135*0.15*pow((temp+273.15)/(tnom+273.15),-0.55))
+ lbigsd   = (-1.0e-04*0.15*pow((temp+273.15)/(tnom+273.15),-0.55))
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.0)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (2e-08)
+ nigc     = (2.0)
+ lnigc    = (0.0)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (3.2e-09)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (6.5e-11*cox+0.5*cfr_pmos_ana_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ana_s_ply_met*1e6-0.5*cfr_pmos_ana_s_ply_met*1e6)
+ cgdo     = (6.5e-11*cox+0.5*cfr_pmos_ana_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos_ana_d_ply_met*1e6-0.5*cfr_pmos_ana_d_ply_met*1e6)
+ cgbo     = (1.25e-10)
+ cgsl     = (1.7e-10)
+ cgdl     = (1.7e-10)
+ ckappas  = (0.6)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (5e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (4.2e-08)
+ dwc      = (-3.5e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.4)
+ lnoff    = (0.5)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.095)
+ lvoffcv  = (-0.05)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.9)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (15.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (0.0)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.1)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos_ana_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos_ana_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos_ana_sd_body)
+ njts     = (8.0)
+ njtssw   = (6.0)
+ njtsswg  = (8.0)
+ xtss     = (0.3)
+ xtssws   = (0.2)
+ xtsswgs  = (0.4)
+ vtss     = (3.0)
+ vtssws   = (3.0)
+ vtsswgs  = (3.0)
+ tnjts    = (-0.3)
+ tnjtssw  = (-0.3)
+ tnjtsswg = (-0.3)
+ jtweff   = (0.0)
+ cjs      = (1.0e12*acj0_junc_pmos_ana_sd_body)
+ pbs      = (aphi_junc_pmos_ana_sd_body)
+ mjs      = (aexm_junc_pmos_ana_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos_ana_sd_body)
+ pbsws    = (pphi_junc_pmos_ana_sd_body)
+ mjsws    = (pexm_junc_pmos_ana_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos_ana_sd_body)
+ pbswgs   = (chphi_junc_pmos_ana_sd_body)
+ mjswgs   = (chexm_junc_pmos_ana_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.28)
+ lute     = (-0.09)
+ wute     = (0.15)
+ pute     = (0.085)
+ kt1      = (-0.207)
+ lkt1     = (0.0)
+ wkt1     = (0.05)
+ pkt1     = (-0.01)
+ kt1l     = (2.5e-08)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.02286)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (0.0)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-0.003)
+ lub1     = (0.0)
+ wub1     = (0.0008)
+ pub1     = (-0.0003)
+ uc1      = (0.02)
+ luc1     = (-0.02)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.0)
+ lprt     = (0.0)
+ wprt     = (0.0)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos_ana_sd_body)
+ xtis     = (0.01)
+ tpb      = (0.001171)
+ tpbsw    = (0.000651)
+ tpbswg   = (0.0004)
+ tcj      = (0.00082)
+ tcjsw    = (0.00022)
+ tcjswg   = (0.001)
+ saref    = (3.45e-07)
+ sbref    = (3.45e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (1.0)
+ wlodku0  = (1.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (1.0)
+ wlodvth  = (1.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (0.0)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (0.0)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)
+ noia     = (noia_pmos_ana_10hv_bsim4)
+ noib     = (noib_pmos_ana_10hv_bsim4)
+ noic     = (noic_pmos_ana_10hv_bsim4)
+ ef       = (ef_pmos_ana_10hv_bsim4)
+ em       = (em_pmos_ana_10hv_bsim4)

mpmos_ana_10hv_i (d g s b) pmos_ana_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ng
xcnwtub_sub (b sub) cnwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmos_ana_10hv_dfrt
ends

subckt nmos3_zvt_10hv (d g s b sub)

parameters
+    l                              = 1.11
+    w                              = 0.69
+    ng                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 0
+    ring                           = 1
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3
+    nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3
+    nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3
+    nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3
+    nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3
+    nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3
+    nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3
+    nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3
+    nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3 = tmp_nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos3_zvt_vthratio      = (1.0)
+    presto_nmos3_zvt_betaratio     = (1.05)
+    relimo_ratio1_a_hci_nmos3_zvt_10hv = (0.167966407)
+    relimo_ratio1_b_hci_nmos3_zvt_10hv = (-0.577035393)
+    nde                            = (mod(ng,2))
+    nse                            = (2-nde)
+    nd                             = ((ng+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    default_as                     = ((lg2aa_s_nmos3_zvt_10hv*(wg2aa_se_nmos3_zvt_10hv+w)*nse+lg2g_s_nmos3_zvt_10hv*(wg2aa_si_nmos3_zvt_10hv+w)*nsi)/ngtotal)
+    default_ps                     = ((2*((lg2aa_s_nmos3_zvt_10hv+wg2aa_se_nmos3_zvt_10hv+w)*nse+(lg2g_s_nmos3_zvt_10hv+wg2aa_si_nmos3_zvt_10hv+w)*nsi))/ngtotal)
+    default_ad                     = ((lg2aa_d_nmos3_zvt_10hv*(wg2aa_de_nmos3_zvt_10hv+w)*nde+lg2g_d_nmos3_zvt_10hv*(wg2aa_di_nmos3_zvt_10hv+w)*ndi)/ngtotal)
+    default_pd                     = ((2*((lg2aa_d_nmos3_zvt_10hv+wg2aa_de_nmos3_zvt_10hv+w)*nde+(lg2g_d_nmos3_zvt_10hv+wg2aa_di_nmos3_zvt_10hv+w)*ndi))/ngtotal)
+    as_i                           = ((acj0_junc_nmos3_zvt_s_body/acj0_junc_nmos3_zvt_d_body)*((as/ngtotal)+(as==0)*(1-lpe)*default_as))
+    ps_i                           = ((pcj0_junc_nmos3_zvt_s_body/pcj0_junc_nmos3_zvt_d_body)*((ps/ngtotal)+(ps==0)*(1-lpe)*default_ps))
+    ad_i                           = ((ad/ngtotal)+(ad==0)*(1-lpe)*default_ad)
+    pd_i                           = ((pd/ngtotal)+(pd==0)*(1-lpe)*default_pd)
+    nrs_i                          = (lg2ct_s_nmos3_zvt_10hv/w)
+    nrd_i                          = (lg2ct_d_nmos3_zvt_10hv/w)
+    liso                           = (1.8+(lg2aa_s_nmos3_zvt_10hv*nse+lg2g_s_nmos3_zvt_10hv*nsi)+l*ng+(lg2g_d_nmos3_zvt_10hv*ndi+lg2aa_d_nmos3_zvt_10hv*nde)+1.11)
+    wiso                           = (wg2trench_nmos3_zvt_10hv+w)
+    abox2sub                       = (wiso*liso)
+    pbox2sub                       = ((wiso+liso)*2)
+    d_perim_ch                     = ((nde*w+2*ndi*w)/ngtotal)
+    d_perim_nonch                  = ((pd_i<=0)*(default_pd-d_perim_ch)+(pd_i>0)*((pd_i>d_perim_ch)*(pd_i-d_perim_ch)+(pd_i<=d_perim_ch)*0))
+    totalperim_d                   = (d_perim_ch+d_perim_nonch)
+    jsw_junc_nmos3_zvt_d_body      = ((pjs_junc_nmos3_zvt_d_body*d_perim_nonch+chjs_junc_nmos3_zvt_d_body*d_perim_ch)/totalperim_d)
+    dela_dwox_nmos3_zvt_wdist      = (0+(wdist==0)*(0.020561)+(wdist==2)*(0.0192777))
+    dela_dl_nmos3_zvt_wdist        = (0+(wdist==0)*(0.00261325)+(wdist==2)*(-0.0131109))
+    dela_vfb_nmos3_zvt_wdist       = (0+(wdist==0)*(0.00533507)+(wdist==2)*(0.00309655))
+    delr_ubref_nmos3_zvt_wdist     = (1+(wdist==0)*(1.06646-1)+(wdist==2)*(1.02573-1))
+    dela_vtl_nmos3_zvt_wdist       = (0+(wdist==0)*(0.0905744)+(wdist==2)*(0.121428))
+    dela_vtw_nmos3_zvt_wdist       = (0+(wdist==0)*(0.141589)+(wdist==2)*(0.0934089))
+    dela_vtm_nmos3_zvt_wdist       = (0+(wdist==0)*(0.0171288)+(wdist==2)*(0.0187818))
+    dela_ags_nmos3_zvt_wdist       = (0+(wdist==0)*(-0.326078)+(wdist==2)*(-0.213035))
+    dela_b0_nmos3_zvt_wdist        = (0+(wdist==0)*(-0.124346)+(wdist==2)*(-0.117261))
+    dela_wwl_nmos3_zvt_wdist       = (0+(wdist==0)*(0.0329054)+(wdist==2)*(0))
+    nmos3_zvt_astivfb              = (-0.0121+0.00688)
+    nmos3_zvt_bstivfb              = (-2.28e-3*0.54)
+    nmos3_zvt_astinsub             = (-3.4e-4*1.2)
+    nmos3_zvt_astiubref            = (-0.046*1.4)
+    nmos3_zvt_bstiubref            = (-0.002)
+    nmos3_zvt_cstiubref            = (0.089*15*1.54)
+    nmos3_zvt_sapar0               = (0.042+0.045*l)
+    nmos3_zvt_sapar1               = (0.12+0.165*l)
+    sa_i                           = (sa+(sa==0)*(0.72+nmos3_zvt_sapar0*(ng-1)+nmos3_zvt_sapar1*(ng-1)*log(ng)))
+    sb_i                           = (sb+(sb==0)*(0.72+nmos3_zvt_sapar0*(ng-1)+nmos3_zvt_sapar1*(ng-1)*log(ng)))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.72)+1/(0.5*l+0.72))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti                    = ((stimod_on)*((nmos3_zvt_astivfb+nmos3_zvt_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti                   = ((stimod_on)*((1+nmos3_zvt_astinsub*stress)/(1+nmos3_zvt_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti                     = ((stimod_on)*(((1+(nmos3_zvt_astiubref+l*nmos3_zvt_bstiubref)*stress+(nmos3_zvt_cstiubref/sqrt(w)))/(1+(nmos3_zvt_astiubref+l*nmos3_zvt_bstiubref)*stress0+(nmos3_zvt_cstiubref/sqrt(w)))))+(1-stimod_on))
+    wscref                         = (1)
+    w2gdrain                       = (1.83)
+    w2gsource                      = (2.52)
+    w2gtop                         = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    w2gbottom                      = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    wsc1_i                         = ((wsc1)+(wdist==0)*(wsc1==0)*(w2gdrain)+(wdist==1)*(40)+(wdist==2)*(10))
+    wsc2_i                         = ((wsc2)+(wdist==0)*(wsc1==0)*(w2gbottom)+(wdist==1)*(40)+(wdist==2)*(10))
+    wsc3_i                         = ((wsc3)+(wdist==0)*(wsc1==0)*(w2gsource)+(wdist==1)*(40)+(wdist==2)*(10))
+    wsc4_i                         = ((wsc4)+(wdist==0)*(wsc1==0)*(w2gtop)+(wdist==1)*(40)+(wdist==2)*(10))
+    wsca                           = ((1/(l*w))*(w*wscref**2*(1/wsc1_i-(1/(wsc1_i+l)))+l*wscref**2*(1/wsc2_i-(1/(wsc2_i+w)))+w*wscref**2*(1/wsc3_i-(1/(wsc3_i+l)))+l*wscref**2*(1/wsc4_i-(1/(wsc4_i+w)))))
+    wscb                           = ((1/(l*w))*(w*wscref/100*((10*wsc1_i/wscref+1)*exp(-10*wsc1_i/wscref)-(10*(wsc1_i+l)/wscref+1)*exp(-10*(wsc1_i+l)/wscref))+l*wscref/100*((10*wsc2_i/wscref+1)*exp(-10*wsc2_i/wscref)-(10*(wsc2_i+w)/wscref+1)*exp(-10*(wsc2_i+w)/wscref))+w*wscref/100*((10*wsc3_i/wscref+1)*exp(-10*wsc3_i/wscref)-(10*(wsc3_i+l)/wscref+1)*exp(-10*(wsc3_i+l)/wscref))+l*wscref/100*((10*wsc4_i/wscref+1)*exp(-10*wsc4_i/wscref)-(10*(wsc4_i+w)/wscref+1)*exp(-10*(wsc4_i+w)/wscref))))
+    wscc                           = ((1/(l*w))*(w*wscref/400*((20*wsc1_i/wscref+1)*exp(-20*wsc1_i/wscref)-(20*(wsc1_i+l)/wscref+1)*exp(-20*(wsc1_i+l)/wscref))+l*wscref/400*((20*wsc2_i/wscref+1)*exp(-20*wsc2_i/wscref)-(20*(wsc2_i+w)/wscref+1)*exp(-20*(wsc2_i+w)/wscref))+w*wscref/400*((20*wsc3_i/wscref+1)*exp(-20*wsc3_i/wscref)-(20*(wsc3_i+l)/wscref+1)*exp(-20*(wsc3_i+l)/wscref))+l*wscref/400*((20*wsc4_i/wscref+1)*exp(-20*wsc4_i/wscref)-(20*(wsc4_i+w)/wscref+1)*exp(-20*(wsc4_i+w)/wscref))))
+    wsc1_ref                       = (1.83)
+    wsc2_ref                       = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    wsc3_ref                       = (2.52)
+    wsc4_ref                       = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    wsca_ref                       = ((1/(l*w))*(w*wscref**2*(1/wsc1_ref-(1/(wsc1_ref+l)))+l*wscref**2*(1/wsc2_ref-(1/(wsc2_ref+w)))+w*wscref**2*(1/wsc3_ref-(1/(wsc3_ref+l)))+l*wscref**2*(1/wsc4_ref-(1/(wsc4_ref+w)))))
+    wscb_ref                       = ((1/(l*w))*(w*wscref/100*((10*wsc1_ref/wscref+1)*exp(-10*wsc1_ref/wscref)-(10*(wsc1_ref+l)/wscref+1)*exp(-10*(wsc1_ref+l)/wscref))+l*wscref/100*((10*wsc2_ref/wscref+1)*exp(-10*wsc2_ref/wscref)-(10*(wsc2_ref+w)/wscref+1)*exp(-10*(wsc2_ref+w)/wscref))+w*wscref/100*((10*wsc3_ref/wscref+1)*exp(-10*wsc3_ref/wscref)-(10*(wsc3_ref+l)/wscref+1)*exp(-10*(wsc3_ref+l)/wscref))+l*wscref/100*((10*wsc4_ref/wscref+1)*exp(-10*wsc4_ref/wscref)-(10*(wsc4_ref+w)/wscref+1)*exp(-10*(wsc4_ref+w)/wscref))))
+    wscc_ref                       = ((1/(l*w))*(w*wscref/400*((20*wsc1_ref/wscref+1)*exp(-20*wsc1_ref/wscref)-(20*(wsc1_ref+l)/wscref+1)*exp(-20*(wsc1_ref+l)/wscref))+l*wscref/400*((20*wsc2_ref/wscref+1)*exp(-20*wsc2_ref/wscref)-(20*(wsc2_ref+w)/wscref+1)*exp(-20*(wsc2_ref+w)/wscref))+w*wscref/400*((20*wsc3_ref/wscref+1)*exp(-20*wsc3_ref/wscref)-(20*(wsc3_ref+l)/wscref+1)*exp(-20*(wsc3_ref+l)/wscref))+l*wscref/400*((20*wsc4_ref/wscref+1)*exp(-20*wsc4_ref/wscref)-(20*(wsc4_ref+w)/wscref+1)*exp(-20*(wsc4_ref+w)/wscref))))
+    web                            = (1e+3)
+    wec                            = (1e+5)
+    kvfbwe                         = (0.002221)
+    knsubwe                        = (0.001187)
+    kubrefwe                       = (0.001157)
+    wp_proxmod_on                  = (enable_wpe==1)
+    del_vfb_wpe_ref                = (kvfbwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_ub_wpe_ref                 = (1+kubrefwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_nsub_wpe_ref               = (1+knsubwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    del_vfb_wpe                    = ((wp_proxmod_on)*(kvfbwe*(wsca+web*wscb+wec*wscc)-del_vfb_wpe_ref))
+    fac_ub_wpe                     = ((wp_proxmod_on)*(1+kubrefwe*(wsca+web*wscb+wec*wscc))/fac_ub_wpe_ref+(1-wp_proxmod_on))
+    fac_nsub_wpe                   = ((wp_proxmod_on)*(1+knsubwe*(wsca+web*wscb+wec*wscc))/fac_nsub_wpe_ref+(1-wp_proxmod_on))
+    dt2gdrain                      = (1.83)
+    dt2gsource                     = (2.52)
+    dt2gtop                        = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    dt2gbottom                     = ((w<=0.77)*(1.155-0.5*(w-0.69))+(w>=0.78)*(1.125))
+    tsc1_i                         = ((tsc1)+(wdist==0)*(tsc1==0)*(dt2gdrain)+(wdist==1)*(40)+(wdist==2)*(10))
+    tsc2_i                         = ((tsc2)+(wdist==0)*(tsc1==0)*(dt2gbottom)+(wdist==1)*(40)+(wdist==2)*(10))
+    tsc3_i                         = ((tsc3)+(wdist==0)*(tsc1==0)*(dt2gsource)+(wdist==1)*(40)+(wdist==2)*(10))
+    tsc4_i                         = ((tsc4)+(wdist==0)*(tsc1==0)*(dt2gtop)+(wdist==1)*(40)+(wdist==2)*(10))
+    adtnsub                        = (3.729)
+    adtvfb                         = (0.9844)
+    bdtvfb                         = (0.8553)
+    adtubref                       = (9.7125)
+    bdtubref                       = (8.183*0.1)
+    cdtubref                       = (0.31)
+    consub                         = (0.0001)
+    covfb                          = (0.0001)
+    coubref                        = (0.0001)
+    dtpara1                        = (-10)
+    dtpara2                        = (-5)
+    dtpara3                        = (-10)
+    dtpara4                        = (-5)
+    dtstress                       = (dtpara1*1/(tsc1_i+0.5*l)+dtpara2*1/(tsc2_i+0.5*w)+dtpara3*1/(tsc3_i+0.5*l)+dtpara4*1/(tsc4_i+0.5*w))
+    dtstressref                    = (dtpara1*1/(dt2gdrain+0.5*l)+dtpara2*1/(dt2gbottom+0.5*w)+dtpara3*1/(dt2gsource+0.5*l)+dtpara4*1/(dt2gtop+0.5*w))
+    dt_proxmod_on                  = (enable_dte==1)
+    fac_nsub_dte_ref               = (1+consub*(1+adtnsub*dtstressref*sqrt(l)))
+    fac_ub_dte_ref                 = (1+coubref*(1+(adtubref+l*bdtubref)*dtstressref+cdtubref/sqrt(w)))
+    del_vfb_dte                    = ((dt_proxmod_on)*(covfb*((adtvfb+bdtvfb/sqrt(w))*(dtstress-dtstressref))))
+    fac_nsub_dte                   = ((dt_proxmod_on)*(1+consub*(1+adtnsub*dtstress*sqrt(l)))/fac_nsub_dte_ref+(1-dt_proxmod_on))
+    fac_ub_dte                     = ((dt_proxmod_on)*(1+coubref*(1+(adtubref+l*bdtubref)*dtstress+cdtubref/sqrt(w)))/fac_ub_dte_ref+(1-dt_proxmod_on))
+    delr_tox_nmos3_zvt_10hv_bsim3v3 = (nom_delr_tox_nmos3_zvt_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thin_tox_bsim3v3*sig_delr_tox_nmos3_zvt_10hv_bsim3v3+nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3*smm_delr_tox_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_nmos3_zvt_10hv_bsim3v3 = (nom_dela_dwox_nmos3_zvt_10hv_bsim3v3+nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3*sig_dela_dwox_nmos3_zvt_10hv_bsim3v3+nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3*smm_dela_dwox_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vfb_nmos3_zvt_10hv_bsim3v3 = (nom_dela_vfb_nmos3_zvt_10hv_bsim3v3+del_vfb_sti+del_vfb_wpe+del_vfb_dte+nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3*sig_dela_vfb_nmos3_zvt_10hv_bsim3v3+nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3*smm_dela_vfb_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_ubref_nmos3_zvt_10hv_bsim3v3 = ((fac_ub_sti*fac_ub_wpe*fac_ub_dte)*nom_delr_ubref_nmos3_zvt_10hv_bsim3v3*(1+nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3*sig_delr_ubref_nmos3_zvt_10hv_bsim3v3+nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3*smm_delr_ubref_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dl_nmos3_zvt_10hv_bsim3v3 = (nom_dela_dl_nmos3_zvt_10hv_bsim3v3+nsig_dela_dl_nmos3_zvt_10hv_bsim3v3*sig_dela_dl_nmos3_zvt_10hv_bsim3v3+nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3*smm_dela_dl_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_nmos3_zvt_10hv_bsim3v3 = (nom_dela_vtl_nmos3_zvt_10hv_bsim3v3+nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3*sig_dela_vtl_nmos3_zvt_10hv_bsim3v3+nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3*smm_dela_vtl_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtw_nmos3_zvt_10hv_bsim3v3 = (nom_dela_vtw_nmos3_zvt_10hv_bsim3v3+nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3*sig_dela_vtw_nmos3_zvt_10hv_bsim3v3+nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3*smm_dela_vtw_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtm_nmos3_zvt_10hv_bsim3v3 = (nom_dela_vtm_nmos3_zvt_10hv_bsim3v3+nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3*sig_dela_vtm_nmos3_zvt_10hv_bsim3v3)
+    dela_wwl_nmos3_zvt_10hv_bsim3v3 = (nom_dela_wwl_nmos3_zvt_10hv_bsim3v3+nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3*sig_dela_wwl_nmos3_zvt_10hv_bsim3v3)
+    delr_rsh_nmos3_zvt_10hv_bsim3v3 = ((1.0+nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3*smm_delr_rsh_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    delr_nsub_nmos3_zvt_10hv_bsim3v3 = ((fac_nsub_sti*fac_nsub_wpe*fac_nsub_dte)*(1+nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3*smm_delr_nsub_nmos3_zvt_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.54e-09*delr_tox_nmos3_zvt_10hv_bsim3v3)
+    cox                            = (epsox/tox)
+    tags_nmos3_zvt_10hv_bsim3v3    = (-0.4)
+    tvoff_nmos3_zvt_10hv_bsim3v3   = (-0.0005)

model nmos3_zvt_10hv bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_nmos3_zvt_d_body)
+ pb       = (aphi_junc_nmos3_zvt_d_body)
+ mj       = (aexm_junc_nmos3_zvt_d_body)
+ js       = (1.0e12*ajs_junc_nmos3_zvt_d_body)
+ nj       = ((ajnd_junc_nmos3_zvt_d_body+pjnd_junc_nmos3_zvt_d_body+chjnd_junc_nmos3_zvt_d_body)/((((ajnd_junc_nmos3_zvt_d_body<0)|(ajnd_junc_nmos3_zvt_d_body>0)))+(((pjnd_junc_nmos3_zvt_d_body<0)|(pjnd_junc_nmos3_zvt_d_body>0)))+(((chjnd_junc_nmos3_zvt_d_body<0)|(chjnd_junc_nmos3_zvt_d_body>0)))))
+ cjsw     = (1.0e6*pcj0_junc_nmos3_zvt_d_body)
+ pbsw     = (pphi_junc_nmos3_zvt_d_body)
+ mjsw     = (pexm_junc_nmos3_zvt_d_body)
+ jsw      = (1.0e6*jsw_junc_nmos3_zvt_d_body)
+ cjswg    = (1.0e6*chcj0_junc_nmos3_zvt_d_body)
+ pbswg    = (chphi_junc_nmos3_zvt_d_body)
+ mjswg    = (chexm_junc_nmos3_zvt_d_body)
+ capmod   = (3)
+ cf       = (0)
+ cgbo     = (1.27782e-10)
+ cgso     = (2.80347e-08*cox+0.5*cfr_nmos3_zvt_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos3_zvt_s_ply_met*1e6-0.5*cfr_nmos3_zvt_s_ply_met*1e6)
+ cgsl     = (1.44494e-09)
+ cgdo     = (2.6497e-08*cox+0.5*cfr_nmos3_zvt_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos3_zvt_d_ply_met*1e6-0.5*cfr_nmos3_zvt_d_ply_met*1e6)
+ cgdl     = (1.26147e-09)
+ ckappa   = (0.000103272)
+ dlc      = (3.679e-08)
+ llc      = (3.023e-14)
+ lwc      = (2.532e-14)
+ lwlc     = (0.0)
+ dwc      = (-5.765e-08)
+ wwc      = (0.0)
+ wlc      = (0.0)
+ wwlc     = (0.0)
+ voffcv   = (-0.085)
+ noff     = (2.5)
+ acde     = (1.067)
+ moin     = (5.0)
+ mobmod   = (1.0)
+ rsh      = (9.8)
+ tox      = (3.54e-09*delr_tox_nmos3_zvt_10hv_bsim3v3)
+ pscbe2   = (1e-30)
+ pscbe1   = (4e+20)
+ vfb      = ((-1.17+dela_vfb_nmos3_zvt_wdist+dela_vfb_nmos3_zvt_10hv_bsim3v3)+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos3_zvt_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos3_zvt_10hv-relimo_ratio1_b_hci_nmos3_zvt_10hv))
+ vbm      = (-1.65)
+ xt       = (1.935e-07)
+ nch      = (7.38551e+16*delr_nsub_nmos3_zvt_10hv_bsim3v3)
+ nsub     = (1.63144e+16*delr_nsub_nmos3_zvt_10hv_bsim3v3)
+ voff     = (-0.1233+tvoff_nmos3_zvt_10hv_bsim3v3*(temp-27))
+ nfactor  = (0.4039)
+ u0       = ((640.3*delr_ubref_nmos3_zvt_wdist*delr_ubref_nmos3_zvt_10hv_bsim3v3)*delr_u0_relimo)
+ pu0      = (-50.0)
+ ua       = (1.786e-09)
+ ub       = (1e-18)
+ uc       = (1.001e-10)
+ pua      = (4e-10)
+ a0       = ((1.3)*delr_a0_relimo)
+ ags      = (1.08+dela_ags_nmos3_zvt_wdist)*(1+tags_nmos3_zvt_10hv_bsim3v3*(temp-tnom)/(tnom+273.15))
+ keta     = (-0.07818)
+ wint     = (1.759e-07-0.5e-6*dela_dwox_nmos3_zvt_wdist-0.5e-6*dela_dwox_nmos3_zvt_10hv_bsim3v3)
+ ww       = (-4.809e-14)
+ wwn      = (0.98)
+ k3       = (-27.11+80*dela_vtw_nmos3_zvt_10hv_bsim3v3)
+ k3b      = (5.432)
+ w0       = (4.773e-07+1e-06*dela_vtw_nmos3_zvt_wdist)
+ dwg      = (-4.135e-08)
+ dwb      = (0.0)
+ b0       = (3.301e-07+1e-06*dela_b0_nmos3_zvt_wdist)
+ b1       = (-6.101e-08)
+ lint     = (-7.08e-08-0.5e-6*dela_dl_nmos3_zvt_wdist-0.5e-6*dela_dl_nmos3_zvt_10hv_bsim3v3)
+ ll       = (-1.1e-14)
+ lln      = (0.9)
+ nlx      = (2e-06+1e-06*dela_vtl_nmos3_zvt_wdist+1e-06*dela_vtl_nmos3_zvt_10hv_bsim3v3)
+ dvt0     = (0.4895)
+ dvt1     = (0.02195)
+ dvt2     = (0.1003)
+ rdsw     = ((428.1*delr_rsh_nmos3_zvt_10hv_bsim3v3)*delr_rdsw_relimo)
+ wr       = (1.0)
+ prwg     = (0.3)
+ prwb     = (0.5)
+ cdsc     = (0.0)
+ cdscd    = (0.0)
+ cdscb    = (0.0)
+ vsat     = (300000.0)
+ a1       = (0.0)
+ a2       = (0.9999)
+ pclm     = (0.00688)
+ pdiblc1  = (0.039)
+ pdiblc2  = (5.491e-11)
+ pdiblcb  = (2.161)
+ drout    = (2.005)
+ pvag     = (0.0)
+ delta    = (0.002258)
+ eta0     = (0.002879)
+ etab     = (-0.0008628)
+ dsub     = (2.901e-06)
+ alpha0   = (-1.199e-07)
+ alpha1   = (0.57)
+ beta0    = (13.39)
+ dvt0w    = (-0.1198+dela_vtm_nmos3_zvt_wdist+dela_vtm_nmos3_zvt_10hv_bsim3v3)
+ dvt1w    = (4078.0)
+ dvt2w    = (-0.071)
+ wwl      = (4.047e-19+1e-18*dela_wwl_nmos3_zvt_wdist+1e-18*dela_wwl_nmos3_zvt_10hv_bsim3v3)
+ lwl      = (-2.258e-18)
+ wl       = (-3.319e-12)
+ wln      = (0.8711)
+ lw       = (-2e-12)
+ lwn      = (0.8863)
+ binunit  = (1.0)
+ wketa    = (0.04905)
+ lketa    = (0.06415)
+ lags     = (1.2)
+ la0      = (-1.13)
+ pa0      = (-2.2)
+ pags     = (1.5)
+ pketa    = (-0.00247)
+ ute      = (-2.31)
+ wute     = (0.1)
+ pute     = (1.3)
+ kt1      = (-0.2213)
+ pkt1     = (0.3)
+ kt2      = (-0.015)
+ ua1      = (-1.1e-09)
+ ub1      = (-1.35e-18)
+ lua1     = (-1.4e-09)
+ lub1     = (0.0)
+ uc1      = (-1.4e-10)
+ kt1l     = (-7.049e-09)
+ prt      = (0.0)
+ at       = (200000.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ noimod   = (noimod_nmos3_zvt_10hv_bsim3v3)
+ noia     = (noia_nmos3_zvt_10hv_bsim3v3)
+ noib     = (noib_nmos3_zvt_10hv_bsim3v3)
+ noic     = (noic_nmos3_zvt_10hv_bsim3v3)
+ ef       = (ef_nmos3_zvt_10hv_bsim3v3)
+ em       = (em_nmos3_zvt_10hv_bsim3v3)

model rdint resistor
+ tnom  = (27)
+ rsh   = (25.4685)
+ tc1   = (0)
+ tc2   = (0)

mnmos3_zvt_10hv_i (d_i g s b) nmos3_zvt_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=(ngtotal)
rrdint (d_i d) rdint w=(w) l=(0.27) m=(ngtotal)
xcpwtub_box_sub_10hv (b sub) cpwtub_box_sub_10hv area=((abox2sub*(1-lpe)+lpe*0.001)*ring+(1-ring)*0.001) perim=((pbox2sub*(1-lpe)+lpe*0.001)*ring+(1-ring)*0.001) soa=1

include "./smos10hv_ade_dfrt.scs" section=nmos3_zvt_10hv_dfrt
ends

subckt nsrampg_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.225
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrd                            = 0
+    nrs                            = 0
+    lpe                            = 0
+    ring                           = 0
+    soa                            = 1
+    nsmm_delr_gox_nsrampg_10hv_bsim3v3 = tmp_nsmm_delr_gox_nsrampg_10hv_bsim3v3
+    nsmm_dela_vfb_nsrampg_10hv_bsim3v3 = tmp_nsmm_dela_vfb_nsrampg_10hv_bsim3v3
+    nsmm_delr_nsub_nsrampg_10hv_bsim3v3 = tmp_nsmm_delr_nsub_nsrampg_10hv_bsim3v3
+    nsmm_dela_vtl_nsrampg_10hv_bsim3v3 = tmp_nsmm_dela_vtl_nsrampg_10hv_bsim3v3
+    nsmm_dela_dl_nsrampg_10hv_bsim3v3 = tmp_nsmm_dela_dl_nsrampg_10hv_bsim3v3
+    nsmm_dela_dwox_nsrampg_10hv_bsim3v3 = tmp_nsmm_dela_dwox_nsrampg_10hv_bsim3v3
+    nsmm_delr_ubref_nsrampg_10hv_bsim3v3 = tmp_nsmm_delr_ubref_nsrampg_10hv_bsim3v3
+    nsmm_delr_rsh_nsrampg_10hv_bsim3v3 = tmp_nsmm_delr_rsh_nsrampg_10hv_bsim3v3
+    nsmm_dela_vtw_nsrampg_10hv_bsim3v3 = tmp_nsmm_dela_vtw_nsrampg_10hv_bsim3v3
+    we                             = (0.5*(wemin_nsrampg_10hv+w+sqrt((w-wemin_nsrampg_10hv)*(w-wemin_nsrampg_10hv))))
+    as_i                           = (as+(as==0)*(1-lpe)*(lg2aa_nsrampg_10hv*we))
+    ps_i                           = (ps+(ps==0)*(1-lpe)*(2*(lg2aa_nsrampg_10hv+we)))
+    ad_i                           = (ad+(ad==0)*(1-lpe)*(lg2aa_nsrampg_10hv*we))
+    pd_i                           = (pd+(pd==0)*(1-lpe)*(2*(lg2aa_nsrampg_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_nsrampg_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_nsrampg_10hv/w))
+    liso                           = (laa2iso_left_nsrampg_10hv+lg2aa_nsrampg_10hv+l+lg2aa_nsrampg_10hv+laa2iso_right_nsrampg_10hv)
+    wiso                           = (wg2iso_nsrampg_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    delr_tox_nsrampg_10hv_bsim3v3  = (nom_delr_tox_nsrampg_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thin_tox_bsim3v3*sig_delr_tox_nsrampg_10hv_bsim3v3+nsmm_delr_gox_nsrampg_10hv_bsim3v3*smm_delr_gox_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    dela_dl_nsrampg_10hv_bsim3v3   = (nsmm_dela_dl_nsrampg_10hv_bsim3v3*smm_dela_dl_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np))
+    dela_dwox_nsrampg_10hv_bsim3v3 = (nom_dela_dwox_nsrampg_10hv_bsim3v3+nsig_dela_dwox_nsrampg_10hv_bsim3v3*sig_dela_dwox_nsrampg_10hv_bsim3v3+nsmm_dela_dwox_nsrampg_10hv_bsim3v3*smm_dela_dwox_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_ubref_nsrampg_10hv_bsim3v3 = (nom_delr_ubref_nsrampg_10hv_bsim3v3*(1.0+nsig_delr_ubref_nsrampg_10hv_bsim3v3*sig_delr_ubref_nsrampg_10hv_bsim3v3+nsmm_delr_ubref_nsrampg_10hv_bsim3v3*smm_delr_ubref_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    delr_rsh_nsrampg_10hv_bsim3v3  = (1+nsmm_delr_rsh_nsrampg_10hv_bsim3v3*smm_delr_rsh_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_nsub_nsrampg_10hv_bsim3v3 = (1+nsmm_delr_nsub_nsrampg_10hv_bsim3v3*smm_delr_nsub_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np))
+    dela_vfb_nsrampg_10hv_bsim3v3  = (nsmm_dela_vfb_nsrampg_10hv_bsim3v3*smm_dela_vfb_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np)+nsmm_dela_vtl_nsrampg_10hv_bsim3v3*smm_dela_vtl_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np)/l+nsmm_dela_vtw_nsrampg_10hv_bsim3v3*smm_dela_vtw_nsrampg_10hv_bsim3v3(l,w)/sqrt(1*np)/w)
+    dela_vtw_nsrampg_10hv_bsim3v3  = (nom_dela_vtw_nsrampg_10hv_bsim3v3+nsig_dela_vtw_nsrampg_10hv_bsim3v3*sig_dela_vtw_nsrampg_10hv_bsim3v3)
+    dela_vtm_nsrampg_10hv_bsim3v3  = (nom_dela_vtm_nsrampg_10hv_bsim3v3+nsig_dela_vtm_nsrampg_10hv_bsim3v3*sig_dela_vtm_nsrampg_10hv_bsim3v3)
+    dela_dwwl_nsrampg_10hv_bsim3v3 = (nom_dela_dwwl_nsrampg_10hv_bsim3v3+nsig_dela_dwwl_nsrampg_10hv_bsim3v3*sig_dela_dwwl_nsrampg_10hv_bsim3v3)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.59e-09*delr_tox_nsrampg_10hv_bsim3v3)
+    cox                            = (epsox/tox)

model nsrampg_10hv bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_nsrampg_sd_body)
+ pb       = (aphi_junc_nsrampg_sd_body)
+ mj       = (aexm_junc_nsrampg_sd_body)
+ js       = (1.0e12*ajs_junc_nsrampg_sd_body)
+ nj       = (ajnd_junc_nsrampg_sd_body)
+ cjsw     = (1.0e6*pcj0_junc_nsrampg_sd_body)
+ pbsw     = (pphi_junc_nsrampg_sd_body)
+ mjsw     = (pexm_junc_nsrampg_sd_body)
+ jsw      = (1.0e6*pjs_junc_nsrampg_sd_body)
+ cjswg    = (1.0e6*chcj0_junc_nsrampg_sd_body)
+ pbswg    = (chphi_junc_nsrampg_sd_body)
+ mjswg    = (chexm_junc_nsrampg_sd_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (2.15e-08*cox+0.5*cfr_nsrampg_s_ply_m1ct*1e6+(1-lpe)*cfr_nsrampg_s_ply_met*1e6-0.5*cfr_nsrampg_s_ply_met*1e6)
+ cgdo     = (2.15e-08*cox+0.5*cfr_nsrampg_d_ply_m1ct*1e6+(1-lpe)*cfr_nsrampg_d_ply_met*1e6-0.5*cfr_nsrampg_d_ply_met*1e6)
+ dlc      = (3.80965e-08)
+ dwc      = (-2.70585e-08)
+ cgsl     = (1.025e-10)
+ cgdl     = (1.025e-10)
+ cf       = (0)
+ ckappa   = (6)
+ acde     = (0.85)
+ voffcv   = (-0.125)
+ wwc      = (0)
+ llc      = (0)
+ wlc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wwlc     = (-1.95626e-21)
+ mobmod   = (1)
+ rsh      = (9.8)
+ tox      = (3.4999987e-09*delr_tox_nsrampg_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-0.34205e-08-0.5e-06*dela_dl_nsrampg_10hv_bsim3v3)
+ wint     = (5.27305e-08-0.5e-06*dela_dwox_nsrampg_10hv_bsim3v3)
+ ww       = (-1.0335e-14)
+ u0       = (504.715*delr_ubref_nsrampg_10hv_bsim3v3)
+ rdsw     = (88.5529*delr_rsh_nsrampg_10hv_bsim3v3)
+ nsub     = (1.87794e+17*delr_nsub_nsrampg_10hv_bsim3v3)
+ nch      = (1.82748e+17*delr_nsub_nsrampg_10hv_bsim3v3)
+ vfb      = (-0.78191+dela_vfb_nsrampg_10hv_bsim3v3)
+ vbm      = (-1.65)
+ xt       = (8.47204e-08)
+ alpha0   = (1.28e-06)
+ alpha1   = (24.25)
+ beta0    = (17.15)
+ a0       = (6.05767565)
+ ags      = (0.615872)
+ keta     = (-0.0327269)
+ ua       = (2.015e-11)
+ ub       = (1.97276e-18)
+ uc       = (0)
+ eta0     = (0.142216)
+ etab     = (-0.155)
+ drout    = (0.801304)
+ nlx      = (6.63627e-7)
+ dvt0     = (0.05751)
+ dvt1     = (0.815)
+ dvt2     = (0)
+ k3       = (-3.553365+80*dela_vtw_nsrampg_10hv_bsim3v3)
+ k3b      = (0.96749)
+ w0       = (2.5925e-12)
+ dwg      = (-2.8e-9)
+ dwb      = (6.89712e-10)
+ b0       = (-5.22e-8)
+ b1       = (0)
+ prwg     = (-0.003)
+ prwb     = (-0.15)
+ pclm     = (0.76859)
+ pdiblc1  = (0.001)
+ pdiblc2  = (0.1)
+ pdiblcb  = (0.290403)
+ delta    = (0.00247013)
+ vsat     = (94735.75)
+ ll       = (3.25296e-15)
+ dvt0w    = (-0.1241133+dela_vtm_nsrampg_10hv_bsim3v3)
+ dvt1w    = (518875)
+ dvt2w    = (0.28)
+ wl       = (-1.671678e-14)
+ lw       = (7.09593e-16)
+ lwl      = (-1.65273e-21)
+ wwl      = (2.226e-21-0.5e-20*dela_dwwl_nsrampg_10hv_bsim3v3)
+ wln      = (0.982853)
+ lwn      = (0.991408)
+ lln      = (0.974652)
+ wwn      = (0.991068)
+ nfactor  = (1.0)
+ voff     = (-0.21)
+ pa0      = (-0.1825)
+ pketa    = (-0.0035)
+ ute      = (-1.0485)
+ kt1      = (-0.1)
+ kt1l     = (-7.5e-9)
+ kt2      = (-0.03)
+ ua1      = (5.147e-9)
+ uc1      = (-2.5e-10)
+ prt      = (35)
+ at       = (3.0e4)
+ noimod   = (noimod_nsrampg_10hv_bsim3v3)

mnsrampg_10hv_i (d g s b) nsrampg_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=nsrampg_10hv_dfrt
ends

subckt nsrampd_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.36
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrd                            = 0
+    nrs                            = 0
+    lpe                            = 0
+    ring                           = 0
+    soa                            = 1
+    nsmm_delr_gox_nsrampd_10hv_bsim3v3 = tmp_nsmm_delr_gox_nsrampd_10hv_bsim3v3
+    nsmm_dela_vfb_nsrampd_10hv_bsim3v3 = tmp_nsmm_dela_vfb_nsrampd_10hv_bsim3v3
+    nsmm_delr_nsub_nsrampd_10hv_bsim3v3 = tmp_nsmm_delr_nsub_nsrampd_10hv_bsim3v3
+    nsmm_dela_vtl_nsrampd_10hv_bsim3v3 = tmp_nsmm_dela_vtl_nsrampd_10hv_bsim3v3
+    nsmm_dela_dl_nsrampd_10hv_bsim3v3 = tmp_nsmm_dela_dl_nsrampd_10hv_bsim3v3
+    nsmm_dela_dwox_nsrampd_10hv_bsim3v3 = tmp_nsmm_dela_dwox_nsrampd_10hv_bsim3v3
+    nsmm_delr_ubref_nsrampd_10hv_bsim3v3 = tmp_nsmm_delr_ubref_nsrampd_10hv_bsim3v3
+    nsmm_delr_rsh_nsrampd_10hv_bsim3v3 = tmp_nsmm_delr_rsh_nsrampd_10hv_bsim3v3
+    nsmm_dela_vtw_nsrampd_10hv_bsim3v3 = tmp_nsmm_dela_vtw_nsrampd_10hv_bsim3v3
+    we                             = (0.5*(wemin_nsrampd_10hv+w+sqrt((w-wemin_nsrampd_10hv)*(w-wemin_nsrampd_10hv))))
+    as_i                           = (as+(as==0)*(1-lpe)*(lg2aa_nsrampd_10hv*we))
+    ps_i                           = (ps+(ps==0)*(1-lpe)*(2*(lg2aa_nsrampd_10hv+we)))
+    ad_i                           = (ad+(ad==0)*(1-lpe)*(lg2aa_nsrampd_10hv*we))
+    pd_i                           = (pd+(pd==0)*(1-lpe)*(2*(lg2aa_nsrampd_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_nsrampd_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_nsrampd_10hv/w))
+    liso                           = (laa2iso_left_nsrampd_10hv+lg2aa_nsrampd_10hv+l+lg2aa_nsrampd_10hv+laa2iso_right_nsrampd_10hv)
+    wiso                           = (wg2iso_nsrampd_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    delr_tox_nsrampd_10hv_bsim3v3  = (nom_delr_tox_nsrampd_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thin_tox_bsim3v3*sig_delr_tox_nsrampd_10hv_bsim3v3+nsmm_delr_gox_nsrampd_10hv_bsim3v3*smm_delr_gox_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    dela_dl_nsrampd_10hv_bsim3v3   = (nom_dela_dl_nsrampd_10hv_bsim3v3+nsig_dela_dl_nsrampd_10hv_bsim3v3*sig_dela_dl_nsrampd_10hv_bsim3v3+nsmm_dela_dl_nsrampd_10hv_bsim3v3*smm_dela_dl_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np))
+    dela_dwox_nsrampd_10hv_bsim3v3 = (nom_dela_dwox_nsrampd_10hv_bsim3v3+nsig_dela_dwox_nsrampd_10hv_bsim3v3*sig_dela_dwox_nsrampd_10hv_bsim3v3+nsmm_dela_dwox_nsrampd_10hv_bsim3v3*smm_dela_dwox_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_ubref_nsrampd_10hv_bsim3v3 = (nom_delr_ubref_nsrampd_10hv_bsim3v3*(1.0+nsig_delr_ubref_nsrampd_10hv_bsim3v3*sig_delr_ubref_nsrampd_10hv_bsim3v3+nsmm_delr_ubref_nsrampd_10hv_bsim3v3*smm_delr_ubref_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    delr_rsh_nsrampd_10hv_bsim3v3  = (1+nsmm_delr_rsh_nsrampd_10hv_bsim3v3*smm_delr_rsh_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_nsub_nsrampd_10hv_bsim3v3 = (1+nsmm_delr_nsub_nsrampd_10hv_bsim3v3*smm_delr_nsub_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np))
+    dela_vfb_nsrampd_10hv_bsim3v3  = (nom_dela_vfb_nsrampd_10hv_bsim3v3+nsig_dela_vfb_nsrampd_10hv_bsim3v3*sig_dela_vfb_nsrampd_10hv_bsim3v3+nsmm_dela_vfb_nsrampd_10hv_bsim3v3*smm_dela_vfb_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np)+nsmm_dela_vtl_nsrampd_10hv_bsim3v3*smm_dela_vtl_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np)/l+nsmm_dela_vtw_nsrampd_10hv_bsim3v3*smm_dela_vtw_nsrampd_10hv_bsim3v3(l,w)/sqrt(1*np)/w)
+    dela_vtl_nsrampd_10hv_bsim3v3  = (nom_dela_vtl_nsrampd_10hv_bsim3v3+nsig_dela_vtl_nsrampd_10hv_bsim3v3*sig_dela_vtl_nsrampd_10hv_bsim3v3)
+    dela_vtw_nsrampd_10hv_bsim3v3  = (nom_dela_vtw_nsrampd_10hv_bsim3v3+nsig_dela_vtw_nsrampd_10hv_bsim3v3*sig_dela_vtw_nsrampd_10hv_bsim3v3)
+    dela_vtm_nsrampd_10hv_bsim3v3  = (nom_dela_vtm_nsrampd_10hv_bsim3v3+nsig_dela_vtm_nsrampd_10hv_bsim3v3*sig_dela_vtm_nsrampd_10hv_bsim3v3)
+    dela_dwwl_nsrampd_10hv_bsim3v3 = (nom_dela_dwwl_nsrampd_10hv_bsim3v3+nsig_dela_dwwl_nsrampd_10hv_bsim3v3*sig_dela_dwwl_nsrampd_10hv_bsim3v3)
+    dela_a0_nsrampd_10hv_bsim3v3   = (nom_dela_a0_nsrampd_10hv_bsim3v3+nsig_dela_a0_nsrampd_10hv_bsim3v3*sig_dela_a0_nsrampd_10hv_bsim3v3)
+    dela_b0_nsrampd_10hv_bsim3v3   = (nom_dela_b0_nsrampd_10hv_bsim3v3+nsig_dela_b0_nsrampd_10hv_bsim3v3*sig_dela_b0_nsrampd_10hv_bsim3v3)
+    delr_vsat_nsrampd_10hv_bsim3v3 = (nom_delr_vsat_nsrampd_10hv_bsim3v3+nsig_delr_vsat_nsrampd_10hv_bsim3v3*sig_delr_vsat_nsrampd_10hv_bsim3v3)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.59e-09*delr_tox_nsrampd_10hv_bsim3v3)
+    cox                            = (epsox/tox)

model nsrampd_10hv bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_nsrampd_sd_body)
+ pb       = (aphi_junc_nsrampd_sd_body)
+ mj       = (aexm_junc_nsrampd_sd_body)
+ js       = (1.0e12*ajs_junc_nsrampd_sd_body)
+ nj       = (ajnd_junc_nsrampd_sd_body)
+ cjsw     = (1.0e6*pcj0_junc_nsrampd_sd_body)
+ pbsw     = (pphi_junc_nsrampd_sd_body)
+ mjsw     = (pexm_junc_nsrampd_sd_body)
+ jsw      = (1.0e6*pjs_junc_nsrampd_sd_body)
+ cjswg    = (1.0e6*chcj0_junc_nsrampd_sd_body)
+ pbswg    = (chphi_junc_nsrampd_sd_body)
+ mjswg    = (chexm_junc_nsrampd_sd_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (2.15e-08*cox+0.5*cfr_nsrampd_s_ply_m1ct*1e6+(1-lpe)*cfr_nsrampd_s_ply_met*1e6-0.5*cfr_nsrampd_s_ply_met*1e6)
+ cgdo     = (2.15e-08*cox+0.5*cfr_nsrampd_d_ply_m1ct*1e6+(1-lpe)*cfr_nsrampd_d_ply_met*1e6-0.5*cfr_nsrampd_d_ply_met*1e6)
+ dlc      = (3.80965e-08)
+ dwc      = (-2.70585e-08)
+ cgsl     = (1.025e-10)
+ cgdl     = (1.025e-10)
+ cf       = (0)
+ ckappa   = (6)
+ acde     = (0.85)
+ voffcv   = (-0.125)
+ wwc      = (0)
+ llc      = (0)
+ wlc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wwlc     = (-1.95626e-21)
+ mobmod   = (1)
+ rsh      = (9.8)
+ tox      = (3.4999987e-09*delr_tox_nsrampd_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-0.34205e-08-0.5e-06*dela_dl_nsrampd_10hv_bsim3v3)
+ wint     = (5.27305e-08-0.5e-06*dela_dwox_nsrampd_10hv_bsim3v3)
+ ww       = (-1.0335e-14)
+ u0       = (504.715*delr_ubref_nsrampd_10hv_bsim3v3)
+ rdsw     = (88.5529*delr_rsh_nsrampd_10hv_bsim3v3)
+ nsub     = (1.87794e+17*delr_nsub_nsrampd_10hv_bsim3v3)
+ nch      = (1.82748e+17*delr_nsub_nsrampd_10hv_bsim3v3)
+ vfb      = (-0.78191+dela_vfb_nsrampd_10hv_bsim3v3)
+ vbm      = (-1.65)
+ xt       = (8.47204e-08)
+ alpha0   = (1.28e-06)
+ alpha1   = (24.25)
+ beta0    = (17.15)
+ a0       = (3.08767565+dela_a0_nsrampd_10hv_bsim3v3)
+ ags      = (0.615872)
+ keta     = (-0.0327269)
+ ua       = (2.015e-11)
+ ub       = (1.97276e-18)
+ uc       = (0)
+ eta0     = (0.142216)
+ etab     = (-0.155)
+ drout    = (0.801304)
+ nlx      = (6.63627e-7)
+ dvt0     = (0.05751+dela_vtl_nsrampd_10hv_bsim3v3)
+ dvt1     = (0.815)
+ dvt2     = (0)
+ k3       = (-0.8553365+dela_vtw_nsrampd_10hv_bsim3v3)
+ k3b      = (0.06749)
+ w0       = (2.5925e-12)
+ dwg      = (-2.8e-9)
+ dwb      = (6.89712e-10)
+ b0       = (-5.22e-8+1e-6*dela_b0_nsrampd_10hv_bsim3v3)
+ b1       = (0)
+ prwg     = (-0.003)
+ prwb     = (-0.15)
+ pclm     = (0.76859)
+ pdiblc1  = (0.001)
+ pdiblc2  = (0.1)
+ pdiblcb  = (0.290403)
+ delta    = (0.00247013)
+ vsat     = (94735.75*delr_vsat_nsrampd_10hv_bsim3v3)
+ ll       = (3.25296e-15)
+ dvt0w    = (-0.17241133+dela_vtm_nsrampd_10hv_bsim3v3)
+ dvt1w    = (518875)
+ dvt2w    = (0.28)
+ wl       = (-1.671678e-14)
+ lw       = (7.09593e-16)
+ lwl      = (-1.65273e-21)
+ wwl      = (3.6226e-21-0.5e-20*dela_dwwl_nsrampd_10hv_bsim3v3)
+ wln      = (0.982853)
+ lwn      = (0.991408)
+ lln      = (0.974652)
+ wwn      = (0.991068)
+ nfactor  = (1.0)
+ voff     = (-0.301)
+ pa0      = (-0.1825)
+ pketa    = (-0.0035)
+ ute      = (-0.93)
+ kt1      = (-0.1)
+ kt1l     = (-7.5e-9)
+ kt2      = (-0.03)
+ ua1      = (5.247e-9)
+ uc1      = (-2.5e-10)
+ prt      = (35)
+ at       = (3.0e4)
+ noimod   = (noimod_nsrampd_10hv_bsim3v3)

mnsrampd_10hv_i (d g s b) nsrampd_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np
xcpwtub_sub (b sub) cpwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=nsrampd_10hv_dfrt
ends

subckt psrampu_10hv (d g s b sub)

parameters
+    l                              = 0.15
+    w                              = 0.195
+    np                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    nrs                            = 0
+    nrd                            = 0
+    lpe                            = 0
+    ring                           = 0
+    soa                            = 1
+    nsmm_delr_gox_psrampu_10hv_bsim3v3 = tmp_nsmm_delr_gox_psrampu_10hv_bsim3v3
+    nsmm_dela_vfb_psrampu_10hv_bsim3v3 = tmp_nsmm_dela_vfb_psrampu_10hv_bsim3v3
+    nsmm_delr_nsub_psrampu_10hv_bsim3v3 = tmp_nsmm_delr_nsub_psrampu_10hv_bsim3v3
+    nsmm_dela_vtl_psrampu_10hv_bsim3v3 = tmp_nsmm_dela_vtl_psrampu_10hv_bsim3v3
+    nsmm_dela_dl_psrampu_10hv_bsim3v3 = tmp_nsmm_dela_dl_psrampu_10hv_bsim3v3
+    nsmm_dela_dwox_psrampu_10hv_bsim3v3 = tmp_nsmm_dela_dwox_psrampu_10hv_bsim3v3
+    nsmm_delr_ubref_psrampu_10hv_bsim3v3 = tmp_nsmm_delr_ubref_psrampu_10hv_bsim3v3
+    nsmm_delr_rsh_psrampu_10hv_bsim3v3 = tmp_nsmm_delr_rsh_psrampu_10hv_bsim3v3
+    nsmm_dela_vtw_psrampu_10hv_bsim3v3 = tmp_nsmm_dela_vtw_psrampu_10hv_bsim3v3
+    we                             = (0.5*(wemin_psrampu_10hv+w+sqrt((w-wemin_psrampu_10hv)*(w-wemin_psrampu_10hv))))
+    as_i                           = (as+(as==0)*(1-lpe)*(lg2aa_psrampu_10hv*we))
+    ps_i                           = (ps+(ps==0)*(1-lpe)*(2*(lg2aa_psrampu_10hv+we)))
+    ad_i                           = (ad+(ad==0)*(1-lpe)*(lg2aa_psrampu_10hv*we))
+    pd_i                           = (pd+(pd==0)*(1-lpe)*(2*(lg2aa_psrampu_10hv+we)))
+    nrs_i                          = (nrs+(nrs==0)*(lg2ct_psrampu_10hv/w))
+    nrd_i                          = (nrd+(nrd==0)*(lg2ct_psrampu_10hv/w))
+    liso                           = (laa2iso_left_psrampu_10hv+lg2aa_psrampu_10hv+l+lg2aa_psrampu_10hv+laa2iso_right_psrampu_10hv)
+    wiso                           = (wg2iso_psrampu_10hv*2+we)
+    aiso                           = (liso*wiso*np)
+    piso                           = ((liso+wiso)*2*np)
+    delr_tox_psrampu_10hv_bsim3v3  = (nom_delr_tox_psrampu_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thin_tox_bsim3v3*sig_delr_tox_psrampu_10hv_bsim3v3+nsmm_delr_gox_psrampu_10hv_bsim3v3*smm_delr_gox_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    dela_dwox_psrampu_10hv_bsim3v3 = (nom_dela_dwox_psrampu_10hv_bsim3v3+nsig_dela_dwox_psrampu_10hv_bsim3v3*sig_dela_dwox_psrampu_10hv_bsim3v3+nsmm_dela_dwox_psrampu_10hv_bsim3v3*smm_dela_dwox_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np))
+    dela_vfb_psrampu_10hv_bsim3v3  = (nom_dela_vfb_psrampu_10hv_bsim3v3+nsig_dela_vfb_psrampu_10hv_bsim3v3*sig_dela_vfb_psrampu_10hv_bsim3v3+nsmm_dela_vfb_psrampu_10hv_bsim3v3*smm_dela_vfb_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np)+nsmm_dela_vtl_psrampu_10hv_bsim3v3*smm_dela_vtl_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np)/l+nsmm_dela_vtw_psrampu_10hv_bsim3v3*smm_dela_vtw_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np)/w)
+    dela_vtl_psrampu_10hv_bsim3v3  = (nom_dela_vtl_psrampu_10hv_bsim3v3+nsig_dela_vtl_psrampu_10hv_bsim3v3*sig_dela_vtl_psrampu_10hv_bsim3v3)
+    dela_dl_psrampu_10hv_bsim3v3   = (nom_dela_dl_psrampu_10hv_bsim3v3+nsig_dela_dl_psrampu_10hv_bsim3v3*sig_dela_dl_psrampu_10hv_bsim3v3+nsmm_dela_dl_psrampu_10hv_bsim3v3*smm_dela_dl_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_ubref_psrampu_10hv_bsim3v3 = (nom_delr_ubref_psrampu_10hv_bsim3v3*(1.0+nsig_delr_ubref_psrampu_10hv_bsim3v3*sig_delr_ubref_psrampu_10hv_bsim3v3+nsmm_delr_ubref_psrampu_10hv_bsim3v3*smm_delr_ubref_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np)))
+    dela_vtm_psrampu_10hv_bsim3v3  = (nom_dela_vtm_psrampu_10hv_bsim3v3+nsig_dela_vtm_psrampu_10hv_bsim3v3*sig_dela_vtm_psrampu_10hv_bsim3v3)
+    dela_vtw_psrampu_10hv_bsim3v3  = (nom_dela_vtw_psrampu_10hv_bsim3v3+nsig_dela_vtw_psrampu_10hv_bsim3v3*sig_dela_vtw_psrampu_10hv_bsim3v3)
+    dela_wwl_psrampu_10hv_bsim3v3  = (nom_dela_wwl_psrampu_10hv_bsim3v3+nsig_dela_wwl_psrampu_10hv_bsim3v3*sig_dela_wwl_psrampu_10hv_bsim3v3)
+    dela_a0_psrampu_10hv_bsim3v3   = (nom_dela_a0_psrampu_10hv_bsim3v3+nsig_dela_a0_psrampu_10hv_bsim3v3*sig_dela_a0_psrampu_10hv_bsim3v3)
+    delr_rsh_psrampu_10hv_bsim3v3  = (1+nsmm_delr_rsh_psrampu_10hv_bsim3v3*smm_delr_rsh_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np))
+    delr_nsub_psrampu_10hv_bsim3v3 = (1+nsmm_delr_nsub_psrampu_10hv_bsim3v3*smm_delr_nsub_psrampu_10hv_bsim3v3(l,w)/sqrt(1*np))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (3.47e-09*delr_tox_psrampu_10hv_bsim3v3)
+    cox                            = (epsox/tox)

model psrampu_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_psrampu_sd_body)
+ pb       = (aphi_junc_psrampu_sd_body)
+ mj       = (aexm_junc_psrampu_sd_body)
+ js       = (1.0e12*ajs_junc_psrampu_sd_body)
+ nj       = (ajnd_junc_psrampu_sd_body)
+ cjsw     = (1.0e6*pcj0_junc_psrampu_sd_body)
+ pbsw     = (pphi_junc_psrampu_sd_body)
+ mjsw     = (pexm_junc_psrampu_sd_body)
+ jsw      = (1.0e6*pjs_junc_psrampu_sd_body)
+ cjswg    = (1.0e6*chcj0_junc_psrampu_sd_body)
+ pbswg    = (chphi_junc_psrampu_sd_body)
+ mjswg    = (chexm_junc_psrampu_sd_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (1.15e-08*cox+0.5*cfr_psrampu_s_ply_m1ct*1e6+(1-lpe)*cfr_psrampu_s_ply_met*1e6-0.5*cfr_psrampu_s_ply_met*1e6)
+ cgdo     = (1.15e-08*cox+0.5*cfr_psrampu_d_ply_m1ct*1e6+(1-lpe)*cfr_psrampu_d_ply_met*1e6-0.5*cfr_psrampu_d_ply_met*1e6)
+ cgdl     = (2.2e-10)
+ cgsl     = (2.2e-10)
+ dlc      = (3.8e-08)
+ dwc      = (-5.5e-08)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = (-8.0e-21)
+ acde     = (1.25)
+ moin     = (20)
+ voffcv   = (-0.025)
+ noff     = (1.2)
+ ckappa   = (1.85)
+ cf       = (0)
+ mobmod   = (1)
+ rsh      = (8.3)
+ tox      = (3.47e-09*delr_tox_psrampu_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (4.32036e-08-0.5e-06*dela_dl_psrampu_10hv_bsim3v3)
+ wint     = (1.12e-08-0.5e-06*dela_dwox_psrampu_10hv_bsim3v3)
+ ww       = (-7.90958396e-14)
+ u0       = (168.055*delr_ubref_psrampu_10hv_bsim3v3)
+ rdsw     = (208.4376*delr_rsh_psrampu_10hv_bsim3v3)
+ nsub     = (5.20353e+17*delr_nsub_psrampu_10hv_bsim3v3)
+ nch      = (6.4956125545530445e+17*delr_nsub_psrampu_10hv_bsim3v3)
+ vfb      = (-1.0413669+dela_vfb_psrampu_10hv_bsim3v3)
+ vbm      = (-1.65)
+ xt       = (4.71772881411993e-08)
+ alpha1   = (0.8)
+ alpha0   = (5.0e-08)
+ beta0    = (18)
+ a0       = (5.699+dela_a0_psrampu_10hv_bsim3v3)
+ ags      = (0.549)
+ keta     = (-0.019577)
+ ua       = (2.11324e-09)
+ ub       = (8.86738e-19)
+ uc       = (0)
+ eta0     = (0.01)
+ etab     = (-0.00611148)
+ drout    = (0.166171)
+ nlx      = (2.33532e-07+1e-6*dela_vtl_psrampu_10hv_bsim3v3)
+ dvt0     = (0.76)
+ dvt1     = (0.1823)
+ dvt2     = (0.2956)
+ dvt0w    = (-0.36239+dela_vtm_psrampu_10hv_bsim3v3)
+ dvt1w    = (7.1076e+05)
+ dvt2w    = (0.0006332)
+ k3       = (-6.22898+80*dela_vtw_psrampu_10hv_bsim3v3)
+ k3b      = (3.4675)
+ w0       = (0)
+ dwg      = (-2.51094e-08)
+ dwb      = (-3.105359e-09)
+ b0       = (1.95892297e-08)
+ b1       = (4.63760782e-05)
+ prwg     = (0.1705868)
+ prwb     = (0.8960809)
+ pclm     = (2.8381)
+ pdiblc1  = (0.0006304)
+ pdiblc2  = (0.0534368)
+ pdiblcb  = (-1.225)
+ delta    = (0.0578296)
+ vsat     = (602076.1529)
+ voff     = (-0.175)
+ nfactor  = (1.0)
+ ll       = (-4.93438524e-12)
+ wl       = (2.17124e-15)
+ lw       = (-6.88049e-17)
+ lwl      = (-2.20509e-20)
+ wwl      = (-7.247732e-21+1e-18*dela_wwl_psrampu_10hv_bsim3v3)
+ lln      = (0.549635)
+ wln      = (0.996471)
+ lwn      = (1.19831)
+ wwn      = (0.85326)
+ kt1      = (-0.2226)
+ ute      = (-1.163)
+ ua1      = (2.455e-09)
+ ub1      = (-5.11e-18)
+ uc1      = (-5.6e-11)
+ kt1l     = (-7.8e-09)
+ at       = (300)
+ kt2      = (-0.0336)
+ noimod   = (noimod_psrampu_10hv_bsim3v3)

mpsrampu_10hv_i (d g s b) psrampu_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=np
xcnwtub_sub (b sub) cnwtub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=psrampu_10hv_dfrt
ends

subckt nmos5_10hv (d g s b sub)

parameters
+    l                              = 0.64
+    w                              = 0.69
+    ng                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 0
+    ring                           = 1
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_nmos5_10hv_bsim4 = tmp_nsmm_delr_gox_nmos5_10hv_bsim4
+    nsmm_dela_vfb_nmos5_10hv_bsim4 = tmp_nsmm_dela_vfb_nmos5_10hv_bsim4
+    nsmm_delr_nsub_nmos5_10hv_bsim4 = tmp_nsmm_delr_nsub_nmos5_10hv_bsim4
+    nsmm_dela_vtl_nmos5_10hv_bsim4 = tmp_nsmm_dela_vtl_nmos5_10hv_bsim4
+    nsmm_dela_dl_nmos5_10hv_bsim4  = tmp_nsmm_dela_dl_nmos5_10hv_bsim4
+    nsmm_dela_dwox_nmos5_10hv_bsim4 = tmp_nsmm_dela_dwox_nmos5_10hv_bsim4
+    nsmm_delr_ubref_nmos5_10hv_bsim4 = tmp_nsmm_delr_ubref_nmos5_10hv_bsim4
+    nsmm_delr_rsh_nmos5_10hv_bsim4 = tmp_nsmm_delr_rsh_nmos5_10hv_bsim4
+    nsmm_dela_vtw_nmos5_10hv_bsim4 = tmp_nsmm_dela_vtw_nmos5_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nmos5_vthratio          = (1.0)
+    presto_nmos5_betaratio         = (1.32)
+    relimo_ratio1_a_hci_nmos5_10hv = (0.173319328)
+    relimo_ratio1_b_hci_nmos5_10hv = (-1.33287605)
+    nde                            = (mod(ng,2))
+    nse                            = (2-nde)
+    nd                             = ((ng+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    default_as                     = ((as/ng)+(as==0)*(1-lpe)*((lg2aa_nmos5_10hv*nse+lg2g_nmos5_10hv*nsi)*w/ng))
+    default_ps                     = ((ps/ng)+(ps==0)*(1-lpe)*((2*(lg2aa_nmos5_10hv*nse+lg2g_nmos5_10hv*nsi)+2*ns*w)/ng))
+    default_ad                     = ((ad/ng)+(ad==0)*(1-lpe)*((lg2aa_nmos5_10hv*nde+lg2g_nmos5_10hv*ndi)*w/ng))
+    default_pd                     = ((pd/ng)+(pd==0)*(1-lpe)*((2*(lg2aa_nmos5_10hv*nde+lg2g_nmos5_10hv*ndi)+2*nd*w)/ng))
+    as_i                           = ((acj0_junc_nmos5_s_body/acj0_junc_nmos5_d_body)*((as/ngtotal)+(as==0)*(1-lpe)*default_as))
+    ps_i                           = ((pcj0_junc_nmos5_s_body/pcj0_junc_nmos5_d_body)*((ps/ngtotal)+(ps==0)*(1-lpe)*default_ps))
+    ad_i                           = ((ad/ngtotal)+(ad==0)*(1-lpe)*default_ad)
+    pd_i                           = ((pd/ngtotal)+(pd==0)*(1-lpe)*default_pd)
+    nrs_i                          = (lg2ct_nmos5_10hv/w)
+    nrd_i                          = (lg2ct_nmos5_10hv/w)
+    liso                           = (laa2iso_left_nmos5_10hv+lg2aa_nmos5_10hv*(nse+nde)+lg2g_nmos5_10hv*(nsi+ndi)+(l+lg_2nd_nmos5_10hv)*ngtotal+laa2iso_right_nmos5_10hv)
+    wiso_i                         = (wg2iso_nmos5_10hv*2+w)
+    wiso                           = (3*(wiso_i<=3)+wiso_i*(wiso_i>3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    nmos5_astivfb                  = (0.014)
+    nmos5_bstivfb                  = (-0.01)
+    nmos5_astinsub                 = (-3.4e-3)
+    nmos5_astiubref                = (-0.10)
+    nmos5_bstiubref                = (-0.0092)
+    nmos5_cstiubref                = (3.25)
+    nmos5_astivsat                 = (-0.03)
+    ng_a                           = int_round(ng/2)+mod(ng,2)
+    ng_b                           = ng-ng_a
+    sa_out                         = 0.375
+    sb_out                         = 0.375
+    sds                            = 0.42
+    sdd                            = 1.18
+    sbx                            = 0.755
+    sdeff                          = sds+sdd+l
+    saeffa                         = sa_val_10hv(sa_out,l,ng_a,sdeff)
+    sab                            = sa_out+l+sdd
+    saeffb                         = sa_val_10hv(sab,l,ng_b,sdeff)
+    saeff                          = ng/(ng_a/(saeffa+l/2)+ng_b/(saeffb+l/2))-l/2
+    ng_odd                         = mod(ng,2)
+    sbeffb                         = sa_val_10hv(sb_out,l,ng_b,sdeff)
+    sba                            = sb_out+l+sdd
+    sbeffa                         = sa_val_10hv(sba,l,ng_a,sdeff)
+    sbeff_even                     = ng/(ng_a/(sbeffa+l/2)+ng_b/(sbeffb+l/2))-l/2
+    sbxb                           = sbx+l+sds
+    sbeffbo                        = sa_val_10hv(sbxb,l,ng_b,sdeff)
+    sbeffao                        = sa_val_10hv(sbx,l,ng_a,sdeff)
+    sbeff_odd                      = ng/(ng_a/(sbeffao+l/2)+ng_b/(sbeffbo+l/2))-l/2
+    sbeff                          = ng_odd*sbeff_odd+(1-ng_odd)*sbeff_even
+    sa_i                           = (sa+(sa==0)*(saeff))
+    sb_i                           = (sb+(sb==0)*(sbeff))
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.375)+1/(0.5*l+0.755))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti                    = ((stimod_on)*((nmos5_astivfb+nmos5_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti                   = ((stimod_on)*((1+nmos5_astinsub*stress)/(1+nmos5_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti                     = ((stimod_on)*(((1+(nmos5_astiubref+l*nmos5_bstiubref)*stress+(nmos5_cstiubref/sqrt(w)))/(1+(nmos5_astiubref+l*nmos5_bstiubref)*stress0+(nmos5_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fac_vsat_sti                   = ((stimod_on)*((1+(nmos5_astivsat)*stress)/(1+(nmos5_astivsat)*stress0))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = -1.1e-08
+    ldmu0_dte                      = 1.8e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,ng,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,ng,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = -1.1e-08
+    wdmu0_dte                      = 2e-7
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+((temp-27)*(-3.25e-3)+(temp-27)*(temp-27)*(7e-6)))
+    delr_tox_nmos5_10hv_bsim4      = (nom_delr_tox_nmos5_10hv_bsim4*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_nmos5_10hv_bsim4+nsmm_delr_gox_nmos5_10hv_bsim4*smm_delr_gox_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_dwox_nmos5_10hv_bsim4     = (nom_dela_dwox_nmos5_10hv_bsim4+nsig_dela_dwox_nmos5_10hv_bsim4*sig_dela_dwox_nmos5_10hv_bsim4+nsmm_dela_dwox_nmos5_10hv_bsim4*smm_dela_dwox_nmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_vfb_nmos5_10hv_bsim4      = (nom_dela_vfb_nmos5_10hv_bsim4+del_vfb_sti+dela_vth_dte+nsig_dela_vfb_nmos5_10hv_bsim4*sig_dela_vfb_nmos5_10hv_bsim4+tc_vth_mm*(nsmm_dela_vfb_nmos5_10hv_bsim4*smm_dela_vfb_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)+nsmm_dela_vtl_nmos5_10hv_bsim4*smm_dela_vtl_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_nmos5_10hv_bsim4*smm_dela_vtw_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)/w))
+    delr_ubref_nmos5_10hv_bsim4    = ((fac_ub_sti*delr_mu0_dte)*nom_delr_ubref_nmos5_10hv_bsim4*(1.0+nsig_delr_ubref_nmos5_10hv_bsim4*sig_delr_ubref_nmos5_10hv_bsim4+nsmm_delr_ubref_nmos5_10hv_bsim4*smm_delr_ubref_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_ags_nmos5_10hv_bsim4      = (nom_dela_ags_nmos5_10hv_bsim4+nsig_dela_ags_nmos5_10hv_bsim4*sig_dela_ags_nmos5_10hv_bsim4)
+    dela_vtl_nmos5_10hv_bsim4      = (nom_dela_vtl_nmos5_10hv_bsim4+nsig_dela_vtl_nmos5_10hv_bsim4*sig_dela_vtl_nmos5_10hv_bsim4)
+    dela_dl_nmos5_10hv_bsim4       = (nom_dela_dl_nmos5_10hv_bsim4+nsig_dela_dl_nmos5_10hv_bsim4*sig_dela_dl_nmos5_10hv_bsim4+nsmm_dela_dl_nmos5_10hv_bsim4*smm_dela_dl_nmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    delr_vsat_nmos5_10hv_bsim4     = ((fac_vsat_sti)*nom_delr_vsat_nmos5_10hv_bsim4*(1.0+nsig_delr_vsat_nmos5_10hv_bsim4*sig_delr_vsat_nmos5_10hv_bsim4))
+    delr_pvsat_nmos5_10hv_bsim4    = (nom_delr_pvsat_nmos5_10hv_bsim4*(1.0+nsig_delr_pvsat_nmos5_10hv_bsim4*sig_delr_pvsat_nmos5_10hv_bsim4))
+    dela_b0_nmos5_10hv_bsim4       = (nom_dela_b0_nmos5_10hv_bsim4+nsig_dela_b0_nmos5_10hv_bsim4*sig_dela_b0_nmos5_10hv_bsim4)
+    dela_k3_nmos5_10hv_bsim4       = (nom_dela_k3_nmos5_10hv_bsim4+nsig_dela_k3_nmos5_10hv_bsim4*sig_dela_k3_nmos5_10hv_bsim4)
+    dela_vtm_nmos5_10hv_bsim4      = (nom_dela_vtm_nmos5_10hv_bsim4+nsig_dela_vtm_nmos5_10hv_bsim4*sig_dela_vtm_nmos5_10hv_bsim4)
+    dela_pu0_nmos5_10hv_bsim4      = (nom_dela_pu0_nmos5_10hv_bsim4+nsig_dela_pu0_nmos5_10hv_bsim4*sig_dela_pu0_nmos5_10hv_bsim4)
+    delr_rsh_nmos5_10hv_bsim4      = (1+nsmm_delr_rsh_nmos5_10hv_bsim4*smm_delr_rsh_nmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    delr_nsub_nmos5_10hv_bsim4     = ((fac_nsub_sti)*(1+nsmm_delr_nsub_nmos5_10hv_bsim4*smm_delr_nsub_nmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    delr_jts_nmos5_10hv_bsim4      = (exp(nom_dela_jts_nmos5_10hv_bsim4+nsig_dela_jts_nmos5_10hv_bsim4*sig_dela_jts_nmos5_10hv_bsim4))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.31e-08*delr_tox_nmos5_10hv_bsim4)
+    cox                            = (epsox/tox)
+    ut2                            = (-4.5e-06)
+    u0delta                        = (1+ut2*(1/l)*(temp-tnom)*(temp-tnom))
+    kboq                           = (8.617087e-5)
+    vtm0                           = (kboq*tnom)
+    eg0                            = (1.16-7.02e-4*tnom*tnom/(tnom+1108.0))
+    nit                            = (1.45e10*(tnom/300.15)*sqrt(tnom/300.15)*exp(21.5565981-eg0/(2.0*vtm0)))
+    phis                           = (0.4+vtm0*log(1e17/nit)+0.08)
+    sqrt_delr_nsub                 = (sqrt(delr_nsub_nmos5_10hv_bsim4))
+    fitpar                         = (2.0)

model nmos5_10hv bsim4 type=n version=4.7
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ cjs      = (1.0e12*acj0_junc_nmos5_s_body)
+ pbs      = (aphi_junc_nmos5_s_body)
+ mjs      = (aexm_junc_nmos5_s_body)
+ jss      = (1.0e12*ajs_junc_nmos5_s_body)
+ njs      = (ajnd_junc_nmos5_s_body)
+ cjsws    = (1.0e6*pcj0_junc_nmos5_s_body)
+ pbsws    = (pphi_junc_nmos5_s_body)
+ mjsws    = (pexm_junc_nmos5_s_body)
+ jsws     = (1.0e6*pjs_junc_nmos5_s_body)
+ cjswgs   = (1.0e6*chcj0_junc_nmos5_s_body)
+ pbswgs   = (chphi_junc_nmos5_s_body)
+ mjswgs   = (chexm_junc_nmos5_s_body)
+ jswgs    = (1.0e+6*chjs_junc_nmos5_s_body)
+ jsd      = (1.0e12*ajs_junc_nmos5_d_body)
+ njd      = (ajnd_junc_nmos5_d_body)
+ cjswgd   = (1.0e6*chcj0_junc_nmos5_d_body)
+ mjswgd   = (chexm_junc_nmos5_d_body)
+ jswd     = (1.0e6*pjs_junc_nmos5_d_body)
+ jswgd    = (1.0e+6*chjs_junc_nmos5_d_body)
+ cgso     = (1e-10/delr_tox_nmos5_10hv_bsim4+(0.5*cfr_nmos5_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos5_s_ply_met*1e6-0.5*cfr_nmos5_s_ply_met*1e6))
+ cgdo     = (4.5e-10/delr_tox_nmos5_10hv_bsim4+(0.5*cfr_nmos5_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos5_s_ply_met*1e6-0.5*cfr_nmos5_s_ply_met*1e6))
+ cgbo     = (0.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ igcmod   = (0.0)
+ igbmod   = (0.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ wpemod   = (1.0)
+ tempmod  = (1.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (1.32e-08*delr_tox_nmos5_10hv_bsim4)
+ toxm     = (1.32e-08)
+ toxp     = (((1.32e-08*delr_tox_nmos5_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1e17*delr_nsub_nmos5_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (1e20)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (-1e-08-0.5e-7*dela_dl_nmos5_10hv_bsim4)
+ wint     = (9.7e-08-0.5e-7*dela_dwox_nmos5_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (0.0)
+ wwl      = (0.0)
+ wln      = (1.0)
+ ww       = (-2.5e-14)
+ wwn      = (1.0)
+ ll       = (4e-14)
+ lln      = (1.0)
+ lw       = (4.5e-14)
+ lwn      = (1.05)
+ dwg      = (-7e-09)
+ ldwg     = (0.0)
+ wdwg     = (0.0)
+ pdwg     = (0.0)
+ dwb      = (-3e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = ((0.627+dela_vfb_nmos5_10hv_bsim4+dela_vtl_nmos5_10hv_bsim4/l)+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nmos5_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nmos5_10hv-relimo_ratio1_b_hci_nmos5_10hv)+(sqrt_delr_nsub-1)*0.78*fitpar*sqrt(phis))
+ lvth0    = (0.0)
+ wvth0    = (0.0)
+ pvth0    = (-0.007+dela_vtm_nmos5_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (1.5)
+ phin     = (0.08)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.78*sqrt_delr_nsub)
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.016*sqrt_delr_nsub)
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (5.0+10*dela_k3_nmos5_10hv_bsim4)
+ lk3      = (0.0)
+ wk3      = (0.0)
+ pk3      = (0.0)
+ k3b      = (-1.5)
+ lk3b     = (0.0)
+ wk3b     = (0.0)
+ pk3b     = (0.0)
+ w0       = (2.5e-06)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (1.008e-07)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (-9.2e-08)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (5e-09)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (2.2)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.53)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.032)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (0.0)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (5300000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (-0.032)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = ((1.13)*delr_a0_relimo)
+ la0      = (-1.27)
+ wa0      = (0.0)
+ pa0      = (0.23)
+ ags      = (0.15+dela_ags_nmos5_10hv_bsim4)
+ lags     = (0.1)
+ wags     = (0.0)
+ pags     = (0.09)
+ b0       = (5e-08+1e-7*dela_b0_nmos5_10hv_bsim4)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (0.0)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.009024)
+ lketa    = (-0.04)
+ wketa    = (0.0)
+ pketa    = (0.029)
+ a1       = (0.0)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((455.9*u0delta*delr_ubref_nmos5_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0*u0delta)
+ wu0      = (0.0*u0delta)
+ pu0      = ((-24.0+dela_pu0_nmos5_10hv_bsim4)*u0delta)
+ ua       = (-3.882e-10)
+ lua      = (2.4e-10)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (2.529e-18)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (0.082)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.67)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (76000.0*delr_vsat_nmos5_10hv_bsim4)
+ lvsat    = (0.0)
+ wvsat    = (0.0)
+ pvsat    = (11000.0*delr_pvsat_nmos5_10hv_bsim4)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.67)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.13)
+ lvoff    = (0.0)
+ wvoff    = (-0.03)
+ pvoff    = (0.0)
+ tvoff    = (0.0)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (0.0)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.0001)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-0.1)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.1)
+ dsub     = (0.56)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (1e-05)
+ lcit     = (0.0001)
+ wcit     = (0.0002)
+ pcit     = (-0.0001)
+ cdsc     = (0.00024)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.001)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.43)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.0005)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (-0.00005)
+ pdiblcb  = (0.0)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (0.56)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (3000.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (0.3)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.006)
+ ldelta   = (0.012)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = ((2130.0*delr_rsh_nmos5_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (180.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.16)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.04)
+ prwb     = (0.09)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.0)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (2e-09)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (0.5)
+ lalpha1  = (0.0)
+ walpha1  = (-0.15)
+ palpha1  = (0.13)
+ beta0    = (25.0)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (0.0)
+ lagidl   = (0.0)
+ wagidl   = (0.0)
+ pagidl   = (0.0)
+ bgidl    = (2300000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (0.5)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (0.8)
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (0.43)
+ laigbacc = (0.0)
+ waigbacc = (0.0)
+ paigbacc = (0.0)
+ bigbacc  = (0.054)
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.075)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (1.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.35)
+ laigbinv = (0.0)
+ waigbinv = (0.0)
+ paigbinv = (0.0)
+ bigbinv  = (0.03)
+ lbigbinv = (0.0)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.006)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.1)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (0.43)
+ laigc    = (0.0)
+ waigc    = (0.0)
+ paigc    = (0.0)
+ bigc     = (0.054)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.075)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.43)
+ laigsd   = (0.0)
+ waigsd   = (0.0)
+ paigsd   = (0.0)
+ bigsd    = (0.054)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.075)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (0.0)
+ nigc     = (1.0)
+ lnigc    = (0.0)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (1.32e-08)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgsl     = (5e-11)
+ lcgsl    = (0.0)
+ wcgsl    = (0.0)
+ pcgsl    = (0.0)
+ cgdl     = (1e-10)
+ lcgdl    = (0.0)
+ wcgdl    = (0.0)
+ pcgdl    = (0.0)
+ ckappas  = (0.6)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (3e-08*2.2)
+ dwc      = (-7e-08*1.05)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (2.0)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.07)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.4)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (5.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (-3.5e-14*0.48)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.0005)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jtss     = (1e-08*delr_jts_nmos5_10hv_bsim4)
+ jtssws   = (1.5e-11*delr_jts_nmos5_10hv_bsim4)
+ jtsswgs  = (1e-11*delr_jts_nmos5_10hv_bsim4)
+ jtsd     = (1e-08*delr_jts_nmos5_10hv_bsim4)
+ jtsswd   = (1e-11*delr_jts_nmos5_10hv_bsim4)
+ jtsswgd  = (1e-11*delr_jts_nmos5_10hv_bsim4)
+ njts     = (20.0)
+ njtssw   = (20.0)
+ njtsswg  = (20.0)
+ njtsd    = (25.0)
+ njtsswd  = (25.0)
+ njtsswgd = (25.0)
+ xtss     = (0.1)
+ xtssws   = (0.3)
+ xtsswgs  = (0.5)
+ xtsd     = (0.2)
+ xtsswd   = (0.3)
+ xtsswgd  = (0.4)
+ vtss     = (10.0)
+ vtssws   = (10.0)
+ vtsswgs  = (10.0)
+ tnjts    = (0.0)
+ tnjtssw  = (-0.3)
+ tnjtsswg = (-0.6)
+ tnjtsd   = (0.0)
+ tnjtsswd = (-0.25)
+ tnjtsswgd = (-0.48)
+ jtweff   = (5e-06)
+ fc       = (0.5)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.72)
+ lute     = (0.2)
+ wute     = (0.2)
+ pute     = (-0.02)
+ kt1      = (-0.43)
+ lkt1     = (0.0)
+ wkt1     = (0.0)
+ pkt1     = (0.02)
+ kt1l     = (0.0)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.05)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (-0.005)
+ lua1     = (0.0)
+ wua1     = (-0.0025)
+ pua1     = (0.001)
+ ub1      = (-0.0021)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-5.6e-11)
+ luc1     = (0.0)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (0.0015)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (0.001)
+ lprt     = (0.0)
+ wprt     = (0.0016)
+ pprt     = (0.0)
+ xtis     = (1.0)
+ tpb      = (0.00165)
+ tpbsw    = (0.00165)
+ tpbswg   = (0.00165)
+ tcj      = (0.00096)
+ tcjsw    = (0.0)
+ tcjswg   = (0.0009)
+ saref    = (1e-06)
+ sbref    = (1e-06)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (1e-2)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (2e-5)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)
+ noia     = (noia_nmos5_10hv_bsim4)
+ noib     = (noib_nmos5_10hv_bsim4)
+ noic     = (noic_nmos5_10hv_bsim4)
+ ef       = (ef_nmos5_10hv_bsim4)
+ em       = (em_nmos5_10hv_bsim4)

model rdint resistor
+ tnom  = (27)
+ rsh   = (670)
+ tc1   = (0.000015)
+ tc2   = (0.000002)

mnmos5_10hv_i (d_i g s b) nmos5_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ngtotal sca=sca_f scb=scb_f scc=scc_f
rrdint (d_i d) rdint w=(w) l=(1.3) m=(ngtotal)
xcdgontub_sub (b sub) cdgontub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=nmos5_10hv_dfrt
ends

subckt pmos5_10hv (d g s b sub)

parameters
+    l                              = 1.02
+    w                              = 0.69
+    ng                             = 1
+    as                             = 0
+    ps                             = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    sa                             = 0
+    sb                             = 0
+    wdist                          = 0
+    ring                           = 1
+    soa                            = 1
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_gox_pmos5_10hv_bsim4 = tmp_nsmm_delr_gox_pmos5_10hv_bsim4
+    nsmm_dela_vfb_pmos5_10hv_bsim4 = tmp_nsmm_dela_vfb_pmos5_10hv_bsim4
+    nsmm_delr_nsub_pmos5_10hv_bsim4 = tmp_nsmm_delr_nsub_pmos5_10hv_bsim4
+    nsmm_dela_vtl_pmos5_10hv_bsim4 = tmp_nsmm_dela_vtl_pmos5_10hv_bsim4
+    nsmm_dela_dl_pmos5_10hv_bsim4  = tmp_nsmm_dela_dl_pmos5_10hv_bsim4
+    nsmm_dela_dwox_pmos5_10hv_bsim4 = tmp_nsmm_dela_dwox_pmos5_10hv_bsim4
+    nsmm_delr_ubref_pmos5_10hv_bsim4 = tmp_nsmm_delr_ubref_pmos5_10hv_bsim4
+    nsmm_delr_rsh_pmos5_10hv_bsim4 = tmp_nsmm_delr_rsh_pmos5_10hv_bsim4
+    nsmm_dela_vtw_pmos5_10hv_bsim4 = tmp_nsmm_dela_vtw_pmos5_10hv_bsim4
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos5_vthratio          = 1.0
+    presto_pmos5_betaratio         = 1.1
+    relimo_ratio1_a_hci_pmos5_10hv = (0.250554324)
+    relimo_ratio1_b_hci_pmos5_10hv = (-0.864139756)
+    nde                            = (mod(ng,2))
+    nse                            = (2-nde)
+    nd                             = ((ng+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    as_i                           = ((as/ng)+(as==0)*(1-lpe)*((lg2aa_pmos5_10hv*nse+lg2g_pmos5_10hv*nsi)*w/ng))
+    ps_i                           = ((ps/ng)+(ps==0)*(1-lpe)*((2*(lg2aa_pmos5_10hv*nse+lg2g_pmos5_10hv*nsi)+2*ns*w)/ng))
+    ad_i                           = ((ad/ng)+(ad==0)*(1-lpe)*((lg2aa_pmos5_10hv*nde+lg2g_pmos5_10hv*ndi)*w/ng))
+    pd_i                           = ((pd/ng)+(pd==0)*(1-lpe)*((2*(lg2aa_pmos5_10hv*nde+lg2g_pmos5_10hv*ndi)+2*nd*w)/ng))
+    nrs_i                          = (lg2ct_pmos5_10hv/w)
+    nrd_i                          = (lg2ct_pmos5_10hv/w)
+    liso                           = (laa2iso_left_pmos5_10hv+lg2aa_pmos5_10hv*(nse+nde)+lg2g_pmos5_10hv*(nsi+ndi)+l*ng+laa2iso_right_pmos5_10hv)
+    wiso_i                         = (wg2iso_pmos5_10hv*2+w)
+    wiso                           = (3*(wiso_i<=3)+wiso_i*(wiso_i>3))
+    aiso                           = (liso*wiso)
+    piso                           = ((liso+wiso)*2)
+    dela_dwox_pmos5_wdist          = (0+(wdist==1)*0.0251198+(wdist==2)*0.024208)
+    dela_vfb_pmos5_wdist           = (0+(wdist==1)*(-0.0116633)+(wdist==2)*(0.00398903))
+    delr_ubref_pmos5_wdist         = (1+(wdist==1)*(1.01691-1)+(wdist==2)*(1.00422-1))
+    dela_dl_pmos5_wdist            = (0+(wdist==1)*0.0131893+(wdist==2)*0.0049807)
+    dela_vtl_pmos5_wdist           = (0+(wdist==1)*(-0.0649301)+(wdist==2)*(-0.0192495))
+    dela_vtw_pmos5_wdist           = (0+(wdist==1)*(-0.0118711)+(wdist==2)*(-0.0235191))
+    dela_vtwb_pmos5_wdist          = (0+(wdist==1)*0.5+(wdist==2)*0.5)
+    pmos5_astivfb                  = (-0.0033)
+    pmos5_bstivfb                  = (1.28e-4)
+    pmos5_astinsub                 = (-1.8e-4)
+    pmos5_astiubref                = (0.072*1.08)
+    pmos5_bstiubref                = (0.0232)
+    pmos5_cstiubref                = (0.009*53)
+    sa_out                         = (0.375)
+    sb_out                         = (0.375)
+    sd_sti                         = (0.42)
+    saeff                          = sa_val_10hv(sa_out,l,ng,sd_sti)
+    sbeff                          = sa_val_10hv(sb_out,l,ng,sd_sti)
+    sa_i                           = (sa+(sa==0)*saeff)
+    sb_i                           = (sb+(sb==0)*sbeff)
+    stress                         = (1/(0.5*l+sa_i)+1/(0.5*l+sb_i))
+    stress0                        = (1/(0.5*l+0.375)+1/(0.5*l+0.375))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pmos5_astivfb+pmos5_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pmos5_astinsub*stress)/(1+pmos5_astinsub*stress0))+(1-stimod_on))
+    fac_ubref_sti_final            = ((stimod_on)*(((1+(pmos5_astiubref+l*pmos5_bstiubref)*stress+(pmos5_cstiubref/sqrt(w)))/(1+(pmos5_astiubref+l*pmos5_bstiubref)*stress0+(pmos5_cstiubref/sqrt(w)))))+(1-stimod_on))
+    fscale                         = (1e-06)
+    fshrink                        = (1)
+    lm                             = (l*fscale)
+    wm                             = (w*fscale)
+    sd                             = (0)
+    sd_m                           = (sd*fscale)
+    sd_ref                         = (0.42*fscale)
+    sd_f                           = (sd<=0)*(sd_ref)+(sd>0)*sd_m
+    wpmxdis                        = (15*fscale*fshrink)
+    wsc1_ref                       = (wpmxdis)//dcmodulevalue
+    wsc3_ref                       = (15*fscale*fshrink)
+    wsc4_ref                       = (15*fscale*fshrink)
+    wsc2_ref                       = (15*fscale*fshrink)
+    wsc1_i                         = ((wsc1<=0)*(wsc1_ref)+(wsc1>0)*(wsc1*fscale*fshrink))
+    wsc1_var                       = (wsc1_i<=wpmxdis)*wsc1_i+(wsc1_i>wpmxdis)*wpmxdis
+    wsc4_i                         = ((wsc4<=0)*(wsc4_ref)+(wsc4>0)*(wsc4*fscale*fshrink))
+    wsc4_var                       = (wsc4_i<=wpmxdis)*wsc4_i+(wsc4_i>wpmxdis)*wpmxdis
+    wsc3_i                         = ((wsc3<=0)*(wsc3_ref)+(wsc3>0)*(wsc3*fscale*fshrink))
+    wsc3_var                       = (wsc3_i<=wpmxdis)*wsc3_i+(wsc3_i>wpmxdis)*wpmxdis
+    wsc2_i                         = ((wsc2<=0)*(wsc2_ref)+(wsc2>0)*(wsc2*fscale*fshrink))
+    wsc2_var                       = (wsc2_i<=wpmxdis)*wsc2_i+(wsc2_i>wpmxdis)*wpmxdis
+    scref_f                        = (1e-6)
+    sca_ref                        = sca_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f)
+    scb_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,10)
+    scc_ref                        = scb_val_10hv(wsc1_ref,wsc4_ref,wsc3_ref,wsc2_ref,wm,lm,ng,sd_f,scref_f,20)
+    sca_i                          = sca_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f)
+    scb_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,10)
+    scc_i                          = scb_val_10hv(wsc1_var,wsc4_var,wsc3_var,wsc2_var,wm,lm,ng,sd_f,scref_f,20)
+    sca_f                          = (sca_i-sca_ref)*enable_wpe
+    scb_f                          = (scb_i-scb_ref)*enable_wpe
+    scc_f                          = (scc_i-scc_ref)*enable_wpe
+    corner_dte                     = 5e-6
+    ldelta_dte                     = 1.0//um
+    ldvth_dte                      = -1.1e-08
+    ldmu0_dte                      = -1.8e-7
+    tsc1_eff_m                     = (tsc1+ldelta_dte)*fscale
+    tsc3_eff_m                     = (tsc3+ldelta_dte)*fscale
+    tsc1_eff_f                     = sa_val_10hv(tsc1_eff_m,lm,ng,sd_f)
+    tsc3_eff_f                     = sa_val_10hv(tsc3_eff_m,lm,ng,sd_f)
+    davth_dte_tsc1_tsc3            = ldvth_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    drmu0_dte_tsc1_tsc3            = 1+ldmu0_dte*(lm/(lm+corner_dte))*((tsc1>0)/(tsc1_eff_f+lm/2)+(tsc3>0)/(tsc3_eff_f+lm/2))
+    wdelta_dte                     = 5.0//um
+    wdvth_dte                      = 1.1e-08
+    wdmu0_dte                      = 2.2e-7
+    tsc2_eff_f                     = (tsc2+wdelta_dte)*fscale
+    tsc4_eff_f                     = (tsc4+wdelta_dte)*fscale
+    davth_dte_tsc2_tsc4            = wdvth_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    drmu0_dte_tsc2_tsc4            = 1+wdmu0_dte*(wm/(wm+corner_dte))*((tsc2>0)/(tsc2_eff_f+wm/2)+(tsc4>0)/(tsc4_eff_f+wm/2))
+    dela_vth_dte                   = (davth_dte_tsc1_tsc3+davth_dte_tsc2_tsc4)*enable_dte
+    delr_mu0_dte                   = drmu0_dte_tsc1_tsc3*drmu0_dte_tsc2_tsc4*enable_dte+1-enable_dte
+    tc_vth_mm                      = (1+((temp-27)*(-2.01e-3)+(temp-27)*(temp-27)*(4.4e-6)))
+    delr_tox_pmos5_10hv_bsim4      = (nom_delr_tox_pmos5_10hv_bsim4*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_pmos5_10hv_bsim4+nsmm_delr_gox_pmos5_10hv_bsim4*smm_delr_gox_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_dwox_pmos5_10hv_bsim4     = (nom_dela_dwox_pmos5_10hv_bsim4+nsig_dela_dwox_pmos5_10hv_bsim4*sig_dela_dwox_pmos5_10hv_bsim4+nsmm_dela_dwox_pmos5_10hv_bsim4*smm_dela_dwox_pmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_vfb_pmos5_10hv_bsim4      = (nom_dela_vfb_pmos5_10hv_bsim4+del_vfb_sti_final+dela_vth_dte+nsig_dela_vfb_pmos5_10hv_bsim4*sig_dela_vfb_pmos5_10hv_bsim4+tc_vth_mm*(nsmm_dela_vfb_pmos5_10hv_bsim4*smm_dela_vfb_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)+nsmm_dela_vtl_pmos5_10hv_bsim4*smm_dela_vtl_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_pmos5_10hv_bsim4*smm_dela_vtw_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)/w))
+    delr_ubref_pmos5_10hv_bsim4    = (nom_delr_ubref_pmos5_10hv_bsim4*(fac_ubref_sti_final*delr_mu0_dte)*(1+nsig_delr_ubref_pmos5_10hv_bsim4*sig_delr_ubref_pmos5_10hv_bsim4+nsmm_delr_ubref_pmos5_10hv_bsim4*smm_delr_ubref_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    dela_dl_pmos5_10hv_bsim4       = (nom_dela_dl_pmos5_10hv_bsim4+nsig_dela_dl_pmos5_10hv_bsim4*sig_dela_dl_pmos5_10hv_bsim4+nsmm_dela_dl_pmos5_10hv_bsim4*smm_dela_dl_pmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    dela_vtl_pmos5_10hv_bsim4      = (nom_dela_vtl_pmos5_10hv_bsim4+nsig_dela_vtl_pmos5_10hv_bsim4*sig_dela_vtl_pmos5_10hv_bsim4)
+    dela_vtw_pmos5_10hv_bsim4      = (nom_dela_vtw_pmos5_10hv_bsim4+nsig_dela_vtw_pmos5_10hv_bsim4*sig_dela_vtw_pmos5_10hv_bsim4)
+    dela_vtm_pmos5_10hv_bsim4      = (nom_dela_vtm_pmos5_10hv_bsim4+nsig_dela_vtm_pmos5_10hv_bsim4*sig_dela_vtm_pmos5_10hv_bsim4)
+    dela_a0_pmos5_10hv_bsim4       = (nom_dela_a0_pmos5_10hv_bsim4+nsig_dela_a0_pmos5_10hv_bsim4*sig_dela_a0_pmos5_10hv_bsim4)
+    dela_wags_pmos5_10hv_bsim4     = (nom_dela_wags_pmos5_10hv_bsim4+nsig_dela_wags_pmos5_10hv_bsim4*sig_dela_wags_pmos5_10hv_bsim4)
+    dela_vsat_pmos5_10hv_bsim4     = (nom_dela_vsat_pmos5_10hv_bsim4+nsig_dela_vsat_pmos5_10hv_bsim4*sig_dela_vsat_pmos5_10hv_bsim4)
+    dela_wwl_pmos5_10hv_bsim4      = (nom_dela_wwl_pmos5_10hv_bsim4+nsig_dela_wwl_pmos5_10hv_bsim4*sig_dela_wwl_pmos5_10hv_bsim4)
+    delr_agidl_pmos5_10hv_bsim4    = (nom_delr_agidl_pmos5_10hv_bsim4*exp(nsig_delr_agidl_pmos5_10hv_bsim4*sig_delr_agidl_pmos5_10hv_bsim4))
+    delr_rsh_pmos5_10hv_bsim4      = (1+nsmm_delr_rsh_pmos5_10hv_bsim4*smm_delr_rsh_pmos5_10hv_bsim4(l,w)/sqrt(1*ng))
+    delr_nsub_pmos5_10hv_bsim4     = (fac_nsub_sti_final*(1+nsmm_delr_nsub_pmos5_10hv_bsim4*smm_delr_nsub_pmos5_10hv_bsim4(l,w)/sqrt(1*ng)))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.30e-08*delr_tox_pmos5_10hv_bsim4)
+    cox                            = (epsox/tox)
+    kboq                           = (8.617087e-5)
+    vtm                            = (kboq*(temp+273.15))
+    eg                             = (1.16-7.02e-4*(temp+273.15)*(temp+273.15)/((temp+273.15)+1108.0))
+    nit                            = (1.45e10*((temp+273.15)/300.15)*sqrt((temp+273.15)/300.15)*exp(21.5565981-eg/(2.0*vtm)))
+    phis                           = (0.4+vtm*log(1e+17/nit)+0.03342)

model pmos5_10hv bsim4 type=p version=4.7
+ minr     = (1e-4)
+ vbox     = (500)
+ paramchk = (1.0)
+ binunit  = (1.0)
+ mobmod   = (1.0)
+ cvchargemod = (0.0)
+ mtrlmod  = (0.0)
+ rdsmod   = (0.0)
+ igcmod   = (0.0)
+ igbmod   = (0.0)
+ capmod   = (2.0)
+ rgatemod = (0.0)
+ rbodymod = (0.0)
+ trnqsmod = (0.0)
+ acnqsmod = (0.0)
+ fnoimod  = (1.0)
+ tnoimod  = (0.0)
+ diomod   = (1.0)
+ wpemod   = (1.0)
+ tempmod  = (0.0)
+ permod   = (1.0)
+ geomod   = (0.0)
+ rgeomod  = (0.0)
+ epsrox   = (3.9)
+ epsrgate = (11.7)
+ epsrsub  = (11.7)
+ eot      = (1.5e-09)
+ toxe     = (1.333e-08*delr_tox_pmos5_10hv_bsim4)
+ toxm     = (1.333e-08)
+ toxp     = (((1.333e-08*delr_tox_pmos5_10hv_bsim4))-((0.0)))
+ xj       = (1.5e-07)
+ lxj      = (0.0)
+ wxj      = (0.0)
+ pxj      = (0.0)
+ ndep     = (1e+17*delr_nsub_pmos5_10hv_bsim4)
+ lndep    = (0.0)
+ wndep    = (0.0)
+ pndep    = (0.0)
+ ngate    = (0.0)
+ lngate   = (0.0)
+ wngate   = (0.0)
+ pngate   = (0.0)
+ nsd      = (1e+20)
+ lnsd     = (0.0)
+ wnsd     = (0.0)
+ pnsd     = (0.0)
+ lxt      = (0.0)
+ wxt      = (0.0)
+ pxt      = (0.0)
+ rsh      = (0.0)
+ rshg     = (0.1)
+ lint     = (2.155e-07-0.5e-06*dela_dl_pmos5_wdist-0.5e-06*dela_dl_pmos5_10hv_bsim4)
+ wint     = (1.495e-07-0.5e-06*dela_dwox_pmos5_wdist-0.5e-06*dela_dwox_pmos5_10hv_bsim4)
+ wl       = (0.0)
+ lwl      = (8.397e-20)
+ wwl      = (-1.4e-20+1e-20*dela_wwl_pmos5_10hv_bsim4)
+ wln      = (1.0)
+ ww       = (-7.2e-14)
+ wwn      = (1.0)
+ ll       = (-8e-14)
+ lln      = (1.0)
+ lw       = (-1.311e-13)
+ lwn      = (1.0)
+ dwg      = (-4.3e-09)
+ ldwg     = (0.0)
+ wdwg     = (-1e-09)
+ pdwg     = (0.0)
+ dwb      = (2.862e-09)
+ ldwb     = (0.0)
+ wdwb     = (0.0)
+ pdwb     = (0.0)
+ vth0     = ((-0.702-dela_vfb_pmos5_10hv_bsim4)-dela_vth_relimo-(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos5_vthratio-hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pmos5_10hv-relimo_ratio1_b_hci_pmos5_10hv)-dela_vfb_pmos5_wdist-(sqrt(delr_nsub_pmos5_10hv_bsim4)-1)*0.8*(92/53)*sqrt(phis))
+ lvth0    = (0.0)
+ wvth0    = (0.0+dela_vtw_pmos5_wdist+dela_vtw_pmos5_10hv_bsim4)
+ pvth0    = (0.009104+dela_vtm_pmos5_10hv_bsim4)
+ vfb      = (-1.0)
+ lvfb     = (0.0)
+ wvfb     = (0.0)
+ pvfb     = (0.0)
+ vddeot   = (-1.5)
+ phin     = (0.03342)
+ lphin    = (0.0)
+ wphin    = (0.0)
+ pphin    = (0.0)
+ k1       = (0.8*sqrt(delr_nsub_pmos5_10hv_bsim4))
+ lk1      = (0.0)
+ wk1      = (0.0)
+ pk1      = (0.0)
+ k2       = (0.0115*sqrt(delr_nsub_pmos5_10hv_bsim4))
+ lk2      = (0.0)
+ wk2      = (0.0)
+ pk2      = (0.0)
+ k3       = (0.0)
+ lk3      = (0.0)
+ wk3      = (0.0)
+ pk3      = (0.0)
+ k3b      = (0.99+dela_vtwb_pmos5_wdist)
+ lk3b     = (0.75)
+ wk3b     = (0.0)
+ pk3b     = (0.0)
+ w0       = (0.0)
+ lw0      = (0.0)
+ ww0      = (0.0)
+ pw0      = (0.0)
+ lpe0     = (0.0+1e-06*dela_vtl_pmos5_wdist+1e-06*dela_vtl_pmos5_10hv_bsim4)
+ llpe0    = (0.0)
+ wlpe0    = (0.0)
+ plpe0    = (0.0)
+ lpeb     = (0.0)
+ llpeb    = (0.0)
+ wlpeb    = (0.0)
+ plpeb    = (0.0)
+ vbm      = (-3.0)
+ lvbm     = (0.0)
+ wvbm     = (0.0)
+ pvbm     = (0.0)
+ dvt0     = (2.2)
+ ldvt0    = (0.0)
+ wdvt0    = (0.0)
+ pdvt0    = (0.0)
+ dvt1     = (0.83)
+ ldvt1    = (0.0)
+ wdvt1    = (0.0)
+ pdvt1    = (0.0)
+ dvt2     = (-0.032)
+ ldvt2    = (0.0)
+ wdvt2    = (0.0)
+ pdvt2    = (0.0)
+ dvtp0    = (0.0)
+ ldvtp0   = (0.0)
+ wdvtp0   = (0.0)
+ pdvtp0   = (0.0)
+ dvtp1    = (0.0)
+ ldvtp1   = (0.0)
+ wdvtp1   = (0.0)
+ pdvtp1   = (0.0)
+ dvt0w    = (0.0)
+ ldvt0w   = (0.0)
+ wdvt0w   = (0.0)
+ pdvt0w   = (0.0)
+ dvt1w    = (5300000.0)
+ ldvt1w   = (0.0)
+ wdvt1w   = (0.0)
+ pdvt1w   = (0.0)
+ dvt2w    = (0.0)
+ ldvt2w   = (0.0)
+ wdvt2w   = (0.0)
+ pdvt2w   = (0.0)
+ a0       = (((0.9399+((temp+273.15)-(27+273.15))*0.001541+dela_a0_pmos5_10hv_bsim4))*delr_a0_relimo)
+ la0      = (0.0)
+ wa0      = (0.0)
+ pa0      = (0.0)
+ ags      = (0.09248)
+ lags     = (0.24)
+ wags     = (0.0+dela_wags_pmos5_10hv_bsim4)
+ pags     = (0.0)
+ b0       = (5e-08)
+ lb0      = (0.0)
+ wb0      = (0.0)
+ pb0      = (0.0)
+ b1       = (1e-08)
+ lb1      = (0.0)
+ wb1      = (0.0)
+ pb1      = (0.0)
+ keta     = (-0.001695)
+ lketa    = (-0.06)
+ wketa    = (0.0043)
+ pketa    = (0.0)
+ a1       = (1e-15)
+ la1      = (0.0)
+ wa1      = (0.0)
+ pa1      = (0.0)
+ a2       = (1.0)
+ la2      = (0.0)
+ wa2      = (0.0)
+ pa2      = (0.0)
+ phig     = (4.05)
+ ni0sub   = (14500000000.0)
+ bg0sub   = (1.16)
+ tbgasub  = (0.000702)
+ tbgbsub  = (1108.0)
+ ados     = (1.0)
+ bdos     = (1.0)
+ tempeot  = (300.1)
+ leffeot  = (1.0)
+ weffeot  = (10.0)
+ u0       = ((153.5*delr_ubref_pmos5_wdist*delr_ubref_pmos5_10hv_bsim4)*delr_u0_relimo)
+ lu0      = (0.0)
+ wu0      = (0.0)
+ pu0      = (0.0)
+ ua       = (1.909e-09)
+ lua      = (0.0)
+ wua      = (0.0)
+ pua      = (0.0)
+ ub       = (6.213e-19)
+ lub      = (0.0)
+ wub      = (0.0)
+ pub      = (0.0)
+ uc       = (-0.01799)
+ luc      = (0.0)
+ wuc      = (0.0)
+ puc      = (0.0)
+ ud       = (1e+14)
+ lud      = (0.0)
+ wud      = (0.0)
+ pud      = (0.0)
+ up       = (0.0)
+ lup      = (0.0)
+ wup      = (0.0)
+ pup      = (0.0)
+ lp       = (1e-08)
+ llp      = (0.0)
+ wlp      = (0.0)
+ plp      = (0.0)
+ eu       = (1.0)
+ leu      = (0.0)
+ weu      = (0.0)
+ peu      = (0.0)
+ vsat     = (40000.0+4e+4*dela_vsat_pmos5_10hv_bsim4)
+ lvsat    = (2400.0)
+ wvsat    = (0.0)
+ pvsat    = (10080.0)
+ lambda   = (0.0)
+ llambda  = (0.0)
+ wlambda  = (0.0)
+ plambda  = (0.0)
+ vtl      = (200000.0)
+ lvtl     = (0.0)
+ wvtl     = (0.0)
+ pvtl     = (0.0)
+ lc       = (5e-09)
+ xn       = (3.0)
+ lxn      = (0.0)
+ wxn      = (0.0)
+ pxn      = (0.0)
+ easub    = (4.05)
+ ucs      = (1.0)
+ lucs     = (0.0)
+ wucs     = (0.0)
+ pucs     = (0.0)
+ ucste    = (-0.004775)
+ lucste   = (0.0)
+ wucste   = (0.0)
+ pucste   = (0.0)
+ voff     = (-0.142)
+ lvoff    = (0.0)
+ wvoff    = (-0.005)
+ pvoff    = (0.0)
+ tvoff    = (0.004)
+ ltvoff   = (0.0)
+ wtvoff   = (0.0)
+ ptvoff   = (0.0)
+ voffl    = (2e-08)
+ minv     = (0.0)
+ lminv    = (0.0)
+ wminv    = (0.0)
+ pminv    = (0.0)
+ nfactor  = (1.0)
+ lnfactor = (0.0)
+ wnfactor = (0.0)
+ pnfactor = (0.0)
+ eta0     = (0.1138)
+ leta0    = (0.0)
+ weta0    = (0.0)
+ peta0    = (0.0)
+ etab     = (-1.1)
+ letab    = (0.0)
+ wetab    = (0.0)
+ petab    = (0.0)
+ dsub     = (1.431)
+ ldsub    = (0.0)
+ wdsub    = (0.0)
+ pdsub    = (0.0)
+ cit      = (0.0)
+ lcit     = (0.0002)
+ wcit     = (0.0)
+ pcit     = (0.0)
+ cdsc     = (0.0)
+ lcdsc    = (0.0)
+ wcdsc    = (0.0)
+ pcdsc    = (0.0)
+ cdscb    = (0.0)
+ lcdscb   = (0.0)
+ wcdscb   = (0.0)
+ pcdscb   = (0.0)
+ cdscd    = (0.0)
+ lcdscd   = (0.0)
+ wcdscd   = (0.0)
+ pcdscd   = (0.0)
+ pclm     = (0.6946)
+ lpclm    = (0.0)
+ wpclm    = (0.0)
+ ppclm    = (0.0)
+ pdiblc1  = (0.39)
+ lpdiblc1 = (0.0)
+ wpdiblc1 = (0.0)
+ ppdiblc1 = (0.0)
+ pdiblc2  = (0.0002346)
+ lpdiblc2 = (0.0)
+ wpdiblc2 = (0.0)
+ ppdiblc2 = (0.0)
+ pdiblcb  = (0.0578)
+ lpdiblcb = (0.0)
+ wpdiblcb = (0.0)
+ ppdiblcb = (0.0)
+ drout    = (6.225)
+ ldrout   = (0.0)
+ wdrout   = (0.0)
+ pdrout   = (0.0)
+ pscbe1   = (424000000.0)
+ lpscbe1  = (0.0)
+ wpscbe1  = (0.0)
+ ppscbe1  = (0.0)
+ pscbe2   = (1e-12)
+ lpscbe2  = (0.0)
+ wpscbe2  = (0.0)
+ ppscbe2  = (0.0)
+ fprout   = (0.0)
+ lfprout  = (0.0)
+ wfprout  = (0.0)
+ pfprout  = (0.0)
+ pvag     = (4.301)
+ lpvag    = (0.0)
+ wpvag    = (0.0)
+ ppvag    = (0.0)
+ delta    = (0.001)
+ ldelta   = (0.0)
+ wdelta   = (0.0)
+ pdelta   = (0.0)
+ pdits    = (0.0)
+ lpdits   = (0.0)
+ wpdits   = (0.0)
+ ppdits   = (0.0)
+ pditsl   = (0.0)
+ pditsd   = (0.0)
+ lpditsd  = (0.0)
+ wpditsd  = (0.0)
+ ppditsd  = (0.0)
+ rdsw     = (861.7*(delr_rsh_pmos5_10hv_bsim4)*delr_rdsw_relimo)
+ lrdsw    = (0.0)
+ wrdsw    = (0.0)
+ prdsw    = (175.0)
+ rdswmin  = (0.0)
+ rdw      = (100.0)
+ lrdw     = (0.0)
+ wrdw     = (0.0)
+ prdw     = (0.0)
+ rdwmin   = (0.0)
+ rsw      = (100.0)
+ lrsw     = (0.0)
+ wrsw     = (0.0)
+ prsw     = (0.0)
+ rswmin   = (0.0)
+ prwg     = (0.0213)
+ lprwg    = (0.0)
+ wprwg    = (0.0)
+ pprwg    = (0.0)
+ prwb     = (-0.4207)
+ lprwb    = (0.0)
+ wprwb    = (0.0)
+ pprwb    = (0.2037)
+ wr       = (1.0)
+ lwr      = (0.0)
+ wwr      = (0.0)
+ pwr      = (0.0)
+ alpha0   = (1.88e-06)
+ lalpha0  = (0.0)
+ walpha0  = (0.0)
+ palpha0  = (0.0)
+ alpha1   = (33.8*(1-1.3e-3*(temp-27)))
+ lalpha1  = (0.0)
+ walpha1  = (0.0)
+ palpha1  = (0.0)
+ beta0    = (41.59)
+ lbeta0   = (0.0)
+ wbeta0   = (0.0)
+ pbeta0   = (0.0)
+ agidl    = (2.362e-08*delr_agidl_pmos5_10hv_bsim4)
+ lagidl   = (0.0)
+ wagidl   = (-6e-09*delr_agidl_pmos5_10hv_bsim4)
+ pagidl   = (0.0)
+ bgidl    = (3379000000.0)
+ lbgidl   = (0.0)
+ wbgidl   = (0.0)
+ pbgidl   = (0.0)
+ cgidl    = (62.12)
+ lcgidl   = (0.0)
+ wcgidl   = (0.0)
+ pcgidl   = (0.0)
+ egidl    = (-4.044*(1+4.75e-3*(temp-27)))
+ legidl   = (0.0)
+ wegidl   = (0.0)
+ pegidl   = (0.0)
+ aigbacc  = (0.43)
+ laigbacc = (0.0)
+ waigbacc = (0.0)
+ paigbacc = (0.0)
+ bigbacc  = (0.054)
+ lbigbacc = (0.0)
+ wbigbacc = (0.0)
+ pbigbacc = (0.0)
+ cigbacc  = (0.075)
+ lcigbacc = (0.0)
+ wcigbacc = (0.0)
+ pcigbacc = (0.0)
+ nigbacc  = (1.0)
+ lnigbacc = (0.0)
+ wnigbacc = (0.0)
+ pnigbacc = (0.0)
+ aigbinv  = (0.35)
+ laigbinv = (0.0)
+ waigbinv = (0.0)
+ paigbinv = (0.0)
+ bigbinv  = (0.03)
+ lbigbinv = (0.0)
+ wbigbinv = (0.0)
+ pbigbinv = (0.0)
+ cigbinv  = (0.006)
+ lcigbinv = (0.0)
+ wcigbinv = (0.0)
+ pcigbinv = (0.0)
+ eigbinv  = (1.1)
+ leigbinv = (0.0)
+ weigbinv = (0.0)
+ peigbinv = (0.0)
+ nigbinv  = (3.0)
+ lnigbinv = (0.0)
+ wnigbinv = (0.0)
+ pnigbinv = (0.0)
+ aigc     = (0.31)
+ laigc    = (0.0)
+ waigc    = (0.0)
+ paigc    = (0.0)
+ bigc     = (0.024)
+ lbigc    = (0.0)
+ wbigc    = (0.0)
+ pbigc    = (0.0)
+ cigc     = (0.03)
+ lcigc    = (0.0)
+ wcigc    = (0.0)
+ pcigc    = (0.0)
+ aigsd    = (0.31)
+ laigsd   = (0.0)
+ waigsd   = (0.0)
+ paigsd   = (0.0)
+ bigsd    = (0.024)
+ lbigsd   = (0.0)
+ wbigsd   = (0.0)
+ pbigsd   = (0.0)
+ cigsd    = (0.03)
+ lcigsd   = (0.0)
+ wcigsd   = (0.0)
+ pcigsd   = (0.0)
+ dlcig    = (0.0)
+ nigc     = (1.0)
+ lnigc    = (0.0)
+ wnigc    = (0.0)
+ pnigc    = (0.0)
+ poxedge  = (1.0)
+ lpoxedge = (0.0)
+ wpoxedge = (0.0)
+ ppoxedge = (0.0)
+ pigcd    = (1.0)
+ lpigcd   = (0.0)
+ wpigcd   = (0.0)
+ ppigcd   = (0.0)
+ ntox     = (1.0)
+ lntox    = (0.0)
+ wntox    = (0.0)
+ pntox    = (0.0)
+ toxref   = (1.3e-08)
+ vfbsdoff = (0.0)
+ lvfbsdoff = (0.0)
+ wvfbsdoff = (0.0)
+ pvfbsdoff = (0.0)
+ tvfbsdoff = (0.0)
+ ltvfbsdoff = (0.0)
+ wtvfbsdoff = (0.0)
+ ptvfbsdoff = (0.0)
+ cgso     = (6.6e-11/delr_tox_pmos5_10hv_bsim4+(0.5*cfr_pmos5_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos5_s_ply_met*1e6-0.5*cfr_pmos5_s_ply_met*1e6))
+ cgdo     = (1.44e-11/delr_tox_pmos5_10hv_bsim4+(0.5*cfr_pmos5_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos5_s_ply_met*1e6-0.5*cfr_pmos5_s_ply_met*1e6))
+ cgbo     = (0.0)
+ cgsl     = (2.222e-11)
+ cgdl     = (2.101e-10)
+ ckappas  = (1.481)
+ lckappas = (0.0)
+ wckappas = (0.0)
+ pckappas = (0.0)
+ xpart    = (0.0+1*(xpart_bsim_flag==1))
+ clc      = (1e-07)
+ lclc     = (0.0)
+ wclc     = (0.0)
+ pclc     = (0.0)
+ cle      = (0.6)
+ lcle     = (0.0)
+ wcle     = (0.0)
+ pcle     = (0.0)
+ dlc      = (6.475e-08)
+ dwc      = (-5.8e-08)
+ vfbcv    = (-1.0)
+ lvfbcv   = (0.0)
+ wvfbcv   = (0.0)
+ pvfbcv   = (0.0)
+ noff     = (1.0)
+ lnoff    = (0.0)
+ wnoff    = (0.0)
+ pnoff    = (0.0)
+ voffcv   = (-0.086)
+ lvoffcv  = (0.0)
+ wvoffcv  = (0.0)
+ pvoffcv  = (0.0)
+ minvcv   = (0.0)
+ lminvcv  = (0.0)
+ wminvcv  = (0.0)
+ pminvcv  = (0.0)
+ voffcvl  = (0.0)
+ acde     = (0.7379)
+ lacde    = (0.0)
+ wacde    = (0.0)
+ pacde    = (0.0)
+ moin     = (5.0)
+ lmoin    = (0.0)
+ wmoin    = (0.0)
+ pmoin    = (0.0)
+ llc      = (0.0)
+ wlc      = (0.0)
+ lwc      = (-2.35e-14)
+ lwlc     = (0.0)
+ wwc      = (0.0)
+ wwlc     = (0.0)
+ dmcg     = (0.0)
+ dmci     = (0.0)
+ dmdg     = (0.0)
+ dmcgt    = (0.0)
+ dwj      = (0.0)
+ xgw      = (0.0)
+ xgl      = (0.0)
+ xl       = (0.0)
+ xw       = (0.0)
+ ngcon    = (1.0)
+ ijthsrev = (0.1)
+ ijthsfwd = (0.0005)
+ xjbvs    = (1.0)
+ bvs      = (10.0)
+ jss      = (1.0e12*ajs_junc_pmos5_sd_body)
+ jsws     = (1.0e6*pjs_junc_pmos5_sd_body)
+ jswgs    = (1.0e6*chjs_junc_pmos5_sd_body)
+ jtss     = (8e-06)
+ jtssws   = (4.8e-12)
+ jtsswgs  = (4.8e-12)
+ njts     = (35.0)
+ njtssw   = (55.0)
+ njtsswg  = (55.0)
+ xtss     = (0.778)
+ xtssws   = (0.56)
+ xtsswgs  = (0.56)
+ vtss     = (20.0)
+ vtssws   = (20.0)
+ vtsswgs  = (20.0)
+ tnjts    = (2.0)
+ tnjtssw  = (2.5)
+ tnjtsswg = (2.5)
+ jtweff   = (3.5e-05)
+ cjs      = (1.0e12*acj0_junc_pmos5_sd_body)
+ mjs      = (aexm_junc_pmos5_sd_body)
+ pbs      = (aphi_junc_pmos5_sd_body)
+ fc       = (0.5)
+ cjsws    = (1.0e6*pcj0_junc_pmos5_sd_body)
+ mjsws    = (pexm_junc_pmos5_sd_body)
+ pbsws    = (pphi_junc_pmos5_sd_body)
+ cjswgs   = (1.0e6*chcj0_junc_pmos5_sd_body)
+ mjswgs   = (chexm_junc_pmos5_sd_body)
+ pbswgs   = (chphi_junc_pmos5_sd_body)
+ fcsw     = (0.5)
+ tnom     = (27.0)
+ trise    = (0.0)
+ ute      = (-1.322)
+ lute     = (0.0)
+ wute     = (0.05531)
+ pute     = (0.0)
+ kt1      = (-0.3237)
+ lkt1     = (0.0)
+ wkt1     = (0.0)
+ pkt1     = (0.0)
+ kt1l     = (6.374e-09)
+ lkt1l    = (0.0)
+ wkt1l    = (0.0)
+ pkt1l    = (0.0)
+ kt2      = (-0.05642)
+ lkt2     = (0.0)
+ wkt2     = (0.0)
+ pkt2     = (0.0)
+ ua1      = (1e-13)
+ lua1     = (0.0)
+ wua1     = (0.0)
+ pua1     = (0.0)
+ ub1      = (-2.396e-18)
+ lub1     = (0.0)
+ wub1     = (0.0)
+ pub1     = (0.0)
+ uc1      = (-0.02212)
+ luc1     = (1e-15)
+ wuc1     = (0.0)
+ puc1     = (0.0)
+ ud1      = (0.0)
+ lud1     = (0.0)
+ wud1     = (0.0)
+ pud1     = (0.0)
+ at       = (13960.0)
+ lat      = (0.0)
+ wat      = (0.0)
+ pat      = (0.0)
+ prt      = (1076.0)
+ lprt     = (0.0)
+ wprt     = (-337.8)
+ pprt     = (0.0)
+ njs      = (ajnd_junc_pmos5_sd_body)
+ xtis     = (0.0001409)
+ tpb      = (0.001863)
+ tpbsw    = (0.002048)
+ tpbswg   = (0.001847)
+ tcj      = (0.001136)
+ tcjsw    = (0.002101)
+ tcjswg   = (0.001283)
+ saref    = (3.75e-07)
+ sbref    = (3.75e-07)
+ wlod     = (0.0)
+ ku0      = (0.0)
+ lku0     = (0.0)
+ wku0     = (0.0)
+ pku0     = (0.0)
+ kvsat    = (0.0)
+ tku0     = (0.0)
+ llodku0  = (0.0)
+ wlodku0  = (0.0)
+ kvth0    = (0.0)
+ lkvth0   = (0.0)
+ wkvth0   = (0.0)
+ pkvth0   = (0.0)
+ llodvth  = (0.0)
+ wlodvth  = (0.0)
+ stk2     = (0.0)
+ lodk2    = (1.0)
+ steta0   = (0.0)
+ lodeta0  = (1.0)
+ web      = (0.0)
+ wec      = (0.0)
+ kvth0we  = (-3e-2)
+ lkvth0we = (0.0)
+ wkvth0we = (0.0)
+ pkvth0we = (0.0)
+ k2we     = (0.0)
+ lk2we    = (0.0)
+ wk2we    = (0.0)
+ pk2we    = (0.0)
+ ku0we    = (-5e-5)
+ lku0we   = (0.0)
+ wku0we   = (0.0)
+ pku0we   = (0.0)
+ scref    = (1e-06)
+ af       = (1.0)
+ kf       = (0.0)
+ lintnoi  = (0.0)
+ ntnoi    = (1.0)
+ tnoia    = (1.5)
+ tnoib    = (3.5)
+ rnoia    = (0.577)
+ rnoib    = (0.5164)
+ rdc      = (0.0)
+ rsc      = (0.0)
+ noia     = (noia_pmos5_10hv_bsim4)
+ noib     = (noib_pmos5_10hv_bsim4)
+ noic     = (noic_pmos5_10hv_bsim4)
+ ef       = (ef_pmos5_10hv_bsim4)
+ em       = (em_pmos5_10hv_bsim4)

mpmos5_10hv_i (d g s b) pmos5_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ngtotal sca=sca_f scb=scb_f scc=scc_f
xcdgoptub_sub (b sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmos5_10hv_dfrt
ends

subckt nmos45_10hv (d g s b sub)

parameters
+    l                              = 0.65
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_gox_nmos45_10hv_bsim3v3 = tmp_nsmm_delr_gox_nmos45_10hv_bsim3v3
+    nsmm_dela_vfb_nmos45_10hv_bsim3v3 = tmp_nsmm_dela_vfb_nmos45_10hv_bsim3v3
+    nsmm_delr_nsub_nmos45_10hv_bsim3v3 = tmp_nsmm_delr_nsub_nmos45_10hv_bsim3v3
+    nsmm_dela_vtl_nmos45_10hv_bsim3v3 = tmp_nsmm_dela_vtl_nmos45_10hv_bsim3v3
+    nsmm_dela_dl_nmos45_10hv_bsim3v3 = tmp_nsmm_dela_dl_nmos45_10hv_bsim3v3
+    nsmm_dela_dwox_nmos45_10hv_bsim3v3 = tmp_nsmm_dela_dwox_nmos45_10hv_bsim3v3
+    nsmm_delr_ubref_nmos45_10hv_bsim3v3 = tmp_nsmm_delr_ubref_nmos45_10hv_bsim3v3
+    nsmm_delr_rsh_nmos45_10hv_bsim3v3 = tmp_nsmm_delr_rsh_nmos45_10hv_bsim3v3
+    nsmm_dela_vtw_nmos45_10hv_bsim3v3 = tmp_nsmm_dela_vtw_nmos45_10hv_bsim3v3
+    ngtotal                        = (ng+(mod(ng,2)))
+    nga                            = (2)
+    ng_residue                     = (mod(ngtotal,nga))
+    number_of_nga                  = ((ngtotal-ng_residue)/nga)
+    nde_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(mod(ng_residue,2)))
+    nse_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(2-nde_residue))
+    nd_residue                     = ((((ng_residue<0)|(ng_residue>0)))*((ng_residue+nde_residue)/2))
+    ns_residue                     = ((((ng_residue<0)|(ng_residue>0)))*(1-nde_residue+nd_residue))
+    ndi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(nd_residue-nde_residue))
+    nsi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(ns_residue-nse_residue))
+    nde_nga                        = (mod(nga,2))
+    nse_nga                        = (2-nde_nga)
+    nd_nga                         = ((nga+nde_nga)/2)
+    ns_nga                         = (1-nde_nga+nd_nga)
+    ndi_nga                        = (nd_nga-nde_nga)
+    nsi_nga                        = (ns_nga-nse_nga)
+    nde_allnga                     = (number_of_nga*nde_nga)
+    nse_allnga                     = (number_of_nga*nse_nga)
+    nd_allnga                      = (number_of_nga*nd_nga)
+    ns_allnga                      = (number_of_nga*ns_nga)
+    ndi_allnga                     = (number_of_nga*ndi_nga)
+    nsi_allnga                     = (number_of_nga*nsi_nga)
+    nde                            = (nde_residue+nde_allnga)
+    nse                            = (nse_residue+nse_allnga)
+    nd                             = (nd_residue+nd_allnga)
+    ns                             = (ns_residue+ns_allnga)
+    ndi                            = (ndi_residue+ndi_allnga)
+    nsi                            = (nsi_residue+nsi_allnga)
+    nde_outside                    = ((ng_residue==0)*nde_nga+(((ng_residue<0)|(ng_residue>0)))*nde_residue)
+    default_as                     = ((lg2aa_s_nmos45_10hv*(wg2aa_se_nmos45_10hv+w)*nse+lg2g_s_nmos45_10hv*(wg2aa_si_nmos45_10hv+w)*nsi)/ngtotal)
+    default_ps                     = ((2*((lg2aa_s_nmos45_10hv+wg2aa_se_nmos45_10hv+w)*nse+(lg2g_s_nmos45_10hv+wg2aa_si_nmos45_10hv+w)*nsi))/ngtotal)
+    default_ad                     = ((lg2aa_d_nmos45_10hv*(wg2aa_de_nmos45_10hv+w)*nde+lg2g_d_nmos45_10hv*(wg2aa_di_nmos45_10hv+w)*ndi)/ngtotal)
+    default_pd                     = ((2*((lg2aa_d_nmos45_10hv+wg2aa_de_nmos45_10hv+w)*nde+(lg2g_d_nmos45_10hv+wg2aa_di_nmos45_10hv+w)*ndi))/ngtotal)
+    as_i                           = ((acj0_junc_nmos45_s_body/acj0_junc_nmos45_d_body)*default_as)
+    ps_i                           = ((pcj0_junc_nmos45_s_body/pcj0_junc_nmos45_d_body)*default_ps)
+    ad_i                           = ((lg2aa_d_nmos45_10hv*(wg2aa_de_nmos45_10hv+w)*nde+lg2g_d_nmos45_10hv*(wg2aa_di_nmos45_10hv+w)*ndi)/ngtotal)
+    pd_i                           = ((2*((lg2aa_d_nmos45_10hv+wg2aa_de_nmos45_10hv+w)*nde+(lg2g_d_nmos45_10hv+wg2aa_di_nmos45_10hv+w)*ndi))/ngtotal)
+    nrs_i                          = (lg2ct_s_nmos45_10hv/w)
+    nrd_i                          = (lg2ct_d_nmos45_10hv/w)
+    length1                        = (trench2se_body_nmos45_10hv*(1+(ng_residue==0)*(nse_nga-1))+trench2se_nobody_nmos45_10hv*((((ng_residue<0)|(ng_residue>0)))*(nse_residue-1))+trench2de_nmos45_10hv*nde_outside)
+    length2                        = (l*ngtotal+lg2aa_s_nmos45_10hv*nse+lg2g_s_nmos45_10hv*nsi+lg2aa_d_nmos45_10hv*nde+lg2g_d_nmos45_10hv*ndi+s2s_inside_nmos45_10hv*(number_of_nga-1+(((ng_residue<0)|(ng_residue>0)))))
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_nmos45_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
+    length_m2m1                    = (wbox2sub-6.27)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*(length_m2m1+width_m2m1))
+    csb_nmos45_10hv_m2m1           = ((number_of_nga+1)*(cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)+(cpp_m2_m1*2*0.33*0.725+cfr_m2_m1*2*0.725)*(number_of_nga-1))
+    csb_nmos45_10hv_m2m1_par       = ((1-lpe)*csb_nmos45_10hv_m2m1+lpe*1e-20)
+    cgs_nmos45_10hv_m2m1_par       = ((1-lpe)*((l+0.5*lg2g_d_nmos45_10hv)*ng*cfr_m2_m1)+lpe*1e-20)
+    d_perim_ch                     = ((nde*w+2*ndi*w)/ngtotal)
+    d_perim_nonch                  = ((pd_i<=0)*(default_pd-d_perim_ch)+(pd_i>0)*((pd_i>d_perim_ch)*(pd_i-d_perim_ch)+(pd_i<=d_perim_ch)*0))
+    totalperim_d                   = (d_perim_ch+d_perim_nonch)
+    jsw_junc_nmos45_d_body         = ((pjs_junc_nmos45_d_body*d_perim_nonch+chjs_junc_nmos45_d_body*d_perim_ch)/totalperim_d)
+    delr_tox_nmos45_10hv_bsim3v3   = (nom_delr_tox_nmos45_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_nmos45_10hv_bsim3v3+nsmm_delr_gox_nmos45_10hv_bsim3v3*smm_delr_gox_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_nmos45_10hv_bsim3v3  = (nom_dela_dwox_nmos45_10hv_bsim3v3+nsig_dela_dwox_nmos45_10hv_bsim3v3*sig_dela_dwox_nmos45_10hv_bsim3v3+nsmm_dela_dwox_nmos45_10hv_bsim3v3*smm_dela_dwox_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vfb_nmos45_10hv_bsim3v3   = (nom_dela_vfb_nmos45_10hv_bsim3v3+nsig_dela_vfb_nmos45_10hv_bsim3v3*sig_dela_vfb_nmos45_10hv_bsim3v3+nsmm_dela_vfb_nmos45_10hv_bsim3v3*smm_dela_vfb_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)+nsmm_dela_vtl_nmos45_10hv_bsim3v3*smm_dela_vtl_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_nmos45_10hv_bsim3v3*smm_dela_vtw_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)/w)
+    delr_ubref_nmos45_10hv_bsim3v3 = (nom_delr_ubref_nmos45_10hv_bsim3v3*(1.0+nsig_delr_ubref_nmos45_10hv_bsim3v3*sig_delr_ubref_nmos45_10hv_bsim3v3+nsmm_delr_ubref_nmos45_10hv_bsim3v3*smm_delr_ubref_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dl_nmos45_10hv_bsim3v3    = (nom_dela_dl_nmos45_10hv_bsim3v3+nsig_dela_dl_nmos45_10hv_bsim3v3*sig_dela_dl_nmos45_10hv_bsim3v3+nsmm_dela_dl_nmos45_10hv_bsim3v3*smm_dela_dl_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_nmos45_10hv_bsim3v3   = (nom_dela_vtl_nmos45_10hv_bsim3v3+nsig_dela_vtl_nmos45_10hv_bsim3v3*sig_dela_vtl_nmos45_10hv_bsim3v3)
+    dela_vtw_nmos45_10hv_bsim3v3   = (nom_dela_vtw_nmos45_10hv_bsim3v3+nsig_dela_vtw_nmos45_10hv_bsim3v3*sig_dela_vtw_nmos45_10hv_bsim3v3)
+    dela_vtm_nmos45_10hv_bsim3v3   = (nom_dela_vtm_nmos45_10hv_bsim3v3+nsig_dela_vtm_nmos45_10hv_bsim3v3*sig_dela_vtm_nmos45_10hv_bsim3v3)
+    dela_a0_nmos45_10hv_bsim3v3    = (nom_dela_a0_nmos45_10hv_bsim3v3+nsig_dela_a0_nmos45_10hv_bsim3v3*sig_dela_a0_nmos45_10hv_bsim3v3)
+    dela_la0_nmos45_10hv_bsim3v3   = (nom_dela_la0_nmos45_10hv_bsim3v3+nsig_dela_la0_nmos45_10hv_bsim3v3*sig_dela_la0_nmos45_10hv_bsim3v3)
+    dela_b0_nmos45_10hv_bsim3v3    = (nom_dela_b0_nmos45_10hv_bsim3v3+nsig_dela_b0_nmos45_10hv_bsim3v3*sig_dela_b0_nmos45_10hv_bsim3v3)
+    delr_vsat_nmos45_10hv_bsim3v3  = (nom_delr_vsat_nmos45_10hv_bsim3v3*(1.0+nsig_delr_vsat_nmos45_10hv_bsim3v3*sig_delr_vsat_nmos45_10hv_bsim3v3))
+    dela_pa0_nmos45_10hv_bsim3v3   = (nom_dela_pa0_nmos45_10hv_bsim3v3+nsig_dela_pa0_nmos45_10hv_bsim3v3*sig_dela_pa0_nmos45_10hv_bsim3v3)
+    delr_rsh_nmos45_10hv_bsim3v3   = (1+nsmm_delr_rsh_nmos45_10hv_bsim3v3*smm_delr_rsh_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_nsub_nmos45_10hv_bsim3v3  = (1+nsmm_delr_nsub_nmos45_10hv_bsim3v3*smm_delr_nsub_nmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.32e-08*delr_tox_nmos45_10hv_bsim3v3)
+    cox                            = (epsox/tox)

model nmos45_10hv bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_nmos45_d_body)
+ pb       = (aphi_junc_nmos45_d_body)
+ mj       = (aexm_junc_nmos45_d_body)
+ js       = (1.0e12*ajs_junc_nmos45_d_body)
+ nj       = ((ajnd_junc_nmos45_d_body+pjnd_junc_nmos45_d_body+chjnd_junc_nmos45_d_body)/((((ajnd_junc_nmos45_d_body<0)|(ajnd_junc_nmos45_d_body>0)))+(((pjnd_junc_nmos45_d_body<0)|(pjnd_junc_nmos45_d_body>0)))+(((chjnd_junc_nmos45_d_body<0)|(chjnd_junc_nmos45_d_body>0)))))
+ cjsw     = (1.0e6*pcj0_junc_nmos45_d_body)
+ pbsw     = (pphi_junc_nmos45_d_body)
+ mjsw     = (pexm_junc_nmos45_d_body)
+ jsw      = (1.0e6*jsw_junc_nmos45_d_body)
+ cjswg    = (1.0e6*chcj0_junc_nmos45_d_body)
+ pbswg    = (chphi_junc_nmos45_d_body)
+ mjswg    = (chexm_junc_nmos45_d_body)
+ capmod   = (3)
+ cf       = (0)
+ cgbo     = (8.80056e-10)
+ cgso     = (8.0e-08*cox+0.5*cfr_nmos45_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos45_s_ply_met*1e6-0.5*cfr_nmos45_s_ply_met*1e6-lpe*cfr_m2_ply*1e6)
+ cgsl     = (1.25e-10)
+ cgdo     = (1.1e-8*cox+0.5*cfr_nmos45_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos45_d_ply_met*1e6-0.5*cfr_nmos45_d_ply_met*1e6)
+ cgdl     = (2.8e-09)
+ ckappa   = (0.4)
+ dlc      = (-9.25441e-07)
+ llc      = (8.82822e-14)
+ lwc      = (-1.39686e-12)
+ lwlc     = (0)
+ dwc      = (-3.26499e-08)
+ wwc      = (0)
+ wlc      = (0)
+ wwlc     = (0)
+ voffcv   = (-0.0503643)
+ noff     = (2.94121)
+ acde     = (0.410823)
+ moin     = (5)
+ mobmod   = (1)
+ rsh      = (10.4)
+ tox      = (1.316e-08*delr_tox_nmos45_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-1.59166e-07-0.5e-06*dela_dl_nmos45_10hv_bsim3v3)
+ wint     = (1.224e-07-0.5e-06*dela_dwox_nmos45_10hv_bsim3v3)
+ ww       = (-6.03e-14)
+ u0       = (482.2008*delr_ubref_nmos45_10hv_bsim3v3)
+ rdsw     = (1250.81*delr_rsh_nmos45_10hv_bsim3v3)
+ nsub     = (1.2189e+17*delr_nsub_nmos45_10hv_bsim3v3)
+ nch      = (1.740e+17*delr_nsub_nmos45_10hv_bsim3v3)
+ vfb      = (-1.14170187+dela_vfb_nmos45_10hv_bsim3v3)
+ vbm      = (-5.5)
+ xt       = (1.47887017723381e-07)
+ alpha1   = (0.0065)
+ alpha0   = (0)
+ beta0    = (80)
+ a0       = (0.919+dela_a0_nmos45_10hv_bsim3v3)
+ la0      = (0+dela_la0_nmos45_10hv_bsim3v3)
+ ags      = (0.125)
+ keta     = (0.00158)
+ ua       = (1.23e-10)
+ ub       = (1.7216e-18)
+ uc       = (3.5e-11)
+ eta0     = (0)
+ etab     = (0)
+ drout    = (1.9295)
+ nlx      = (4.00879e-07+1e-06*dela_vtl_nmos45_10hv_bsim3v3)
+ dvt0     = (1.8)
+ dvt1     = (0.289283)
+ dvt2     = (0.032)
+ dvt0w    = (0.165+dela_vtm_nmos45_10hv_bsim3v3)
+ dvt1w    = (6.8e+04)
+ dvt2w    = (0.32)
+ k3       = (4.2521+80*dela_vtw_nmos45_10hv_bsim3v3)
+ k3b      = (1.21866)
+ w0       = (2.05182e-06)
+ dwg      = (-0.25827e-08)
+ dwb      = (-1.04582e-08)
+ b0       = (1.07341e-07+1e-06*dela_b0_nmos45_10hv_bsim3v3)
+ b1       = (6.09313e-06)
+ prwg     = (-0.15)
+ prwb     = (0.625)
+ pclm     = (1.7598)
+ pdiblc1  = (0.039)
+ pdiblc2  = (0.000168102)
+ pdiblcb  = (0.0741371)
+ delta    = (0.00157563)
+ vsat     = (1.45e+05*delr_vsat_nmos45_10hv_bsim3v3)
+ ll       = (0.37622e-13)
+ voff     = (-0.15)
+ wwl      = (-5.03e-20)
+ ute      = (-1.30)
+ kt1      = (-0.34)
+ kt2      = (-0.0085)
+ ua1      = (3.28e-09)
+ ub1      = (-4.61e-18)
+ uc1      = (-0.5e-11)
+ kt1l     = (-3.0e-08)
+ prt      = (5500)
+ at       = (0)
+ pa0      = (0+dela_pa0_nmos45_10hv_bsim3v3)
+ noimod   = (noimod_nmos45_10hv_bsim3v3)
+ noia     = (noia_nmos45_10hv_bsim3v3)
+ noib     = (noib_nmos45_10hv_bsim3v3)
+ noic     = (noic_nmos45_10hv_bsim3v3)
+ ef       = (ef_nmos45_10hv_bsim3v3)
+ em       = (em_nmos45_10hv_bsim3v3)

model rdint resistor
+ tnom  = (27)
+ rsh   = (2905.882)
+ tc1   = (4.50e-03)
+ tc2   = (1.25e-05)

mnmos45_10hv_i (d_i g s b) nmos45_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=(ngtotal)
ccsb_nmos45_10hv_m2m1_par (s b) capacitor c=csb_nmos45_10hv_m2m1_par
ccgs_nmos45_10hv_m2m1_par (g s) capacitor c=cgs_nmos45_10hv_m2m1_par
rrdint (d_i d) rdint w=(w+1) l=(3.4) m=(ngtotal)
xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=1

include "./smos10hv_ade_dfrt.scs" section=nmos45_10hv_dfrt
ends

subckt pmos45_10hv (d g s b sub)

parameters
+    l                              = 1.0
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    ring                           = 1
+    soa                            = 1
+    nsmm_delr_gox_pmos45_10hv_bsim3v3 = tmp_nsmm_delr_gox_pmos45_10hv_bsim3v3
+    nsmm_dela_vfb_pmos45_10hv_bsim3v3 = tmp_nsmm_dela_vfb_pmos45_10hv_bsim3v3
+    nsmm_delr_nsub_pmos45_10hv_bsim3v3 = tmp_nsmm_delr_nsub_pmos45_10hv_bsim3v3
+    nsmm_dela_vtl_pmos45_10hv_bsim3v3 = tmp_nsmm_dela_vtl_pmos45_10hv_bsim3v3
+    nsmm_dela_dl_pmos45_10hv_bsim3v3 = tmp_nsmm_dela_dl_pmos45_10hv_bsim3v3
+    nsmm_dela_dwox_pmos45_10hv_bsim3v3 = tmp_nsmm_dela_dwox_pmos45_10hv_bsim3v3
+    nsmm_delr_ubref_pmos45_10hv_bsim3v3 = tmp_nsmm_delr_ubref_pmos45_10hv_bsim3v3
+    nsmm_delr_rsh_pmos45_10hv_bsim3v3 = tmp_nsmm_delr_rsh_pmos45_10hv_bsim3v3
+    nsmm_dela_vtw_pmos45_10hv_bsim3v3 = tmp_nsmm_dela_vtw_pmos45_10hv_bsim3v3
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos45_vthratio         = 1.0
+    presto_pmos45_betaratio        = 1.0
+    ngtotal                        = (ng)
+    nga                            = (6)
+    ng_residue                     = (mod(ng,nga))
+    number_of_nga                  = ((ng-ng_residue)/nga)
+    nde_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(mod(ng_residue,2)))
+    nse_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(2-nde_residue))
+    nd_residue                     = ((((ng_residue<0)|(ng_residue>0)))*((ng_residue+nde_residue)/2))
+    ns_residue                     = ((((ng_residue<0)|(ng_residue>0)))*(1-nde_residue+nd_residue))
+    ndi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(nd_residue-nde_residue))
+    nsi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(ns_residue-nse_residue))
+    nde_nga                        = (mod(nga,2))
+    nse_nga                        = (2-nde_nga)
+    nd_nga                         = ((nga+nde_nga)/2)
+    ns_nga                         = (1-nde_nga+nd_nga)
+    ndi_nga                        = (nd_nga-nde_nga)
+    nsi_nga                        = (ns_nga-nse_nga)
+    nde_allnga                     = (number_of_nga*nde_nga)
+    nse_allnga                     = (number_of_nga*nse_nga)
+    nd_allnga                      = (number_of_nga*nd_nga)
+    ns_allnga                      = (number_of_nga*ns_nga)
+    ndi_allnga                     = (number_of_nga*ndi_nga)
+    nsi_allnga                     = (number_of_nga*nsi_nga)
+    nde                            = (nde_residue+nde_allnga)
+    nse                            = (nse_residue+nse_allnga)
+    nd                             = (nd_residue+nd_allnga)
+    ns                             = (ns_residue+ns_allnga)
+    ndi                            = (ndi_residue+ndi_allnga)
+    nsi                            = (nsi_residue+nsi_allnga)
+    as_i                           = ((acj0_junc_pmos45_s_body/acj0_junc_pmos45_d_body)*((lg2aa_s_pmos45_10hv*nse+lg2g_s_pmos45_10hv*nsi)*w/ng))
+    ps_i                           = ((pcj0_junc_pmos45_s_body/pcj0_junc_pmos45_d_body)*((2*(lg2aa_s_pmos45_10hv*nse+lg2g_s_pmos45_10hv*nsi)+2*ns*w)/ng))
+    ad_i                           = ((0*nde+lg2g_d_pmos45_10hv*ndi)*(w+2*wg2hvpw_pmos45_10hv)/ng)
+    pd_i                           = ((2*(0*nde+lg2g_d_pmos45_10hv*ndi)+2*nd*(w+2*wg2hvpw_pmos45_10hv))/ng)
+    nrs_i                          = (lg2ct_s_pmos45_10hv/w)
+    nrd_i                          = (lg2ct_d_pmos45_10hv/w)
+    liso                           = (1.8+(lg2aa_s_pmos45_10hv*nse+lg2g_s_pmos45_10hv*nsi)+l*ng+lg2g_d_pmos45_10hv*ndi+(number_of_nga-1+(((ng_residue<0)|(ng_residue>0))))*1.05+1.11)
+    wiso                           = (w+2*wg2hvpw_pmos45_10hv+2*1)
+    aiso                           = (wiso*liso)
+    piso                           = ((wiso+liso)*2)
+    delr_tox_pmos45_10hv_bsim3v3   = (nom_delr_tox_pmos45_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_pmos45_10hv_bsim3v3+nsmm_delr_gox_pmos45_10hv_bsim3v3*smm_delr_gox_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_pmos45_10hv_bsim3v3  = (nom_dela_dwox_pmos45_10hv_bsim3v3+nsig_dela_dwox_pmos45_10hv_bsim3v3*sig_dela_dwox_pmos45_10hv_bsim3v3+nsmm_dela_dwox_pmos45_10hv_bsim3v3*smm_dela_dwox_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_ubref_pmos45_10hv_bsim3v3 = (nom_delr_ubref_pmos45_10hv_bsim3v3*(1.0+nsig_delr_ubref_pmos45_10hv_bsim3v3*sig_delr_ubref_pmos45_10hv_bsim3v3+nsmm_delr_ubref_pmos45_10hv_bsim3v3*smm_delr_ubref_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_vfb_pmos45_10hv_bsim3v3   = (nom_dela_vfb_pmos45_10hv_bsim3v3+nsig_dela_vfb_pmos45_10hv_bsim3v3*sig_dela_vfb_pmos45_10hv_bsim3v3+nsmm_dela_vfb_pmos45_10hv_bsim3v3*smm_dela_vfb_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)+nsmm_dela_vtl_pmos45_10hv_bsim3v3*smm_dela_vtl_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_pmos45_10hv_bsim3v3*smm_dela_vtw_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng)/w)
+    dela_dl_pmos45_10hv_bsim3v3    = (nom_dela_dl_pmos45_10hv_bsim3v3+nsig_dela_dl_pmos45_10hv_bsim3v3*sig_dela_dl_pmos45_10hv_bsim3v3+nsmm_dela_dl_pmos45_10hv_bsim3v3*smm_dela_dl_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_pmos45_10hv_bsim3v3   = (nom_dela_vtl_pmos45_10hv_bsim3v3+nsig_dela_vtl_pmos45_10hv_bsim3v3*sig_dela_vtl_pmos45_10hv_bsim3v3)
+    dela_vtw_pmos45_10hv_bsim3v3   = (nom_dela_vtw_pmos45_10hv_bsim3v3+nsig_dela_vtw_pmos45_10hv_bsim3v3*sig_dela_vtw_pmos45_10hv_bsim3v3)
+    dela_vtm_pmos45_10hv_bsim3v3   = (nom_dela_vtm_pmos45_10hv_bsim3v3+nsig_dela_vtm_pmos45_10hv_bsim3v3*sig_dela_vtm_pmos45_10hv_bsim3v3)
+    dela_a0_pmos45_10hv_bsim3v3    = (nom_dela_a0_pmos45_10hv_bsim3v3+nsig_dela_a0_pmos45_10hv_bsim3v3*sig_dela_a0_pmos45_10hv_bsim3v3)
+    dela_b0_pmos45_10hv_bsim3v3    = (nom_dela_b0_pmos45_10hv_bsim3v3+nsig_dela_b0_pmos45_10hv_bsim3v3*sig_dela_b0_pmos45_10hv_bsim3v3)
+    dela_wwl_pmos45_10hv_bsim3v3   = (nom_dela_wwl_pmos45_10hv_bsim3v3+nsig_dela_wwl_pmos45_10hv_bsim3v3*sig_dela_wwl_pmos45_10hv_bsim3v3)
+    delr_rsh_pmos45_10hv_bsim3v3   = (1+nsmm_delr_rsh_pmos45_10hv_bsim3v3*smm_delr_rsh_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_nsub_pmos45_10hv_bsim3v3  = (1+nsmm_delr_nsub_pmos45_10hv_bsim3v3*smm_delr_nsub_pmos45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_prsh_pmos45_10hv_bsim3v3  = (nom_delr_prsh_pmos45_10hv_bsim3v3*(1.0+nsig_delr_prsh_pmos45_10hv_bsim3v3*sig_delr_prsh_pmos45_10hv_bsim3v3))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.319e-08*delr_tox_pmos45_10hv_bsim3v3)
+    cox                            = (epsox/tox)
+    cgs_parasitic                  = ((1-lpe)*(ng*(l+0.5*lg2g_d_pmos45_10hv)*cfr_m2_m1)+1e-20)
+    csb_parasitic                  = ((1-lpe)*(w*cfr_m2_m1+(number_of_nga-1+(((ng_residue<0)|(ng_residue>0))))*2*w*cfr_m2_m1)+1e-20)

model pmos45_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_pmos45_d_body)
+ pb       = (aphi_junc_pmos45_d_body)
+ mj       = (aexm_junc_pmos45_d_body)
+ js       = (1.0e12*ajs_junc_pmos45_d_body)
+ nj       = (ajnd_junc_pmos45_d_body)
+ cjsw     = (1.0e6*pcj0_junc_pmos45_d_body)
+ pbsw     = (pphi_junc_pmos45_d_body)
+ mjsw     = (pexm_junc_pmos45_d_body)
+ jsw      = (1.0e6*pjs_junc_pmos45_d_body)
+ cjswg    = (1.0e6*chcj0_junc_pmos45_d_body)
+ pbswg    = (chphi_junc_pmos45_d_body)
+ mjswg    = (chexm_junc_pmos45_d_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (5.0e-08*cox+0.5*cfr_pmos45_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos45_s_ply_met*1e6-0.5*cfr_pmos45_s_ply_met*1e6-(lpe)*cfr_m2_ply*1e6)
+ cgdo     = (2.5e-08*cox+0.5*cfr_pmos45_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos45_d_ply_met*1e6-0.5*cfr_pmos45_d_ply_met*1e6)
+ cf       = (0)
+ dlc      = (-4.19515e-07)
+ dwc      = (-3.0505e-07)
+ acde     = (1.0)
+ moin     = (24)
+ noff     = (1.75)
+ cgsl     = (0.7e-10)
+ cgdl     = (8.5e-10)
+ ckappa   = (0.5)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = (0)
+ mobmod   = (1)
+ rsh      = (8.4)
+ tox      = (1.319e-08*delr_tox_pmos45_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-10.59515e-08-0.5e-06*dela_dl_pmos45_10hv_bsim3v3)
+ wint     = (9.505e-08-0.5e-06*dela_dwox_pmos45_10hv_bsim3v3)
+ ww       = (-7.39e-15)
+ u0       = ((149.719*delr_ubref_pmos45_10hv_bsim3v3)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pmos45_betaratio))
+ rdsw     = ((1919.96*delr_rsh_pmos45_10hv_bsim3v3)*delr_rdsw_relimo)
+ nsub     = (1.32227e+17*delr_nsub_pmos45_10hv_bsim3v3)
+ nch      = (1.479693e+17*delr_nsub_pmos45_10hv_bsim3v3)
+ vfb      = (-1.02860645+dela_vfb_pmos45_10hv_bsim3v3+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos45_vthratio)
+ vbm      = (-5.5)
+ xt       = (2.49021515976251e-07)
+ alpha1   = (1.5e-03)
+ alpha0   = (-1.2e-09)
+ beta0    = (88)
+ a0       = ((1.02237+dela_a0_pmos45_10hv_bsim3v3)*delr_a0_relimo)
+ ags      = (0.1173)
+ keta     = (-0.0026554)
+ ua       = (1.92164e-09)
+ ub       = (2.8014e-19)
+ uc       = (-4.27525e-11)
+ eta0     = (0)
+ etab     = (0)
+ drout    = (5.1917)
+ nlx      = (2.808e-07+1e-06*dela_vtl_pmos45_10hv_bsim3v3)
+ dvt0     = (0.81)
+ dvt1     = (0.131)
+ dvt2     = (0.1)
+ dvt0w    = (0.07+dela_vtm_pmos45_10hv_bsim3v3)
+ dvt1w    = (2.2e+04)
+ dvt2w    = (-0.032)
+ k3       = (0.13925+80*dela_vtw_pmos45_10hv_bsim3v3)
+ k3b      = (0.93815)
+ w0       = (0)
+ dwg      = (-5.1413e-09)
+ dwb      = (-1.544e-08)
+ b0       = (-3.24158e-07+1.0e-06*dela_b0_pmos45_10hv_bsim3v3)
+ b1       = (1.80373e-06)
+ prwg     = (-0.185237)
+ prwb     = (0.983)
+ pclm     = (0.189569)
+ pdiblc1  = (0.039)
+ pdiblc2  = (0.000145541)
+ pdiblcb  = (0.0106943)
+ delta    = (0.0143701)
+ vsat     = (500815)
+ ll       = (0.975e-13)
+ voff     = (-0.175)
+ lln      = (0.987)
+ wwl      = (6.6812e-20+1e-18*dela_wwl_pmos45_10hv_bsim3v3)
+ ua1      = (0.03e-09)
+ ub1      = (-2.3e-18)
+ uc1      = (-5.6e-11)
+ kt1      = (-0.3335)
+ ute      = (-1.315)
+ kt1l     = (1.5e-08)
+ prt      = (6500)
+ kt2      = (-0.01)
+ noimod   = (noimod_pmos45_10hv_bsim3v3)
+ noia     = (noia_pmos45_10hv_bsim3v3)
+ noib     = (noib_pmos45_10hv_bsim3v3)
+ noic     = (noic_pmos45_10hv_bsim3v3)
+ ef       = (ef_pmos45_10hv_bsim3v3)
+ em       = (em_pmos45_10hv_bsim3v3)

model rdint resistor
+ rsh   = (9199.224*delr_prsh_pmos45_10hv_bsim3v3)
+ tc1   = (4.9e-03)
+ tc2   = (0.9e-05)

mpmos45_10hv_i (d_i g s b) pmos45_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ngtotal
rrdint (d_i d) rdint w=(w+0.35) l=(2.575) m=(ngtotal)
ccgs_parasitic (g s) capacitor c=cgs_parasitic
ccsb_parasitic (s b) capacitor c=csb_parasitic
xcdgoptub_sub (b sub) cdgoptub_box_sub_10hv area=(((aiso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((piso*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmos45_10hv_dfrt
ends

subckt pmoshs45_10hv (d g s b sub)

parameters
+    l                              = 1.0
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    soa                            = 1
+    nsmm_delr_gox_pmoshs45_10hv_bsim3v3 = tmp_nsmm_delr_gox_pmoshs45_10hv_bsim3v3
+    nsmm_dela_vfb_pmoshs45_10hv_bsim3v3 = tmp_nsmm_dela_vfb_pmoshs45_10hv_bsim3v3
+    nsmm_delr_nsub_pmoshs45_10hv_bsim3v3 = tmp_nsmm_delr_nsub_pmoshs45_10hv_bsim3v3
+    nsmm_dela_vtl_pmoshs45_10hv_bsim3v3 = tmp_nsmm_dela_vtl_pmoshs45_10hv_bsim3v3
+    nsmm_dela_dl_pmoshs45_10hv_bsim3v3 = tmp_nsmm_dela_dl_pmoshs45_10hv_bsim3v3
+    nsmm_dela_dwox_pmoshs45_10hv_bsim3v3 = tmp_nsmm_dela_dwox_pmoshs45_10hv_bsim3v3
+    nsmm_delr_ubref_pmoshs45_10hv_bsim3v3 = tmp_nsmm_delr_ubref_pmoshs45_10hv_bsim3v3
+    nsmm_delr_rsh_pmoshs45_10hv_bsim3v3 = tmp_nsmm_delr_rsh_pmoshs45_10hv_bsim3v3
+    nsmm_dela_vtw_pmoshs45_10hv_bsim3v3 = tmp_nsmm_dela_vtw_pmoshs45_10hv_bsim3v3
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmoshs45_vthratio       = 1.0
+    presto_pmoshs45_betaratio      = 1.0
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    as_i                           = ((acj0_junc_pmoshs45_s_body/acj0_junc_pmoshs45_d_body)*((lg2aa_s_pmoshs45_10hv*nse)*w/2))
+    ps_i                           = ((pcj0_junc_pmoshs45_s_body/pcj0_junc_pmoshs45_d_body)*((2*lg2aa_s_pmoshs45_10hv*nse+2*w*nse)/2))
+    ad_i                           = ((0*nde+lg2g_d_pmoshs45_10hv*ndi)*(w+2*wg2iso_pmoshs45_10hv)/ng)
+    pd_i                           = ((2*(0*nde+lg2g_d_pmoshs45_10hv*ndi)+2*nd*(w+2*wg2iso_pmoshs45_10hv))/ng)
+    nrs_i                          = (lg2ct_s_pmoshs45_10hv/w)
+    nrd_i                          = (lg2ct_d_pmoshs45_10hv/w)
+    wiso                           = (w+2*wg2iso_pmoshs45_10hv)
+    liso                           = (lg2iso_pmoshs45_10hv*nse+l*ng+lg2g_d_pmoshs45_10hv*ndi+lg2g_s_pmoshs45_10hv*nsi)
+    area_iso                       = (wiso*liso)
+    peri_iso                       = (2*(wiso+liso))
+    delr_tox_pmoshs45_10hv_bsim3v3 = (nom_delr_tox_pmoshs45_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_pmoshs45_10hv_bsim3v3+nsmm_delr_gox_pmoshs45_10hv_bsim3v3*smm_delr_gox_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_pmoshs45_10hv_bsim3v3 = (nom_dela_dwox_pmoshs45_10hv_bsim3v3+nsig_dela_dwox_pmoshs45_10hv_bsim3v3*sig_dela_dwox_pmoshs45_10hv_bsim3v3+nsmm_dela_dwox_pmoshs45_10hv_bsim3v3*smm_dela_dwox_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_ubref_pmoshs45_10hv_bsim3v3 = (nom_delr_ubref_pmoshs45_10hv_bsim3v3*(1.0+nsig_delr_ubref_pmoshs45_10hv_bsim3v3*sig_delr_ubref_pmoshs45_10hv_bsim3v3+nsmm_delr_ubref_pmoshs45_10hv_bsim3v3*smm_delr_ubref_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_vfb_pmoshs45_10hv_bsim3v3 = (nom_dela_vfb_pmoshs45_10hv_bsim3v3+nsig_dela_vfb_pmoshs45_10hv_bsim3v3*sig_dela_vfb_pmoshs45_10hv_bsim3v3+nsmm_dela_vfb_pmoshs45_10hv_bsim3v3*smm_dela_vfb_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng)+nsmm_dela_vtl_pmoshs45_10hv_bsim3v3*smm_dela_vtl_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_pmoshs45_10hv_bsim3v3*smm_dela_vtw_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng)/w)
+    dela_dl_pmoshs45_10hv_bsim3v3  = (nom_dela_dl_pmoshs45_10hv_bsim3v3+nsig_dela_dl_pmoshs45_10hv_bsim3v3*sig_dela_dl_pmoshs45_10hv_bsim3v3+nsmm_dela_dl_pmoshs45_10hv_bsim3v3*smm_dela_dl_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_pmoshs45_10hv_bsim3v3 = (nom_dela_vtl_pmoshs45_10hv_bsim3v3+nsig_dela_vtl_pmoshs45_10hv_bsim3v3*sig_dela_vtl_pmoshs45_10hv_bsim3v3)
+    dela_vtw_pmoshs45_10hv_bsim3v3 = (nom_dela_vtw_pmoshs45_10hv_bsim3v3+nsig_dela_vtw_pmoshs45_10hv_bsim3v3*sig_dela_vtw_pmoshs45_10hv_bsim3v3)
+    dela_vtm_pmoshs45_10hv_bsim3v3 = (nom_dela_vtm_pmoshs45_10hv_bsim3v3+nsig_dela_vtm_pmoshs45_10hv_bsim3v3*sig_dela_vtm_pmoshs45_10hv_bsim3v3)
+    dela_a0_pmoshs45_10hv_bsim3v3  = (nom_dela_a0_pmoshs45_10hv_bsim3v3+nsig_dela_a0_pmoshs45_10hv_bsim3v3*sig_dela_a0_pmoshs45_10hv_bsim3v3)
+    dela_wwl_pmoshs45_10hv_bsim3v3 = (nom_dela_wwl_pmoshs45_10hv_bsim3v3+nsig_dela_wwl_pmoshs45_10hv_bsim3v3*sig_dela_wwl_pmoshs45_10hv_bsim3v3)
+    delr_rsh_pmoshs45_10hv_bsim3v3 = (1+nsmm_delr_rsh_pmoshs45_10hv_bsim3v3*smm_delr_rsh_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_nsub_pmoshs45_10hv_bsim3v3 = (1+nsmm_delr_nsub_pmoshs45_10hv_bsim3v3*smm_delr_nsub_pmoshs45_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_prsh_pmoshs45_10hv_bsim3v3 = (nom_delr_prsh_pmoshs45_10hv_bsim3v3*(1.0+nsig_delr_prsh_pmoshs45_10hv_bsim3v3*sig_delr_prsh_pmoshs45_10hv_bsim3v3))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.319e-08*delr_tox_pmoshs45_10hv_bsim3v3)
+    cox                            = (epsox/tox)
+    cgs_parasitic                  = ((1-lpe)*(ng*(l+0.5*lg2g_d_pmoshs45_10hv)*cfr_m2_m1)+1e-20)
+    csb_parasitic                  = ((1-lpe)*(ng*w*cfr_m2_m1)+1e-20)

model pmoshs45_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_pmoshs45_d_body)
+ pb       = (aphi_junc_pmoshs45_d_body)
+ mj       = (aexm_junc_pmoshs45_d_body)
+ js       = (1.0e12*ajs_junc_pmoshs45_d_body)
+ nj       = (ajnd_junc_pmoshs45_d_body)
+ cjsw     = (1.0e6*pcj0_junc_pmoshs45_d_body)
+ pbsw     = (pphi_junc_pmoshs45_d_body)
+ mjsw     = (pexm_junc_pmoshs45_d_body)
+ jsw      = (1.0e6*pjs_junc_pmoshs45_d_body)
+ cjswg    = (1.0e6*chcj0_junc_pmoshs45_d_body)
+ pbswg    = (chphi_junc_pmoshs45_d_body)
+ mjswg    = (chexm_junc_pmoshs45_d_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (5.0e-08*cox+0.5*cfr_pmoshs45_s_ply_m1ct*1e6+(1-lpe)*cfr_pmoshs45_s_ply_met*1e6-0.5*cfr_pmoshs45_s_ply_met*1e6-(lpe)*cfr_m2_ply*1e6)
+ cgdo     = (2.0e-08*cox+0.5*cfr_pmoshs45_d_ply_m1ct*1e6+(1-lpe)*cfr_pmoshs45_d_ply_met*1e6-0.5*cfr_pmoshs45_d_ply_met*1e6)
+ cf       = (0)
+ dlc      = (-4.19515e-07)
+ dwc      = (-1.50505e-07)
+ acde     = (1.0)
+ moin     = (24)
+ noff     = (1.75)
+ cgsl     = (0.66e-10)
+ cgdl     = (8.5e-10)
+ ckappa   = (0.5)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = (0)
+ mobmod   = (1)
+ rsh      = (8.4)
+ tox      = (1.319e-08*delr_tox_pmoshs45_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-10.59515e-08-0.5e-06*dela_dl_pmoshs45_10hv_bsim3v3)
+ wint     = (9.505e-08-0.5e-06*dela_dwox_pmoshs45_10hv_bsim3v3)
+ ww       = (-7.39e-15)
+ u0       = ((149.719*delr_ubref_pmoshs45_10hv_bsim3v3)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pmoshs45_betaratio))
+ rdsw     = ((1919.96*delr_rsh_pmoshs45_10hv_bsim3v3)*delr_rdsw_relimo)
+ nsub     = (1.32227e+17*delr_nsub_pmoshs45_10hv_bsim3v3)
+ nch      = (1.485693e+17*delr_nsub_pmoshs45_10hv_bsim3v3)
+ vfb      = (-1.0357579+dela_vfb_pmoshs45_10hv_bsim3v3+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmoshs45_vthratio)
+ vbm      = (-5.5)
+ xt       = (2.49021515976251e-07)
+ alpha1   = (1.5e-03)
+ alpha0   = (-1.2e-09)
+ beta0    = (88)
+ a0       = ((1.02237+dela_a0_pmoshs45_10hv_bsim3v3)*delr_a0_relimo)
+ ags      = (0.1173)
+ keta     = (-0.0026554)
+ ua       = (1.92164e-09)
+ ub       = (2.8014e-19)
+ uc       = (-4.27525e-11)
+ eta0     = (0)
+ etab     = (0)
+ drout    = (5.1917)
+ nlx      = (2.738e-07+1e-06*dela_vtl_pmoshs45_10hv_bsim3v3)
+ dvt0     = (0.81)
+ dvt1     = (0.131)
+ dvt2     = (0.11)
+ dvt0w    = (0.07+dela_vtm_pmoshs45_10hv_bsim3v3)
+ dvt1w    = (2.2e+04)
+ dvt2w    = (-0.032)
+ k3       = (1.86+80*dela_vtw_pmoshs45_10hv_bsim3v3)
+ k3b      = (0.80815)
+ w0       = (0)
+ dwg      = (-5.1413e-09)
+ dwb      = (-1.544e-08)
+ b0       = (-3.24158e-07)
+ b1       = (1.80373e-06)
+ prwg     = (-0.185237)
+ prwb     = (0.983)
+ pclm     = (0.189569)
+ pdiblc1  = (0.039)
+ pdiblc2  = (0.000145541)
+ pdiblcb  = (0.0106943)
+ delta    = (0.0143701)
+ vsat     = (500815)
+ ll       = (0.975e-13)
+ voff     = (-0.175)
+ lln      = (0.987)
+ wwl      = (6.6812e-20+1e-18*dela_wwl_pmoshs45_10hv_bsim3v3)
+ ua1      = (0.31e-09)
+ ub1      = (-2.6e-18)
+ uc1      = (-5.6e-11)
+ kt1      = (-0.3335)
+ ute      = (-1.285)
+ kt1l     = (1.5e-08)
+ prt      = (6500)
+ kt2      = (-0.01)
+ noimod   = (noimod_pmoshs45_10hv_bsim3v3)
+ noia     = (noia_pmoshs45_10hv_bsim3v3)
+ noib     = (noib_pmoshs45_10hv_bsim3v3)
+ noic     = (noic_pmoshs45_10hv_bsim3v3)
+ ef       = (ef_pmoshs45_10hv_bsim3v3)
+ em       = (em_pmoshs45_10hv_bsim3v3)

model rdint resistor
+ rsh   = (9199.224*delr_prsh_pmoshs45_10hv_bsim3v3)
+ tc1   = (4.9e-03)
+ tc2   = (1.0e-05)

mpmoshs45_10hv_i (d_i g s b) pmoshs45_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ngtotal
rrdint (d_i d) rdint w=(w+0.35) l=(2.575) m=(ngtotal)
ccgs_parasitic (g s) capacitor c=cgs_parasitic
ccsb_parasitic (s b) capacitor c=csb_parasitic
xcdgoptub_sub (b sub) cdgoptub_box_sub_10hv area=(area_iso*(1-lpe)) perim=(peri_iso*(1-lpe)) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmoshs45_10hv_dfrt
ends

subckt nmos90_10hv (d g s b sub)

parameters
+    l                              = 1.5
+    w                              = 2
+    ng                             = 2
+    lpe                            = 0
+    soa                            = 1
+    nsmm_delr_gox_nmos90_10hv_bsim3v3 = tmp_nsmm_delr_gox_nmos90_10hv_bsim3v3
+    nsmm_dela_vfb_nmos90_10hv_bsim3v3 = tmp_nsmm_dela_vfb_nmos90_10hv_bsim3v3
+    nsmm_delr_nsub_nmos90_10hv_bsim3v3 = tmp_nsmm_delr_nsub_nmos90_10hv_bsim3v3
+    nsmm_dela_vtl_nmos90_10hv_bsim3v3 = tmp_nsmm_dela_vtl_nmos90_10hv_bsim3v3
+    nsmm_dela_dl_nmos90_10hv_bsim3v3 = tmp_nsmm_dela_dl_nmos90_10hv_bsim3v3
+    nsmm_dela_dwox_nmos90_10hv_bsim3v3 = tmp_nsmm_dela_dwox_nmos90_10hv_bsim3v3
+    nsmm_delr_ubref_nmos90_10hv_bsim3v3 = tmp_nsmm_delr_ubref_nmos90_10hv_bsim3v3
+    nsmm_delr_rsh_nmos90_10hv_bsim3v3 = tmp_nsmm_delr_rsh_nmos90_10hv_bsim3v3
+    nsmm_dela_vtw_nmos90_10hv_bsim3v3 = tmp_nsmm_dela_vtw_nmos90_10hv_bsim3v3
+    ngtotal                        = (ng+(mod(ng,2)))
+    nga                            = (2)
+    ng_residue                     = (mod(ngtotal,nga))
+    number_of_nga                  = ((ngtotal-ng_residue)/nga)
+    nde_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(mod(ng_residue,2)))
+    nse_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(2-nde_residue))
+    nd_residue                     = ((((ng_residue<0)|(ng_residue>0)))*((ng_residue+nde_residue)/2))
+    ns_residue                     = ((((ng_residue<0)|(ng_residue>0)))*(1-nde_residue+nd_residue))
+    ndi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(nd_residue-nde_residue))
+    nsi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(ns_residue-nse_residue))
+    nde_nga                        = (mod(nga,2))
+    nse_nga                        = (2-nde_nga)
+    nd_nga                         = ((nga+nde_nga)/2)
+    ns_nga                         = (1-nde_nga+nd_nga)
+    ndi_nga                        = (nd_nga-nde_nga)
+    nsi_nga                        = (ns_nga-nse_nga)
+    nde_allnga                     = (number_of_nga*nde_nga)
+    nse_allnga                     = (number_of_nga*nse_nga)
+    nd_allnga                      = (number_of_nga*nd_nga)
+    ns_allnga                      = (number_of_nga*ns_nga)
+    ndi_allnga                     = (number_of_nga*ndi_nga)
+    nsi_allnga                     = (number_of_nga*nsi_nga)
+    nde                            = (nde_residue+nde_allnga)
+    nse                            = (nse_residue+nse_allnga)
+    nd                             = (nd_residue+nd_allnga)
+    ns                             = (ns_residue+ns_allnga)
+    ndi                            = (ndi_residue+ndi_allnga)
+    nsi                            = (nsi_residue+nsi_allnga)
+    nde_outside                    = ((ng_residue==0)*nde_nga+(((ng_residue<0)|(ng_residue>0)))*nde_residue)
+    default_as                     = ((lg2aa_s_nmos90_10hv*(wg2aa_se_nmos90_10hv+w)*nse+lg2g_s_nmos90_10hv*(wg2aa_si_nmos90_10hv+w)*nsi)/ngtotal)
+    default_ps                     = ((2*((lg2aa_s_nmos90_10hv+wg2aa_se_nmos90_10hv+w)*nse+(lg2g_s_nmos90_10hv+wg2aa_si_nmos90_10hv+w)*nsi))/ngtotal)
+    default_ad                     = ((lg2aa_d_nmos90_10hv*(wg2aa_de_nmos90_10hv+w)*nde+lg2g_d_nmos90_10hv*(wg2aa_di_nmos90_10hv+w)*ndi)/ngtotal)
+    default_pd                     = ((2*((lg2aa_d_nmos90_10hv+wg2aa_de_nmos90_10hv+w)*nde+(lg2g_d_nmos90_10hv+wg2aa_di_nmos90_10hv+w)*ndi))/ngtotal)
+    as_i                           = ((acj0_junc_nmos90_s_body/acj0_junc_nmos90_d_body)*default_as)
+    ps_i                           = ((pcj0_junc_nmos90_s_body/pcj0_junc_nmos90_d_body)*default_ps)
+    ad_i                           = ((lg2aa_d_nmos90_10hv*(wg2aa_de_nmos90_10hv+w)*nde+lg2g_d_nmos90_10hv*(wg2aa_di_nmos90_10hv+w)*ndi)/ngtotal)
+    pd_i                           = ((2*((lg2aa_d_nmos90_10hv+wg2aa_de_nmos90_10hv+w)*nde+(lg2g_d_nmos90_10hv+wg2aa_di_nmos90_10hv+w)*ndi))/ngtotal)
+    nrs_i                          = (lg2ct_s_nmos90_10hv/w)
+    nrd_i                          = (lg2ct_d_nmos90_10hv/w)
+    length1                        = (trench2se_body_nmos90_10hv*(1+(ng_residue==0)*(nse_nga-1))+trench2se_nobody_nmos90_10hv*((((ng_residue<0)|(ng_residue>0)))*(nse_residue-1))+trench2de_nmos90_10hv*nde_outside)
+    length2                        = (l*ngtotal+lg2aa_s_nmos90_10hv*nse+lg2g_s_nmos90_10hv*nsi+lg2aa_d_nmos90_10hv*nde+lg2g_d_nmos90_10hv*ndi+s2s_inside_nmos90_10hv*(number_of_nga-1+(((ng_residue<0)|(ng_residue>0)))))
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_nmos90_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
+    length_m2m1                    = (wbox2sub-11.285)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*(length_m2m1+width_m2m1))
+    csb_nmos90_10hv_m2m1           = ((number_of_nga+1)*(cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)+(cpp_m2_m1*2*1*0.69+cfr_m2_m1*2*0.69)*(number_of_nga-1))
+    csb_nmos90_10hv_m2m1_par       = ((1-lpe)*csb_nmos90_10hv_m2m1+lpe*1e-20)
+    cgs_nmos90_10hv_m2m1_par       = ((1-lpe)*((l+0.5*lg2g_d_nmos90_10hv)*ng*cfr_m2_m1)+lpe*1e-20)
+    d_perim_ch                     = ((nde*w+2*ndi*w)/ngtotal)
+    d_perim_nonch                  = ((pd_i<=0)*(default_pd-d_perim_ch)+(pd_i>0)*((pd_i>d_perim_ch)*(pd_i-d_perim_ch)+(pd_i<=d_perim_ch)*0))
+    totalperim_d                   = (d_perim_ch+d_perim_nonch)
+    jsw_junc_nmos90_d_body         = ((pjs_junc_nmos90_d_body*d_perim_nonch+chjs_junc_nmos90_d_body*d_perim_ch)/totalperim_d)
+    delr_tox_nmos90_10hv_bsim3v3   = (nom_delr_tox_nmos90_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_nmos90_10hv_bsim3v3+nsmm_delr_gox_nmos90_10hv_bsim3v3*smm_delr_gox_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_nmos90_10hv_bsim3v3  = (nom_dela_dwox_nmos90_10hv_bsim3v3+nsig_dela_dwox_nmos90_10hv_bsim3v3*sig_dela_dwox_nmos90_10hv_bsim3v3+nsmm_dela_dwox_nmos90_10hv_bsim3v3*smm_dela_dwox_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vfb_nmos90_10hv_bsim3v3   = (nom_dela_vfb_nmos90_10hv_bsim3v3+nsig_dela_vfb_nmos90_10hv_bsim3v3*sig_dela_vfb_nmos90_10hv_bsim3v3+nsmm_dela_vfb_nmos90_10hv_bsim3v3*smm_dela_vfb_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)+nsmm_dela_vtl_nmos90_10hv_bsim3v3*smm_dela_vtl_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_nmos90_10hv_bsim3v3*smm_dela_vtw_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)/w)
+    delr_ubref_nmos90_10hv_bsim3v3 = (nom_delr_ubref_nmos90_10hv_bsim3v3*(1.0+nsig_delr_ubref_nmos90_10hv_bsim3v3*sig_delr_ubref_nmos90_10hv_bsim3v3+nsmm_delr_ubref_nmos90_10hv_bsim3v3*smm_delr_ubref_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dl_nmos90_10hv_bsim3v3    = (nom_dela_dl_nmos90_10hv_bsim3v3+nsig_dela_dl_nmos90_10hv_bsim3v3*sig_dela_dl_nmos90_10hv_bsim3v3+nsmm_dela_dl_nmos90_10hv_bsim3v3*smm_dela_dl_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_nmos90_10hv_bsim3v3   = (nom_dela_vtl_nmos90_10hv_bsim3v3+nsig_dela_vtl_nmos90_10hv_bsim3v3*sig_dela_vtl_nmos90_10hv_bsim3v3)
+    dela_vtw_nmos90_10hv_bsim3v3   = (nom_dela_vtw_nmos90_10hv_bsim3v3+nsig_dela_vtw_nmos90_10hv_bsim3v3*sig_dela_vtw_nmos90_10hv_bsim3v3)
+    dela_vtm_nmos90_10hv_bsim3v3   = (nom_dela_vtm_nmos90_10hv_bsim3v3+nsig_dela_vtm_nmos90_10hv_bsim3v3*sig_dela_vtm_nmos90_10hv_bsim3v3)
+    dela_a0_nmos90_10hv_bsim3v3    = (nom_dela_a0_nmos90_10hv_bsim3v3+nsig_dela_a0_nmos90_10hv_bsim3v3*sig_dela_a0_nmos90_10hv_bsim3v3)
+    delr_rdsw_nmos90_10hv_bsim3v3  = (nom_delr_rdsw_nmos90_10hv_bsim3v3*(1.0+nsig_delr_rdsw_nmos90_10hv_bsim3v3*sig_delr_rdsw_nmos90_10hv_bsim3v3))
+    dela_wwl_nmos90_10hv_bsim3v3   = (0)
+    delr_rsh_nmos90_10hv_bsim3v3   = (1+nsmm_delr_rsh_nmos90_10hv_bsim3v3*smm_delr_rsh_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_nsub_nmos90_10hv_bsim3v3  = (1+nsmm_delr_nsub_nmos90_10hv_bsim3v3*smm_delr_nsub_nmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.316e-08*delr_tox_nmos90_10hv_bsim3v3)
+    cox                            = (epsox/tox)
+    tn                             = (27.0)
+    tkr                            = (tn+273.15)
+    tkd                            = (temp+273.15)
+    stalpha                        = (-2.0)
+    fac_alpha                      = ((tkd/tkr)**stalpha)

model nmos90_10hv bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_nmos90_d_body)
+ pb       = (aphi_junc_nmos90_d_body)
+ mj       = (aexm_junc_nmos90_d_body)
+ js       = (1.0e12*ajs_junc_nmos90_d_body)
+ nj       = ((ajnd_junc_nmos90_d_body+pjnd_junc_nmos90_d_body+chjnd_junc_nmos90_d_body)/((((ajnd_junc_nmos90_d_body<0)|(ajnd_junc_nmos90_d_body>0)))+(((pjnd_junc_nmos90_d_body<0)|(pjnd_junc_nmos90_d_body>0)))+(((chjnd_junc_nmos90_d_body<0)|(chjnd_junc_nmos90_d_body>0)))))
+ cjsw     = (1.0e6*pcj0_junc_nmos90_d_body)
+ pbsw     = (pphi_junc_nmos90_d_body)
+ mjsw     = (pexm_junc_nmos90_d_body)
+ jsw      = (1.0e6*jsw_junc_nmos90_d_body)
+ cjswg    = (1.0e6*chcj0_junc_nmos90_d_body)
+ pbswg    = (chphi_junc_nmos90_d_body)
+ mjswg    = (chexm_junc_nmos90_d_body)
+ capmod   = (3)
+ cf       = (0)
+ cgbo     = (1.43724e-09)
+ cgso     = (5.6e-08*cox+0.5*cfr_nmos90_s_ply_m1ct*1e6+(1-lpe)*cfr_nmos90_s_ply_met*1e6-0.5*cfr_nmos90_s_ply_met*1e6-lpe*cfr_m2_ply*1e6)
+ cgsl     = (1.1e-10)
+ cgdo     = (3.4e-08*cox+0.5*cfr_nmos90_d_ply_m1ct*1e6+(1-lpe)*cfr_nmos90_d_ply_met*1e6-0.5*cfr_nmos90_d_ply_met*1e6)
+ cgdl     = (2.0e-09)
+ ckappa   = (0.6)
+ dlc      = (-3.77316e-07)
+ llc      = (-4.46747e-13)
+ lwc      = (-4.03663e-11)
+ lwlc     = (0)
+ dwc      = (-2.05402e-08)
+ wwc      = (0)
+ wlc      = (0)
+ wwlc     = (0)
+ voffcv   = (-0.0164361)
+ noff     = (2.61845)
+ acde     = (0.468313)
+ moin     = (5)
+ mobmod   = (1)
+ rsh      = (10.4)
+ tox      = (1.316e-08*delr_tox_nmos90_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ vfb      = (-1.12708+dela_vfb_nmos90_10hv_bsim3v3)
+ vbm      = (-5.5)
+ xt       = (6.58508e-08)
+ nch      = (2.6969e+17*delr_nsub_nmos90_10hv_bsim3v3)
+ nsub     = (1.69756e+17*delr_nsub_nmos90_10hv_bsim3v3)
+ u0       = (523.967*delr_ubref_nmos90_10hv_bsim3v3)
+ ua       = (3.915e-10)
+ ub       = (1.9623e-18)
+ uc       = (9.53232e-11)
+ a0       = (1.379)
+ ags      = (0.14+dela_a0_nmos90_10hv_bsim3v3)
+ keta     = (-0.008)
+ wint     = (1.51407e-07-0.5e-06*dela_dwox_nmos90_10hv_bsim3v3)
+ ww       = (-1.98208e-13)
+ wwn      = (0.87224)
+ k3       = (4.816+80*dela_vtw_nmos90_10hv_bsim3v3)
+ k3b      = (4.342)
+ w0       = (5.6766e-06)
+ dwg      = (-1.39868e-08)
+ dwb      = (1.13209e-08)
+ b0       = (0)
+ b1       = (0.792193)
+ lint     = (-2.10427e-08-0.5e-06*dela_dl_nmos90_10hv_bsim3v3)
+ ll       = (-1.83222e-11)
+ lln      = (0.642666)
+ nlx      = (5.65e-07+1e-06*dela_vtl_nmos90_10hv_bsim3v3)
+ dvt0     = (3.58)
+ dvt1     = (0.1671)
+ dvt2     = (0.126405)
+ rdsw     = (3049.02*delr_rdsw_nmos90_10hv_bsim3v3*delr_rsh_nmos90_10hv_bsim3v3)
+ wr       = (1)
+ prwg     = (-0.0818159)
+ prwb     = (0.404388)
+ cdsc     = (0.00024)
+ cdscd    = (0)
+ cdscb    = (0)
+ vsat     = (4.8779e+05)
+ a1       = (1.87257)
+ a2       = (0.01)
+ pclm     = (1.84512)
+ pdiblc1  = (0.00358826)
+ pdiblc2  = (8.985e-07)
+ pdiblcb  = (0.217104)
+ drout    = (1.09401)
+ pvag     = (0)
+ delta    = (0.0372643)
+ eta0     = (0.159909)
+ etab     = (-0.018028)
+ dsub     = (2.27141)
+ alpha0   = (6.5e-09*fac_alpha)
+ alpha1   = (0.001*fac_alpha)
+ beta0    = (68)
+ dvt0w    = (0.35+dela_vtm_nmos90_10hv_bsim3v3)
+ dvt1w    = (70570)
+ dvt2w    = (2.558)
+ wwl      = (-1.50966e-16+1e-15*dela_wwl_nmos90_10hv_bsim3v3)
+ lwl      = (-7.23299e-17)
+ wl       = (-7.08242e-12)
+ wln      = (0.61565)
+ lw       = (-1.18341e-12)
+ lwn      = (0.745886)
+ ute      = (-1.65732)
+ kt1      = (-0.425)
+ kt2      = (-0.025)
+ ua1      = (2.5e-09)
+ ub1      = (-5.41e-18)
+ uc1      = (-2.07303e-11)
+ kt1l     = (-2.60134e-08)
+ prt      = (2000)
+ noimod   = (noimod_nmos90_10hv_bsim3v3)
+ noia     = (noia_nmos90_10hv_bsim3v3)
+ noib     = (noib_nmos90_10hv_bsim3v3)
+ noic     = (noic_nmos90_10hv_bsim3v3)
+ ef       = (ef_nmos90_10hv_bsim3v3)
+ em       = (em_nmos90_10hv_bsim3v3)

model rdint resistor
+ tnom  = (27)
+ rsh   = (2437.84)
+ etch  = (5.53787e-06)
+ tc1   = (5.8e-03)
+ tc2   = (1.5e-05)

mnmos90_10hv_i (d_i g s b) nmos90_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=(ngtotal)
ccsb_nmos90_10hv_m2m1_par (s b) capacitor c=csb_nmos90_10hv_m2m1_par
ccgs_nmos90_10hv_m2m1_par (g s) capacitor c=cgs_nmos90_10hv_m2m1_par
rrdint (d_i d) rdint w=(w+13.7) l=(7.285) m=(ngtotal)
xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=1

include "./smos10hv_ade_dfrt.scs" section=nmos90_10hv_dfrt
ends

subckt pmos90_10hv (d g s b sub)

parameters
+    l                              = 1.0
+    w                              = 5.0
+    ng                             = 2
+    lpe                            = 0
+    soa                            = 1
+    nsmm_delr_gox_pmos90_10hv_bsim3v3 = tmp_nsmm_delr_gox_pmos90_10hv_bsim3v3
+    nsmm_dela_vfb_pmos90_10hv_bsim3v3 = tmp_nsmm_dela_vfb_pmos90_10hv_bsim3v3
+    nsmm_delr_nsub_pmos90_10hv_bsim3v3 = tmp_nsmm_delr_nsub_pmos90_10hv_bsim3v3
+    nsmm_dela_vtl_pmos90_10hv_bsim3v3 = tmp_nsmm_dela_vtl_pmos90_10hv_bsim3v3
+    nsmm_dela_dl_pmos90_10hv_bsim3v3 = tmp_nsmm_dela_dl_pmos90_10hv_bsim3v3
+    nsmm_dela_dwox_pmos90_10hv_bsim3v3 = tmp_nsmm_dela_dwox_pmos90_10hv_bsim3v3
+    nsmm_delr_ubref_pmos90_10hv_bsim3v3 = tmp_nsmm_delr_ubref_pmos90_10hv_bsim3v3
+    nsmm_delr_rsh_pmos90_10hv_bsim3v3 = tmp_nsmm_delr_rsh_pmos90_10hv_bsim3v3
+    nsmm_dela_vtw_pmos90_10hv_bsim3v3 = tmp_nsmm_dela_vtw_pmos90_10hv_bsim3v3
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pmos90_vthratio         = 1.0
+    presto_pmos90_betaratio        = 1.0
+    ngtotal                        = (ng+(mod(ng,2)))
+    nga                            = (2)
+    ng_residue                     = (mod(ngtotal,nga))
+    number_of_nga                  = ((ngtotal-ng_residue)/nga)
+    nde_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(mod(ng_residue,2)))
+    nse_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(2-nde_residue))
+    nd_residue                     = ((((ng_residue<0)|(ng_residue>0)))*((ng_residue+nde_residue)/2))
+    ns_residue                     = ((((ng_residue<0)|(ng_residue>0)))*(1-nde_residue+nd_residue))
+    ndi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(nd_residue-nde_residue))
+    nsi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(ns_residue-nse_residue))
+    nde_nga                        = (mod(nga,2))
+    nse_nga                        = (2-nde_nga)
+    nd_nga                         = ((nga+nde_nga)/2)
+    ns_nga                         = (1-nde_nga+nd_nga)
+    ndi_nga                        = (nd_nga-nde_nga)
+    nsi_nga                        = (ns_nga-nse_nga)
+    nde_allnga                     = (number_of_nga*nde_nga)
+    nse_allnga                     = (number_of_nga*nse_nga)
+    nd_allnga                      = (number_of_nga*nd_nga)
+    ns_allnga                      = (number_of_nga*ns_nga)
+    ndi_allnga                     = (number_of_nga*ndi_nga)
+    nsi_allnga                     = (number_of_nga*nsi_nga)
+    nde                            = (nde_residue+nde_allnga)
+    nse                            = (nse_residue+nse_allnga)
+    nd                             = (nd_residue+nd_allnga)
+    ns                             = (ns_residue+ns_allnga)
+    ndi                            = (ndi_residue+ndi_allnga)
+    nsi                            = (nsi_residue+nsi_allnga)
+    nde_outside                    = ((ng_residue==0)*nde_nga+(((ng_residue<0)|(ng_residue>0)))*nde_residue)
+    default_as                     = ((lg2aa_s_pmos90_10hv*(wg2aa_se_pmos90_10hv+w)*nse+lg2g_s_pmos90_10hv*(wg2aa_si_pmos90_10hv+w)*nsi)/ngtotal)
+    default_ps                     = ((2*((lg2aa_s_pmos90_10hv+wg2aa_se_pmos90_10hv+w)*nse+(lg2g_s_pmos90_10hv+wg2aa_si_pmos90_10hv+w)*nsi))/ngtotal)
+    default_ad                     = ((lg2aa_d_pmos90_10hv*(wg2aa_de_pmos90_10hv+w)*nde+lg2g_d_pmos90_10hv*(wg2aa_di_pmos90_10hv+w)*ndi)/ngtotal)
+    default_pd                     = ((2*((lg2aa_d_pmos90_10hv+wg2aa_de_pmos90_10hv+w)*nde+(lg2g_d_pmos90_10hv+wg2aa_di_pmos90_10hv+w)*ndi))/ngtotal)
+    as_i                           = ((acj0_junc_pmos90_s_body/acj0_junc_pmos90_d_body)*default_as)
+    ps_i                           = ((pcj0_junc_pmos90_s_body/pcj0_junc_pmos90_d_body)*default_ps)
+    ad_i                           = ((lg2aa_d_pmos90_10hv*(wg2aa_de_pmos90_10hv+w)*nde+lg2g_d_pmos90_10hv*(wg2aa_di_pmos90_10hv+w)*ndi)/ngtotal)
+    pd_i                           = ((2*((lg2aa_d_pmos90_10hv+wg2aa_de_pmos90_10hv+w)*nde+(lg2g_d_pmos90_10hv+wg2aa_di_pmos90_10hv+w)*ndi))/ngtotal)
+    nrs_i                          = (lg2ct_s_pmos90_10hv/w)
+    nrd_i                          = (lg2ct_d_pmos90_10hv/w)
+    length1                        = (trench2se_body_pmos90_10hv*(1+(ng_residue==0)*(nse_nga-1))+trench2se_nobody_pmos90_10hv*((((ng_residue<0)|(ng_residue>0)))*(nse_residue-1))+trench2de_pmos90_10hv*nde_outside)
+    length2                        = (l*ngtotal+lg2aa_s_pmos90_10hv*nse+lg2g_s_pmos90_10hv*nsi+lg2aa_d_pmos90_10hv*nde+lg2g_d_pmos90_10hv*ndi+s2s_inside_pmos90_10hv*(number_of_nga-1+(((ng_residue<0)|(ng_residue>0)))))
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_pmos90_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
+    length_m2m1                    = (wbox2sub-11.285)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*(length_m2m1+width_m2m1))
+    csb_pmos90_10hv_m2m1           = ((number_of_nga+1)*(cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)+(cpp_m2_m1*2*1*0.69+cfr_m2_m1*2*0.69)*(number_of_nga-1))
+    csb_pmos90_10hv_m2m1_par       = ((1-lpe)*csb_pmos90_10hv_m2m1+lpe*1e-20)
+    cgs_pmos90_10hv_m2m1_par       = ((1-lpe)*((l+0.5*lg2g_d_pmos90_10hv)*ng*cfr_m2_m1)+lpe*1e-20)
+    d_perim_ch                     = ((nde*w+2*ndi*w)/ngtotal)
+    d_perim_nonch                  = ((pd_i<=0)*(default_pd-d_perim_ch)+(pd_i>0)*((pd_i>d_perim_ch)*(pd_i-d_perim_ch)+(pd_i<=d_perim_ch)*0))
+    totalperim_d                   = (d_perim_ch+d_perim_nonch)
+    delr_tox_pmos90_10hv_bsim3v3   = (nom_delr_tox_pmos90_10hv_bsim3v3*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_pmos90_10hv_bsim3v3+nsmm_delr_gox_pmos90_10hv_bsim3v3*smm_delr_gox_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_dwox_pmos90_10hv_bsim3v3  = (nom_dela_dwox_pmos90_10hv_bsim3v3+nsig_dela_dwox_pmos90_10hv_bsim3v3*sig_dela_dwox_pmos90_10hv_bsim3v3+nsmm_dela_dwox_pmos90_10hv_bsim3v3*smm_dela_dwox_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_ubref_pmos90_10hv_bsim3v3 = (nom_delr_ubref_pmos90_10hv_bsim3v3*(1.0+nsig_delr_ubref_pmos90_10hv_bsim3v3*sig_delr_ubref_pmos90_10hv_bsim3v3+nsmm_delr_ubref_pmos90_10hv_bsim3v3*smm_delr_ubref_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)))
+    dela_vfb_pmos90_10hv_bsim3v3   = (nom_dela_vfb_pmos90_10hv_bsim3v3+nsig_dela_vfb_pmos90_10hv_bsim3v3*sig_dela_vfb_pmos90_10hv_bsim3v3+nsmm_dela_vfb_pmos90_10hv_bsim3v3*smm_dela_vfb_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)+nsmm_dela_vtl_pmos90_10hv_bsim3v3*smm_dela_vtl_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)/l+nsmm_dela_vtw_pmos90_10hv_bsim3v3*smm_dela_vtw_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng)/w)
+    dela_dl_pmos90_10hv_bsim3v3    = (nom_dela_dl_pmos90_10hv_bsim3v3+nsig_dela_dl_pmos90_10hv_bsim3v3*sig_dela_dl_pmos90_10hv_bsim3v3+nsmm_dela_dl_pmos90_10hv_bsim3v3*smm_dela_dl_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    dela_vtl_pmos90_10hv_bsim3v3   = (nom_dela_vtl_pmos90_10hv_bsim3v3+nsig_dela_vtl_pmos90_10hv_bsim3v3*sig_dela_vtl_pmos90_10hv_bsim3v3)
+    dela_vtw_pmos90_10hv_bsim3v3   = (nom_dela_vtw_pmos90_10hv_bsim3v3+nsig_dela_vtw_pmos90_10hv_bsim3v3*sig_dela_vtw_pmos90_10hv_bsim3v3)
+    dela_vtm_pmos90_10hv_bsim3v3   = (nom_dela_vtm_pmos90_10hv_bsim3v3+nsig_dela_vtm_pmos90_10hv_bsim3v3*sig_dela_vtm_pmos90_10hv_bsim3v3)
+    dela_a0_pmos90_10hv_bsim3v3    = (nom_dela_a0_pmos90_10hv_bsim3v3+nsig_dela_a0_pmos90_10hv_bsim3v3*sig_dela_a0_pmos90_10hv_bsim3v3)
+    dela_b0_pmos90_10hv_bsim3v3    = (nom_dela_b0_pmos90_10hv_bsim3v3+nsig_dela_b0_pmos90_10hv_bsim3v3*sig_dela_b0_pmos90_10hv_bsim3v3)
+    dela_wwl_pmos90_10hv_bsim3v3   = (nom_dela_wwl_pmos90_10hv_bsim3v3+nsig_dela_wwl_pmos90_10hv_bsim3v3*sig_dela_wwl_pmos90_10hv_bsim3v3)
+    delr_rsh_pmos90_10hv_bsim3v3   = (1+nsmm_delr_rsh_pmos90_10hv_bsim3v3*smm_delr_rsh_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    delr_nsub_pmos90_10hv_bsim3v3  = (1+nsmm_delr_nsub_pmos90_10hv_bsim3v3*smm_delr_nsub_pmos90_10hv_bsim3v3(l,w)/sqrt(1*ng))
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (1.319e-08*delr_tox_pmos90_10hv_bsim3v3)
+    cox                            = (epsox/tox)

model pmos90_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ cj       = (1.0e12*acj0_junc_pmos90_d_body)
+ pb       = (aphi_junc_pmos90_d_body)
+ mj       = (aexm_junc_pmos90_d_body)
+ js       = (1.0e12*ajs_junc_pmos90_d_body)
+ nj       = (ajnd_junc_pmos90_d_body)
+ cjsw     = (1.0e6*pcj0_junc_pmos90_d_body)
+ pbsw     = (pphi_junc_pmos90_d_body)
+ mjsw     = (pexm_junc_pmos90_d_body)
+ jsw      = (1.0e6*pjs_junc_pmos90_d_body)
+ cjswg    = (1.0e6*chcj0_junc_pmos90_d_body)
+ pbswg    = (chphi_junc_pmos90_d_body)
+ mjswg    = (chexm_junc_pmos90_d_body)
+ capmod   = (3)
+ cgbo     = (0)
+ cgso     = (5.25e-08*cox+0.5*cfr_pmos90_s_ply_m1ct*1e6+(1-lpe)*cfr_pmos90_s_ply_met*1e6-0.5*cfr_pmos90_s_ply_met*1e6-(lpe)*cfr_m2_ply*1e6)
+ cgdo     = (13.5e-08*cox+0.5*cfr_pmos90_d_ply_m1ct*1e6+(1-lpe)*cfr_pmos90_d_ply_met*1e6-0.5*cfr_pmos90_d_ply_met*1e6)
+ cf       = (0)
+ dlc      = (-2.09515e-07)
+ dwc      = (-10.0505e-07)
+ acde     = (1.0)
+ moin     = (24)
+ noff     = (1.75)
+ cgsl     = (0.6e-10)
+ cgdl     = (0.75e-10)
+ ckappa   = (0.8)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = (0)
+ mobmod   = (1)
+ rsh      = (8.4)
+ tox      = (1.319e-08*delr_tox_pmos90_10hv_bsim3v3)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (-2.037e-07-0.5e-06*dela_dl_pmos90_10hv_bsim3v3)
+ wint     = (3.6565e-07-0.5e-06*dela_dwox_pmos90_10hv_bsim3v3)
+ ww       = (-12.1355e-13)
+ u0       = ((160.526*delr_ubref_pmos90_10hv_bsim3v3)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pmos90_betaratio))
+ rdsw     = ((21982.6*delr_rsh_pmos90_10hv_bsim3v3)*delr_rdsw_relimo)
+ nsub     = (1.3986e+17*delr_nsub_pmos90_10hv_bsim3v3)
+ nch      = (1.46287e+17*delr_nsub_pmos90_10hv_bsim3v3)
+ vfb      = (-0.9719861+dela_vfb_pmos90_10hv_bsim3v3+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pmos90_vthratio)
+ vbm      = (-2.75)
+ xt       = (1.3887e-07)
+ alpha1   = (7.0e-04)
+ alpha0   = (0)
+ beta0    = (60)
+ a0       = ((1.287+dela_a0_pmos90_10hv_bsim3v3)*delr_a0_relimo)
+ ags      = (0.1099)
+ keta     = (0.01773)
+ ua       = (1.89591e-09)
+ ub       = (7.32008e-19)
+ uc       = (-1.11408e-10)
+ eta0     = (0)
+ etab     = (-0.0226608)
+ drout    = (11.916)
+ nlx      = (3.662e-07+1e-6*dela_vtl_pmos90_10hv_bsim3v3)
+ dvt0     = (0.86)
+ dvt1     = (0.11)
+ dvt2     = (0.15)
+ dvt0w    = (0.075+dela_vtm_pmos90_10hv_bsim3v3)
+ dvt1w    = (3.5e+04)
+ dvt2w    = (-1.5)
+ k3       = (-6.723+80*dela_vtw_pmos90_10hv_bsim3v3)
+ k3b      = (1.17095)
+ w0       = (1.37929e-06)
+ wr       = (0.9)
+ dwg      = (-3.30639e-08)
+ dwb      = (4.13877e-08)
+ b0       = (2.00279e-08+1e-06*dela_b0_pmos90_10hv_bsim3v3)
+ b1       = (0)
+ prwg     = (-0.115)
+ prwb     = (0.400239)
+ pclm     = (10.4217)
+ pdiblc1  = (3.9)
+ pdiblc2  = (2.33176e-08)
+ pdiblcb  = (-0.659352)
+ delta    = (0.06202)
+ vsat     = (277395.9)
+ ll       = (0.20832e-12)
+ lln      = (0.897378)
+ wwl      = (1.06931e-19+1e-18*dela_wwl_pmos90_10hv_bsim3v3)
+ lwl      = (2.78023e-18)
+ lwn      = (0.827245)
+ wln      = (1.148)
+ wwn      = (0.945)
+ wl       = (9.80226e-16)
+ lw       = (9.80226e-14)
+ voff     = (-0.175)
+ kt1      = (-0.336)
+ ute      = (-1.2012)
+ ua1      = (1.31e-09)
+ ub1      = (-4.01e-18)
+ uc1      = (-5.6e-11)
+ kt1l     = (-5.5e-08)
+ prt      = (22370)
+ kt2      = (-0.05)
+ noimod   = (noimod_pmos90_10hv_bsim3v3)
+ noia     = (noia_pmos90_10hv_bsim3v3)
+ noib     = (noib_pmos90_10hv_bsim3v3)
+ noic     = (noic_pmos90_10hv_bsim3v3)
+ ef       = (ef_pmos90_10hv_bsim3v3)
+ em       = (em_pmos90_10hv_bsim3v3)

model rdint resistor
+ rsh   = (7309.5575)
+ tc1   = (6.0e-03)
+ tc2   = (1.0e-05)

mpmos90_10hv_i (d_i g s b) pmos90_10hv l=l w=w ad=ad_i as=as_i pd=pd_i ps=ps_i nrd=nrd_i nrs=nrs_i m=ngtotal
ccsb_pmos90_10hv_m2m1_par (s b) capacitor c=csb_pmos90_10hv_m2m1_par
ccgs_pmos90_10hv_m2m1_par (g s) capacitor c=cgs_pmos90_10hv_m2m1_par
rrdint (d_i d) rdint w=(w+2.0) l=(7.01) m=(ngtotal)
xcdgoptub_sub (b sub) cdgoptub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=(1)

include "./smos10hv_ade_dfrt.scs" section=pmos90_10hv_dfrt
ends



//ahdl_include "./veriloga/v2.0.16/sphv.va"

subckt nmos45b_10hv (d g s b sub)
parameters
+ w		=1.8
+ l		=0.65
+ ng		=2
+ lpe		=0
+ ring          =1
+ soa           =1
+ selfheat	=1
+ mode_rthcth	=1
+ sti_dummy     =0

parameters
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nmos45b_vthratio        = (1.0/1.1212)
+    presto_nmos45b_ronratio        = (0.01/1.5)
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+ng_dmy)
+    ngtotal                        = (ngeff+(mod(ngeff,2)))
+    nga                            = (2)
+    ng_residue                     = (mod(ngtotal,nga))
+    number_of_nga                  = ((ngtotal-ng_residue)/nga)
+    nde_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(mod(ng_residue,2)))
+    nse_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(2-nde_residue))
+    nd_residue                     = ((((ng_residue<0)|(ng_residue>0)))*((ng_residue+nde_residue)/2))
+    ns_residue                     = ((((ng_residue<0)|(ng_residue>0)))*(1-nde_residue+nd_residue))
+    ndi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(nd_residue-nde_residue))
+    nsi_residue                    = ((((ng_residue<0)|(ng_residue>0)))*(ns_residue-nse_residue))
+    nde_nga                        = (mod(nga,2))
+    nse_nga                        = (2-nde_nga)
+    nd_nga                         = ((nga+nde_nga)/2)
+    ns_nga                         = (1-nde_nga+nd_nga)
+    ndi_nga                        = (nd_nga-nde_nga)
+    nsi_nga                        = (ns_nga-nse_nga)
+    nde_allnga                     = (number_of_nga*nde_nga)
+    nse_allnga                     = (number_of_nga*nse_nga)
+    nd_allnga                      = (number_of_nga*nd_nga)
+    ns_allnga                      = (number_of_nga*ns_nga)
+    ndi_allnga                     = (number_of_nga*ndi_nga)
+    nsi_allnga                     = (number_of_nga*nsi_nga)
+    nde                            = (nde_residue+nde_allnga)
+    nse                            = (nse_residue+nse_allnga)
+    nd                             = (nd_residue+nd_allnga)
+    ns                             = (ns_residue+ns_allnga)
+    ndi                            = (ndi_residue+ndi_allnga)
+    nsi                            = (nsi_residue+nsi_allnga)
+    nde_outside                    = ((ng_residue==0)*nde_nga+(((ng_residue<0)|(ng_residue>0)))*nde_residue)


// check these values against layout
+    lg2ct_s_nmos45b_10hv            = (0.12)
+    lg2ct_d_nmos45b_10hv            = (3.4)
+    lg2aa_s_nmos45b_10hv            = (0.375)
+    lg2aa_d_nmos45b_10hv            = (0)
+    lg2g_s_nmos45b_10hv             = (1.8)
+    lg2g_d_nmos45b_10hv             = (7.4)
+    wg2aa_se_nmos45b_10hv           = (0)
+    wg2aa_de_nmos45b_10hv           = (0)
+    wg2aa_si_nmos45b_10hv           = (0)
+    wg2aa_di_nmos45b_10hv           = (8.32)     // 2 times
+    wg2trench_nmos45b_10hv          = (10.32)
+    trench2se_body_nmos45b_10hv     = (1.8)
+    trench2se_nobody_nmos45b_10hv   = (0)
+    trench2de_nmos45b_10hv          = (0)
+    s2s_inside_nmos45b_10hv         = (1.05)
+    djunc                           = (2e-6)  //scale does not impact vertically, unit should be in meter
+    lactd                           =(1.0)
+    ldr1                            =(1.15)
+    ldrift                          =(1.70)
+    lgply2sti                       =(0.35)
+    wg2plye_nmos45b_10hv            =(9.30)     // 2 times distance of channel top edge to poly top edge
+    lsebc                           =(0.525)
+    lsti_g_nmos45b_10hv             =(0.7)
+    lsti_d_nmos45b_10hv             =(1.9)
+    wae2plye_isti_g_nmos45b_10hv    =(3.0)
+    wae2plye_isti_d_nmos45b_10hv    =(6.82)
+    as                              = ((lg2aa_s_nmos45b_10hv*(wg2aa_se_nmos45b_10hv+w)*nse+lg2g_s_nmos45b_10hv*(wg2aa_si_nmos45b_10hv+w)*nsi)/ngtotal)
+    ps                              = ((2*((lg2aa_s_nmos45b_10hv+wg2aa_se_nmos45b_10hv+w)*nse+(lg2g_s_nmos45b_10hv+wg2aa_si_nmos45b_10hv+w)*nsi))/ngtotal)
//**** calculation for d/b junction:JD and JD2 ********
+ ad2=(w+wg2aa_di_nmos45b_10hv)*(ldrift/2+lactd/2)
+ pd2=(lactd+ldrift)
+ ad=(w+wg2aa_di_nmos45b_10hv)*(ldr1+lgply2sti+ldrift/2)
+ pd=(2*(ldr1+lgply2sti+ldrift/2)+w+wg2aa_di_nmos45b_10hv)
// L and W for trench box calculation wg2trench_nmos45b_10hv should be 2*each side
+    length1                        = (trench2se_body_nmos45b_10hv*(1+(ng_residue==0)*(nse_nga-1))+trench2se_nobody_nmos45b_10hv*((((ng_residue<0)|(ng_residue>0)))*(nse_residue-1))+trench2de_nmos45b_10hv*nde_outside)
+    length2                        = (l*ngtotal+lg2aa_s_nmos45b_10hv*nse+lg2g_s_nmos45b_10hv*nsi+lg2aa_d_nmos45b_10hv*nde+lg2g_d_nmos45b_10hv*ndi+s2s_inside_nmos45b_10hv*(number_of_nga-1+(((ng_residue<0)|(ng_residue>0)))))
+    lbox2sub                       = (length1+length2)
+    wbox2sub                       = (wg2trench_nmos45b_10hv+w)
+    abox2sub                       = (lbox2sub*wbox2sub)
+    pbox2sub                       = (2*(lbox2sub+wbox2sub))
// metal par cap
+    length_m2m1                    = (wbox2sub-6.27)
+    width_m2m1                     = (0.33)
+    area_m2m1                      = (length_m2m1*width_m2m1)
+    perim_m2m1                     = (2*(length_m2m1+width_m2m1))
+    csb_nmos45b_10hv_m2m1          = ((number_of_nga+1)*(cfr_m2_m1*perim_m2m1+cpp_m2_m1*area_m2m1)+(cpp_m2_m1*2*0.33*0.725+cfr_m2_m1*2*0.725)*(number_of_nga-1))
+    csb_nmos45b_10hv_m2m1_par      = ((1-lpe)*csb_nmos45b_10hv_m2m1+lpe*1e-20)
+    cgs_nmos45b_10hv_m2m1_par      = ((1-lpe)*((l+0.5*lg2g_d_nmos45b_10hv)*ng*cfr_m2_m1)+lpe*1e-20)
//**** multi-ng scaling ****
+ thesatl_ng_del =   0.2
+ thesatl_ng_fac =   (ngeff/(ngeff+thesatl_ng_del))/(2/(2+thesatl_ng_del))
+ dvth_ng=w/(w+0.5)*1.65*0.0088*(ngeff-2)/ngeff
+ ecrit_ng_del=0
+ ecrit_ng_fac=(ngeff/(ngeff+ecrit_ng_del))/(2/(2+ecrit_ng_del))
+ rshldd_ng_fac=(1+(ngeff/(ngeff+6)-2/(2+6))*0.13)
+ rva_ng_fac=(ngeff+1)/(ngeff)/((2+1)/(2))
//**** geometry input for vfunctions: rthch_think_wafer()********
//**** vfunction:   (rth, cth)=rthcth_thin_wafer(weff, leff, rtc1, rtc2, ctc1, ctc2)
//**** description: calculate thermal resistance rth. inputs in micrometer. outputs in K/W.
//**** weff: effective width in micrometer for thermal injection.
//**** leff: effective length in micrometer for thermal injection.
+ w_heat_um	 =	w				// in unit of micrometer
+ l_heat_um	 =	((lsebc+lg2aa_s_nmos45b_10hv+l+ldr1+ldrift+lactd*0.5)*ng-2*lsebc)	// in unit of micrometer for ng>2
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat_um)*(l_heat_um)
+ aspr__1__=max((w_heat_um),(l_heat_um))/min((w_heat_um),(l_heat_um))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f=w/(w+2)*((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nmos45b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nmos45b_sphv_10hv)*ngeff		// for ng=1
+ cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff									// for ng=1
+ swshe = selfheat*enable_selfheat
+ rth_f_sw = (swshe>0)*rth_f
+ tfact_ecrit	=	1+(tc1_ecrit_nmos45b_sphv_10hv+tc2_ecrit_nmos45b_sphv_10hv*(temp-tnom))*(temp-tnom)
+ tfact_rth=pow((temp+273.15)/(27+273.15),0.5)

//**** calculation for poly over field parasitic cap: cgd_ply_fld ********

+ aply_fld_cgd=(0.5* lg2g_d_nmos45b_10hv *(wg2aa_di_nmos45b_10hv+w)-(wae2plye_isti_g_nmos45b_10hv+w)*lsti_g_nmos45b_10hv-0.5*(wae2plye_isti_d_nmos45b_10hv+w )*lsti_d_nmos45b_10hv-w*ldr1)*ng
+ pply_fld_cgd= 0
+ cgd_ply_fld=aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld

//cgd_ply_fld for dummy

+ aply_fld_cgd_dmy=(0.5* lg2g_d_nmos45b_10hv *(wg2aa_di_nmos45b_10hv+w)-(wae2plye_isti_g_nmos45b_10hv+w)*lsti_g_nmos45b_10hv-0.5*(wae2plye_isti_d_nmos45b_10hv+w )*lsti_d_nmos45b_10hv-w*ldr1)*ng_dmy
+ pply_fld_cgd_dmy= 0
+ cgd_ply_fld_dmy=aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld


//**** calculation for poly over field parasitic cap: cgb_ply_fld ********
+ aply_fld_cgb=((wg2plye_nmos45b_10hv*l)+(0.5*wg2plye_nmos45b_10hv-0.5*wg2aa_di_nmos45b_10hv)* lg2g_d_nmos45b_10hv )*ng
+ pply_fld_cgb= (wg2plye_nmos45b_10hv+2*(l+ldr1))*ng*3.5  //3.5 for cgb fitting
+ cgb_ply_fld=aply_fld_cgb*cpp_ply_fld+pply_fld_cgb*cfr_ply_fld


//cgb_ply_fld for dummy
+ aply_fld_cgb_dmy=((wg2plye_nmos45b_10hv*l)+(0.5*wg2plye_nmos45b_10hv-0.5*wg2aa_di_nmos45b_10hv)* lg2g_d_nmos45b_10hv )*ng_dmy
+ pply_fld_cgb_dmy =(wg2plye_nmos45b_10hv+2*(l+ldr1))*ng_dmy*3.5  //3.5 for cgb fitting
+ cgb_ply_fld_dmy=aply_fld_cgb_dmy*cpp_ply_fld+pply_fld_cgb_dmy*cfr_ply_fld


//**** calculation for m1 to poly gate capacitance, unit is micron ********
+ lpoly              = l+ldr1
+ cfr_ply_m1_s         = w*nom_cfr_m1_ply*ng*(1-lpe)+lpe*1e-19
+ cfr_m1_m2_bs         = (0.33*(w)*nom_cpp_m2_m1)*ns*(1-lpe)+lpe*1e-19

//** mismatch  and casing parameter ** //
+    nsmm_delr_tox_nmos45b_sphv_10hv 	= tmp_nsmm_delr_tox_nmos45b_sphv_10hv
+    nsmm_dela_vfb_nmos45b_sphv_10hv 	= tmp_nsmm_dela_vfb_nmos45b_sphv_10hv
+    nsmm_delr_nsub_nmos45b_sphv_10hv 	= tmp_nsmm_delr_nsub_nmos45b_sphv_10hv
+    nsmm_dela_dl_nmos45b_sphv_10hv  	= tmp_nsmm_dela_dl_nmos45b_sphv_10hv
+    nsmm_dela_dw_nmos45b_sphv_10hv  	= tmp_nsmm_dela_dw_nmos45b_sphv_10hv
+    nsmm_dela_vtl_nmos45b_sphv_10hv 	= tmp_nsmm_dela_vtl_nmos45b_sphv_10hv
+    nsmm_dela_vtw_nmos45b_sphv_10hv 	= tmp_nsmm_dela_vtw_nmos45b_sphv_10hv
+    nsmm_delr_mobref_nmos45b_sphv_10hv = tmp_nsmm_delr_mobref_nmos45b_sphv_10hv
+    nsmm_delr_rshl_nmos45b_sphv_10hv 	= tmp_nsmm_delr_rshl_nmos45b_sphv_10hv

+    tc_vth_mm                      = (1+(temp-27)*(-1.7e-3)*1.5)
+    delr_tox_nmos45b_sphv_10hv		=(nom_delr_tox_nmos45b_sphv_10hv*(1.0+nsig_delr_mosfet_thick_tox*sig_delr_tox_nmos45b_sphv_10hv+nsmm_delr_tox_nmos45b_sphv_10hv*smm_delr_tox_nmos45b_sphv_10hv(l,w)/sqrt(ng/2)))
//+    delr_tox_nmos45b_sphv_10hv		=(nom_delr_tox_nmos45b_sphv_10hv*(1.0+nsig_delr_tox_nmos45b_sphv_10hv*sig_delr_tox_nmos45b_sphv_10hv+nsmm_delr_tox_nmos45b_sphv_10hv*smm_delr_tox_nmos45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nmos45b_sphv_10hv		=(nom_dela_dw_nmos45b_sphv_10hv+nsig_dela_dw_nmos45b_sphv_10hv*sig_dela_dw_nmos45b_sphv_10hv+nsmm_dela_dw_nmos45b_sphv_10hv*smm_dela_dw_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_dl_nmos45b_sphv_10hv		=(nom_dela_dl_nmos45b_sphv_10hv+nsig_dela_dl_nmos45b_sphv_10hv*sig_dela_dl_nmos45b_sphv_10hv+nsmm_dela_dl_nmos45b_sphv_10hv*smm_dela_dl_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_dlw_nmos45b_sphv_10hv 	=(nom_dela_dlw_nmos45b_sphv_10hv+nsig_dela_dlw_nmos45b_sphv_10hv*sig_dela_dlw_nmos45b_sphv_10hv)
+    dela_vfb_nmos45b_sphv_10hv		=(nom_dela_vfb_nmos45b_sphv_10hv+nsig_dela_vfb_nmos45b_sphv_10hv*sig_dela_vfb_nmos45b_sphv_10hv+tc_vth_mm*nsmm_dela_vfb_nmos45b_sphv_10hv*smm_dela_vfb_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtl_nmos45b_sphv_10hv 	=(nom_dela_vtl_nmos45b_sphv_10hv+nsig_dela_vtl_nmos45b_sphv_10hv*sig_dela_vtl_nmos45b_sphv_10hv+tc_vth_mm*nsmm_dela_vtl_nmos45b_sphv_10hv*smm_dela_vtl_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtw_nmos45b_sphv_10hv 	=(nom_dela_vtw_nmos45b_sphv_10hv+nsig_dela_vtw_nmos45b_sphv_10hv*sig_dela_vtw_nmos45b_sphv_10hv+tc_vth_mm*nsmm_dela_vtw_nmos45b_sphv_10hv*smm_dela_vtw_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtm_nmos45b_sphv_10hv 	=(nom_dela_vtm_nmos45b_sphv_10hv+nsig_dela_vtm_nmos45b_sphv_10hv*sig_dela_vtm_nmos45b_sphv_10hv)
+    delr_mobref_nmos45b_sphv_10hv	=(nom_delr_mobref_nmos45b_sphv_10hv*(1.0+nsig_delr_mobref_nmos45b_sphv_10hv*sig_delr_mobref_nmos45b_sphv_10hv+nsmm_delr_mobref_nmos45b_sphv_10hv*smm_delr_mobref_nmos45b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_satl_nmos45b_sphv_10hv 	=(nom_delr_satl_nmos45b_sphv_10hv*(1.0+nsig_delr_satl_nmos45b_sphv_10hv*sig_delr_satl_nmos45b_sphv_10hv))
+    delr_rshl_nmos45b_sphv_10hv	=(nom_delr_rshl_nmos45b_sphv_10hv*(1.0+nsig_delr_rshl_nmos45b_sphv_10hv*sig_delr_rshl_nmos45b_sphv_10hv))*(1+nsmm_delr_rshl_nmos45b_sphv_10hv*smm_delr_rshl_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_nmos45b_sphv_10hv 	=(1+nsmm_delr_nsub_nmos45b_sphv_10hv*smm_delr_nsub_nmos45b_sphv_10hv(l,w)/sqrt(ng/2))

+    delr_cjs_nmos45b_sphv_10hv	=(nom_delr_cjs_nmos45b_sphv_10hv*(1.0+nsig_delr_cjs_nmos45b_sphv_10hv*sig_delr_cjs_nmos45b_sphv_10hv))
+    delr_cjd_nmos45b_sphv_10hv	=(nom_delr_cjd_nmos45b_sphv_10hv*(1.0+nsig_delr_cjd_nmos45b_sphv_10hv*sig_delr_cjd_nmos45b_sphv_10hv))
+    delr_jsideal_nmos45b_sphv_10hv	=(nom_delr_jsideal_nmos45b_sphv_10hv*exp(nsig_delr_jsideal_nmos45b_sphv_10hv*sig_delr_jsideal_nmos45b_sphv_10hv))
+    delr_jdideal_nmos45b_sphv_10hv	=(nom_delr_jdideal_nmos45b_sphv_10hv*exp(nsig_delr_jdideal_nmos45b_sphv_10hv*sig_delr_jdideal_nmos45b_sphv_10hv))
+    delr_jsnonideal_nmos45b_sphv_10hv	=(nom_delr_jsnonideal_nmos45b_sphv_10hv*exp(nsig_delr_jsnonideal_nmos45b_sphv_10hv*sig_delr_jsnonideal_nmos45b_sphv_10hv))
+    delr_jdnonideal_nmos45b_sphv_10hv	=(nom_delr_jdnonideal_nmos45b_sphv_10hv*exp(nsig_delr_jdnonideal_nmos45b_sphv_10hv*sig_delr_jdnonideal_nmos45b_sphv_10hv))
//+    tleak=1 //((temp+273.15)/(tnom+273.15))**0*exp(1.12/(2*8.62e-5*(tnom+273.15))-1.12/(2*8.62e-5*(temp+273.15)))
// cap for DGO
//+    epsox                          = (3.9*8.85e-12)
//+    tox                            = (1.32e-08*delr_tox_nmos45b_sphv_10hv)
//+    cox                            = (epsox/tox)

cgb_fld_d (g b) capacitor c=(cgb_ply_fld)
cgd_fld_d (g d) capacitor c=(cgd_ply_fld)

cgs_ply_m1_s (g s) capacitor c=(cfr_ply_m1_s+0.1e-15*ng)  //constant part for NS cgg
cbs_m1_m2_s (b s) capacitor c=(cfr_m1_m2_bs)

ccsb_nmos45_10hv_m2m1_par (s b) capacitor c=csb_nmos45b_10hv_m2m1_par
ccgs_nmos45_10hv_m2m1_par (g s) capacitor c=cgs_nmos45b_10hv_m2m1_par

xcdgontub_box_sub_10hv (b sub) cdgontub_box_sub_10hv area=(abox2sub*(1-lpe)) perim=(pbox2sub*(1-lpe)) soa=1

if (ng_dmy >= 2){

cgb_fld_d_dmy (s b) capacitor c=(cgb_ply_fld_dmy)

cgd_fld_d_dmy (s d) capacitor c=(cgd_ply_fld_dmy)

amost_dmy (d s s b dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=w ldr1=ldr1 mult=ng_dmy ad=(ad) pd=(pd) as=(as) ps=(ps) ad2=(ad2) pd2=(pd2)

}



amost (d g s b dtemp) sphvt_simkit
+ w          =w
+ l          =l
+ ldrift      	=ldrift
+ wdrift      	=w
+ ldr1          =ldr1
+ mult          =ng
+ ad          =(ad)
+ pd          =(pd)
+ as          =(as)
+ ps          =(ps)
+ ad2          =(ad2)
+ pd2          =(pd2)

model sphvt_simkit sphvt
+ type           = n
+ vdscale=1+0.02/(l*l)
+ tr           = 27
+ trj           = 27
+ swgeo       	= 1
+ swigate     	  = 0
+ swimpact    	   = 1
+ swgidl      	 = 1
+ swgedi      	 = 1
+ swjunc      	 = 2
+ swjunasym   	    = 1
+ swshe       	= selfheat*enable_selfheat
+ swtcec       	= 1
+ swimpdr     	  = 1
+ swexp       	= 1
+ swdelvtac   	    = 1
+ swnud       	= 1
+ swptest     	  = 0
+ swdrlin       =0
+ xvsat           = xvsat_nmos45b_sphv_10hv
+ qmc           = qmc_nmos45b_sphv_10hv
+ lvaro       	= lvaro_nmos45b_sphv_10hv
+ lvarl       	= lvarl_nmos45b_sphv_10hv
+ lvarw       	= lvarw_nmos45b_sphv_10hv+dela_dlw_nmos45b_sphv_10hv
+ lap           = lap_nmos45b_sphv_10hv+1e-6*dela_dl_nmos45b_sphv_10hv
+ wvaro       	= wvaro_nmos45b_sphv_10hv
+ wvarl       	= wvarl_nmos45b_sphv_10hv
+ wvarw       	= wvarw_nmos45b_sphv_10hv
+ wot           = wot_nmos45b_sphv_10hv+0.5e-6*dela_dw_nmos45b_sphv_10hv
+ dlq           = dlq_nmos45b_sphv_10hv
+ dwq           = dwq_nmos45b_sphv_10hv
+ vfbo           = vfbo_nmos45b_sphv_10hv+dela_vfb_nmos45b_sphv_10hv+dvth_ng+dela_vth_relimo+hvgsvthdegr*presto_nmos45b_vthratio
+ vfbl           = vfbl_nmos45b_sphv_10hv+dela_vtl_nmos45b_sphv_10hv
+ vfbw           = vfbw_nmos45b_sphv_10hv+dela_vtw_nmos45b_sphv_10hv
+ vfblw       	= vfblw_nmos45b_sphv_10hv+dela_vtm_nmos45b_sphv_10hv
+ stvfbo      	 = stvfbo_nmos45b_sphv_10hv
+ stvfbl      	 = stvfbl_nmos45b_sphv_10hv
+ stvfbw      	 = stvfbw_nmos45b_sphv_10hv
+ stvfblw     	  = stvfblw_nmos45b_sphv_10hv
+ toxo           = toxo_nmos45b_sphv_10hv*delr_tox_nmos45b_sphv_10hv
+ epsroxo     	  = epsroxo_nmos45b_sphv_10hv
+ nsubo       	= nsubo_nmos45b_sphv_10hv*delr_nsub_nmos45b_sphv_10hv
+ nsubw       	= nsubw_nmos45b_sphv_10hv
+ wseg           = wseg_nmos45b_sphv_10hv
+ npck           = npck_nmos45b_sphv_10hv
+ npckw       	= npckw_nmos45b_sphv_10hv
+ wsegp       	= wsegp_nmos45b_sphv_10hv
+ lpck           = lpck_nmos45b_sphv_10hv
+ lpckw       	= lpckw_nmos45b_sphv_10hv
+ fol1           = fol1_nmos45b_sphv_10hv
+ fol2           = fol2_nmos45b_sphv_10hv
+ facneffaco  	     = facneffaco_nmos45b_sphv_10hv
+ facneffacl  	     = facneffacl_nmos45b_sphv_10hv
+ facneffacw  	     = facneffacw_nmos45b_sphv_10hv
+ facneffaclw 	      = facneffaclw_nmos45b_sphv_10hv
+ gfacnudo    	   = gfacnudo_nmos45b_sphv_10hv
+ gfacnudl    	   = gfacnudl_nmos45b_sphv_10hv
+ gfacnudlexp 	      = gfacnudlexp_nmos45b_sphv_10hv
+ gfacnudw    	   = gfacnudw_nmos45b_sphv_10hv
+ gfacnudlw   	    = gfacnudlw_nmos45b_sphv_10hv
+ vsbnudo     	  = vsbnudo_nmos45b_sphv_10hv
+ dvsbnudo    	   = dvsbnudo_nmos45b_sphv_10hv
+ vnsubo      	 = vnsubo_nmos45b_sphv_10hv
+ nslpo       	= nslpo_nmos45b_sphv_10hv
+ dnsubo      	 = dnsubo_nmos45b_sphv_10hv
+ dphibo      	 = dphibo_nmos45b_sphv_10hv
+ dphibl      	 = dphibl_nmos45b_sphv_10hv
+ dphiblexp   	    = dphiblexp_nmos45b_sphv_10hv
+ dphibw      	 = dphibw_nmos45b_sphv_10hv
+ dphiblw     	  = dphiblw_nmos45b_sphv_10hv
+ delvtaco    	   = delvtaco_nmos45b_sphv_10hv
+ delvtacl    	   = delvtacl_nmos45b_sphv_10hv
+ delvtaclexp 	      = delvtaclexp_nmos45b_sphv_10hv
+ delvtacw    	   = delvtacw_nmos45b_sphv_10hv
+ delvtaclw   	    = delvtaclw_nmos45b_sphv_10hv
+ npo           = npo_nmos45b_sphv_10hv
+ npl           = npl_nmos45b_sphv_10hv
+ cto           = cto_nmos45b_sphv_10hv
+ ctl           = ctl_nmos45b_sphv_10hv
+ ctlexp      	 = ctlexp_nmos45b_sphv_10hv
+ ctw           = ctw_nmos45b_sphv_10hv
+ ctlw           = ctlw_nmos45b_sphv_10hv
+ toxovo      	 = toxovo_nmos45b_sphv_10hv*delr_tox_nmos45b_sphv_10hv
+ toxovdo     	  = toxovdo_nmos45b_sphv_10hv*delr_tox_nmos45b_sphv_10hv
+ lov           = lov_nmos45b_sphv_10hv
+ dlovd       	= dlovd_nmos45b_sphv_10hv
+ novo           = novo_nmos45b_sphv_10hv
+ novdo       	= novdo_nmos45b_sphv_10hv
+ cfl           = cfl_nmos45b_sphv_10hv
+ cflexp      	 = cflexp_nmos45b_sphv_10hv
+ cfw           = cfw_nmos45b_sphv_10hv
+ cfbo           = cfbo_nmos45b_sphv_10hv
+ uo           = uo_nmos45b_sphv_10hv*delr_mobref_nmos45b_sphv_10hv*delr_u0_relimo
+ fbet1       	= fbet1_nmos45b_sphv_10hv
+ fbet1w      	 = fbet1w_nmos45b_sphv_10hv
+ lp1           = lp1_nmos45b_sphv_10hv
+ lp1w           = lp1w_nmos45b_sphv_10hv
+ fbet2       	= fbet2_nmos45b_sphv_10hv
+ lp2           = lp2_nmos45b_sphv_10hv
+ betw1       	= betw1_nmos45b_sphv_10hv
+ betw2       	= betw2_nmos45b_sphv_10hv
+ wbet           = wbet_nmos45b_sphv_10hv
+ stbeto      	 = stbeto_nmos45b_sphv_10hv
+ stbetl      	 = stbetl_nmos45b_sphv_10hv
+ stbetw      	 = stbetw_nmos45b_sphv_10hv
+ stbetlw     	  = stbetlw_nmos45b_sphv_10hv
+ mueo           = mueo_nmos45b_sphv_10hv
+ muew           = muew_nmos45b_sphv_10hv
+ stmueo      	 = stmueo_nmos45b_sphv_10hv
+ themuo      	 = themuo_nmos45b_sphv_10hv
+ stthemuo    	   = stthemuo_nmos45b_sphv_10hv
+ cso           = cso_nmos45b_sphv_10hv
+ csl           = csl_nmos45b_sphv_10hv
+ cslexp      	 = cslexp_nmos45b_sphv_10hv
+ csw           = csw_nmos45b_sphv_10hv
+ cslw           = cslw_nmos45b_sphv_10hv
+ stcso       	= stcso_nmos45b_sphv_10hv
+ xcoro       	= xcoro_nmos45b_sphv_10hv
+ xcorl       	= xcorl_nmos45b_sphv_10hv
+ xcorw       	= xcorw_nmos45b_sphv_10hv
+ xcorlw      	 = xcorlw_nmos45b_sphv_10hv
+ stxcoro     	  = stxcoro_nmos45b_sphv_10hv
+ fetao       	= fetao_nmos45b_sphv_10hv
+ rsw1           = rsw1_nmos45b_sphv_10hv
+ rsw2           = rsw2_nmos45b_sphv_10hv
+ strso       	= strso_nmos45b_sphv_10hv
+ rsbo           = rsbo_nmos45b_sphv_10hv
+ rsgo           = rsgo_nmos45b_sphv_10hv
+ thesato     	  = thesato_nmos45b_sphv_10hv
+ thesatl     	  = thesatl_nmos45b_sphv_10hv*delr_satl_nmos45b_sphv_10hv*thesatl_ng_fac
+ thesatlexp  	     = thesatlexp_nmos45b_sphv_10hv
+ thesatw     	  = thesatw_nmos45b_sphv_10hv
+ thesatlw    	   = thesatlw_nmos45b_sphv_10hv
+ stthesato   	    = stthesato_nmos45b_sphv_10hv
+ stthesatl   	    = stthesatl_nmos45b_sphv_10hv
+ stthesatw   	    = stthesatw_nmos45b_sphv_10hv
+ stthesatlw  	     = stthesatlw_nmos45b_sphv_10hv
+ thesatbo    	   = thesatbo_nmos45b_sphv_10hv
+ thesatgo    	   = thesatgo_nmos45b_sphv_10hv
+ thesatgl    	   = thesatgl_nmos45b_sphv_10hv
+ thesatgw    	   = thesatgw_nmos45b_sphv_10hv
+ axo           = axo_nmos45b_sphv_10hv
+ axl           = axl_nmos45b_sphv_10hv
+ alpl           = alpl_nmos45b_sphv_10hv
+ alplexp     	  = alplexp_nmos45b_sphv_10hv
+ alpw           = alpw_nmos45b_sphv_10hv
+ alp1l1      	 = alp1l1_nmos45b_sphv_10hv
+ alp1lexp    	   = alp1lexp_nmos45b_sphv_10hv
+ alp1l2      	 = alp1l2_nmos45b_sphv_10hv
+ alp1w       	= alp1w_nmos45b_sphv_10hv
+ alp2l1      	 = alp2l1_nmos45b_sphv_10hv
+ alp2lexp    	   = alp2lexp_nmos45b_sphv_10hv
+ alp2l2      	 = alp2l2_nmos45b_sphv_10hv
+ alp2w       	= alp2w_nmos45b_sphv_10hv
+ vpo           = vpo_nmos45b_sphv_10hv
+ a1o           = a1o_nmos45b_sphv_10hv
+ a1l           = a1l_nmos45b_sphv_10hv
+ a1w           = a1w_nmos45b_sphv_10hv
+ a2o           = a2o_nmos45b_sphv_10hv
+ sta2o       	= sta2o_nmos45b_sphv_10hv
+ a3o           = a3o_nmos45b_sphv_10hv
+ a3l           = a3l_nmos45b_sphv_10hv
+ a3w           = a3w_nmos45b_sphv_10hv
+ a4o           = a4o_nmos45b_sphv_10hv
+ a4l           = a4l_nmos45b_sphv_10hv
+ a4w           = a4w_nmos45b_sphv_10hv
+ gcoo           = gcoo_nmos45b_sphv_10hv
+ iginvlw     	  = iginvlw_nmos45b_sphv_10hv
+ igovw       	= igovw_nmos45b_sphv_10hv
+ igovdw      	 = igovdw_nmos45b_sphv_10hv
+ stigo       	= stigo_nmos45b_sphv_10hv
+ gc2o           = gc2o_nmos45b_sphv_10hv
+ gc3o           = gc3o_nmos45b_sphv_10hv
+ chibo       	= chibo_nmos45b_sphv_10hv
+ agidlw      	 = agidlw_nmos45b_sphv_10hv
+ agidldw     	  = agidldw_nmos45b_sphv_10hv
+ bgidlo      	 = bgidlo_nmos45b_sphv_10hv
+ bgidldo     	  = bgidldo_nmos45b_sphv_10hv
+ stbgidlo    	   = stbgidlo_nmos45b_sphv_10hv
+ stbgidldo   	    = stbgidldo_nmos45b_sphv_10hv
+ cgidlo      	 = cgidlo_nmos45b_sphv_10hv
+ cgidldo     	  = cgidldo_nmos45b_sphv_10hv
+ cgbovl      	 = cgbovl_nmos45b_sphv_10hv
+ cfrw           = cfrw_nmos45b_sphv_10hv
+ cfrdw       	= cfrdw_nmos45b_sphv_10hv
+ fnto           = fnto_nmos45b_sphv_10hv
+ nfalw       	= nfalw_nmos45b_sphv_10hv
+ nfblw       	= nfblw_nmos45b_sphv_10hv
+ nfclw       	= nfclw_nmos45b_sphv_10hv
+ efo           = efo_nmos45b_sphv_10hv
+ lintnoi     	  = lintnoi_nmos45b_sphv_10hv
+ alpnoi      	 = alpnoi_nmos45b_sphv_10hv
+ kvthoweo    	   = kvthoweo_nmos45b_sphv_10hv
+ kvthowel    	   = kvthowel_nmos45b_sphv_10hv
+ kvthowew    	   = kvthowew_nmos45b_sphv_10hv
+ kvthowelw   	    = kvthowelw_nmos45b_sphv_10hv
+ kuoweo      	 = kuoweo_nmos45b_sphv_10hv
+ kuowel      	 = kuowel_nmos45b_sphv_10hv
+ kuowew      	 = kuowew_nmos45b_sphv_10hv
+ kuowelw     	  = kuowelw_nmos45b_sphv_10hv
+ rgo           = rgo_nmos45b_sphv_10hv
+ rsh           = rsh_nmos45b_sphv_10hv
+ rbulko      	 = rbulko_nmos45b_sphv_10hv
+ rwello      	 = rwello_nmos45b_sphv_10hv
+ rjunso      	 = rjunso_nmos45b_sphv_10hv/(w+dwrjunso_nmos45b_sphv_10hv)
+ rjundo      	 = rjundo_nmos45b_sphv_10hv/(w+dwrjundo_nmos45b_sphv_10hv)*(sqrt(l)/(sqrt(l)+2))
+ rint           = rint_nmos45b_sphv_10hv
+ rvpoly      	 = rvpoly_nmos45b_sphv_10hv
+ rshg           = rshg_nmos45b_sphv_10hv
+ dlsil       	= dlsil_nmos45b_sphv_10hv
+ saref       	= saref_nmos45b_sphv_10hv
+ sbref       	= sbref_nmos45b_sphv_10hv
+ wlod           = wlod_nmos45b_sphv_10hv
+ kuo           = kuo_nmos45b_sphv_10hv
+ kvsat       	= kvsat_nmos45b_sphv_10hv
+ tkuo           = tkuo_nmos45b_sphv_10hv
+ lkuo           = lkuo_nmos45b_sphv_10hv
+ wkuo           = wkuo_nmos45b_sphv_10hv
+ pkuo           = pkuo_nmos45b_sphv_10hv
+ llodkuo     	  = llodkuo_nmos45b_sphv_10hv
+ wlodkuo     	  = wlodkuo_nmos45b_sphv_10hv
+ kvtho       	= kvtho_nmos45b_sphv_10hv
+ lkvtho      	 = lkvtho_nmos45b_sphv_10hv
+ wkvtho      	 = wkvtho_nmos45b_sphv_10hv
+ pkvtho      	 = pkvtho_nmos45b_sphv_10hv
+ llodvth     	  = llodvth_nmos45b_sphv_10hv
+ wlodvth     	  = wlodvth_nmos45b_sphv_10hv
+ stetao      	 = stetao_nmos45b_sphv_10hv
+ lodetao     	  = lodetao_nmos45b_sphv_10hv
+ scref       	= scref_nmos45b_sphv_10hv
+ web           = web_nmos45b_sphv_10hv
+ wec           = wec_nmos45b_sphv_10hv
+ adr1o       	= adr1o_nmos45b_sphv_10hv
+ adr1l       	= adr1l_nmos45b_sphv_10hv
+ adr1w       	= adr1w_nmos45b_sphv_10hv
+ adr2o       	= adr2o_nmos45b_sphv_10hv
+ stadr2o     	  = stadr2o_nmos45b_sphv_10hv
+ adr3o       	= adr3o_nmos45b_sphv_10hv
+ adr3l       	= adr3l_nmos45b_sphv_10hv
+ adr3w       	= adr3w_nmos45b_sphv_10hv
+ adr4o       	= adr4o_nmos45b_sphv_10hv
+ adr4l       	= adr4l_nmos45b_sphv_10hv
+ adr4w       	= adr4w_nmos45b_sphv_10hv
+ adr5o       	= adr5o_nmos45b_sphv_10hv
+ adr5l       	= adr5l_nmos45b_sphv_10hv
+ adr5w       	= adr5w_nmos45b_sphv_10hv
+ bidr1o      	 = bidr1o_nmos45b_sphv_10hv
+ bidr1l      	 = bidr1l_nmos45b_sphv_10hv
+ bidr1w      	 = bidr1w_nmos45b_sphv_10hv
+ bidr2o      	 = bidr2o_nmos45b_sphv_10hv
+ bidr2w      	 = bidr2w_nmos45b_sphv_10hv
+ rtho           = rth_f_sw*tfact_rth
+ rthl           = 0
+ rthw           = 0
+ rthlw       	= 0
+ strtho      	 = strtho_nmos45b_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw       	= 0
+ rshldd       = rshldd_nmos45b_sphv_10hv*rshldd_ng_fac*delr_rshl_nmos45b_sphv_10hv*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nmos45b_ronratio)
+ xw           = xw_nmos45b_sphv_10hv
+ nwxw           = nwxw_nmos45b_sphv_10hv
+ xl           = xl_nmos45b_sphv_10hv
+ xlw           = xlw_nmos45b_sphv_10hv
+ dxlsat      	 = dxlsat_nmos45b_sphv_10hv
+ nst           = nst_nmos45b_sphv_10hv
+ ats           = ats_nmos45b_sphv_10hv
+ dfinf       	= dfinf_nmos45b_sphv_10hv
+ dfw           = dfw_nmos45b_sphv_10hv
+ dfl           = dfl_nmos45b_sphv_10hv
+ dflw           = dflw_nmos45b_sphv_10hv
+ dp           = dp_nmos45b_sphv_10hv
+ ecrit       	= ecrit_nmos45b_sphv_10hv*tfact_ecrit*((w+0.5)/w)*ecrit_ng_fac
+ ecorn       	= ecorn_nmos45b_sphv_10hv*tfact_ecrit*((w+0.5)/w)
+ du           = du_nmos45b_sphv_10hv
+ tc1           = tc1_nmos45b_sphv_10hv
+ tc2           = tc2_nmos45b_sphv_10hv
+ tc1l           = tc1l_nmos45b_sphv_10hv
+ tc2l           = tc2l_nmos45b_sphv_10hv
+ tc1w           = tc1w_nmos45b_sphv_10hv
+ tc2w           = tc2w_nmos45b_sphv_10hv
+ theacc      	 = theacc_nmos45b_sphv_10hv
+ theacc2     	  = theacc2_nmos45b_sphv_10hv
+ aacc     	  = aacc_nmos45b_sphv_10hv
+ rva           = rva_nmos45b_sphv_10hv*(w+2)/w*rva_ng_fac
+ dta           = dta_nmos45b_sphv_10hv
+ eais1area     = eais1area_nmos45b_sphv_10hv
+ eais2area     = eais2area_nmos45b_sphv_10hv
+ eairarea      = eairarea_nmos45b_sphv_10hv
+ eais1sti      = eais1sti_nmos45b_sphv_10hv
+ eais2sti      = eais2sti_nmos45b_sphv_10hv
+ eairsti       = eairsti_nmos45b_sphv_10hv
+ eais1gat      = eais1gat_nmos45b_sphv_10hv
+ eais2gat      = eais2gat_nmos45b_sphv_10hv
+ eairgat       = eairgat_nmos45b_sphv_10hv
+ eais1aread    = eais1aread_nmos45b_sphv_10hv
+ eais2aread    = eais2aread_nmos45b_sphv_10hv
+ eairaread     = eairaread_nmos45b_sphv_10hv
+ eais1stid     = eais1stid_nmos45b_sphv_10hv
+ eais2stid     = eais2stid_nmos45b_sphv_10hv
+ eairstid      = eairstid_nmos45b_sphv_10hv
+ eais1gatd     = eais1gatd_nmos45b_sphv_10hv
+ eais2gatd     = eais2gatd_nmos45b_sphv_10hv
+ eairgatd      = eairgatd_nmos45b_sphv_10hv
+ eais1aread2   = eais1aread2_nmos45b_sphv_10hv
+ eais2aread2   = eais2aread2_nmos45b_sphv_10hv
+ eairaread2    = eairaread2_nmos45b_sphv_10hv
+ eais1stid2    = eais1stid2_nmos45b_sphv_10hv
+ eais2stid2    = eais2stid2_nmos45b_sphv_10hv
+ eairstid2     = eairstid2_nmos45b_sphv_10hv
+ ikfarea               = ikfarea_nmos45b_sphv_10hv
+ ikflsti               = ikfarea_nmos45b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nmos45b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nmos45b_sphv_10hv
+ stikfsti              = stikfarea_nmos45b_sphv_10hv
+ stikfgat              = stikfarea_nmos45b_sphv_10hv
+ ikfaread              = ikfaread_nmos45b_sphv_10hv*(w/(w+dwikfaread_nmos45b_sphv_10hv))
+ ikflstid              = ikfaread_nmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos45b_sphv_10hv))
+ ikflgatd              = ikfaread_nmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos45b_sphv_10hv))
+ ikfaread2             = ikfaread_nmos45b_sphv_10hv*(w/(w+dwikfaread_nmos45b_sphv_10hv))
+ ikflstid2             = ikfaread_nmos45b_sphv_10hv*djunc*(w/(w+dwikfaread_nmos45b_sphv_10hv))
+ stikfaread             = stikfaread_nmos45b_sphv_10hv
+ stikfstid             = stikfaread_nmos45b_sphv_10hv
+ stikfgatd             = stikfaread_nmos45b_sphv_10hv
+ stikfaread2            = stikfaread_nmos45b_sphv_10hv
+ stikfstid2            = stikfaread_nmos45b_sphv_10hv
+ //*** junc cap parameters for s/b ***
+ //in ams2p0 synced cjarea, cjlsti and cjlgat three paramters
+ cjarea      	 =	cjarea_nmos45b_sphv_10hv*delr_cjs_nmos45b_sphv_10hv
+ cjlsti      	 =	0
+ cjlgat      	 =	cjarea_nmos45b_sphv_10hv*djunc*delr_cjs_nmos45b_sphv_10hv
+ vbiarea     	  =	vbiarea_nmos45b_sphv_10hv
+ vbisti      	 =	vbiarea_nmos45b_sphv_10hv
+ vbigat      	 =	vbiarea_nmos45b_sphv_10hv
+ parea       	=	parea_nmos45b_sphv_10hv
+ psti           =	parea_nmos45b_sphv_10hv
+ pgat           =	parea_nmos45b_sphv_10hv
+ //*** ideal current parameters for s/b ***
+ is1area 	 	  = is1area_nmos45b_sphv_10hv*delr_jsideal_nmos45b_sphv_10hv
+ stis1area 	 	  = stis1area_nmos45b_sphv_10hv
+ n1area 		 	  = n1area_nmos45b_sphv_10hv
+ is1lsti 	 	  = is1area_nmos45b_sphv_10hv*djunc*delr_jsideal_nmos45b_sphv_10hv
+ stis1sti	 	  = stis1area_nmos45b_sphv_10hv
+ n1sti 		 	  = n1area_nmos45b_sphv_10hv
+ is1lgat 	 	  = is1area_nmos45b_sphv_10hv*djunc*delr_jsideal_nmos45b_sphv_10hv
+ stis1gat 	 	  = stis1area_nmos45b_sphv_10hv
+ n1gat 		 	  = n1area_nmos45b_sphv_10hv
+ //*** non-ideal current parameters for s/b ***
+ is2area   		 = is2area_nmos45b_sphv_10hv*delr_jsnonideal_nmos45b_sphv_10hv
+ stis2area 		 = stis2area_nmos45b_sphv_10hv
+ n2area 	  		 = n2area_nmos45b_sphv_10hv
+ is2lsti   		 = is2area_nmos45b_sphv_10hv*djunc*delr_jsnonideal_nmos45b_sphv_10hv
+ stis2sti  		 = stis2area_nmos45b_sphv_10hv
+ n2sti 	  		 = n2area_nmos45b_sphv_10hv
+ is2lgat   		 = is2area_nmos45b_sphv_10hv*djunc*delr_jsnonideal_nmos45b_sphv_10hv
+ stis2gat  		 = stis2area_nmos45b_sphv_10hv
+ n2gat 	  		 = n2area_nmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for s/b ***
+ irarea 	 		  = irarea_nmos45b_sphv_10hv*delr_jsnonideal_nmos45b_sphv_10hv*(l+0.4)/l
+ stirarea 		  = stirarea_nmos45b_sphv_10hv
+ nrarea 	 		  = nrarea_nmos45b_sphv_10hv
+ irlsti 	 		  = irarea_nmos45b_sphv_10hv*djunc*delr_jsnonideal_nmos45b_sphv_10hv*(l+0.4)/l
+ stirsti  		  = stirarea_nmos45b_sphv_10hv
+ nrsti 	 		  = nrarea_nmos45b_sphv_10hv
+ irlgat 	 		  = irarea_nmos45b_sphv_10hv*djunc*delr_jsnonideal_nmos45b_sphv_10hv*(l+0.4)/l
+ stirgat  		  = stirarea_nmos45b_sphv_10hv
+ nrgat 	 		  = nrarea_nmos45b_sphv_10hv
+ // *** rr for s/b ***
+ ttarea   	 = ttarea_nmos45b_sphv_10hv
+ ttlsti   	 = ttlsti_nmos45b_sphv_10hv
+ ttlgat   	 = ttlgat_nmos45b_sphv_10hv
+ //*** junc cap parameters for d/b ***
+ cjaread    	  =	  cjaread_nmos45b_sphv_10hv*delr_cjd_nmos45b_sphv_10hv
+ cjlstid    	  =	  0
+ cjlgatd    	  =	  cjaread_nmos45b_sphv_10hv*djunc*delr_cjd_nmos45b_sphv_10hv
+ vbiaread   	   =	  vbiaread_nmos45b_sphv_10hv
+ vbistid    	  =	  vbistid_nmos45b_sphv_10hv
+ vbigatd    	  =	  vbigatd_nmos45b_sphv_10hv
+ paread     	 =	  paread_nmos45b_sphv_10hv
+ pstid      	=	  paread_nmos45b_sphv_10hv
+ pgatd      	=	  paread_nmos45b_sphv_10hv
+ //*** ideal current parameters for d/b ***
+ is1aread   		 = is1aread_nmos45b_sphv_10hv*delr_jdideal_nmos45b_sphv_10hv
+ stis1aread 		 = stis1aread_nmos45b_sphv_10hv
+ n1aread    		 = n1aread_nmos45b_sphv_10hv
+ is1lstid   		 = is1aread_nmos45b_sphv_10hv*djunc*delr_jdideal_nmos45b_sphv_10hv*0
+ stis1stid  		 = stis1aread_nmos45b_sphv_10hv
+ n1stid 	   		 = n1aread_nmos45b_sphv_10hv
+ is1lgatd   		 = is1aread_nmos45b_sphv_10hv*djunc*delr_jdideal_nmos45b_sphv_10hv
+ stis1gatd  		 = stis1aread_nmos45b_sphv_10hv
+ n1gatd 	   		 = n1aread_nmos45b_sphv_10hv
+ //*** non-ideal current parameters for d/b ***
+ is2aread   		  = is2aread_nmos45b_sphv_10hv*delr_jdnonideal_nmos45b_sphv_10hv
+ stis2aread 		  = stis2aread_nmos45b_sphv_10hv
+ n2aread    		  = n2aread_nmos45b_sphv_10hv
+ is2lstid   		  = is2aread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv*0
+ stis2stid  		  = stis2aread_nmos45b_sphv_10hv
+ n2stid 	   		  = n2aread_nmos45b_sphv_10hv
+ is2lgatd   		  = is2aread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv
+ stis2gatd  		  = stis2aread_nmos45b_sphv_10hv
+ n2gatd 	   		  = n2aread_nmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d/b ***
+ iraread   		  = iraread_nmos45b_sphv_10hv*delr_jdnonideal_nmos45b_sphv_10hv
+ stiraread 		  = stiraread_nmos45b_sphv_10hv
+ nraread   		  = nraread_nmos45b_sphv_10hv
+ irlstid   		  = iraread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv*0
+ stirstid  		  = stiraread_nmos45b_sphv_10hv
+ nrstid 	  		  = nraread_nmos45b_sphv_10hv
+ irlgatd   		  = iraread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv
+ stirgatd  		  = stiraread_nmos45b_sphv_10hv
+ nrgatd 	  		  = nraread_nmos45b_sphv_10hv
+ // *** rr  for d/b ***
+ ttaread  	  = ttaread_nmos45b_sphv_10hv
+ ttlstid  	  = ttlstid_nmos45b_sphv_10hv
+ ttlgatd  	  = ttlgatd_nmos45b_sphv_10hv
+ //*** junc cap parameters for d2/b ***
+ cjaread2   	   =	      cjaread_nmos45b_sphv_10hv*delr_cjd_nmos45b_sphv_10hv
+ cjlstid2   	   =	      cjaread_nmos45b_sphv_10hv*djunc*delr_cjd_nmos45b_sphv_10hv
+ vbiaread2  	    =	      vbiaread_nmos45b_sphv_10hv
+ vbistid2   	   =	      vbiaread_nmos45b_sphv_10hv
+ paread2    	  =	      paread_nmos45b_sphv_10hv
+ pstid2     	 =	      paread_nmos45b_sphv_10hv
+ //*** ideal current parameters for d2/b ***
+ is1aread2   		  = is1aread_nmos45b_sphv_10hv*delr_jdideal_nmos45b_sphv_10hv
+ stis1aread2 		  = stis1aread_nmos45b_sphv_10hv
+ n1aread2    		  = n1aread_nmos45b_sphv_10hv
+ is1lstid2   		  = is1aread_nmos45b_sphv_10hv*djunc*delr_jdideal_nmos45b_sphv_10hv*0
+ stis1stid2  		  = stis1aread_nmos45b_sphv_10hv
+ n1stid2     		  = n1aread_nmos45b_sphv_10hv
+ //*** non-ideal current parameters for d2/b ***
+ is2aread2   		  = is2aread_nmos45b_sphv_10hv*delr_jdnonideal_nmos45b_sphv_10hv
+ stis2aread2 		  = stis2aread_nmos45b_sphv_10hv
+ n2aread2    		  = n2aread_nmos45b_sphv_10hv
+ is2lstid2   		  = is2aread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv*0
+ stis2stid2  		  = stis2aread_nmos45b_sphv_10hv
+ n2stid2     		  = n2aread_nmos45b_sphv_10hv
+ //*** non-ideal reverse current parameters for d2/b ***
+ iraread2   		  = iraread_nmos45b_sphv_10hv*delr_jdnonideal_nmos45b_sphv_10hv
+ stiraread2 		  = stiraread_nmos45b_sphv_10hv
+ nraread2   		  = nraread_nmos45b_sphv_10hv
+ irlstid2   		  = iraread_nmos45b_sphv_10hv*djunc*delr_jdnonideal_nmos45b_sphv_10hv*0
+ stirstid2  		  = stiraread_nmos45b_sphv_10hv
+ nrstid2    		  = nraread_nmos45b_sphv_10hv
+ // *** ??  for d2/b ***
+ ttaread2 	   = ttaread2_nmos45b_sphv_10hv
+ ttlstid2 	   = ttlstid2_nmos45b_sphv_10hv




include "./smos10hv_ade_dfrt.scs" section=nmos45b_10hv_dfrt
ends

// pmos45b_10hv



//ahdl_include "./veriloga/v2.0.16/sphv.va"


subckt pmos45b_10hv (d g s b sub)
parameters
+ l=1.0
+ w=1.8
+ ng=2
+ lpe=0
+ soa=1
+ selfheat=1
+ sti_dummy=0

parameters
+ mode_rthcth=1
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pmos45b_vthratio    = 1.0*(0.0037*1/l+0.9906)
+    presto_pmos45b_ronratio    = 0.01/1.0/(0.3*l+1.0)
+ nde=(fmod(ng,2))
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)         //treat two adjacent sources separated by body as one
+ ndi=(nd-nde)
+ nsi=(ns-nse)          //treat two adjacent sources separated by body as one

//dummy parameters
+ ng_dmy=(2*sti_dummy)
+ ngeff=(ng+ng_dmy)
+ ns_eff = (1+ngeff/2)
+ ndi_eff=(ngeff/2)
+ nsi_eff=((ngeff-2)/2)

+ nga=((sti_dummy==0)*6 + (1-(sti_dummy==0))*2)
+ ng_residue=(mod(ng,nga))
+ number_of_nga=((ng-ng_residue)/nga)
+ number_of_body_internal=number_of_nga-1+(ng_residue>0)
+ number_of_body_edge=number_of_nga+1-number_of_body_internal

+ ng_residue_eff=(mod(ngeff,nga))
+ number_of_nga_eff=((ngeff-ng_residue_eff)/nga)
+ number_of_body_internal_eff=number_of_nga_eff-1+(ng_residue_eff>0)
+ number_of_body_edge_eff=number_of_nga_eff+1-number_of_body_internal_eff

+ ns_strip=ns_eff+number_of_body_internal_eff
+ ns_strip_shared_nga=(nga/2-1)*number_of_nga_eff
+ ns_strip_shared_residue=(ng_residue_eff/2-1)
+ ns_strip_shared=ns_strip_shared_nga+ns_strip_shared_residue
+ ns_strip_edge=ns_strip-ns_strip_shared


//calculation of junction instance parameters
+    lacts    = 0.375
+    lacts_shared = 0.42
+    ldr1     = 0.65
+    lsplit   = 0.35
+    ldrift   = 1.7
+    lactd    = 0.69
+    wdrift   = (w)
+    wg2aa_di=3.73*2   //poly edge to active
+    wnhv2aa_di=3.24*2  //nhv inner edge to active

+    as_i=((lacts*w)*ns_strip_edge+(lacts_shared*w)*ns_strip_shared)/ngeff
+    ps_i=(2*(lacts+w)*ns_strip_edge+2*(lacts_shared+w)*ns_strip_shared)/ngeff

+    length_ad = (ldr1+lsplit)+ldrift/2
+    width_ad  = w+wnhv2aa_di
+    length_ad2= lactd/2+ldrift/2
+    ad_i      = length_ad*width_ad
+    pd_i      = length_ad*2+width_ad
+    ad2_i     = length_ad2*width_ad
+    pd2_i     = length_ad2*2

//calculation for nbl/psub junction
+    lg2pepi_s    = 2.175  // dt to poly end with body
+    lg2pepi_s_nb    = 1.485  // dt to poly end without body
+    lp2p_d    =  6.09 	   // drain nhv end to nhv end
+    lb2b_s    = 0.42	   // poly end to ploy at internal source without body
+    lb2b_s_b  = 1.8	   // poly end to ploy at internal source with body
+    wg2pepi   = 4.24     // width active side to DT interal edge
+    xbody     = ((lg2pepi_s-lg2pepi_s_nb)*number_of_body_edge_eff+lg2pepi_s_nb*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff+number_of_body_internal_eff*(lb2b_s_b-lb2b_s))
+    ybody     = (wg2pepi*2+w)
+    abody     = (xbody*ybody)
+    pbody     = (2*(xbody+ybody))

//calculation of parasitic cap cbs_m2m1 (m1-m2 overlap vertical part)
//no overlap

//calculation of parasitic cap cgd_m1m2 (m1-m2 no overlap in pcell)

//calculation of parasitic cap cgs_m1m2 (m1-m2 no overlap)

//**** calculation for m1 to poly gate capacitance, Cgs, unit is micron ********
+ cfr_ply_m1_s         = w*nom_cfr_m1_ply*ng*(1-lpe)+lpe*1e-19


//calculation of poly over field oxide parasitic cap:cgd_ply_fld
+   lnhv2ply_d=1.8   //nhv to poly edge
+   wae2plye_isti_g=1.5*2
+   wae2plye_isti_g_d=2.28*2
+   lpoly_hole=0.7  //small hole
+   lpoly_hole_d=2.49  //big hole enclose drain active
+   aply_fld_cgd=((lnhv2ply_d+lpoly_hole_d/2)*(wnhv2aa_di+w)-(wae2plye_isti_g+w)*lpoly_hole-(wae2plye_isti_g_d+w)*(lpoly_hole_d/2)-ldr1*w)*ng
+   pply_fld_cgd= (2*lpoly_hole+wae2plye_isti_g*2+w+lpoly_hole_d+wae2plye_isti_g_d+w)*ng
+   cgd_ply_fld=aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld

//cgd_ply_fld for dummy
+   aply_fld_cgd_dmy =((lnhv2ply_d+lpoly_hole_d/2)*(wnhv2aa_di+w)-(wae2plye_isti_g+w)*lpoly_hole-(wae2plye_isti_g_d+w)*(lpoly_hole_d/2)-ldr1*w)*ng_dmy
+   pply_fld_cgd_dmy = (2*lpoly_hole+wae2plye_isti_g*2+w+lpoly_hole_d+wae2plye_isti_g_d+w)*ng_dmy
+   cgd_ply_fld_dmy =aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld


//calculation of poly over field oxide parasitic cal:cap cgb_ply_fld
+ aply_fld_cgb=(wg2aa_di*l+lp2p_d*(wg2aa_di-wnhv2aa_di)/2)*ng
+ pply_fld_cgb=(wg2aa_di+2*l+lp2p_d)*ng
+ cgb_ply_fld =(cpp_ply_fld*aply_fld_cgb+pply_fld_cgb*cfr_ply_fld)


//cgb_ply_fld for dummy
