+ rva      = (rva_nld45b_tlp_sphv_10hv)
+ dta      = (dta_nld45b_tlp_sphv_10hv)
+ trj      = (trj_nld45b_tlp_sphv_10hv)
+ cjarea   = (cjarea_nld45b_tlp_sphv_10hv)
+ cjlsti   = (cjlsti_nld45b_tlp_sphv_10hv)
+ cjlgat   = (cjlgat_nld45b_tlp_sphv_10hv)
+ vbiarea  = (vbiarea_nld45b_tlp_sphv_10hv)
+ vbisti   = (vbisti_nld45b_tlp_sphv_10hv)
+ vbigat   = (vbigat_nld45b_tlp_sphv_10hv)
+ parea    = (parea_nld45b_tlp_sphv_10hv)
+ psti     = (psti_nld45b_tlp_sphv_10hv)
+ pgat     = (pgat_nld45b_tlp_sphv_10hv)
+ is1area  = (is1area_nld45b_tlp_sphv_10hv)
+ ttarea   = (ttarea_nld45b_tlp_sphv_10hv)
+ is2area  = (is2area_nld45b_tlp_sphv_10hv)
+ irarea   = (irarea_nld45b_tlp_sphv_10hv)
+ stis1area = (stis1area_nld45b_tlp_sphv_10hv)
+ stis2area = (stis2area_nld45b_tlp_sphv_10hv)
+ stirarea = (stirarea_nld45b_tlp_sphv_10hv)
+ n1area   = (n1area_nld45b_tlp_sphv_10hv)
+ n2area   = (n2area_nld45b_tlp_sphv_10hv)
+ nrarea   = (nrarea_nld45b_tlp_sphv_10hv)
+ is1lsti  = (is1lsti_nld45b_tlp_sphv_10hv)
+ ttlsti   = (ttlsti_nld45b_tlp_sphv_10hv)
+ is2lsti  = (is2lsti_nld45b_tlp_sphv_10hv)
+ irlsti   = (irlsti_nld45b_tlp_sphv_10hv)
+ stis1sti = (stis1sti_nld45b_tlp_sphv_10hv)
+ stis2sti = (stis2sti_nld45b_tlp_sphv_10hv)
+ stirsti  = (stirsti_nld45b_tlp_sphv_10hv)
+ n1sti    = (n1sti_nld45b_tlp_sphv_10hv)
+ n2sti    = (n2sti_nld45b_tlp_sphv_10hv)
+ nrsti    = (nrsti_nld45b_tlp_sphv_10hv)
+ is1lgat  = (is1lgat_nld45b_tlp_sphv_10hv)
+ ttlgat   = (ttlgat_nld45b_tlp_sphv_10hv)
+ is2lgat  = (is2lgat_nld45b_tlp_sphv_10hv)
+ irlgat   = (irlgat_nld45b_tlp_sphv_10hv)
+ stis1gat = (stis1gat_nld45b_tlp_sphv_10hv)
+ stis2gat = (stis2gat_nld45b_tlp_sphv_10hv)
+ stirgat  = (stirgat_nld45b_tlp_sphv_10hv)
+ n1gat    = (n1gat_nld45b_tlp_sphv_10hv)
+ n2gat    = (n2gat_nld45b_tlp_sphv_10hv)
+ nrgat    = (nrgat_nld45b_tlp_sphv_10hv)
+ cjaread  = (cjaread_nld45b_tlp_sphv_10hv*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlstid  = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlgatd  = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ vbiaread = (vbiaread_nld45b_tlp_sphv_10hv)
+ vbistid  = (vbistid_nld45b_tlp_sphv_10hv)
+ vbigatd  = (vbigatd_nld45b_tlp_sphv_10hv)
+ paread   = (paread_nld45b_tlp_sphv_10hv)
+ pstid    = (pstid_nld45b_tlp_sphv_10hv)
+ pgatd    = (pgatd_nld45b_tlp_sphv_10hv)
+ is1aread = (is1aread_nld45b_tlp_sphv_10hv*delr_is_nld45b_tlp_sphv_10hv)
+ ttaread  = (ttaread_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2aread = (is2aread_nld45b_tlp_sphv_10hv*delr_is2_nld45b_tlp_sphv_10hv)
+ iraread  = (iraread_nld45b_tlp_sphv_10hv*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1aread = (stis1aread_nld45b_tlp_sphv_10hv)
+ stis2aread = (stis2aread_nld45b_tlp_sphv_10hv)
+ stiraread = (stiraread_nld45b_tlp_sphv_10hv)
+ n1aread  = (n1aread_nld45b_tlp_sphv_10hv)
+ n2aread  = (n2aread_nld45b_tlp_sphv_10hv)
+ nraread  = (nraread_nld45b_tlp_sphv_10hv)
+ is1lstid = (is1aread_nld45b_tlp_sphv_10hv*djunc*delr_is_nld45b_tlp_sphv_10hv)
+ ttlstid  = (ttlstid_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lstid = (is2aread_nld45b_tlp_sphv_10hv*djunc*delr_is2_nld45b_tlp_sphv_10hv)
+ irlstid  = (iraread_nld45b_tlp_sphv_10hv*djunc*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1stid = (stis1stid_nld45b_tlp_sphv_10hv)
+ stis2stid = (stis2stid_nld45b_tlp_sphv_10hv)
+ stirstid = (stirstid_nld45b_tlp_sphv_10hv)
+ n1stid   = (n1stid_nld45b_tlp_sphv_10hv)
+ n2stid   = (n2stid_nld45b_tlp_sphv_10hv)
+ nrstid   = (nrstid_nld45b_tlp_sphv_10hv)
+ is1lgatd = (is1aread_nld45b_tlp_sphv_10hv*djunc*delr_is_nld45b_tlp_sphv_10hv)
+ ttlgatd  = (ttlgatd_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lgatd = (is2aread_nld45b_tlp_sphv_10hv*djunc*delr_is2_nld45b_tlp_sphv_10hv)
+ irlgatd  = (iraread_nld45b_tlp_sphv_10hv*djunc*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1gatd = (stis1gatd_nld45b_tlp_sphv_10hv)
+ stis2gatd = (stis2gatd_nld45b_tlp_sphv_10hv)
+ stirgatd = (stirgatd_nld45b_tlp_sphv_10hv)
+ n1gatd   = (n1gatd_nld45b_tlp_sphv_10hv)
+ n2gatd   = (n2gatd_nld45b_tlp_sphv_10hv)
+ nrgatd   = (nrgatd_nld45b_tlp_sphv_10hv)
+ cjaread2 = (cjaread_nld45b_tlp_sphv_10hv*delr_cj_nld45b_tlp_sphv_10hv)
+ cjlstid2 = (cjaread_nld45b_tlp_sphv_10hv*djunc*delr_cj_nld45b_tlp_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld45b_tlp_sphv_10hv)
+ vbistid2 = (vbistid2_nld45b_tlp_sphv_10hv)
+ paread2  = (paread2_nld45b_tlp_sphv_10hv)
+ pstid2   = (pstid2_nld45b_tlp_sphv_10hv)
+ is1aread2 = (is1aread_nld45b_tlp_sphv_10hv)
+ ttaread2 = (ttaread2_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2aread2 = (is2aread_nld45b_tlp_sphv_10hv)
+ iraread2 = (iraread2_nld45b_tlp_sphv_10hv*delr_ir_nld45b_tlp_sphv_10hv)
+ stis1aread2 = (stis1aread_nld45b_tlp_sphv_10hv)
+ stis2aread2 = (stis2aread_nld45b_tlp_sphv_10hv)
+ stiraread2 = (stiraread2_nld45b_tlp_sphv_10hv)
+ n1aread2 = (n1aread2_nld45b_tlp_sphv_10hv)
+ n2aread2 = (n2aread2_nld45b_tlp_sphv_10hv)
+ nraread2 = (nraread2_nld45b_tlp_sphv_10hv)
+ is1lstid2 = (is1aread_nld45b_tlp_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_nld45b_tlp_sphv_10hv)*(1+dwtt/weff)
+ is2lstid2 = (is2aread_nld45b_tlp_sphv_10hv*djunc)
+ irlstid2 = (iraread2_nld45b_tlp_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld45b_tlp_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld45b_tlp_sphv_10hv)
+ stirstid2 = (stirstid2_nld45b_tlp_sphv_10hv)
+ n1stid2  = (n1stid2_nld45b_tlp_sphv_10hv)
+ n2stid2  = (n2stid2_nld45b_tlp_sphv_10hv)
+ nrstid2  = (nrstid2_nld45b_tlp_sphv_10hv)
+ eais1area		= eais1area_nld45b_tlp_sphv_10hv
+ eais2area		= eais2area_nld45b_tlp_sphv_10hv
+ eairarea		= eairarea_nld45b_tlp_sphv_10hv
+ eais1sti		= eais1sti_nld45b_tlp_sphv_10hv
+ eais2sti		= eais2sti_nld45b_tlp_sphv_10hv
+ eairsti	  = eairsti_nld45b_tlp_sphv_10hv
+ eais1gat		= eais1gat_nld45b_tlp_sphv_10hv
+ eais2gat		= eais2gat_nld45b_tlp_sphv_10hv
+ eairgat	  = eairgat_nld45b_tlp_sphv_10hv
+ eais1aread		= eais1aread_nld45b_tlp_sphv_10hv
+ eais2aread		= eais2aread_nld45b_tlp_sphv_10hv
+ eairaread		= eairaread_nld45b_tlp_sphv_10hv
+ eais1stid		= eais1stid_nld45b_tlp_sphv_10hv
+ eais2stid		= eais2stid_nld45b_tlp_sphv_10hv
+ eairstid		= eairstid_nld45b_tlp_sphv_10hv
+ eais1gatd		= eais1gatd_nld45b_tlp_sphv_10hv
+ eais2gatd		= eais2gatd_nld45b_tlp_sphv_10hv
+ eairgatd		= eairgatd_nld45b_tlp_sphv_10hv
+ eais1aread2		= eais1aread2_nld45b_tlp_sphv_10hv
+ eais2aread2		= eais2aread2_nld45b_tlp_sphv_10hv
+ eairaread2		= eairaread2_nld45b_tlp_sphv_10hv
+ eais1stid2		= eais1stid2_nld45b_tlp_sphv_10hv
+ eais2stid2		= eais2stid2_nld45b_tlp_sphv_10hv
+ eairstid2		= eairstid2_nld45b_tlp_sphv_10hv
+ ikfarea               = ikfarea_nld45b_tlp_sphv_10hv
+ ikflsti               = ikfarea_nld45b_tlp_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld45b_tlp_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld45b_tlp_sphv_10hv
+ stikfsti              = stikfarea_nld45b_tlp_sphv_10hv
+ stikfgat              = stikfarea_nld45b_tlp_sphv_10hv
+ ikfaread              = ikfaread_nld45b_tlp_sphv_10hv*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflstid              = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflgatd              = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikfaread2             = ikfaread_nld45b_tlp_sphv_10hv*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ ikflstid2             = ikfaread_nld45b_tlp_sphv_10hv*djunc*(w/(w+dwikfaread_nld45b_tlp_sphv_10hv))
+ stikfaread             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfstid             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfgatd             = stikfaread_nld45b_tlp_sphv_10hv
+ stikfaread2            = stikfaread_nld45b_tlp_sphv_10hv
+ stikfstid2            = stikfaread_nld45b_tlp_sphv_10hv




include "./smos10hv_ade_dfrt.scs" section=nld45b_tlp_10hv_dfrt
ends

// nld100_10hv

subckt nld100_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model, release value
// they are instance parameters, but invisible to the designers,  this means CDF will not use those parameters.
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
//*support mismatch
//*******************************************************************************************************
+    nsmm_delr_tox_nld100_sphv_10hv  = tmp_nsmm_delr_tox_nld100_sphv_10hv
+    nsmm_dela_dw_nld100_sphv_10hv   = tmp_nsmm_dela_dw_nld100_sphv_10hv
+    nsmm_dela_vfb_nld100_sphv_10hv  = tmp_nsmm_dela_vfb_nld100_sphv_10hv
+    nsmm_delr_mobref_nld100_sphv_10hv = tmp_nsmm_delr_mobref_nld100_sphv_10hv
+    nsmm_delr_rshl_nld100_sphv_10hv = tmp_nsmm_delr_rshl_nld100_sphv_10hv
+    nsmm_delr_nsub_nld100_sphv_10hv = tmp_nsmm_delr_nsub_nld100_sphv_10hv
+    l                              = (0.65)
//*******************************************************************************************************
//*relimo model parameters
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+    vfbmm_temp = sqrt(1-2.45e-3*(temp-27))
+    delr_tox_nld100_sphv_10hv      = (nom_delr_tox_nld100_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld100_sphv_10hv+nsmm_delr_tox_nld100_sphv_10hv*smm_delr_tox_nld100_sphv_10hv(l,w)/sqrt(ng)))
//+    delr_tox_nld100_sphv_10hv      = (nom_delr_tox_nld100_sphv_10hv*(1.0+nsig_delr_tox_nld100_sphv_10hv*sig_delr_tox_nld100_sphv_10hv+nsmm_delr_tox_nld100_sphv_10hv*smm_delr_tox_nld100_sphv_10hv(l,w)/sqrt(ng)))
+    dela_dw_nld100_sphv_10hv       = (nsmm_dela_dw_nld100_sphv_10hv*smm_dela_dw_nld100_sphv_10hv(l,w)/sqrt(ng))
+    dela_vfb_nld100_sphv_10hv      = (nom_dela_vfb_nld100_sphv_10hv+nsig_dela_vfb_nld100_sphv_10hv*sig_dela_vfb_nld100_sphv_10hv+nsmm_dela_vfb_nld100_sphv_10hv*smm_dela_vfb_nld100_sphv_10hv(l,w)*(vfbmm_temp)/sqrt(ng))
+    dela_vfbw_nld100_sphv_10hv     = (nom_dela_vfbw_nld100_sphv_10hv+nsig_dela_vfbw_nld100_sphv_10hv*sig_dela_vfbw_nld100_sphv_10hv)
+    delr_mobref_nld100_sphv_10hv   = (1.0+nsmm_delr_mobref_nld100_sphv_10hv*smm_delr_mobref_nld100_sphv_10hv(l,w)/sqrt(ng))
+    dela_vdscale_nld100_sphv_10hv   = (nom_dela_vdscale_nld100_sphv_10hv+nsig_dela_vdscale_nld100_sphv_10hv*sig_dela_vdscale_nld100_sphv_10hv)
+    dela_vdscalew_nld100_sphv_10hv   = (nom_dela_vdscalew_nld100_sphv_10hv+nsig_dela_vdscalew_nld100_sphv_10hv*sig_dela_vdscalew_nld100_sphv_10hv)
+    dela_thesatgo_nld100_sphv_10hv   = (nom_dela_thesatgo_nld100_sphv_10hv+nsig_dela_thesatgo_nld100_sphv_10hv*sig_dela_thesatgo_nld100_sphv_10hv)
+    delr_rshl_nld100_sphv_10hv     = (nom_delr_rshl_nld100_sphv_10hv*(1.0+nsig_delr_rshl_nld100_sphv_10hv*sig_delr_rshl_nld100_sphv_10hv+nsmm_delr_rshl_nld100_sphv_10hv*smm_delr_rshl_nld100_sphv_10hv(l,w)/sqrt(ng)))
+    dela_xw_nld100_sphv_10hv       = (nom_dela_xw_nld100_sphv_10hv+nsig_dela_xw_nld100_sphv_10hv*sig_dela_xw_nld100_sphv_10hv)
+    delr_nsub_nld100_sphv_10hv     = (1+nsmm_delr_nsub_nld100_sphv_10hv*smm_delr_nsub_nld100_sphv_10hv(l,w)/sqrt(ng))
+    delr_cj_nld100_sphv_10hv 	        =(nom_delr_cj_nld100_sphv_10hv*(1.0+nsig_delr_cj_nld100_sphv_10hv*sig_delr_cj_nld100_sphv_10hv))
+    delr_is_nld100_sphv_10hv    	=(nom_delr_is_nld100_sphv_10hv*exp(nsig_delr_is_nld100_sphv_10hv*sig_delr_is_nld100_sphv_10hv))
+    delr_is2_nld100_sphv_10hv    	=(nom_delr_is2_nld100_sphv_10hv*exp(nsig_delr_is2_nld100_sphv_10hv*sig_delr_is2_nld100_sphv_10hv))
+    delr_ir_nld100_sphv_10hv 	        =(nom_delr_ir_nld100_sphv_10hv*exp(nsig_delr_ir_nld100_sphv_10hv*sig_delr_ir_nld100_sphv_10hv))

//dummy gate parameters
+    ng_dmy=(2*sti_dummy)
+    ngeff=(ng+ng_dmy)
+    ndi_eff=(ngeff/2)
+    nsi_eff=((ngeff-2)/2)


//*******************************************************************************************************
//*global and process variables
//*******************************************************************************************************
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    djunc                          = (2.5e-6)  //should not scaled by scale as it is vertical


//*********************************************************************************
//*  fixed parameters and expressions
//*********************************************************************************
+    lch                            = (0.65) // alias to l
+    lacc                           = (0.6)  // alias to ldr1
//+    wdel                           = (2.15)*(1-fem)// =wncom-w
+    ld                             = (6.455)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lch+lacc+ld)  //this distance is the same inside the device and at the edge finger.
+    lflap 			    = (2.15)
+    xiso                           = (1.275)
+    yiso                           = ((10.96)*(1-fem))
+    wdrift                         = (w)
+    ldrift                         = (5.5)
+    ldr1                           = (0.6)
+    lacts                          = (0.455)
+    lactd                          = (1.21)

//*calculated dimensions
+    numbernplus                    = (int_round((w-(0.18*2+0.42)*(1-fem))/0.84))+1*(1-fem)
+    weff                           = (numbernplus*0.42)	// will apply to uoeff=uo*weff/w

//*extracted dimensions
+    lovlap                         = (0.00)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrs                           = (0.02)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrd                           = (0)       // tune par for cfr_ply_s & cfr_ply_d
+    tfact_ecrit=1+(tc1_ecrit_nld100_sphv_10hv+tc2_ecrit_nld100_sphv_10hv*(temp-tnom))*(temp-tnom)

//*simple model factor
+    swdrlin  = (0)
+    fac_rshldd = ((swdrlin==0)+(swdrlin==2)*1.01)


//*------------------------------------
//*calculations for parasitic diodes
//*------------------------------------
//*ncom to pepi (drain to source+body)
+    rncom_end                      = 1.25
+    od2ncom                        = 9.2
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*od2ncom*(1-fem))
+    ancom                          = (xncom*yncom-0.5*(4-pi4models)*rncom_end*rncom_end*(1-fem))
+    pncom                          = (2*xncom+yncom-(4-pi4models)*rncom_end)*(1-fem)
//*junc par for sphv input
+    pd2_i          =2*(0.5*ldrift+0.5*lactd)*(1-fem)
+    pd_i           =(pncom-pd2_i)
+    ad2_i          =((0.5*ldrift+0.5*lactd)*yncom)
+    ad_i           =(ancom-ad2_i)
+    as_i           =0
+    ps_i           =0

//*capacitance to sub ng total
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub*(1-fem)+ysub))

//*-------------------------------------------------------
//*source drain capacitance area and length calculations
//*m1 and m2 parasitic capacitances ignored
//*-------------------------------------------------------
//*poly over field parasitic to drain and source
+    od2poly_w        =10.35
+    xpoly            =(lch+lacc+ld)
+    ypoly            =(w+od2poly_w*2*(1-fem))
+    lsplit           =0.7
+    od2poly_inner_l  =3
+    rhole        =0.6
+    od2poly_inner_w  =4.5

+    aplyfld_s        =xpoly*ypoly-ancom-w*lch
+    pplyfld_s        =(od2poly_w+xpoly)*2*(1-fem)
+    cgs_ply_fld_nld100=(aplyfld_s*cpp_ply_fld+pplyfld_s*cfr_ply_fld)	//ng=1

+    xhole            =(od2poly_inner_l+0.5*lactd)
+    yhole            =(w+od2poly_inner_w*2*(1-fem))
+    ahole            =xhole*yhole-(4-pi4models)*0.5*rhole*rhole*(1-fem)
+    phole            =(yhole+xhole*2*(1-fem)-(4-pi4models)*rhole*(1-fem))
+    psplit           =(w+(od2poly_inner_w*4+lsplit*2)*(1-fem))
+    aplyfld_d        =(ancom-w*lacc-lsplit*yhole-ahole)
+    pplyfld_d        =(psplit+phole)
+    cgd_ply_fld_nld100=(aplyfld_d*cpp_ply_fld+0*pplyfld_d*cfr_ply_fld)	//ng=1, turn off pplyfld_d to fit cgd data

// calculation for poly over field parasitic capaciance
+ dwcgdfldmoscap=32.5*(1-fem)
+ dwcgd_ply_fld=15*(1-fem)
+ cgd_ply_fld=0.85e-16*(w+dwcgd_ply_fld)

// parameters for veriloga
+ vp_nld100_10hv = (45-4)
+ dvp_nld100_10hv = (7)
+ type_nld100_10hv = (1)

//*accumulation area (poly over accum area)
//+ area_accum    = (((w+2*wdel*(1-fem))*lacc+0.5*pi4models*(1-fem)*((ld+lacc)*(ld+lacc)-(ld*ld))))
//+ ldr1_i	=((area_accum/w))   //ng=1 for sphv input

//*fringing capacitance (source side edge of poly wall)
+    lfring_s   = (w)

//*fringing capacitance (drain side edge of poly wall to aa)
+    lfring_d   = (w)

+    cfr_ply_s=(lfring_s)*(lfrs+lovlap)*cpp_ply_sdt   //ng=1
+    cfr_ply_d=(lfring_d)*(lfrd+lovlap)*cpp_ply_sdt   //ng=1


//*parasitic psp mosfet (poly over active on phv+pepi not over channel)
//+    xmosend                        = (2*(lch+lacc+ld))
//+    ymosend                        = (9.85)
//+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*wdel+0.5*pi4models*(ld+lacc)*(ld+lacc))))
//+    wmosend                        = ((amosend/lch)*(1-fem)+fem*1e-3)  //ng=1


//*m1 to poly gate capacitance:
// *check final pcell later
// *total width of source contacts facing gate
+    number_ct_s                    = (int_round((w+(2*8.85-0.18)*(1-fem))/(0.18+0.24))+1*(1-fem))
+    lfr_ct_ply_s                   = (number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-(2*0.075+0.18)*(1-fem))/(0.18+0.24))+1*(1-fem))
+    lfr_ct_ply_d                   = (number_ct_d*0.18)
+    lfr_m1_ply_s                   = ((w+2*8.85*(1-fem))-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (w-lfr_ct_ply_d)
+    cfr_s_ply_met_nld100_sphv_10hv           = (nom_cfr_s_ply_met_nld100_sphv_10hv*(nom_delr_cfr_s_ply_met_nld100_sphv_10hv+nsig_delr_cfr_s_ply_met_nld100_sphv_10hv*sig_delr_cfr_s_ply_met_nld100_sphv_10hv))
+    cfr_d_ply_met_nld100_sphv_10hv           = (nom_cfr_d_ply_met_nld100_sphv_10hv*(nom_delr_cfr_d_ply_met_nld100_sphv_10hv+nsig_delr_cfr_d_ply_met_nld100_sphv_10hv*sig_delr_cfr_d_ply_met_nld100_sphv_10hv))
+    cfr_s_ply_m1ct_nld100_sphv_10hv          = (nom_cfr_s_ply_m1ct_nld100_sphv_10hv*(nom_delr_cfr_s_ply_m1ct_nld100_sphv_10hv+nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv*sig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv))
+    cfr_d_ply_m1ct_nld100_sphv_10hv          = (nom_cfr_d_ply_m1ct_nld100_sphv_10hv*(nom_delr_cfr_d_ply_m1ct_nld100_sphv_10hv+nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv*sig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv))

+    cgs_ply_m1=(lfr_m1_ply_s*cfr_s_ply_met_nld100_sphv_10hv+lfr_ct_ply_s*cfr_s_ply_m1ct_nld100_sphv_10hv)
+    cgd_ply_m1=(lfr_m1_ply_d*cfr_d_ply_met_nld100_sphv_10hv+lfr_ct_ply_d*cfr_d_ply_m1ct_nld100_sphv_10hv)


//*poly gate resistance calculations
+    rgate                       = (rply*(w+2*10.35*(1-fem))/((lch+lacc+lflap)*3))

//**parameters for multi ng
+    fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*0.048*(1-fem))
+    fac_a_ng_vfbo= ((ngeff/(ngeff+0.2)-2/(2+0.2))*(-0.045))*(1-fem)
+    fac_r_ng_uo=(1+(ngeff/(ngeff+2)-2/(2+2))*0.11*(w/(w+4.0))*(1-fem))
+    fac_r_ng_ecrit=(1+(ngeff/(ngeff+1)-2/(2+1))*0.5*(w/(w+10.0))*(1-fem))

// parameters for the self-heating
+    w_heat    =w
+    l_heat    =lcell*ng
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f     =((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld100_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld100_sphv_10hv)*ngeff  //ng=1
+    cth_f     =((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff		//ng=1

// parasitic capacitance caused by dummy gate
//+     aply_fld_cgd_dmy=(0)
//+     pply_fld_cgd_dmy=(0)
//+     cgd_ply_fld_dmy=(0)

// parameters for the D/B diode trr
+ tt_nld100_10hv = 1.0e-9*maxa(6000*1/(w+20),0,1e-12)

// parameters for the BV diode
+ dcbv_nld100_10hv = (125)

// bin parameters
+    dwecrit =(dwecrit_nld100_sphv_10hv)*(1-fem)
+    dwecritw =(dwecritw_nld100_sphv_10hv)*(1-fem)

// BV diode model card:
model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt   = (1e12)
+ tnom    = (27)
+ is      = (1e-30)
+ n       = (1.0)
+ cj      = (1e-30)
+ pta     = (0)
+ tlevc   = (2)
+ tlev    = (2)
+ bv      = (dcbv_nld100_10hv+bvdss_shift)
+ ibv     = (1e-5/1e-12)

model pspmoscap psp103t type=n
+tr=27
+toxo=toxo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv
+dphibo=dphibo_nld100_sphv_10hv-0.35
+dphibw=(dphibw_nld100_sphv_10hv+3.75)*(1-fem)
+vfbo=vfbo_nld100_sphv_10hv+dela_vfb_nld100_sphv_10hv-0.2
+nsubo=nsubo_nld100_sphv_10hv
+nsubw=(nsubw_nld100_sphv_10hv-1.4)*(1-fem)
+rtho=1e18 ctho=0 dwq=(0*(1-fem))

model sphvt_simkit sphvt
+ type     = (n)
+ vdscale  = (vdscale_nld100_sphv_10hv+dela_vdscale_nld100_sphv_10hv+(vdscalew_nld100_sphv_10hv+dela_vdscalew_nld100_sphv_10hv)*(1-fem)/w)
+ vdscaleb = (vdscaleb_nld100_sphv_10hv)
+ stvdscale= (stvdscale_nld100_sphv_10hv+(stvdscalew_nld100_sphv_10hv)*(1-fem)/w)
+ ctgo     = (0.02)
+ ctbo     = (0)
+ stcto    = (1.3)
+ strthao  = (1.55)
+ tr	   = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (1)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ qmc	   = (qmc_nld100_sphv_10hv)
+ lvaro    = (lvaro_nld100_sphv_10hv)
+ lvarl    = (lvarl_nld100_sphv_10hv)
+ lvarw    = (lvarw_nld100_sphv_10hv*(1-fem))
+ lap	   = (lap_nld100_sphv_10hv)
+ wvaro    = (wvaro_nld100_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld100_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld100_sphv_10hv*(1-fem))
+ wot	   = ((wot_nld100_sphv_10hv+0.5e-6*dela_dw_nld100_sphv_10hv)*(1-fem))
+ dlq	   = (dlq_nld100_sphv_10hv)
+ dwq	   = (dwq_nld100_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld100_sphv_10hv+dela_vfb_nld100_sphv_10hv+dela_vth_relimo+fac_a_ng_vfbo)
+ vfbl     = (vfbl_nld100_sphv_10hv)
+ vfbw     = ((vfbw_nld100_sphv_10hv+dela_vfbw_nld100_sphv_10hv)*(1-fem))
+ vfblw    = (vfblw_nld100_sphv_10hv*(1-fem))
+ stvfbo   = (stvfbo_nld100_sphv_10hv)*(1-maxa(-9e-3*(temp-27), 0, 1e-12))
+ stvfbl   = (stvfbl_nld100_sphv_10hv)
+ stvfbw   = (stvfbw_nld100_sphv_10hv*(1-maxa(-18e-2*(temp-27), 0, 1e-12))*(1-fem))
+ stvfblw  = (stvfblw_nld100_sphv_10hv*(1-fem))
+ toxo     = (toxo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ epsroxo  = (epsroxo_nld100_sphv_10hv)
+ nsubo    = (nsubo_nld100_sphv_10hv*delr_nsub_nld100_sphv_10hv)
+ nsubw    = (nsubw_nld100_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld100_sphv_10hv)
+ npck     = (npck_nld100_sphv_10hv)
+ npckw    = (npckw_nld100_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld100_sphv_10hv)
+ lpck     = (lpck_nld100_sphv_10hv)
+ lpckw    = (lpckw_nld100_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld100_sphv_10hv)
+ fol2     = (fol2_nld100_sphv_10hv)
+ facneffaco = (facneffaco_nld100_sphv_10hv)
+ facneffacl = (facneffacl_nld100_sphv_10hv)
+ facneffacw = (facneffacw_nld100_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld100_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld100_sphv_10hv)
+ gfacnudl = (gfacnudl_nld100_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld100_sphv_10hv)
+ gfacnudw = (gfacnudw_nld100_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld100_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld100_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld100_sphv_10hv)
+ vnsubo   = (vnsubo_nld100_sphv_10hv)
+ nslpo    = (nslpo_nld100_sphv_10hv)
+ dnsubo   = (dnsubo_nld100_sphv_10hv)
+ dphibo   = (dphibo_nld100_sphv_10hv)
+ dphibl   = (dphibl_nld100_sphv_10hv)
+ dphiblexp = (dphiblexp_nld100_sphv_10hv)
+ dphibw   = (dphibw_nld100_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld100_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld100_sphv_10hv)
+ delvtacl = (delvtacl_nld100_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld100_sphv_10hv)
+ delvtacw = (delvtacw_nld100_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_nld100_sphv_10hv*(1-fem))
+ npo	   = (npo_nld100_sphv_10hv)
+ npl	   = (npl_nld100_sphv_10hv)
+ cto	   = (cto_nld100_sphv_10hv)
+ ctl	   = (ctl_nld100_sphv_10hv)
+ ctlexp   = (ctlexp_nld100_sphv_10hv)
+ ctw	   = (ctw_nld100_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld100_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ toxovdo  = (toxovdo_nld100_sphv_10hv*delr_tox_nld100_sphv_10hv)
+ lov	   = (lov_nld100_sphv_10hv)
+ dlovd    = (dlovd_nld100_sphv_10hv)
+ novo     = (novo_nld100_sphv_10hv)
+ novdo    = (novdo_nld100_sphv_10hv)
+ cfl	   = (cfl_nld100_sphv_10hv)
+ cflexp   = (cflexp_nld100_sphv_10hv)
+ cfw	   = (cfw_nld100_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld100_sphv_10hv)
+ uo	   = (uo_nld100_sphv_10hv*(weff/w)*delr_mobref_nld100_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_nld100_sphv_10hv)
+ fbet1w   = (fbet1w_nld100_sphv_10hv*(1-fem))
+ lp1	   = (lp1_nld100_sphv_10hv)
+ lp1w     = (lp1w_nld100_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld100_sphv_10hv)
+ lp2	   = (lp2_nld100_sphv_10hv)
+ betw1    = (betw1_nld100_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld100_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld100_sphv_10hv)
+ stbeto   = (stbeto_nld100_sphv_10hv)
+ stbetl   = (stbetl_nld100_sphv_10hv)
+ stbetw   = (stbetw_nld100_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_nld100_sphv_10hv*(1-fem))
+ mueo     = (mueo_nld100_sphv_10hv)
+ muew     = (muew_nld100_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld100_sphv_10hv)
+ themuo   = (themuo_nld100_sphv_10hv)
+ stthemuo = (stthemuo_nld100_sphv_10hv)
+ cso	   = (cso_nld100_sphv_10hv)
+ csl	   = (csl_nld100_sphv_10hv)
+ cslexp   = (cslexp_nld100_sphv_10hv)
+ csw	   = (csw_nld100_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld100_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld100_sphv_10hv)
+ xcoro    = (xcoro_nld100_sphv_10hv)
+ xcorl    = (xcorl_nld100_sphv_10hv)
+ xcorw    = (xcorw_nld100_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_nld100_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_nld100_sphv_10hv)
+ fetao    = (fetao_nld100_sphv_10hv)
+ rsw1     = (rsw1_nld100_sphv_10hv)
+ rsw2     = (rsw2_nld100_sphv_10hv*(1-fem))
+ strso    = (strso_nld100_sphv_10hv)
+ rsbo     = (rsbo_nld100_sphv_10hv)
+ rsgo     = (rsgo_nld100_sphv_10hv)
+ thesato  = ((thesato_nld100_sphv_10hv)*(1+maxa(-0.5e-2*(w/(w+(1-fem)*3.0))*(temp-27),0,1e-9)))
+ thesatl  = (thesatl_nld100_sphv_10hv)
+ thesatlexp = (thesatlexp_nld100_sphv_10hv)
+ thesatw  = (thesatw_nld100_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld100_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld100_sphv_10hv)
+ stthesatl = (stthesatl_nld100_sphv_10hv)
+ stthesatw = (stthesatw_nld100_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_nld100_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_nld100_sphv_10hv)
+ thesatgo = (thesatgo_nld100_sphv_10hv+dela_thesatgo_nld100_sphv_10hv)
+ thesatgl = (thesatgl_nld100_sphv_10hv)
+ thesatgw = ((thesatgw_nld100_sphv_10hv)*(1-fem))
+ axo	   = (axo_nld100_sphv_10hv)
+ axl	   = (axl_nld100_sphv_10hv)
+ alpl     = (alpl_nld100_sphv_10hv)
+ alplexp  = (alplexp_nld100_sphv_10hv)
+ alpw     = (alpw_nld100_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld100_sphv_10hv)
+ alp1lexp = (alp1lexp_nld100_sphv_10hv)
+ alp1l2   = (alp1l2_nld100_sphv_10hv)
+ alp1w    = (alp1w_nld100_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld100_sphv_10hv)
+ alp2lexp = (alp2lexp_nld100_sphv_10hv)
+ alp2l2   = (alp2l2_nld100_sphv_10hv)
+ alp2w    = (alp2w_nld100_sphv_10hv*(1-fem))
+ vpo	   = (vpo_nld100_sphv_10hv)
+ a1o	   = (a1o_nld100_sphv_10hv)
+ a1l	   = (a1l_nld100_sphv_10hv)
+ a1w	   = (a1w_nld100_sphv_10hv*(1-fem))
+ a2o	   = (a2o_nld100_sphv_10hv)
+ sta2o    = (sta2o_nld100_sphv_10hv)
+ a3o	   = (a3o_nld100_sphv_10hv)
+ a3l	   = (a3l_nld100_sphv_10hv)
+ a3w	   = (a3w_nld100_sphv_10hv*(1-fem))
+ a4o	   = (a4o_nld100_sphv_10hv)
+ a4l	   = (a4l_nld100_sphv_10hv)
+ a4w	   = (a4w_nld100_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld100_sphv_10hv)
+ iginvlw  = (iginvlw_nld100_sphv_10hv)
+ igovw    = (igovw_nld100_sphv_10hv)
+ igovdw   = (igovdw_nld100_sphv_10hv)
+ stigo    = (stigo_nld100_sphv_10hv)
+ gc2o     = (gc2o_nld100_sphv_10hv)
+ gc3o     = (gc3o_nld100_sphv_10hv)
+ chibo    = (chibo_nld100_sphv_10hv)
+ agidlw   = (agidlw_nld100_sphv_10hv)
+ agidldw  = (agidldw_nld100_sphv_10hv)
+ bgidlo   = (bgidlo_nld100_sphv_10hv)
+ bgidldo  = (bgidldo_nld100_sphv_10hv)
+ stbgidlo = (stbgidlo_nld100_sphv_10hv)
+ stbgidldo = (stbgidldo_nld100_sphv_10hv)
+ cgidlo   = (cgidlo_nld100_sphv_10hv)
+ cgidldo  = (cgidldo_nld100_sphv_10hv)
+ cgbovl   = (cgbovl_nld100_sphv_10hv)
+ cfrw     = (cfrw_nld100_sphv_10hv)
+ cfrdw    = (cfrdw_nld100_sphv_10hv)
+ fnto     = (fnto_nld100_sphv_10hv)
+ nfalw    = (nfalw_nld100_sphv_10hv)
+ nfblw    = (nfblw_nld100_sphv_10hv)
+ nfclw    = (nfclw_nld100_sphv_10hv)
+ efo	   = (efo_nld100_sphv_10hv)
+ lintnoi  = (lintnoi_nld100_sphv_10hv)
+ alpnoi   = (alpnoi_nld100_sphv_10hv)
+ kvthoweo = (kvthoweo_nld100_sphv_10hv)
+ kvthowel = (kvthowel_nld100_sphv_10hv)
+ kvthowew = (kvthowew_nld100_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_nld100_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_nld100_sphv_10hv)
+ kuowel   = (kuowel_nld100_sphv_10hv)
+ kuowew   = (kuowew_nld100_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_nld100_sphv_10hv*(1-fem))
+ rgo	   = (rgo_nld100_sphv_10hv)
+ rsh	   = (rsh_nld100_sphv_10hv)
+ rbulko   = (rbulko_nld100_sphv_10hv)
+ rwello   = (rwello_nld100_sphv_10hv)
+ rjunso   = (rjunso_nld100_sphv_10hv/(w+(1-fem)*dwrjunso_nld100_sphv_10hv))
+ rjundo   = ((rjundo_nld100_sphv_10hv/(w+(1-fem)*dwrjundo_nld100_sphv_10hv))*(1+0.4e-3*(temp-27)))
+ rint     = (rint_nld100_sphv_10hv)
+ rvpoly   = (rvpoly_nld100_sphv_10hv)
+ rshg     = (rshg_nld100_sphv_10hv)
+ dlsil    = (dlsil_nld100_sphv_10hv)
+ saref    = (saref_nld100_sphv_10hv)
+ sbref    = (sbref_nld100_sphv_10hv)
+ wlod     = (wlod_nld100_sphv_10hv)
+ kuo	   = (kuo_nld100_sphv_10hv)
+ kvsat    = (kvsat_nld100_sphv_10hv)
+ tkuo     = (tkuo_nld100_sphv_10hv)
+ lkuo     = (lkuo_nld100_sphv_10hv)
+ wkuo     = (wkuo_nld100_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_nld100_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_nld100_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld100_sphv_10hv)
+ kvtho    = (kvtho_nld100_sphv_10hv)
+ lkvtho   = (lkvtho_nld100_sphv_10hv)
+ wkvtho   = (wkvtho_nld100_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_nld100_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_nld100_sphv_10hv)
+ wlodvth  = (wlodvth_nld100_sphv_10hv)
+ stetao   = (stetao_nld100_sphv_10hv)
+ lodetao  = (lodetao_nld100_sphv_10hv)
+ scref    = (scref_nld100_sphv_10hv)
+ web	   = (web_nld100_sphv_10hv)
+ wec	   = (wec_nld100_sphv_10hv)
+ adr1o    = (adr1o_nld100_sphv_10hv)
+ adr1l    = (adr1l_nld100_sphv_10hv)
+ adr1w    = (adr1w_nld100_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_nld100_sphv_10hv)
+ stadr2o  = (stadr2o_nld100_sphv_10hv)
+ adr3o    = (adr3o_nld100_sphv_10hv)
+ adr3l    = (adr3l_nld100_sphv_10hv)
+ adr3w    = (adr3w_nld100_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_nld100_sphv_10hv)
+ adr4l    = (adr4l_nld100_sphv_10hv)
+ adr4w    = (adr4w_nld100_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_nld100_sphv_10hv)
+ adr5l    = (adr5l_nld100_sphv_10hv)
+ adr5w    = (adr5w_nld100_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_nld100_sphv_10hv)
+ bidr1l   = (bidr1l_nld100_sphv_10hv)
+ bidr1w   = (bidr1w_nld100_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_nld100_sphv_10hv)
+ bidr2w   = (bidr2w_nld100_sphv_10hv*(1-fem))
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld100_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld100_sphv_10hv*delr_rshl_nld100_sphv_10hv*delr_rdsw_relimo*fac_r_ng_rshldd)*fac_rshldd)
+ xw	   = ((xw_nld100_sphv_10hv+1.0e-6*dela_xw_nld100_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld100_sphv_10hv*(1-fem))
+ xl	   = (xl_nld100_sphv_10hv)
+ xlw	   = (xlw_nld100_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld100_sphv_10hv)
+ nst	   = (nst_nld100_sphv_10hv)
+ ats	   = (ats_nld100_sphv_10hv)
+ dfinf    = (dfinf_nld100_sphv_10hv)
+ dfw	   = (dfw_nld100_sphv_10hv*(1-fem))
+ dfl	   = (dfl_nld100_sphv_10hv)
+ dflw     = (dflw_nld100_sphv_10hv*(1-fem))
+ dp	   = (dp_nld100_sphv_10hv)
+ ecrit    = (ecrit_nld100_sphv_10hv*tfact_ecrit*fac_r_ng_ecrit)*(1+dwecrit/w+dwecritw/(w*w))
+ ecorn    = (ecorn_nld100_sphv_10hv)*(1+dwecrit/w+dwecritw/(w*w))
+ du	   = (du_nld100_sphv_10hv)
+ tc1	   = (tc1_nld100_sphv_10hv)
+ tc2	   = (tc2_nld100_sphv_10hv)
+ tc1l     = (tc1l_nld100_sphv_10hv)
+ tc2l     = (tc2l_nld100_sphv_10hv)
+ tc1w     = (tc1w_nld100_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld100_sphv_10hv*(1-fem))
+ theacc   = (theacc_nld100_sphv_10hv)
+ theacc2  = (theacc2_nld100_sphv_10hv)
+ aacc     = (aacc_nld100_sphv_10hv)
+ rva	   = (rva_nld100_sphv_10hv)
+ dta	   = (dta_nld100_sphv_10hv)
+ trj	   = (27)
+ cjarea   = (cjarea_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlsti   = (cjlsti_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlgat   = (cjlgat_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiarea  = (vbiarea_nld100_sphv_10hv)
+ vbisti   = (vbisti_nld100_sphv_10hv)
+ vbigat   = (vbigat_nld100_sphv_10hv)
+ parea    = (parea_nld100_sphv_10hv)
+ psti     = (psti_nld100_sphv_10hv)
+ pgat     = (pgat_nld100_sphv_10hv)
+ is1area  = (is1area_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttarea   = (tt_nld100_10hv)
+ is2area  = (is2area_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irarea   = (irarea_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1area = (stis1area_nld100_sphv_10hv)
+ stis2area = (stis2area_nld100_sphv_10hv)
+ stirarea = (stirarea_nld100_sphv_10hv)
+ n1area   = (n1area_nld100_sphv_10hv)
+ n2area   = (n2area_nld100_sphv_10hv)
+ nrarea   = (nrarea_nld100_sphv_10hv)
+ is1lsti  = (is1lsti_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlsti   = (tt_nld100_10hv)
+ is2lsti  = (is2lsti_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irlsti   = (irlsti_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1sti = (stis1sti_nld100_sphv_10hv)
+ stis2sti = (stis2sti_nld100_sphv_10hv)
+ stirsti  = (stirsti_nld100_sphv_10hv)
+ n1sti    = (n1sti_nld100_sphv_10hv)
+ n2sti    = (n2sti_nld100_sphv_10hv)
+ nrsti    = (nrsti_nld100_sphv_10hv)
+ is1lgat  = (is1lgat_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlgat   = (tt_nld100_10hv)
+ is2lgat  = (is2lgat_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ irlgat   = (irlgat_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1gat = (stis1gat_nld100_sphv_10hv)
+ stis2gat = (stis2gat_nld100_sphv_10hv)
+ stirgat  = (stirgat_nld100_sphv_10hv)
+ n1gat    = (n1gat_nld100_sphv_10hv)
+ n2gat    = (n2gat_nld100_sphv_10hv)
+ nrgat    = (nrgat_nld100_sphv_10hv)
+ cjaread  = (cjaread_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlstid  = (cjlstid_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlgatd  = (cjlgatd_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiaread = (vbiaread_nld100_sphv_10hv)
+ vbistid  = (vbistid_nld100_sphv_10hv)
+ vbigatd  = (vbigatd_nld100_sphv_10hv)
+ paread   = (paread_nld100_sphv_10hv)
+ pstid    = (pstid_nld100_sphv_10hv)
+ pgatd    = (pgatd_nld100_sphv_10hv)
+ is1aread = (is1aread_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttaread  = (tt_nld100_10hv)
+ is2aread = (is2aread_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ iraread  = (iraread_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1aread = (stis1aread_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2aread = (stis2aread_nld100_sphv_10hv)
+ stiraread = (stiraread_nld100_sphv_10hv)
+ n1aread  = (n1aread_nld100_sphv_10hv)
+ n2aread  = (n2aread_nld100_sphv_10hv)
+ nraread  = (nraread_nld100_sphv_10hv)
+ is1lstid = (is1lstid_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlstid  = (tt_nld100_10hv)
+ is2lstid = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlstid  = (irlstid_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1stid = (stis1stid_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2stid = (stis2stid_nld100_sphv_10hv)
+ stirstid = (stirstid_nld100_sphv_10hv)
+ n1stid   = (n1stid_nld100_sphv_10hv)
+ n2stid   = (n2stid_nld100_sphv_10hv)
+ nrstid   = (nrstid_nld100_sphv_10hv)
+ is1lgatd = (is1lgatd_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttlgatd  = (tt_nld100_10hv)
+ is2lgatd = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlgatd  = (irlgatd_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1gatd = (stis1gatd_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2gatd = (stis2gatd_nld100_sphv_10hv)
+ stirgatd = (stirgatd_nld100_sphv_10hv)
+ n1gatd   = (n1gatd_nld100_sphv_10hv)
+ n2gatd   = (n2gatd_nld100_sphv_10hv)
+ nrgatd   = (nrgatd_nld100_sphv_10hv)
+ cjaread2 = (cjaread_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ cjlstid2 = (cjlstid_nld100_sphv_10hv*delr_cj_nld100_sphv_10hv)
+ vbiaread2 = (vbiaread2_nld100_sphv_10hv)
+ vbistid2 = (vbistid2_nld100_sphv_10hv)
+ paread2  = (paread2_nld100_sphv_10hv)
+ pstid2   = (pstid2_nld100_sphv_10hv)
+ is1aread2 = (is1aread2_nld100_sphv_10hv*delr_is_nld100_sphv_10hv)
+ ttaread2 = (tt_nld100_10hv)
+ is2aread2 = (is2aread_nld100_sphv_10hv*delr_is2_nld100_sphv_10hv)
+ iraread2 = (iraread2_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1aread2 = (stis1aread_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2aread2 = (stis2aread_nld100_sphv_10hv)
+ stiraread2 = (stiraread2_nld100_sphv_10hv)
+ n1aread2 = (n1aread2_nld100_sphv_10hv)*(1+(1-fem)*0.1/w)
+ n2aread2 = (n2aread2_nld100_sphv_10hv)
+ nraread2 = (nraread2_nld100_sphv_10hv)
+ is1lstid2 = (is1aread_nld100_sphv_10hv*djunc*delr_is_nld100_sphv_10hv)
+ ttlstid2 = (tt_nld100_10hv)
+ is2lstid2 = (is2aread_nld100_sphv_10hv*djunc*delr_is2_nld100_sphv_10hv)
+ irlstid2 = (irlstid2_nld100_sphv_10hv*delr_ir_nld100_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld100_sphv_10hv)*(1-(1-fem)*dwstis1_nld100_sphv_10hv/w)
+ stis2stid2 = (stis2stid2_nld100_sphv_10hv)
+ stirstid2 = (stirstid2_nld100_sphv_10hv)
+ n1stid2  = (n1stid2_nld100_sphv_10hv)
+ n2stid2  = (n2stid2_nld100_sphv_10hv)
+ nrstid2  = (nrstid2_nld100_sphv_10hv)
+ eairarea	  = (1.12)
+ eairaread	  = (1.12)
+ eairaread2	  = (1.12)
+ eairgat	  = (1.12)
+ eairgatd	  = (1.12)
+ eairsti	  = (1.12)
+ eairstid	  = (1.12)
+ eairstid2	  = (1.12)
+ eais1area	  = (1.12)
+ eais1aread	  = (1.12)
+ eais1aread2	  = (1.12)
+ eais1gat	  = (1.12)
+ eais1gatd	  = (1.12)
+ eais1sti	  = (1.12)
+ eais1stid	  = (1.12)
+ eais1stid2	  = (1.12)
+ eais2area	  = (1.12)
+ eais2aread	  = (1.12)
+ eais2aread2	  = (1.12)
+ eais2gat	  = (1.12)
+ eais2gatd	  = (1.12)
+ eais2sti	  = (1.12)
+ eais2stid	  = (1.12)
+ eais2stid2	  = (1.12)
+ ikfarea               = ikfarea_nld100_sphv_10hv
+ ikflsti               = ikfarea_nld100_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld100_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld100_sphv_10hv
+ stikfsti              = stikfarea_nld100_sphv_10hv
+ stikfgat              = stikfarea_nld100_sphv_10hv
+ ikfaread              = ikfaread_nld100_sphv_10hv*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflstid              = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflgatd              = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikfaread2             = ikfaread_nld100_sphv_10hv*(w/(w+dwikfaread_nld100_sphv_10hv))
+ ikflstid2             = ikfaread_nld100_sphv_10hv*djunc*(w/(w+dwikfaread_nld100_sphv_10hv))
+ stikfaread             = stikfaread_nld100_sphv_10hv
+ stikfstid             = stikfaread_nld100_sphv_10hv
+ stikfgatd             = stikfaread_nld100_sphv_10hv
+ stikfaread2            = stikfaread_nld100_sphv_10hv
+ stikfstid2            = stikfaread_nld100_sphv_10hv

// ****** ckt elements:
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
//mendcap   (s  intg s  s  dtemp) pspmoscap l=lch w=(wmosend) mult=ng

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=p
+    tr    = 27
+    toxo  = 380e-9
+    vfbo  = 0
+    nsubo = 4.5e22
+    npck  = 1e22
+    lpck  = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo    = 0

mcgdcap (s intg s di dtemp) cgdfldmoscap l=2.15 w=w+dwcgdfldmoscap mult=ng
avdclip (d di intg) vdclip vp=vp_nld100_10hv dvp=dvp_nld100_10hv type=type_nld100_10hv

cgd_fld (intg d) capacitor c=(cgd_ply_fld)  m=ng

cgs_fld       (intg s)  capacitor c=(cgs_ply_fld_nld100) m=ng
cgs_ply_cfr   (intg s)  capacitor c=(cfr_ply_s) m=ng
cgd_m1        (intg d) capacitor c=(cgd_ply_m1)  m=ng
cgs_m1        (intg s) capacitor c=(cgs_ply_m1)  m=ng
rgate     (g intg) resistor r=rgate m=ng
dbodyBV (s rs)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rs d)   resistor r=0.01
xdsub     (s sub) cdgontub_box_sub_10hv  area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1


//dummy_gate model
if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=2.15 w=w+dwcgdfldmoscap mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip vp=vp_nld100_10hv dvp=dvp_nld100_10hv type=type_nld100_10hv

cgd_fld_dmy (s d) capacitor c=(cgd_ply_fld)  m=ng_dmy
cgd_m1_dmy  (s d) capacitor c=(cgd_ply_m1)  m=ng_dmy


}



include "./smos10hv_ade_dfrt.scs" section=nld100_10hv_dfrt
ends
// pld100_10hv

//ahdl_include "./veriloga/v2.0.16/sphv.va"
subckt pld100_10hv (d g s sub)

parameters
+ w				    = (5)
+ ng				    = (2)
+ sti_dummy			    = (0)
+ lpe				    = (0)
+ fem				    = (0)
+ soa				    = (1)
+ selfheat			    = (1)
+ mode_rthcth			    = (1)
+ dela_vth_relimo		    = (0)
+ dela_vth_relimo_mod		    = (0)
+ delr_u0_relimo		    = (1)
+ delr_rdsw_relimo		    = (1)
+ delr_a0_relimo		    = (1)

+ l				    = (0.5)
+ tn                                = (27+273.15)
+ delt                              = (temp+273.15-tn)
+ rs_poly_gate                      = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply                              = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))

+ nsmm_delr_tox_pld100_sphv_10hv    = tmp_nsmm_delr_tox_pld100_sphv_10hv
+ nsmm_dela_vfb_pld100_sphv_10hv    = tmp_nsmm_dela_vfb_pld100_sphv_10hv
+ nsmm_dela_vtw_pld100_sphv_10hv    = tmp_nsmm_dela_vtw_pld100_sphv_10hv
+ nsmm_delr_uch_pld100_sphv_10hv    = tmp_nsmm_delr_uch_pld100_sphv_10hv
+ nsmm_delr_res_pld100_sphv_10hv    = tmp_nsmm_delr_res_pld100_sphv_10hv
+ nsmm_dela_dwox_pld100_sphv_10hv   = tmp_nsmm_dela_dwox_pld100_sphv_10hv
+ nsmm_delr_nsub_pld100_sphv_10hv   = tmp_nsmm_delr_nsub_pld100_sphv_10hv

//process parameters
+ delr_tox_pld100_sphv_10hv         = (nom_delr_tox_pld100_sphv_10hv*(1+sig_delr_tox_pld100_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld100_sphv_10hv*smm_delr_tox_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld100_sphv_10hv         = (nom_dela_vfb_pld100_sphv_10hv+(sig_dela_vfb_pld100_sphv_10hv*nsig_dela_vfb_pld100_sphv_10hv)+nsmm_dela_vfb_pld100_sphv_10hv*smm_dela_vfb_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld100_sphv_10hv         = (nom_dela_vtw_pld100_sphv_10hv+(sig_dela_vtw_pld100_sphv_10hv*nsig_dela_vtw_pld100_sphv_10hv)+nsmm_dela_vtw_pld100_sphv_10hv*smm_dela_vtw_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld100_sphv_10hv         = (nom_delr_uch_pld100_sphv_10hv*(1+sig_delr_uch_pld100_sphv_10hv*nsig_delr_uch_pld100_sphv_10hv+nsmm_delr_uch_pld100_sphv_10hv*smm_delr_uch_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld100_sphv_10hv         = (nom_delr_res_pld100_sphv_10hv*(1+sig_delr_res_pld100_sphv_10hv*nsig_delr_res_pld100_sphv_10hv+nsmm_delr_res_pld100_sphv_10hv*smm_delr_res_pld100_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld100_sphv_10hv        = (nom_dela_dwox_pld100_sphv_10hv+(sig_dela_dwox_pld100_sphv_10hv*nsig_dela_dwox_pld100_sphv_10hv)+nsmm_dela_dwox_pld100_sphv_10hv*smm_dela_dwox_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld100_sphv_10hv        = (1+nsmm_delr_nsub_pld100_sphv_10hv*smm_delr_nsub_pld100_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld100_sphv_10hv	    = (nom_delr_cj_pld100_sphv_10hv*(1.0+nsig_delr_cj_pld100_sphv_10hv*sig_delr_cj_pld100_sphv_10hv))
+ delr_is_pld100_sphv_10hv	    = (nom_delr_is_pld100_sphv_10hv*exp(nsig_delr_is_pld100_sphv_10hv*sig_delr_is_pld100_sphv_10hv))
+ delr_is2_pld100_sphv_10hv	    = (nom_delr_is2_pld100_sphv_10hv*exp(nsig_delr_is2_pld100_sphv_10hv*sig_delr_is2_pld100_sphv_10hv))
+ delr_ir_pld100_sphv_10hv	    = (nom_delr_ir_pld100_sphv_10hv*exp(nsig_delr_ir_pld100_sphv_10hv*sig_delr_ir_pld100_sphv_10hv))
+ dela_dw_pld100_sphv_10hv          = (nom_dela_dw_pld100_sphv_10hv+(sig_dela_dw_pld100_sphv_10hv*nsig_dela_dw_pld100_sphv_10hv))
+ delr_thesat_pld100_sphv_10hv      = (nom_delr_thesat_pld100_sphv_10hv*(1+sig_delr_thesat_pld100_sphv_10hv*nsig_delr_thesat_pld100_sphv_10hv))
+ delr_vdscale_pld100_sphv_10hv     = (nom_delr_vdscale_pld100_sphv_10hv*(1+sig_delr_vdscale_pld100_sphv_10hv*nsig_delr_vdscale_pld100_sphv_10hv))
+ delr_vdscalew_pld100_sphv_10hv    = (nom_delr_vdscalew_pld100_sphv_10hv*(1+sig_delr_vdscalew_pld100_sphv_10hv*nsig_delr_vdscalew_pld100_sphv_10hv))
+ delr_theacc2_pld100_sphv_10hv     = (nom_delr_theacc2_pld100_sphv_10hv*(1+sig_delr_theacc2_pld100_sphv_10hv*nsig_delr_theacc2_pld100_sphv_10hv))


parameters
//+ nde=(fmod(ng,2))
+ nde              = (0)
+ nse              = (2-nde)
+ nd               = ((ng+nde)/2)
+ ns               = (1-nde+nd)
+ ndi              = (nd-nde)
+ nsi              = (ns-nse)

//dummy parameters
+ ng_dmy           = (2*sti_dummy)
+ ngeff            = (ng+ng_dmy)
+ ndi_eff          = (ngeff/2)
+ nsi_eff          = ((ngeff-2)/2)

+ wdrift           = (w)
+ ldrift           = (7.0)
+ ldr1             = (0.55)
+ lacts            = (0.3)
+ lactd            = (1.32)
+ lactg            = (0.35)
+ lacts_i          = (0.39)

// junction area and perimeter calculation
// because s and b are shorted, so let as=ps=0
+ as               = (w*lacts)*0
+ ps               = ((w+lacts)*2)*0
+ w2nhv            = (11.4)
+ rnhv_inner       = (1.4)
+ rnhv_a_inner     = rnhv_inner*rnhv_inner*pi4models
+ rnhv_p_inner     = 2*rnhv_inner*pi4models
+ rnhv_daera       = (rnhv_inner*rnhv_inner-rnhv_a_inner/4.0)*(1-fem)
+ ad               = ((ldr1+lactg+ldrift/2)*(w+2*w2nhv*(1-fem))-rnhv_daera*2)
+ pd               = ((ldr1+lactg+ldrift/2)*2*(1-fem)+(w+2*w2nhv*(1-fem))-4*rnhv_inner*(1-fem)+rnhv_inner*pi4models*(1-fem))
+ ad2              = ((ldrift/2+lactd/2)*(w+2*w2nhv*(1-fem)))
+ pd2              = (ldrift+lactd)*(1-fem)

// nbl-oxide-sub box cap calculation
+ lb2b_d           = (17.12)
+ lp2p_s           = (0.99)
+ lp2dt_s          = (3.66)
+ w2dt             = (14.9)
+ xlnbl            = (lp2dt_s*nse+l*ngeff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl            = (w+2*w2dt*(1-fem))
+ alnbl            = (xlnbl*ylnbl)
+ plnbl            = (2*(xlnbl*(1-fem)+ylnbl))

// rth and cth calculation
+ w_heat           = (w)
+ l_heat           = (lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f            = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld100_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld100_sphv_10hv)*ngeff
+ cth_f            = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

+ djunc            = (2.5*1e-06)

+ tfact_ecrit      = (1+(tc1_ecrit_pld100_sphv_10hv+tc2_ecrit_pld100_sphv_10hv*(temp-tnom))*(temp-tnom))

// calculation for poly over field parasitic capacitance
// calculation for parasitic Cgd
// cgd_ply_fld is not used. Instead, use fitting one come with psp moscap Cgd
+ plysplit_aera    = (w+3.2*2*(1-fem))*0.7
+ plysplit_peri    = (w+3.2*4*(1-fem)+0.7*2*(1-fem))
+ w2ply_inner      = (5.55)
+ w2ply_outer      = (12.4)
+ lp2p_d           = (9.12)
+ lp2p_d_narrow    = (7.92)
+ l_polyear        = (lp2p_d-lp2p_d_narrow)/2
+ dw_polyear       = (1.0)
//+ aply_fld_cgd       = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d+2.0*l_polyear*(w-2*dw_polyear*(1-fem))-4.0*rnhv_daera-2.0*plysplit_aera-w*ldr1*2)/2*ng*(0.85*0+0.85*0.85)
//+ pply_fld_cgd       = (w+2*w2ply_inner*(1-fem)+2*l_polyear*(1-fem)+lp2p_d*(1-fem)+plysplit_peri*1)*ng*(0+1)      //ignore polywin2 perimeter for it's width is just of 0.7
//+ cgd_ply_fld        = (aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld)         using psp moscap to replace it

// parasitic capacitnace caused by dummy gate
// cgd_ply_fld_dmy is not used. Instead, use fitting one come with psp moscap Cgd
//+ aply_fld_cgd_dmy   = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d+2.0*l_polyear*(w-2*dw_polyear*(1-fem))-4.0*rnhv_daera-2.0*plysplit_aera-w*ldr1*2)/2*ng_dmy*(0.85*0+0.85*0.85)
//+ pply_fld_cgd_dmy   = (w+2*w2ply_inner*(1-fem)+2*l_polyear*(1-fem)+lp2p_d*(1-fem)+plysplit_peri*1)*ng_dmy*(0+1)      //ignore polywin2 perimeter for it is just width of 0.7
//+ cgd_ply_fld_dmy    = (aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld)         using psp moscap to replace it

// calculation for parasitic Cgs. For dummy gate, g and s are shorted, so no cgs.
+ aply_fld_cgs     = ((w+2*w2ply_outer*(1-fem))*(2*l+lb2b_d)-(w+2*w2nhv*(1-fem))*lb2b_d+4*rnhv_daera-l*w*2)/2*ng
+ pply_fld_cgs     = (2*w2ply_outer+2*l+lb2b_d)*ng*(1-fem)
+ cgs_ply_fld      = (aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld)+2.3e-15*ng*0.8

//copied from pld90b for psp moscap part, updating the parameters
// calculation for poly over field parasitic capaciance
+ cgd_ply_fld_pp   = 2.7e-17
+ cgs_ply_fld_pp   = 6.0e-15
+ dwcgdfldmoscap   = 35.7*(1-fem)
+ dwcgd_ply_fld    = 35.4667*(1-fem)
+ cgd_ply_fld      = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng
//+ cgs_ply_fld    = cgs_ply_fld_pp*(1-fem)*ng                not use this equ, still used cgs calculated from layout
// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy  = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng_dmy


// parameters for veriloga
+ vp_pld100_10hv   = (32)
+ dvp_pld100_10hv  = (4.5)
+ type_pld100_10hv = (-1)


//calculation for rgate
+ lovlap 	   = (0.5+0.55-0.913-0.078)
+ length 	   = (0.913+0.078+lovlap+2.75)


// simple model factor
+ swdrlin          = (0)
+ fac_rshldd       = ((swdrlin==0)+(swdrlin==2)*0.88848)

// multiple-ng effect
+ fac_r_ng_rshldd  = (1+(ngeff/(ngeff+0.5*(1-fem))-2/(2+0.5))*0.2034*(1+1.25*(1-fem)/w))
+ fac_a_ng_vfbo    = (ngeff/(ngeff+0.5*(1-fem))-2/(2+0.5))*0.0756*(w/(w+2.75*(1-fem)))
+ fac_r_ng_thesato = (1+(ngeff/(ngeff+1*(1-fem))-2/(2+1))*0.765)


// parameters for the BV diode
+ dcbv_pld100_10hv = (122)

// parasitic cgd and cgs between m2 and m3, in p39e cv duts, used for model extraction, and flagged out in final model
//+ cpp_m3_m2        = (6.72904e-17)
//+ cfr_m3_m2        = (4.42231e-17)
//+ no_m2_m3         = int((w+2*w2ply_inner+1.8+1e-6)/(7.8*2))
//+ m2_m3_a          = (2.44*6)*no_m2_m3*ng
//+ m2_m3_p          = (2.44+6)*2*no_m2_m3*ng
//+ cgd_m2_m3        = (m2_m3_a*cpp_m3_m2+m2_m3_p*cfr_m3_m2)
//+ cgs_m2_m3        = (m2_m3_a*cpp_m3_m2+m2_m3_p*cfr_m3_m2)

model dbodyBV diode
+ allow_scaling    = (yes)
+ jmax  	   = (1e12)
+ jmelt 	   = (1e12)
+ tnom  	   = (27)
+ is		   = (1e-30)
+ n		   = (1.0)
+ cj		   = (1e-30)
+ pta		   = (0)
+ tlevc 	   = (2)
+ tlev  	   = (2)
+ bv		   = (dcbv_pld100_10hv+bvdss_shift)
+ ibv		   = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ngeff)
rlimit (rd s) resistor r=0.01


// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w                = w
+ l                = l
+ ldrift           = ldrift
+ wdrift           = wdrift
+ ldr1             = ldr1
+ mult             = ng
+ ad               = ad
+ pd               = pd
+ as               = as
+ ps               = ps
+ ad2              = ad2
+ pd2              = pd2


model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi       = 1
+ swdrlin      = swdrlin
+ xvsat        = xvsat_pld100_sphv_10hv
+ qmc          = qmc_pld100_sphv_10hv
+ lvaro        = lvaro_pld100_sphv_10hv
+ lvarl        = lvarl_pld100_sphv_10hv
+ lvarw        = lvarw_pld100_sphv_10hv*(1-fem)
+ lap          = lap_pld100_sphv_10hv
+ wvaro        = (wvaro_pld100_sphv_10hv+dela_dw_pld100_sphv_10hv)*(1-fem)
+ wvarl        = wvarl_pld100_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld100_sphv_10hv*(1-fem)
+ wot          = wot_pld100_sphv_10hv*(1-fem)
+ dlq          = dlq_pld100_sphv_10hv
+ dwq          = dwq_pld100_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld100_sphv_10hv+dela_vfb_pld100_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo
+ vfbl         = vfbl_pld100_sphv_10hv
+ vfbw         = (vfbw_pld100_sphv_10hv+dela_vtw_pld100_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld100_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld100_sphv_10hv
+ stvfbl       = stvfbl_pld100_sphv_10hv
+ stvfbw       = stvfbw_pld100_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld100_sphv_10hv*(1-fem)
+ toxo         = toxo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ epsroxo      = epsroxo_pld100_sphv_10hv
+ nsubo        = nsubo_pld100_sphv_10hv*delr_nsub_pld100_sphv_10hv
+ nsubw        = nsubw_pld100_sphv_10hv*(1-fem)
+ wseg         = wseg_pld100_sphv_10hv
+ npck         = npck_pld100_sphv_10hv
+ npckw        = npckw_pld100_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld100_sphv_10hv
+ lpck         = lpck_pld100_sphv_10hv
+ lpckw        = lpckw_pld100_sphv_10hv*(1-fem)
+ fol1         = fol1_pld100_sphv_10hv
+ fol2         = fol2_pld100_sphv_10hv
+ facneffaco   = facneffaco_pld100_sphv_10hv
+ facneffacl   = facneffacl_pld100_sphv_10hv
+ facneffacw   = facneffacw_pld100_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld100_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld100_sphv_10hv
+ gfacnudl     = gfacnudl_pld100_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld100_sphv_10hv
+ gfacnudw     = gfacnudw_pld100_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld100_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld100_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld100_sphv_10hv
+ vnsubo       = vnsubo_pld100_sphv_10hv
+ nslpo        = nslpo_pld100_sphv_10hv
+ dnsubo       = dnsubo_pld100_sphv_10hv
+ dphibo       = dphibo_pld100_sphv_10hv
+ dphibl       = dphibl_pld100_sphv_10hv
+ dphiblexp    = dphiblexp_pld100_sphv_10hv
+ dphibw       = dphibw_pld100_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld100_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld100_sphv_10hv
+ delvtacl     = delvtacl_pld100_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld100_sphv_10hv
+ delvtacw     = delvtacw_pld100_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld100_sphv_10hv*(1-fem)
+ npo          = npo_pld100_sphv_10hv
+ npl          = npl_pld100_sphv_10hv
+ cto          = cto_pld100_sphv_10hv
+ ctl          = ctl_pld100_sphv_10hv
+ ctlexp       = ctlexp_pld100_sphv_10hv
+ ctw          = ctw_pld100_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld100_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld100_sphv_10hv
+ ctbo         = ctbo_pld100_sphv_10hv
+ stcto        = stcto_pld100_sphv_10hv
+ toxovo       = toxovo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ toxovdo      = toxovdo_pld100_sphv_10hv*delr_tox_pld100_sphv_10hv
+ lov          = lov_pld100_sphv_10hv
+ dlovd        = dlovd_pld100_sphv_10hv
+ novo         = novo_pld100_sphv_10hv
+ novdo        = novdo_pld100_sphv_10hv
+ cfl          = cfl_pld100_sphv_10hv
+ cflexp       = cflexp_pld100_sphv_10hv
+ cfw          = cfw_pld100_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld100_sphv_10hv
+ uo           = uo_pld100_sphv_10hv*delr_uch_pld100_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld100_sphv_10hv
+ fbet1w       = fbet1w_pld100_sphv_10hv*(1-fem)
+ lp1          = lp1_pld100_sphv_10hv
+ lp1w         = lp1w_pld100_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld100_sphv_10hv
+ lp2          = lp2_pld100_sphv_10hv
+ betw1        = betw1_pld100_sphv_10hv*(1-fem)
+ betw2        = betw2_pld100_sphv_10hv*(1-fem)
+ wbet         = wbet_pld100_sphv_10hv
+ stbeto       = stbeto_pld100_sphv_10hv
+ stbetl       = stbetl_pld100_sphv_10hv
+ stbetw       = stbetw_pld100_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld100_sphv_10hv*(1-fem)
+ mueo         = mueo_pld100_sphv_10hv
+ muew         = muew_pld100_sphv_10hv*(5/w)*(1-fem)
+ stmueo       = stmueo_pld100_sphv_10hv
+ themuo       = themuo_pld100_sphv_10hv
+ stthemuo     = stthemuo_pld100_sphv_10hv
+ cso          = cso_pld100_sphv_10hv
+ csl          = csl_pld100_sphv_10hv
+ cslexp       = cslexp_pld100_sphv_10hv
+ csw          = csw_pld100_sphv_10hv*(1-fem)
+ cslw         = cslw_pld100_sphv_10hv*(1-fem)
+ stcso        = stcso_pld100_sphv_10hv
+ xcoro        = xcoro_pld100_sphv_10hv
+ xcorl        = xcorl_pld100_sphv_10hv
+ xcorw        = xcorw_pld100_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld100_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld100_sphv_10hv
+ fetao        = fetao_pld100_sphv_10hv
+ rsw1         = rsw1_pld100_sphv_10hv
+ rsw2         = rsw2_pld100_sphv_10hv*(1-fem)
+ strso        = strso_pld100_sphv_10hv
+ rsbo         = rsbo_pld100_sphv_10hv
+ rsgo         = rsgo_pld100_sphv_10hv
+ thesato      = thesato_pld100_sphv_10hv*delr_thesat_pld100_sphv_10hv*fac_r_ng_thesato
+ thesatl      = thesatl_pld100_sphv_10hv
+ thesatlexp   = thesatlexp_pld100_sphv_10hv
+ thesatw      = thesatw_pld100_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld100_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld100_sphv_10hv
+ stthesatl    = stthesatl_pld100_sphv_10hv
+ stthesatw    = stthesatw_pld100_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld100_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld100_sphv_10hv
+ thesatgo     = thesatgo_pld100_sphv_10hv
+ thesatgl     = thesatgl_pld100_sphv_10hv
+ thesatgw     = thesatgw_pld100_sphv_10hv*(1-fem)
+ vdscale      = (vdscale_pld100_sphv_10hv*delr_vdscale_pld100_sphv_10hv*(1+vdscalew_pld100_sphv_10hv*delr_vdscalew_pld100_sphv_10hv*(1-fem)/w))
+ vdscaleb     = (vdscaleb_pld100_sphv_10hv*(1+vdscalew_pld100_sphv_10hv*(1-fem)/w))
+ stvdscale    = stvdscale_pld100_sphv_10hv
+ axo          = axo_pld100_sphv_10hv
+ axl          = axl_pld100_sphv_10hv
+ alpl         = alpl_pld100_sphv_10hv
+ alplexp      = alplexp_pld100_sphv_10hv
+ alpw         = alpw_pld100_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld100_sphv_10hv
+ alp1lexp     = alp1lexp_pld100_sphv_10hv
+ alp1l2       = alp1l2_pld100_sphv_10hv
+ alp1w        = alp1w_pld100_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld100_sphv_10hv
+ alp2lexp     = alp2lexp_pld100_sphv_10hv
+ alp2l2       = alp2l2_pld100_sphv_10hv
+ alp2w        = alp2w_pld100_sphv_10hv*(1-fem)
+ vpo          = vpo_pld100_sphv_10hv
+ a1o          = a1o_pld100_sphv_10hv
+ a1l          = a1l_pld100_sphv_10hv
+ a1w          = a1w_pld100_sphv_10hv*(1-fem)
+ a2o          = a2o_pld100_sphv_10hv
+ sta2o        = sta2o_pld100_sphv_10hv
+ a3o          = a3o_pld100_sphv_10hv
+ a3l          = a3l_pld100_sphv_10hv
+ a3w          = a3w_pld100_sphv_10hv*(1-fem)
+ a4o          = a4o_pld100_sphv_10hv
+ a4l          = a4l_pld100_sphv_10hv
+ a4w          = a4w_pld100_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld100_sphv_10hv
+ iginvlw      = iginvlw_pld100_sphv_10hv
+ igovw        = igovw_pld100_sphv_10hv
+ igovdw       = igovdw_pld100_sphv_10hv
+ stigo        = stigo_pld100_sphv_10hv
+ gc2o         = gc2o_pld100_sphv_10hv
+ gc3o         = gc3o_pld100_sphv_10hv
+ chibo        = chibo_pld100_sphv_10hv
+ agidlw       = agidlw_pld100_sphv_10hv
+ agidldw      = agidldw_pld100_sphv_10hv
+ bgidlo       = bgidlo_pld100_sphv_10hv
+ bgidldo      = bgidldo_pld100_sphv_10hv
+ stbgidlo     = stbgidlo_pld100_sphv_10hv
+ stbgidldo    = stbgidldo_pld100_sphv_10hv
+ cgidlo       = cgidlo_pld100_sphv_10hv
+ cgidldo      = cgidldo_pld100_sphv_10hv
+ cgbovl       = cgbovl_pld100_sphv_10hv
+ cfrw         = cfrw_pld100_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld100_sphv_10hv*(1-fem)
+ fnto         = fnto_pld100_sphv_10hv
+ nfalw        = nfalw_pld100_sphv_10hv
+ nfblw        = nfblw_pld100_sphv_10hv
+ nfclw        = nfclw_pld100_sphv_10hv
+ efo          = efo_pld100_sphv_10hv
+ lintnoi      = lintnoi_pld100_sphv_10hv
+ alpnoi       = alpnoi_pld100_sphv_10hv
+ kvthoweo     = kvthoweo_pld100_sphv_10hv
+ kvthowel     = kvthowel_pld100_sphv_10hv
+ kvthowew     = kvthowew_pld100_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld100_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld100_sphv_10hv
+ kuowel       = kuowel_pld100_sphv_10hv
+ kuowew       = kuowew_pld100_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld100_sphv_10hv*(1-fem)
+ rgo          = rgo_pld100_sphv_10hv
+ rsh          = rsh_pld100_sphv_10hv
+ rbulko       = rbulko_pld100_sphv_10hv
+ rwello       = rwello_pld100_sphv_10hv
+ rjunso       = rjunso_pld100_sphv_10hv/(w+dwrjunso_pld100_sphv_10hv*(1-fem))*(1+5.0e-4*(temp-27))
+ rjundo       = rjundo_pld100_sphv_10hv/(w+dwrjundo_pld100_sphv_10hv*(1-fem))*(1+5.0e-4*(temp-27))
+ rint         = rint_pld100_sphv_10hv
+ rvpoly       = rvpoly_pld100_sphv_10hv
+ rshg         = rshg_pld100_sphv_10hv
+ dlsil        = dlsil_pld100_sphv_10hv
+ saref        = saref_pld100_sphv_10hv
+ sbref        = sbref_pld100_sphv_10hv
+ wlod         = wlod_pld100_sphv_10hv
+ kuo          = kuo_pld100_sphv_10hv
+ kvsat        = kvsat_pld100_sphv_10hv
+ tkuo         = tkuo_pld100_sphv_10hv
+ lkuo         = lkuo_pld100_sphv_10hv
+ wkuo         = wkuo_pld100_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld100_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld100_sphv_10hv
+ wlodkuo      = wlodkuo_pld100_sphv_10hv
+ kvtho        = kvtho_pld100_sphv_10hv
+ lkvtho       = lkvtho_pld100_sphv_10hv
+ wkvtho       = wkvtho_pld100_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld100_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld100_sphv_10hv
+ wlodvth      = wlodvth_pld100_sphv_10hv
+ stetao       = stetao_pld100_sphv_10hv
+ lodetao      = lodetao_pld100_sphv_10hv
+ scref        = scref_pld100_sphv_10hv
+ web          = web_pld100_sphv_10hv
+ wec          = wec_pld100_sphv_10hv
+ adr1o        = adr1o_pld100_sphv_10hv
+ adr1l        = adr1l_pld100_sphv_10hv
+ adr1w        = adr1w_pld100_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld100_sphv_10hv
+ stadr2o      = stadr2o_pld100_sphv_10hv
+ adr3o        = adr3o_pld100_sphv_10hv
+ adr3l        = adr3l_pld100_sphv_10hv
+ adr3w        = adr3w_pld100_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld100_sphv_10hv
+ adr4l        = adr4l_pld100_sphv_10hv
+ adr4w        = adr4w_pld100_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld100_sphv_10hv
+ adr5l        = adr5l_pld100_sphv_10hv
+ adr5w        = adr5w_pld100_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld100_sphv_10hv
+ bidr1l       = bidr1l_pld100_sphv_10hv
+ bidr1w       = bidr1w_pld100_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld100_sphv_10hv
+ bidr2w       = bidr2w_pld100_sphv_10hv*(1-fem)
+ rtho         = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld100_sphv_10hv
+ strthao      = strthao_pld100_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld100_sphv_10hv*delr_res_pld100_sphv_10hv*fac_r_ng_rshldd*fac_rshldd*delr_rdsw_relimo)
+ xw           = xw_pld100_sphv_10hv*(1-fem)
+ nwxw         = (nwxw_pld100_sphv_10hv+1.0e-12*dela_dwox_pld100_sphv_10hv)*(1-fem)
+ xl           = xl_pld100_sphv_10hv
+ xlw          = xlw_pld100_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld100_sphv_10hv
+ nst          = nst_pld100_sphv_10hv
+ ats          = ats_pld100_sphv_10hv
+ dfinf        = dfinf_pld100_sphv_10hv
+ dfw          = dfw_pld100_sphv_10hv*(1-fem)
+ dfl          = dfl_pld100_sphv_10hv
+ dflw         = dflw_pld100_sphv_10hv*(1-fem)
+ dp           = dp_pld100_sphv_10hv
+ ecrit        = ecrit_pld100_sphv_10hv*tfact_ecrit/(1+ecritw_pld100_sphv_10hv*(1-fem)/w**1.5)
+ ecorn        = ecorn_pld100_sphv_10hv*tfact_ecrit/(1+ecritw_pld100_sphv_10hv*(1-fem)/w**1.5)
+ du           = du_pld100_sphv_10hv
+ tc1          = tc1_pld100_sphv_10hv
+ tc2          = tc2_pld100_sphv_10hv
+ tc1l         = tc1l_pld100_sphv_10hv
+ tc2l         = tc2l_pld100_sphv_10hv
+ tc1w         = tc1w_pld100_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld100_sphv_10hv*(1-fem)
+ theacc       = theacc_pld100_sphv_10hv
+ theacc2      = theacc2_pld100_sphv_10hv*delr_theacc2_pld100_sphv_10hv
+ rva          = rva_pld100_sphv_10hv
+ dta          = dta_pld100_sphv_10hv
+ trj          = trj_pld100_sphv_10hv
+ cjarea       = cjarea_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlsti       = cjlsti_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlgat       = cjarea_pld100_sphv_10hv*djunc*delr_cj_pld100_sphv_10hv
+ vbiarea      = vbiarea_pld100_sphv_10hv
+ vbisti       = vbisti_pld100_sphv_10hv
+ vbigat       = vbigat_pld100_sphv_10hv
+ parea        = parea_pld100_sphv_10hv
+ psti         = psti_pld100_sphv_10hv
+ pgat         = pgat_pld100_sphv_10hv
+ is1area      = is1area_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttarea       = ttarea_pld100_sphv_10hv
+ is2area      = is2area_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irarea       = irarea_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1area    = stis1area_pld100_sphv_10hv
+ stis2area    = stis2area_pld100_sphv_10hv
+ stirarea     = stirarea_pld100_sphv_10hv
+ n1area       = n1area_pld100_sphv_10hv
+ n2area       = n2area_pld100_sphv_10hv
+ nrarea       = nrarea_pld100_sphv_10hv
+ is1lsti      = is1lsti_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlsti       = ttlsti_pld100_sphv_10hv
+ is2lsti      = is2lsti_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlsti       = irlsti_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1sti     = stis1sti_pld100_sphv_10hv
+ stis2sti     = stis2sti_pld100_sphv_10hv
+ stirsti      = stirsti_pld100_sphv_10hv
+ n1sti        = n1sti_pld100_sphv_10hv
+ n2sti        = n2sti_pld100_sphv_10hv
+ nrsti        = nrsti_pld100_sphv_10hv
+ is1lgat      = is1area_pld100_sphv_10hv*djunc*delr_is_pld100_sphv_10hv
+ ttlgat       = ttlgat_pld100_sphv_10hv
+ is2lgat      = is2area_pld100_sphv_10hv*djunc*delr_is2_pld100_sphv_10hv
+ irlgat       = irarea_pld100_sphv_10hv*djunc*delr_ir_pld100_sphv_10hv
+ stis1gat     = stis1gat_pld100_sphv_10hv
+ stis2gat     = stis2gat_pld100_sphv_10hv
+ stirgat      = stirgat_pld100_sphv_10hv
+ n1gat        = n1gat_pld100_sphv_10hv
+ n2gat        = n2gat_pld100_sphv_10hv
+ nrgat        = nrgat_pld100_sphv_10hv
+ cjaread      = cjaread_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlstid      = cjlstid_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlgatd      = cjlgatd_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ vbiaread     = vbiaread_pld100_sphv_10hv
+ vbistid      = vbistid_pld100_sphv_10hv
+ vbigatd      = vbigatd_pld100_sphv_10hv
+ paread       = paread_pld100_sphv_10hv
+ pstid        = pstid_pld100_sphv_10hv
+ pgatd        = pgatd_pld100_sphv_10hv
+ is1aread     = is1aread_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttaread      = ttaread_pld100_sphv_10hv
+ is2aread     = is2aread_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ iraread      = iraread_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1aread   = stis1aread_pld100_sphv_10hv
+ stis2aread   = stis2aread_pld100_sphv_10hv
+ stiraread    = stiraread_pld100_sphv_10hv
+ n1aread      = n1aread_pld100_sphv_10hv
+ n2aread      = n2aread_pld100_sphv_10hv
+ nraread      = nraread_pld100_sphv_10hv
+ is1lstid     = is1lstid_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlstid      = ttlstid_pld100_sphv_10hv
+ is2lstid     = is2lstid_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlstid      = irlstid_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1stid    = stis1stid_pld100_sphv_10hv
+ stis2stid    = stis2stid_pld100_sphv_10hv
+ stirstid     = stirstid_pld100_sphv_10hv
+ n1stid       = n1stid_pld100_sphv_10hv
+ n2stid       = n2stid_pld100_sphv_10hv
+ nrstid       = nrstid_pld100_sphv_10hv
+ is1lgatd     = is1lgatd_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlgatd      = ttlgatd_pld100_sphv_10hv
+ is2lgatd     = is2lgatd_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlgatd      = irlgatd_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1gatd    = stis1gatd_pld100_sphv_10hv
+ stis2gatd    = stis2gatd_pld100_sphv_10hv
+ stirgatd     = stirgatd_pld100_sphv_10hv
+ n1gatd       = n1gatd_pld100_sphv_10hv
+ n2gatd       = n2gatd_pld100_sphv_10hv
+ nrgatd       = nrgatd_pld100_sphv_10hv
+ cjaread2     = cjaread2_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ cjlstid2     = cjlstid2_pld100_sphv_10hv*delr_cj_pld100_sphv_10hv
+ vbiaread2    = vbiaread2_pld100_sphv_10hv
+ vbistid2     = vbistid2_pld100_sphv_10hv
+ paread2      = paread2_pld100_sphv_10hv
+ pstid2       = pstid2_pld100_sphv_10hv
+ is1aread2    = is1aread2_pld100_sphv_10hv*delr_is_pld100_sphv_10hv/(1+20*(1-fem)/w)
+ ttaread2     = ttaread2_pld100_sphv_10hv
+ is2aread2    = is2aread2_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ iraread2     = iraread2_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1aread2  = stis1aread2_pld100_sphv_10hv
+ stis2aread2  = stis2aread2_pld100_sphv_10hv
+ stiraread2   = stiraread2_pld100_sphv_10hv
+ n1aread2     = n1aread2_pld100_sphv_10hv
+ n2aread2     = n2aread2_pld100_sphv_10hv
+ nraread2     = nraread2_pld100_sphv_10hv
+ is1lstid2    = is1lstid2_pld100_sphv_10hv*delr_is_pld100_sphv_10hv
+ ttlstid2     = ttlstid2_pld100_sphv_10hv
+ is2lstid2    = is2lstid2_pld100_sphv_10hv*delr_is2_pld100_sphv_10hv
+ irlstid2     = irlstid2_pld100_sphv_10hv*delr_ir_pld100_sphv_10hv
+ stis1stid2   = stis1stid2_pld100_sphv_10hv
+ stis2stid2   = stis2stid2_pld100_sphv_10hv
+ stirstid2    = stirstid2_pld100_sphv_10hv
+ n1stid2      = n1stid2_pld100_sphv_10hv
+ n2stid2      = n2stid2_pld100_sphv_10hv
+ nrstid2      = nrstid2_pld100_sphv_10hv
+ aacc         = aacc_pld100_sphv_10hv
+ eais1area    = eais1area_pld100_sphv_10hv
+ eais2area    = eais2area_pld100_sphv_10hv
+ eairarea     = eairarea_pld100_sphv_10hv
+ eais1sti     = eais1sti_pld100_sphv_10hv
+ eais2sti     = eais2sti_pld100_sphv_10hv
+ eairsti      = eairsti_pld100_sphv_10hv
+ eais1gat     = eais1gat_pld100_sphv_10hv
+ eais2gat     = eais2gat_pld100_sphv_10hv
+ eairgat      = eairgat_pld100_sphv_10hv
+ eais1aread   = eais1aread_pld100_sphv_10hv
+ eais2aread   = eais2aread_pld100_sphv_10hv
+ eairaread    = eairaread_pld100_sphv_10hv
+ eais1stid    = eais1stid_pld100_sphv_10hv
+ eais2stid    = eais2stid_pld100_sphv_10hv
+ eairstid     = eairstid_pld100_sphv_10hv
+ eais1gatd    = eais1gatd_pld100_sphv_10hv
+ eais2gatd    = eais2gatd_pld100_sphv_10hv
+ eairgatd     = eairgatd_pld100_sphv_10hv
+ eais1aread2  = eais1aread2_pld100_sphv_10hv
+ eais2aread2  = eais2aread2_pld100_sphv_10hv
+ eairaread2   = eairaread2_pld100_sphv_10hv
+ eais1stid2   = eais1stid2_pld100_sphv_10hv
+ eais2stid2   = eais2stid2_pld100_sphv_10hv
+ eairstid2    = eairstid2_pld100_sphv_10hv
+ ikfaread     = ikfaread_pld100_sphv_10hv
+ ikflstid     = ikflstid_pld100_sphv_10hv
+ ikflgatd     = ikflgatd_pld100_sphv_10hv
+ ikfaread2    = ikfaread2_pld100_sphv_10hv*(w/(w+dwikfaread_pld100_sphv_10hv*(1-fem)))
+ ikflstid2    = ikflstid2_pld100_sphv_10hv
+ stikfaread   = stikfaread_pld100_sphv_10hv
+ stikfstid    = stikfstid_pld100_sphv_10hv
+ stikfgatd    = stikfgatd_pld100_sphv_10hv


// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr    = 27
+    toxo  = 320e-9
+    vfbo  = 0
+    nsubo = 6.1523e22
+    npck  = 1e21
+    lpck  = 1e-6
+    rtho  = 1e18
+    ctho  = 0
+    uo    = 0

mcgdcap (s gi s di dtemp) cgdfldmoscap l=2.75 w=w+dwcgdfldmoscap mult=ng
avdclip (d di gi) vdclip vp=vp_pld100_10hv dvp=dvp_pld100_10hv type=type_pld100_10hv

cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cgs_ply_fld)
rgate (g gi) resistor r=(rply*((w+2*12.175*(1-fem))/(length*3*ng)))
xdsub (s sub) cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)) perim=(plnbl*(1-lpe)) soa=1
//cgd_m3_m2_dut (g d) capacitor c=(cgd_m2_m3)    //this is from p39e duts layout, flag out in final model
//cgs_m3_m2_dut (g s) capacitor c=(cgs_m2_m3)    //this is from p39e duts layout, flag out in final model

if (ng_dmy>=2) {


amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=2.75 w=w+dwcgdfldmoscap mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip  vp=vp_pld100_10hv dvp=dvp_pld100_10hv type=type_pld100_10hv
cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}


include "./smos10hv_ade_dfrt.scs" section=pld100_10hv_dfrt
ends

// nld90b_10hv

subckt nld90b_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    sti_dummy                      = 0
+    fem                            = 0
+    soa                            = 1
// parameters to contorl self-heating model, release value
// they are instance parameter, but invisible to the designers,  this means CDF will not use those parameters.
+    selfheat                       = (1)
+    mode_rthcth                    = (1)
// parameters to contorl self-heating model, extraction value:
//+    selfheat                       = (1)
//+    mode_rthcth                    = (2)
//*support mismatch
//*******************************************************************************************************
+    nsmm_delr_tox_nld90b_sphv_10hv  = tmp_nsmm_delr_tox_nld90b_sphv_10hv
+    nsmm_dela_dw_nld90b_sphv_10hv   = tmp_nsmm_dela_dw_nld90b_sphv_10hv
+    nsmm_dela_vfb_nld90b_sphv_10hv  = tmp_nsmm_dela_vfb_nld90b_sphv_10hv
+    nsmm_delr_mobref_nld90b_sphv_10hv = tmp_nsmm_delr_mobref_nld90b_sphv_10hv
+    nsmm_delr_rshl_nld90b_sphv_10hv = tmp_nsmm_delr_rshl_nld90b_sphv_10hv
+    nsmm_delr_nsub_nld90b_sphv_10hv = tmp_nsmm_delr_nsub_nld90b_sphv_10hv
+    l                              = (0.65)
//*******************************************************************************************************
//*relimo model parameters
//*******************************************************************************************************
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                 = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld90b_vthratio     = 1.0
+    presto_nld90b_ronratio     = 0.01/0.74
//*******************************************************************************************************
//*casing variables
//*******************************************************************************************************
+    vfbmm_temp = sqrt(1-2.45e-3*(temp-27))
+    delr_tox_nld90b_sphv_10hv      = (nom_delr_tox_nld90b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_nld90b_sphv_10hv+nsmm_delr_tox_nld90b_sphv_10hv*smm_delr_tox_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
//+    delr_tox_nld90b_sphv_10hv      = (nom_delr_tox_nld90b_sphv_10hv*(1.0+nsig_delr_tox_nld90b_sphv_10hv*sig_delr_tox_nld90b_sphv_10hv+nsmm_delr_tox_nld90b_sphv_10hv*smm_delr_tox_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_nld90b_sphv_10hv       = (nom_dela_dw_nld90b_sphv_10hv+nsig_dela_dw_nld90b_sphv_10hv*sig_dela_dw_nld90b_sphv_10hv+nsmm_dela_dw_nld90b_sphv_10hv*smm_dela_dw_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_nld90b_sphv_10hv      = (nom_dela_vfb_nld90b_sphv_10hv+nsig_dela_vfb_nld90b_sphv_10hv*sig_dela_vfb_nld90b_sphv_10hv+nsmm_dela_vfb_nld90b_sphv_10hv*smm_dela_vfb_nld90b_sphv_10hv(l,w)*(vfbmm_temp)/sqrt(ng/2))
+    dela_vtwl_nld90b_sphv_10hv     = (nom_dela_vtwl_nld90b_sphv_10hv+nsig_dela_vtwl_nld90b_sphv_10hv*sig_dela_vtwl_nld90b_sphv_10hv)
+    delr_mobref_nld90b_sphv_10hv   = (nom_delr_mobref_nld90b_sphv_10hv*(1.0+nsig_delr_mobref_nld90b_sphv_10hv*sig_delr_mobref_nld90b_sphv_10hv+nsmm_delr_mobref_nld90b_sphv_10hv*smm_delr_mobref_nld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_ids_nld90b_sphv_10hv   = (nom_delr_ids_nld90b_sphv_10hv*(1.0+nsig_delr_ids_nld90b_sphv_10hv*sig_delr_ids_nld90b_sphv_10hv))
+    delr_rshl_nld90b_sphv_10hv     = (nom_delr_rshl_nld90b_sphv_10hv*(1.0+nsig_delr_rshl_nld90b_sphv_10hv*sig_delr_rshl_nld90b_sphv_10hv)+nsmm_delr_rshl_nld90b_sphv_10hv*smm_delr_rshl_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_xw_nld90b_sphv_10hv       = (nom_dela_xw_nld90b_sphv_10hv+nsig_dela_xw_nld90b_sphv_10hv*sig_dela_xw_nld90b_sphv_10hv)
+    delr_nsub_nld90b_sphv_10hv     = (1+nsmm_delr_nsub_nld90b_sphv_10hv*smm_delr_nsub_nld90b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_cj_nld90b_sphv_10hv 	        =(nom_delr_cj_nld90b_sphv_10hv*(1.0+nsig_delr_cj_nld90b_sphv_10hv*sig_delr_cj_nld90b_sphv_10hv))
+    delr_is_nld90b_sphv_10hv    	=(nom_delr_is_nld90b_sphv_10hv*exp(nsig_delr_is_nld90b_sphv_10hv*sig_delr_is_nld90b_sphv_10hv))
+    delr_is2_nld90b_sphv_10hv    	=(nom_delr_is2_nld90b_sphv_10hv*exp(nsig_delr_is2_nld90b_sphv_10hv*sig_delr_is2_nld90b_sphv_10hv))
+    delr_ir_nld90b_sphv_10hv 	        =(nom_delr_ir_nld90b_sphv_10hv*exp(nsig_delr_ir_nld90b_sphv_10hv*sig_delr_ir_nld90b_sphv_10hv))

//dummy gate parameters
+    ng_dmy=(2*sti_dummy)
+    ngeff=(ng+ng_dmy)
+    ndi_eff=(ngeff/2)
+    nsi_eff=((ngeff-2)/2)


//*******************************************************************************************************
//*global and process variables
//*******************************************************************************************************
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    cox                            = (cpp_ply_sdt)
+    coxfield                       = (cpp_ply_fld)
+ rs_poly_gate  = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply          = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    djunc                          = (2.5e-6)  //should not scaled by scale as it is vertical


//*********************************************************************************
//*  fixed parameters and expressions
//*********************************************************************************

+    lch                            = (0.65) // alias to l
+    lacc                           = (0.6)  // alias to ldr1
+    wdel                           = (1.545)*(1-fem)
+    ld                             = (5.555)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lch+lacc+ld)  //this distance is the same inside the device and at the edge finger.
+    lflap 			    = (2.5)
+    xiso                           = (1.275)
+    yiso                           = ((9.46)*(1-fem))
+    wdrift                         = (w)
+    ldrift                         = (4.49)
+    ldr1                           = (0.6)
+    lacts                          = (0.455)
+    lactd                          = (1.41)
//*calculated dimensions
+    numbernplus                    = ((3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))*(1-fem)+fem*int_round(w/0.84))
+    weff                           = (numbernplus*0.42)

//*extracted dimensions
+    lovlap                         = (0.00)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrs                           = (0.02)    // tune par for cfr_ply_s & cfr_ply_d
+    lfrd                           = (0)       // tune par for cfr_ply_s & cfr_ply_d
+ tfact_ecrit=1+(tc1_ecrit_nld90b_sphv_10hv+tc2_ecrit_nld90b_sphv_10hv*(temp-tnom))*(temp-tnom)

//*simple model factor
+ swdrlin  = (0)
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*1.0139)


//*****************************************************
//*parasitic resistance and capacitance calculations
//*****************************************************
//*------------------------------------
//*calculations for parasitic diodes
//*------------------------------------
//*ncom+hvnw to pepi (drain to source+body)
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom*(1-fem))*ng)
+    pncom                          = ((2*wdel+pi4models*xncom)*(1-fem)*ng)
+    chncom                         = (w*ng)
//*junc par for sphv input
+ pd_i=(chncom/ng)
+ pd2_i=(pncom/ng )
+ ad_i=((xncom-0.5*ldrift-0.5*lactd)*yncom)
+ ad2_i=(ancom/ng-ad_i)
+ as_i=0
+ ps_i=0

//*capacitance to sub ng total
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))

//*-------------------------------------------------------
//*source drain capacitance area and length calculations
//*m1 and m2 parasitic capacitances ignored
//*-------------------------------------------------------
//*poly over field parasitic to drain (lflap)
+    rpolyhole                      = (2.355)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.12*(1-fem))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole*(1-fem)))
+    apoly                          = (((w+2*1.545*(1-fem))*rpoly+0.5*pi4models*rpoly*rpoly*(1-fem)))
+    aplyfld_d                      = (apoly-ahole)
+    phole                          = (((w+2*0.12*(1-fem))+pi4models*rpolyhole*(1-fem)))
+    ppoly                          = (((w+2*1.545*(1-fem))+pi4models*rpoly*(1-fem)))
+    pplyfld_d                      = (ppoly+phole)
//+ cgd_ply_fld_nld90b=(aplyfld_d*cpp_ply_fld+0*pplyfld_d*cfr_ply_fld)

//*poly over field parasitic to source (top and bottom poly over field)
+    aplyfld_s                      = ((2*(l+ldr1+ld)*0.5)*(1-fem))
+    pplyfld_s                      = ((2*(l+ldr1+ld+0.5))*(1-fem))
+ cgs_ply_fld_nld90b=(aplyfld_s*cpp_ply_fld+pplyfld_s*cfr_ply_fld)

//*accumulation area (poly over accum area)
+ area_accum    = (((w+2*1.545*(1-fem))*lacc+0.5*pi4models*(1-fem)*((ld+lacc)*(ld+lacc)-(ld*ld))))
+ ldr1_i	=((area_accum/w))

//*fringing capacitance (source side edge of poly wall)
+    lfring_s   = ((w+2*8.35*(1-fem)))

//*fringing capacitance (drain side edge of poly wall to aa)
+    lfring_d=(((w+2*1.545*(1-fem))+(pi4models*ld)*(1-fem)))

+ cfr_ply_s=(lfring_s)*(lfrs+lovlap)*cpp_ply_sdt
+ cfr_ply_d=(lfring_d)*(lfrd+lovlap)*cpp_ply_sdt


//*delta_w due to p+ poly over active on phv+pepi (edge)
+    wmosendpg  		    = (13*(1-fem)+fem*1e-3)

//*parasitic psp mosfet due to p+ poly over active on phv+pepi (channel+edge)
+    rationpg			    = (0.8)
+    wchpg			    = (w-weff)*rationpg
+    wpg			    = (wchpg+wmosendpg)

//*delta_w due to n+ poly over active on phv+pepi (edge)
//*implemented in sphv via dlqs to introduce different delta_w for channel (dwqs) than for drift overlap (dwq_nld90b_sphv_10hv)
+    wmosendng  		    = (42*(1-fem)+fem*1e-3)
+    weff_psp			    = (w*1e-6+wvaro_nld90b_sphv_10hv-2*wot_nld90b_sphv_10hv+dwq_nld90b_sphv_10hv)
+    leff_psp			    = (lch*1e-6+lvaro_nld90b_sphv_10hv-lap_nld90b_sphv_10hv+dlq_nld90b_sphv_10hv)
+    dwqs			    = (wmosendng-wchpg)*1e-6
+    dlqs			    = (dlq_nld90b_sphv_10hv+(dwqs-dwq_nld90b_sphv_10hv)*leff_psp/weff_psp)

// parameters for veriloga
+ vp_nld90b_10hv = (45)
+ dvp_nld90b_10hv = (5)
+ type_nld90b_10hv = (1)


//*m1 to poly gate capacitance:
// *check final pcell later
// *total width of source contacts facing gate
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.74*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (number_ct_d*0.18)
+    lfr_m1_ply_s                   = ((w+2*0.555*(1-fem))-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = ((w+2*0.17*(1-fem))-lfr_ct_ply_d)
+    cfr_s_ply_met_nld90b_sphv_10hv           = (nom_cfr_s_ply_met_nld90b_sphv_10hv*(nom_delr_cfr_s_ply_met_nld90b_sphv_10hv+nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv*sig_delr_cfr_s_ply_met_nld90b_sphv_10hv))
+    cfr_d_ply_met_nld90b_sphv_10hv           = (nom_cfr_d_ply_met_nld90b_sphv_10hv*(nom_delr_cfr_d_ply_met_nld90b_sphv_10hv+nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv*sig_delr_cfr_d_ply_met_nld90b_sphv_10hv))
+    cfr_s_ply_m1ct_nld90b_sphv_10hv          = (nom_cfr_s_ply_m1ct_nld90b_sphv_10hv*(nom_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv+nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv*sig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv))
+    cfr_d_ply_m1ct_nld90b_sphv_10hv          = (nom_cfr_d_ply_m1ct_nld90b_sphv_10hv*(nom_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv+nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv*sig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv))

+ cgs_ply_m1=(lfr_m1_ply_s*cfr_s_ply_met_nld90b_sphv_10hv+lfr_ct_ply_s*cfr_s_ply_m1ct_nld90b_sphv_10hv)
+ cgd_ply_m1=(lfr_m1_ply_d*cfr_d_ply_met_nld90b_sphv_10hv+lfr_ct_ply_d*cfr_d_ply_m1ct_nld90b_sphv_10hv)

//*poly gate resistance calculations

+    rgateout                       = (rply*(w+2*8.625*(1-fem))/((lch+lacc)*3))
+    rgatein                        = (rply*(aplyfld_d/(lflap))/(lflap*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))

//**parameters for multi ng
+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+2)-2/(2+2))*0.04)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+0.2)-2/(2+0.2))*(-0.045)*((w+2.0)/w))
+ fac_r_ng_uo=(1+(ngeff/(ngeff+2)-2/(2+2))*0.04*(w/(w+1.5)))


// parameters for the self-heating
+    w_heat=w
+    l_heat=lcell*ng
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_nld90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_nld90b_sphv_10hv)*ngeff
+ cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

// parasitic capacitance caused by dummy gate
+     aply_fld_cgd_dmy=(0)
+     pply_fld_cgd_dmy=(0)
+     cgd_ply_fld_dmy=(0)

// parameters for the D/B diode trr
+ tt_nld90b_10hv = 1.0e-9*maxa(311.27*(1-0.018882963*w),0,1e-12)

// parameters for the BV diode
+ dcbv_nld90b_10hv = (115)


// BV diode model card:
model dbodyBV diode
+ allow_scaling = (yes)
+ jmax    = (1e12)
+ jmelt   = (1e12)
+ tnom    = (27)
+ is      = (1e-30)
+ n       = (1.0)
+ cj      = (1e-30)
+ pta     = (0)
+ tlevc   = (2)
+ tlev    = (2)
+ bv      = (dcbv_nld90b_10hv+bvdss_shift)
+ ibv     = (1e-5/1e-12)


model pspmoscapgsp psp103t type=n
+ tr	 = 27
+ toxo   = toxo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv
+ vfbo   = vfbo_nld90b_sphv_10hv+dela_vfb_nld90b_sphv_10hv+1.1
+ vfbw   = vfbw_nld90b_sphv_10hv-1.2
+ dphibo = dphibo_nld90b_sphv_10hv-0.25
+ dphibw = (dphibw_nld90b_sphv_10hv+3.75)*(1-fem)
+ nsubo  = nsubo_nld90b_sphv_10hv*0.1
+ nsubw  = (nsubw_nld90b_sphv_10hv-1.4)*(1-fem)
+ rtho   = 1e18
+ ctho   = 0
+ uo	 = 0


model sphvt_simkit sphvt
+ type     = (n)
+ vdscale  = (1.18+(-0.24)*(1-fem)/w)*delr_ids_nld90b_sphv_10hv
+ vdscaleb = (0)
+ stvdscale= (-0.1+(-0.55)*(1-fem)/w)
+ ctgo     = (0.02)
+ ctbo     = (0)
+ stcto    = (1.3)
+ strthao  = (1.55)
+ tr	   = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (1)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (1)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (1)
+ swptest  = (0)
+ swdrlin  = (swdrlin)
+ swgedi   = (1)
+ qmc	   = (qmc_nld90b_sphv_10hv)
+ lvaro    = (lvaro_nld90b_sphv_10hv)
+ lvarl    = (lvarl_nld90b_sphv_10hv)
+ lvarw    = (lvarw_nld90b_sphv_10hv*(1-fem))
+ lap	   = (lap_nld90b_sphv_10hv)
+ wvaro    = (wvaro_nld90b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_nld90b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_nld90b_sphv_10hv*(1-fem))
+ wot	   = ((wot_nld90b_sphv_10hv+0.5e-6*dela_dw_nld90b_sphv_10hv)*(1-fem))
+ dlq	   = (dlqs)
+ dwq	   = (dwq_nld90b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_nld90b_sphv_10hv+dela_vfb_nld90b_sphv_10hv+dela_vth_relimo+fac_a_ng_vfbo+hvgsvthdegr*presto_nld90b_vthratio)
+ vfbl     = (vfbl_nld90b_sphv_10hv)
+ vfbw     = (vfbw_nld90b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_nld90b_sphv_10hv+dela_vtwl_nld90b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_nld90b_sphv_10hv)*(1-maxa(-9e-3*(temp-27), 0, 1e-12))
+ stvfbl   = (stvfbl_nld90b_sphv_10hv)
+ stvfbw   = (stvfbw_nld90b_sphv_10hv*(1-maxa(-18e-2*(temp-27), 0, 1e-12))*(1-fem))
+ stvfblw  = (stvfblw_nld90b_sphv_10hv*(1-fem))
+ toxo     = (toxo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ epsroxo  = (epsroxo_nld90b_sphv_10hv)
+ nsubo    = (nsubo_nld90b_sphv_10hv*delr_nsub_nld90b_sphv_10hv)
+ nsubw    = (nsubw_nld90b_sphv_10hv*(1-fem))
+ wseg     = (wseg_nld90b_sphv_10hv)
+ npck     = (npck_nld90b_sphv_10hv)
+ npckw    = (npckw_nld90b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_nld90b_sphv_10hv)
+ lpck     = (lpck_nld90b_sphv_10hv)
+ lpckw    = (lpckw_nld90b_sphv_10hv*(1-fem))
+ fol1     = (fol1_nld90b_sphv_10hv)
+ fol2     = (fol2_nld90b_sphv_10hv)
+ facneffaco = (facneffaco_nld90b_sphv_10hv)
+ facneffacl = (facneffacl_nld90b_sphv_10hv)
+ facneffacw = (facneffacw_nld90b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_nld90b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_nld90b_sphv_10hv)
+ gfacnudl = (gfacnudl_nld90b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_nld90b_sphv_10hv)
+ gfacnudw = (gfacnudw_nld90b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_nld90b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_nld90b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_nld90b_sphv_10hv)
+ vnsubo   = (vnsubo_nld90b_sphv_10hv)
+ nslpo    = (nslpo_nld90b_sphv_10hv)
+ dnsubo   = (dnsubo_nld90b_sphv_10hv)
+ dphibo   = (dphibo_nld90b_sphv_10hv)
+ dphibl   = (dphibl_nld90b_sphv_10hv)
+ dphiblexp = (dphiblexp_nld90b_sphv_10hv)
+ dphibw   = (dphibw_nld90b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_nld90b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_nld90b_sphv_10hv)
+ delvtacl = (delvtacl_nld90b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_nld90b_sphv_10hv)
+ delvtacw = (delvtacw_nld90b_sphv_10hv*(1-fem))
+ delvtaclw = (delvtaclw_nld90b_sphv_10hv*(1-fem))
+ npo	   = (npo_nld90b_sphv_10hv)
+ npl	   = (npl_nld90b_sphv_10hv)
+ cto	   = (cto_nld90b_sphv_10hv)
+ ctl	   = (ctl_nld90b_sphv_10hv)
+ ctlexp   = (ctlexp_nld90b_sphv_10hv)
+ ctw	   = (ctw_nld90b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_nld90b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ toxovdo  = (toxovdo_nld90b_sphv_10hv*delr_tox_nld90b_sphv_10hv)
+ lov	   = (lov_nld90b_sphv_10hv)
+ dlovd    = (dlovd_nld90b_sphv_10hv)
+ novo     = (novo_nld90b_sphv_10hv)
+ novdo    = (novdo_nld90b_sphv_10hv)
+ cfl	   = (cfl_nld90b_sphv_10hv)
+ cflexp   = (cflexp_nld90b_sphv_10hv)
+ cfw	   = (cfw_nld90b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_nld90b_sphv_10hv)
+ uo	   = (uo_nld90b_sphv_10hv*(weff/w)*delr_mobref_nld90b_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_nld90b_sphv_10hv)
+ fbet1w   = (fbet1w_nld90b_sphv_10hv*(1-fem))
+ lp1	   = (lp1_nld90b_sphv_10hv)
+ lp1w     = (lp1w_nld90b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_nld90b_sphv_10hv)
+ lp2	   = (lp2_nld90b_sphv_10hv)
+ betw1    = (betw1_nld90b_sphv_10hv*(1-fem))
+ betw2    = (betw2_nld90b_sphv_10hv*(1-fem))
+ wbet     = (wbet_nld90b_sphv_10hv)
+ stbeto   = (stbeto_nld90b_sphv_10hv)
+ stbetl   = (stbetl_nld90b_sphv_10hv)
+ stbetw   = (stbetw_nld90b_sphv_10hv*(1-fem))
+ stbetlw  = (stbetlw_nld90b_sphv_10hv*(1-fem))
+ mueo     = (mueo_nld90b_sphv_10hv)
+ muew     = (muew_nld90b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_nld90b_sphv_10hv)
+ themuo   = (themuo_nld90b_sphv_10hv)
+ stthemuo = (stthemuo_nld90b_sphv_10hv)
+ cso	   = (cso_nld90b_sphv_10hv)
+ csl	   = (csl_nld90b_sphv_10hv)
+ cslexp   = (cslexp_nld90b_sphv_10hv)
+ csw	   = (csw_nld90b_sphv_10hv*(1-fem))
+ cslw     = (cslw_nld90b_sphv_10hv*(1-fem))
+ stcso    = (stcso_nld90b_sphv_10hv)
+ xcoro    = (xcoro_nld90b_sphv_10hv)
+ xcorl    = (xcorl_nld90b_sphv_10hv)
+ xcorw    = (xcorw_nld90b_sphv_10hv*(1-fem))
+ xcorlw   = (xcorlw_nld90b_sphv_10hv*(1-fem))
+ stxcoro  = (stxcoro_nld90b_sphv_10hv)
+ fetao    = (fetao_nld90b_sphv_10hv)
+ rsw1     = (rsw1_nld90b_sphv_10hv)
+ rsw2     = (rsw2_nld90b_sphv_10hv*(1-fem))
+ strso    = (strso_nld90b_sphv_10hv)
+ rsbo     = (rsbo_nld90b_sphv_10hv)
+ rsgo     = (rsgo_nld90b_sphv_10hv)
+ thesato  = ((thesato_nld90b_sphv_10hv)*(1+maxa(-0.5e-2*(w/(w+(1-fem)*3.0))*(temp-27),0,1e-9)))
+ thesatl  = (thesatl_nld90b_sphv_10hv)
+ thesatlexp = (thesatlexp_nld90b_sphv_10hv)
+ thesatw  = (thesatw_nld90b_sphv_10hv*(1-fem))
+ thesatlw = (thesatlw_nld90b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_nld90b_sphv_10hv)
+ stthesatl = (stthesatl_nld90b_sphv_10hv)
+ stthesatw = (stthesatw_nld90b_sphv_10hv*(1-fem))
+ stthesatlw = (stthesatlw_nld90b_sphv_10hv*(1-fem))
+ thesatbo = (thesatbo_nld90b_sphv_10hv)
+ thesatgo = (thesatgo_nld90b_sphv_10hv)
+ thesatgl = (thesatgl_nld90b_sphv_10hv)
+ thesatgw = ((thesatgw_nld90b_sphv_10hv)*(1-fem))
+ axo	   = (axo_nld90b_sphv_10hv)
+ axl	   = (axl_nld90b_sphv_10hv)
+ alpl     = (alpl_nld90b_sphv_10hv)
+ alplexp  = (alplexp_nld90b_sphv_10hv)
+ alpw     = (alpw_nld90b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_nld90b_sphv_10hv)
+ alp1lexp = (alp1lexp_nld90b_sphv_10hv)
+ alp1l2   = (alp1l2_nld90b_sphv_10hv)
+ alp1w    = (alp1w_nld90b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_nld90b_sphv_10hv)
+ alp2lexp = (alp2lexp_nld90b_sphv_10hv)
+ alp2l2   = (alp2l2_nld90b_sphv_10hv)
+ alp2w    = (alp2w_nld90b_sphv_10hv*(1-fem))
+ vpo	   = (vpo_nld90b_sphv_10hv)
+ a1o	   = (a1o_nld90b_sphv_10hv)
+ a1l	   = (a1l_nld90b_sphv_10hv)
+ a1w	   = (a1w_nld90b_sphv_10hv*(1-fem))
+ a2o	   = (a2o_nld90b_sphv_10hv)
+ sta2o    = (sta2o_nld90b_sphv_10hv)
+ a3o	   = (a3o_nld90b_sphv_10hv)
+ a3l	   = (a3l_nld90b_sphv_10hv)
+ a3w	   = (a3w_nld90b_sphv_10hv*(1-fem))
+ a4o	   = (a4o_nld90b_sphv_10hv)
+ a4l	   = (a4l_nld90b_sphv_10hv)
+ a4w	   = (a4w_nld90b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_nld90b_sphv_10hv)
+ iginvlw  = (iginvlw_nld90b_sphv_10hv)
+ igovw    = (igovw_nld90b_sphv_10hv)
+ igovdw   = (igovdw_nld90b_sphv_10hv)
+ stigo    = (stigo_nld90b_sphv_10hv)
+ gc2o     = (gc2o_nld90b_sphv_10hv)
+ gc3o     = (gc3o_nld90b_sphv_10hv)
+ chibo    = (chibo_nld90b_sphv_10hv)
+ agidlw   = (agidlw_nld90b_sphv_10hv)
+ agidldw  = (agidldw_nld90b_sphv_10hv)
+ bgidlo   = (bgidlo_nld90b_sphv_10hv)
+ bgidldo  = (bgidldo_nld90b_sphv_10hv)
+ stbgidlo = (stbgidlo_nld90b_sphv_10hv)
+ stbgidldo = (stbgidldo_nld90b_sphv_10hv)
+ cgidlo   = (cgidlo_nld90b_sphv_10hv)
+ cgidldo  = (cgidldo_nld90b_sphv_10hv)
+ cgbovl   = (cgbovl_nld90b_sphv_10hv)
+ cfrw     = (cfrw_nld90b_sphv_10hv)
+ cfrdw    = (cfrdw_nld90b_sphv_10hv)
+ fnto     = (fnto_nld90b_sphv_10hv)
+ nfalw    = (nfalw_nld90b_sphv_10hv)
+ nfblw    = (nfblw_nld90b_sphv_10hv)
+ nfclw    = (nfclw_nld90b_sphv_10hv)
+ efo	   = (efo_nld90b_sphv_10hv)
+ lintnoi  = (lintnoi_nld90b_sphv_10hv)
+ alpnoi   = (alpnoi_nld90b_sphv_10hv)
+ kvthoweo = (kvthoweo_nld90b_sphv_10hv)
+ kvthowel = (kvthowel_nld90b_sphv_10hv)
+ kvthowew = (kvthowew_nld90b_sphv_10hv*(1-fem))
+ kvthowelw = (kvthowelw_nld90b_sphv_10hv*(1-fem))
+ kuoweo   = (kuoweo_nld90b_sphv_10hv)
+ kuowel   = (kuowel_nld90b_sphv_10hv)
+ kuowew   = (kuowew_nld90b_sphv_10hv*(1-fem))
+ kuowelw  = (kuowelw_nld90b_sphv_10hv*(1-fem))
+ rgo	   = (rgo_nld90b_sphv_10hv)
+ rsh	   = (rsh_nld90b_sphv_10hv)
+ rbulko   = (rbulko_nld90b_sphv_10hv)
+ rwello   = (rwello_nld90b_sphv_10hv)
+ rjunso   = (rjunso_nld90b_sphv_10hv/(w+(1-fem)*dwrjunso_nld90b_sphv_10hv))
+ rjundo   = ((rjundo_nld90b_sphv_10hv/(w+(1-fem)*dwrjundo_nld90b_sphv_10hv))*(1+1.0e-3*(temp-27)))
+ rint     = (rint_nld90b_sphv_10hv)
+ rvpoly   = (rvpoly_nld90b_sphv_10hv)
+ rshg     = (rshg_nld90b_sphv_10hv)
+ dlsil    = (dlsil_nld90b_sphv_10hv)
+ saref    = (saref_nld90b_sphv_10hv)
+ sbref    = (sbref_nld90b_sphv_10hv)
+ wlod     = (wlod_nld90b_sphv_10hv)
+ kuo	   = (kuo_nld90b_sphv_10hv)
+ kvsat    = (kvsat_nld90b_sphv_10hv)
+ tkuo     = (tkuo_nld90b_sphv_10hv)
+ lkuo     = (lkuo_nld90b_sphv_10hv)
+ wkuo     = (wkuo_nld90b_sphv_10hv*(1-fem))
+ pkuo     = (pkuo_nld90b_sphv_10hv*(1-fem))
+ llodkuo  = (llodkuo_nld90b_sphv_10hv)
+ wlodkuo  = (wlodkuo_nld90b_sphv_10hv)
+ kvtho    = (kvtho_nld90b_sphv_10hv)
+ lkvtho   = (lkvtho_nld90b_sphv_10hv)
+ wkvtho   = (wkvtho_nld90b_sphv_10hv*(1-fem))
+ pkvtho   = (pkvtho_nld90b_sphv_10hv*(1-fem))
+ llodvth  = (llodvth_nld90b_sphv_10hv)
+ wlodvth  = (wlodvth_nld90b_sphv_10hv)
+ stetao   = (stetao_nld90b_sphv_10hv)
+ lodetao  = (lodetao_nld90b_sphv_10hv)
+ scref    = (scref_nld90b_sphv_10hv)
+ web	   = (web_nld90b_sphv_10hv)
+ wec	   = (wec_nld90b_sphv_10hv)
+ adr1o    = (adr1o_nld90b_sphv_10hv)
+ adr1l    = (adr1l_nld90b_sphv_10hv)
+ adr1w    = (adr1w_nld90b_sphv_10hv*(1-fem))
+ adr2o    = (adr2o_nld90b_sphv_10hv)
+ stadr2o  = (stadr2o_nld90b_sphv_10hv)
+ adr3o    = (adr3o_nld90b_sphv_10hv)
+ adr3l    = (adr3l_nld90b_sphv_10hv)
+ adr3w    = (adr3w_nld90b_sphv_10hv*(1-fem))
+ adr4o    = (adr4o_nld90b_sphv_10hv)
+ adr4l    = (adr4l_nld90b_sphv_10hv)
+ adr4w    = (adr4w_nld90b_sphv_10hv*(1-fem))
+ adr5o    = (adr5o_nld90b_sphv_10hv)
+ adr5l    = (adr5l_nld90b_sphv_10hv)
+ adr5w    = (adr5w_nld90b_sphv_10hv*(1-fem))
+ bidr1o   = (bidr1o_nld90b_sphv_10hv)
+ bidr1l   = (bidr1l_nld90b_sphv_10hv)
+ bidr1w   = (bidr1w_nld90b_sphv_10hv*(1-fem))
+ bidr2o   = (bidr2o_nld90b_sphv_10hv)
+ bidr2w   = (bidr2w_nld90b_sphv_10hv*(1-fem))
+ rtho     = (rth_f)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_nld90b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_nld90b_sphv_10hv*delr_rshl_nld90b_sphv_10hv*delr_rdsw_relimo*fac_r_ng_rshldd)*fac_rshldd*(1+(hcirondegrfac+offrondegrfac)*presto_nld90b_ronratio))
+ xw	   = ((xw_nld90b_sphv_10hv+1.0e-6*dela_xw_nld90b_sphv_10hv)*(1-fem))
+ nwxw     = (nwxw_nld90b_sphv_10hv*(1-fem))
+ xl	   = (xl_nld90b_sphv_10hv)
+ xlw	   = (xlw_nld90b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_nld90b_sphv_10hv)
+ nst	   = (nst_nld90b_sphv_10hv)
+ ats	   = (ats_nld90b_sphv_10hv)
+ dfinf    = (dfinf_nld90b_sphv_10hv)
+ dfw	   = (dfw_nld90b_sphv_10hv*(1-fem))
+ dfl	   = (dfl_nld90b_sphv_10hv)
+ dflw     = (dflw_nld90b_sphv_10hv*(1-fem))
+ dp	   = (dp_nld90b_sphv_10hv)
+ ecrit    = (ecrit_nld90b_sphv_10hv*tfact_ecrit)
+ ecorn    = (ecorn_nld90b_sphv_10hv)
+ du	   = (du_nld90b_sphv_10hv)
+ tc1	   = (tc1_nld90b_sphv_10hv)
+ tc2	   = (tc2_nld90b_sphv_10hv)
+ tc1l     = (tc1l_nld90b_sphv_10hv)
+ tc2l     = (tc2l_nld90b_sphv_10hv)
+ tc1w     = (tc1w_nld90b_sphv_10hv*(1-fem))
+ tc2w     = (tc2w_nld90b_sphv_10hv*(1-fem))
+ theacc   = (theacc_nld90b_sphv_10hv)
+ theacc2  = (theacc2_nld90b_sphv_10hv)
+ aacc     = (aacc_nld90b_sphv_10hv)
+ rva	   = (rva_nld90b_sphv_10hv)
+ dta	   = (dta_nld90b_sphv_10hv)
+ trj	   = (27)
+ cjarea   = (cjarea_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlsti   = (cjlsti_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlgat   = (cjlgat_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ vbiarea  = (vbiarea_nld90b_sphv_10hv)
+ vbisti   = (vbisti_nld90b_sphv_10hv)
+ vbigat   = (vbigat_nld90b_sphv_10hv)
+ parea    = (parea_nld90b_sphv_10hv)
+ psti     = (psti_nld90b_sphv_10hv)
+ pgat     = (pgat_nld90b_sphv_10hv)
+ is1area  = (is1area_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttarea   = (tt_nld90b_10hv)
+ is2area  = (is2area_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irarea   = (irarea_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1area = (stis1area_nld90b_sphv_10hv)
+ stis2area = (stis2area_nld90b_sphv_10hv)
+ stirarea = (stirarea_nld90b_sphv_10hv)
+ n1area   = (n1area_nld90b_sphv_10hv)
+ n2area   = (n2area_nld90b_sphv_10hv)
+ nrarea   = (nrarea_nld90b_sphv_10hv)
+ is1lsti  = (is1lsti_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttlsti   = (tt_nld90b_10hv)
+ is2lsti  = (is2lsti_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irlsti   = (irlsti_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1sti = (stis1sti_nld90b_sphv_10hv)
+ stis2sti = (stis2sti_nld90b_sphv_10hv)
+ stirsti  = (stirsti_nld90b_sphv_10hv)
+ n1sti    = (n1sti_nld90b_sphv_10hv)
+ n2sti    = (n2sti_nld90b_sphv_10hv)
+ nrsti    = (nrsti_nld90b_sphv_10hv)
+ is1lgat  = (is1lgat_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttlgat   = (tt_nld90b_10hv)
+ is2lgat  = (is2lgat_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ irlgat   = (irlgat_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1gat = (stis1gat_nld90b_sphv_10hv)
+ stis2gat = (stis2gat_nld90b_sphv_10hv)
+ stirgat  = (stirgat_nld90b_sphv_10hv)
+ n1gat    = (n1gat_nld90b_sphv_10hv)
+ n2gat    = (n2gat_nld90b_sphv_10hv)
+ nrgat    = (nrgat_nld90b_sphv_10hv)
+ cjaread  = (cjaread_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlstid  = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ cjlgatd  = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ vbiaread = (vbiaread_nld90b_sphv_10hv)
+ vbistid  = (vbigatd_nld90b_sphv_10hv)
+ vbigatd  = (vbigatd_nld90b_sphv_10hv)
+ paread   = (paread_nld90b_sphv_10hv)
+ pstid    = (pgatd_nld90b_sphv_10hv)
+ pgatd    = (pgatd_nld90b_sphv_10hv)
+ is1aread = (is1aread_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttaread  = (tt_nld90b_10hv)
+ is2aread = (is2aread_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ iraread  = (iraread_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1aread = (stis1aread_nld90b_sphv_10hv)
+ stis2aread = (stis2aread_nld90b_sphv_10hv)
+ stiraread = (stiraread_nld90b_sphv_10hv)
+ n1aread  = (n1aread_nld90b_sphv_10hv)
+ n2aread  = (n2aread_nld90b_sphv_10hv)
+ nraread  = (nraread_nld90b_sphv_10hv)
+ is1lstid = (is1lstid_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlstid  = (tt_nld90b_10hv)
+ is2lstid = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlstid  = (irlstid_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1stid = (stis1stid_nld90b_sphv_10hv)
+ stis2stid = (stis2stid_nld90b_sphv_10hv)
+ stirstid = (stirstid_nld90b_sphv_10hv)
+ n1stid   = (n1stid_nld90b_sphv_10hv)
+ n2stid   = (n2stid_nld90b_sphv_10hv)
+ nrstid   = (nrstid_nld90b_sphv_10hv)
+ is1lgatd = (is1lgatd_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlgatd  = (tt_nld90b_10hv)
+ is2lgatd = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlgatd  = (irlgatd_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1gatd = (stis1gatd_nld90b_sphv_10hv)
+ stis2gatd = (stis2gatd_nld90b_sphv_10hv)
+ stirgatd = (stirgatd_nld90b_sphv_10hv)
+ n1gatd   = (n1gatd_nld90b_sphv_10hv)
+ n2gatd   = (n2gatd_nld90b_sphv_10hv)
+ nrgatd   = (nrgatd_nld90b_sphv_10hv)
+ cjaread2 = (cjaread_nld90b_sphv_10hv*delr_cj_nld90b_sphv_10hv)
+ cjlstid2 = (cjaread_nld90b_sphv_10hv*djunc*delr_cj_nld90b_sphv_10hv)
+ vbiaread2 = (vbiaread_nld90b_sphv_10hv)
+ vbistid2 = (vbistid2_nld90b_sphv_10hv)
+ paread2  = (paread_nld90b_sphv_10hv)
+ pstid2   = (pstid2_nld90b_sphv_10hv)
+ is1aread2 = (is1aread2_nld90b_sphv_10hv*delr_is_nld90b_sphv_10hv)
+ ttaread2 = (tt_nld90b_10hv)
+ is2aread2 = (is2aread_nld90b_sphv_10hv*delr_is2_nld90b_sphv_10hv)
+ iraread2 = (iraread2_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1aread2 = (stis1aread_nld90b_sphv_10hv)*(1-(1-fem)*5.0/w)
+ stis2aread2 = (stis2aread_nld90b_sphv_10hv)
+ stiraread2 = (stiraread2_nld90b_sphv_10hv)
+ n1aread2 = (n1aread2_nld90b_sphv_10hv)*(1+(1-fem)*0.1/w)
+ n2aread2 = (n2aread2_nld90b_sphv_10hv)
+ nraread2 = (nraread2_nld90b_sphv_10hv)
+ is1lstid2 = (is1aread_nld90b_sphv_10hv*djunc*delr_is_nld90b_sphv_10hv)
+ ttlstid2 = (tt_nld90b_10hv)
+ is2lstid2 = (is2aread_nld90b_sphv_10hv*djunc*delr_is2_nld90b_sphv_10hv)
+ irlstid2 = (irlstid2_nld90b_sphv_10hv*delr_ir_nld90b_sphv_10hv)
+ stis1stid2 = (stis1stid2_nld90b_sphv_10hv)
+ stis2stid2 = (stis2stid2_nld90b_sphv_10hv)
+ stirstid2 = (stirstid2_nld90b_sphv_10hv)
+ n1stid2  = (n1stid2_nld90b_sphv_10hv)
+ n2stid2  = (n2stid2_nld90b_sphv_10hv)
+ nrstid2  = (nrstid2_nld90b_sphv_10hv)
+ eairarea	  = (1.12)
+ eairaread	  = (1.12)
+ eairaread2	  = (1.12)
+ eairgat	  = (1.12)
+ eairgatd	  = (1.12)
+ eairsti	  = (1.12)
+ eairstid	  = (1.12)
+ eairstid2	  = (1.12)
+ eais1area	  = (1.12)
+ eais1aread	  = (1.12)
+ eais1aread2	  = (1.12)
+ eais1gat	  = (1.12)
+ eais1gatd	  = (1.12)
+ eais1sti	  = (1.12)
+ eais1stid	  = (1.12)
+ eais1stid2	  = (1.12)
+ eais2area	  = (1.12)
+ eais2aread	  = (1.12)
+ eais2aread2	  = (1.12)
+ eais2gat	  = (1.12)
+ eais2gatd	  = (1.12)
+ eais2sti	  = (1.12)
+ eais2stid	  = (1.12)
+ eais2stid2	  = (1.12)
+ ikfarea               = ikfarea_nld90b_sphv_10hv
+ ikflsti               = ikfarea_nld90b_sphv_10hv*djunc
+ ikflgat               = ikfarea_nld90b_sphv_10hv*djunc
+ stikfarea              = stikfarea_nld90b_sphv_10hv
+ stikfsti              = stikfarea_nld90b_sphv_10hv
+ stikfgat              = stikfarea_nld90b_sphv_10hv
+ ikfaread              = ikfaread_nld90b_sphv_10hv*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflstid              = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflgatd              = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikfaread2             = ikfaread_nld90b_sphv_10hv*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ ikflstid2             = ikfaread_nld90b_sphv_10hv*djunc*(w/(w+dwikfaread_nld90b_sphv_10hv))
+ stikfaread             = stikfaread_nld90b_sphv_10hv
+ stikfstid             = stikfaread_nld90b_sphv_10hv
+ stikfgatd             = stikfaread_nld90b_sphv_10hv
+ stikfaread2            = stikfaread_nld90b_sphv_10hv
+ stikfstid2            = stikfaread_nld90b_sphv_10hv

// ******  elements:
mpowermos (d intg s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1_i mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
mendcapp  (s intg s s dtemp) pspmoscapgsp l=lch w=(wpg) mult=ng

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=p
+    tr    = 27
+    toxo  = 380e-9
+    vfbo  = 0
+    nsubo = 1.5e22
+    npck  = 1e22
+    lpck  = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo    = 0

mcgdcap (s intg s di dtemp) cgdfldmoscap l=2.5 w=aplyfld_d/2.5 mult=ng
avdclip (d di intg) vdclip vp=vp_nld90b_10hv dvp=dvp_nld90b_10hv type=type_nld90b_10hv


cgs_fld       (intg s)  capacitor c=(cgs_ply_fld_nld90b) m=ng
cgs_ply_cfr   (intg s)  capacitor c=(cfr_ply_s) m=ng
cgs_m1        (intg s) capacitor c=(cgs_ply_m1)  m=ng
rgate     (g intg) resistor r=rgatetot m=ng
dbodyBV (s rs)  dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rs d)   resistor r=0.01
xdsub     (s sub) cdgontub_box_sub_10hv  area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1

//dummy_gate model
if (ng_dmy>=2) {
mpowermos_dmy (d s s s dtemp) sphvt_simkit w=w l=lch ldrift=ldrift wdrift=wdrift ldr1=ldr1_i mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i
mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=2.5 w=aplyfld_d/2.5 mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip vp=vp_nld90b_10hv dvp=dvp_nld90b_10hv type=type_nld90b_10hv

}


include "./smos10hv_ade_dfrt.scs" section=nld90b_10hv_dfrt
ends
// pld65_10hv

subckt pld65_10hv (d g s sub)

parameters
+ w				 = (2.5)
+ ng				 = (2)
+ lpe				 = (0)
+ sti_dummy			 = (0)
+ fem				 = (0)
+ soa				 = (1)
+ selfheat			 = (1)
+ mode_rthcth			 = (1)
+ dela_vth_relimo		 = (0)
+ dela_vth_relimo_mod		 = (0)
+ delr_u0_relimo		 = (1)
+ delr_rdsw_relimo		 = (1)
+ delr_a0_relimo		 = (1)
+ presto_device_active           = (1)
+ nbtidamage		         = (0.0)
+ nbtivthdegr		         = (0.0)
+ pbtidamage		         = (0.0)
+ pbtivthdegr		         = (0.0)
+ hcirondegrfac 	         = (0.0)
+ offrondegrfac 	         = (0.0)
+ hvgsvthdegr		         = (0.0)
+ hcidamage1		         = (0.0)
+ hcidamage2		         = (0.0)
+ offdamage1		         = (0.0)
+ offdamage2		         = (0.0)
+ hvgsdamage		         = (0.0)
+ presto_pld65_vthratio          = 1.0*(1.0/1.2052)
+ presto_pld65_ronratio          = 0.01/1.0/1.0636
+ l				 = (0.5)
+ tn                             = (27+273.15)
+ delt                           = (temp+273.15-tn)
+ nsmm_delr_tox_pld65_sphv_10hv    = tmp_nsmm_delr_tox_pld65_sphv_10hv
+ nsmm_dela_vfb_pld65_sphv_10hv    = tmp_nsmm_dela_vfb_pld65_sphv_10hv
+ nsmm_dela_vtw_pld65_sphv_10hv    = tmp_nsmm_dela_vtw_pld65_sphv_10hv
+ nsmm_delr_uch_pld65_sphv_10hv    = tmp_nsmm_delr_uch_pld65_sphv_10hv
+ nsmm_delr_res_pld65_sphv_10hv    = tmp_nsmm_delr_res_pld65_sphv_10hv
+ nsmm_dela_dwox_pld65_sphv_10hv   = tmp_nsmm_dela_dwox_pld65_sphv_10hv
+ nsmm_delr_nsub_pld65_sphv_10hv   = tmp_nsmm_delr_nsub_pld65_sphv_10hv


//process parameters
//+ delr_tox_pld65_sphv_10hv    = (nom_delr_tox_pld65_sphv_10hv*(1+sig_delr_tox_pld65_sphv_10hv*nsig_delr_tox_pld65_sphv_10hv+nsmm_delr_tox_pld65_sphv_10hv*smm_delr_tox_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_tox_pld65_sphv_10hv      = (nom_delr_tox_pld65_sphv_10hv*(1+sig_delr_tox_pld65_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld65_sphv_10hv*smm_delr_tox_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld65_sphv_10hv      = (nom_dela_vfb_pld65_sphv_10hv+(sig_dela_vfb_pld65_sphv_10hv*nsig_dela_vfb_pld65_sphv_10hv)+nsmm_dela_vfb_pld65_sphv_10hv*smm_dela_vfb_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld65_sphv_10hv      = (nom_dela_vtw_pld65_sphv_10hv+(sig_dela_vtw_pld65_sphv_10hv*nsig_dela_vtw_pld65_sphv_10hv)+nsmm_dela_vtw_pld65_sphv_10hv*smm_dela_vtw_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld65_sphv_10hv      = (nom_delr_uch_pld65_sphv_10hv*(1+sig_delr_uch_pld65_sphv_10hv*nsig_delr_uch_pld65_sphv_10hv+nsmm_delr_uch_pld65_sphv_10hv*smm_delr_uch_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld65_sphv_10hv      = (nom_delr_res_pld65_sphv_10hv*(1+sig_delr_res_pld65_sphv_10hv*nsig_delr_res_pld65_sphv_10hv+nsmm_delr_res_pld65_sphv_10hv*smm_delr_res_pld65_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld65_sphv_10hv     = (nom_dela_dwox_pld65_sphv_10hv+(sig_dela_dwox_pld65_sphv_10hv*nsig_dela_dwox_pld65_sphv_10hv)+nsmm_dela_dwox_pld65_sphv_10hv*smm_dela_dwox_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld65_sphv_10hv     = (1+nsmm_delr_nsub_pld65_sphv_10hv*smm_delr_nsub_pld65_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld65_sphv_10hv	= (nom_delr_cj_pld65_sphv_10hv*(1.0+nsig_delr_cj_pld65_sphv_10hv*sig_delr_cj_pld65_sphv_10hv))
+ delr_is_pld65_sphv_10hv	= (nom_delr_is_pld65_sphv_10hv*exp(nsig_delr_is_pld65_sphv_10hv*sig_delr_is_pld65_sphv_10hv))
+ delr_is2_pld65_sphv_10hv	= (nom_delr_is2_pld65_sphv_10hv*exp(nsig_delr_is2_pld65_sphv_10hv*sig_delr_is2_pld65_sphv_10hv))
+ delr_ir_pld65_sphv_10hv	= (nom_delr_ir_pld65_sphv_10hv*exp(nsig_delr_ir_pld65_sphv_10hv*sig_delr_ir_pld65_sphv_10hv))

parameters
//+ nde=(fmod(ng,2))
+ nde     = (0)
+ nse     = (2-nde)
+ nd      = ((ng+nde)/2)
+ ns      = (1-nde+nd)
+ ndi     = (nd-nde)
+ nsi     = (ns-nse)

//dummy parameters
+ ng_dmy  = (2*sti_dummy)
+ ng_eff  = (ng+ng_dmy)
+ ndi_eff = (ng_eff/2)
+ nsi_eff = ((ng_eff-2)/2)

+ wdrift  = (w)
+ ldrift  = (3.0)
+ ldr1    = (0.45)
+ lacts   = (0.3)
+ lactd   = (0.69)
+ lactg   = (0.35)

// junction calculation
+ as               = (w*lacts)*0
+ ps               = ((w+lacts)*2.0)*0
+ w2nhv            = (5.3)*(1-fem)
+ rnhv             = (1.44)
+ rnhv_p           = 2*rnhv*pi4models
+ rnhv_a           = rnhv*rnhv*pi4models
+ rnhv_daera       = (rnhv*rnhv-rnhv_a/4.0)*(1-fem)
+ ad               = ((ldr1+lactg+ldrift/2.0)*(w+2.0*w2nhv*(1-fem))-rnhv_daera*2.0*(1-fem))
+ pd               = ((ldr1+lactg+ldrift/2.0)*2.0*(1-fem)+(w+2.0*w2nhv*(1-fem))-4.0*rnhv*(1-fem)+rnhv_p/2.0*(1-fem))
+ ad2              = ((ldrift/2.0+lactd/2.0)*(w+2.0*w2nhv*(1-fem)))
+ pd2              = (ldrift+lactd)*(1-fem)

// nbl-oxide-sub box cap calculation
+ lb2b_d           = (8.29)
+ lp2p_s           = (0.99)
+ lp2dt_s          = (3.66)
+ w2dt             = (9.3)
+ xlnbl            = (lp2dt_s*nse+l*ng_eff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl            = (w+2.0*w2dt*(1-fem))
+ alnbl            = (xlnbl*ylnbl)
+ plnbl            = (2.0*(xlnbl*(1-fem)+ylnbl))

// heat region calculation
+ w_heat           = (w)
+ l_heat           = (lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ fac_rthNgT       = 1.8/(1.0+0.7/ng)*(1+0.00002*(temp-tnom)/(0.03+0.1/ng))
+ rth_f            = ((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld65_sphv_10hv*fac_rthNgT+(mode_rthcth==2)*rth*fac_rth_pld65_sphv_10hv*fac_rthNgT)*ng_eff
+ cth_f            = ((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff

+ djunc            = (2.5*1e-06)


//parasitic rgate calcultion
+ lflap 	   = (1.2)
+ length 	   = (l+ldr1+lflap)
+ w_ploycont2act   = (6.075)
+ rs_poly_gate     = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply             = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ r_gate           = (rply*((w+2*w_ploycont2act*(1-fem))/(length*3*ng)))

// calculation for poly over field parasitic capacitance, from pld90b
+ dwcgdfldmoscap   = (18)*(1-fem)
+ dwcgd_ply_fld    = (5)*(1-fem)
+ cgd_ply_fld      = (4.8e-17)*(w+dwcgd_ply_fld)*ng
+ cgs_ply_fld      = (3.375e-15)*(1-fem)*ng

// parasitic capacitnace caused by dummy gate, from pld90b
+ cgd_ply_fld_dmy  = (4.8e-17)*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld65_10hv    = (27)
+ dvp_pld65_10hv   = (6.2)
+ type_pld65_10hv  = (-1)

// calculation for parasitic Cgd & Cgs from routing, should be flagged off
// nom values are copied from V3M_1_FULL
// those nom's flagged off are used only for parasitic cap of dut routing
//+    nom_cpp_m2_ply_copied                 = (0.0269586592e-15)
//+    nom_cfr_m2_ply_copied                 = (0.0328181197349055e-15)
//+    nom_delr_cpp_m2_ply_copied            = (1)
//+    nom_delr_cfr_m2_ply_copied            = (1)
//+    nom_cpp_m2_m1_copied                  = (0.0672904e-15)
//+    nom_cfr_m2_m1_copied                  = (0.0412247297136575e-15)
//+    nom_delr_cpp_m2_m1_copied             = (1)
//+    nom_delr_cfr_m2_m1_copied             = (1)
+    nom_cpp_m3_ply_copied                 = (0.016515949268292e-15)
+    nom_cfr_m3_ply_copied                 = (0.0312438978945075e-15)
+    nom_delr_cpp_m3_ply_copied            = (1)
+    nom_delr_cfr_m3_ply_copied            = (1)
//+    nom_cpp_m3_m1_copied                  = (0.026105678461538e-15)
//+    nom_cfr_m3_m1_copied                  = (0.0347696665106795e-15)
//+    nom_delr_cpp_m3_m1_copied             = (1)
//+    nom_delr_cfr_m3_m1_copied             = (1)
//+    nom_cpp_ply_fld_copied                = (0.092229166666667e-15)
//+    nom_cfr_ply_fld_copied                = (0.042429385448008e-15)
//+    nom_delr_cpp_ply_fld_copied           = (1)
//+    nom_delr_cfr_ply_fld_copied           = (1)
//+    cpp_ply_fld                           = (nom_cpp_ply_fld_copied*nom_delr_cpp_ply_fld_copied)
//+    cfr_ply_fld                           = (nom_cfr_ply_fld_copied*nom_delr_cfr_ply_fld_copied)

//intrinsic cgs from pcell routing, should be kept
+    w2ply_inner                    = 2.175
+    w2ply_outer                    = 6.3
+    w_m1onpoly                     = 1.27
+    w_m1notonpoly                  = (w2ply_outer-w2ply_inner-w_m1onpoly)
+    w2m1_s                         = 0.555
+    a_m1_poly_cgs                  = 0.45*(w+w2m1_s*2*(1-fem))*ng
+    p_m1_poly_cgs                  = (w+w2m1_s*2*(1-fem))*ng
+    cgs1_m1_ply                    = a_m1_poly_cgs*nom_cpp_m3_ply_copied*nom_delr_cpp_m3_ply_copied+p_m1_poly_cgs*nom_cfr_m3_ply_copied*nom_delr_cfr_m3_ply_copied

//parasitic cgd from dut routing, should be flagged off
//+    a_m2_poly_cgd                  = 0.69*w_m1notonpoly/2*ng
//+    p_m2_poly_cgd                  = w_m1notonpoly*ng
//+    a_m2_m1_cgd                    = 0.69*w_m1onpoly/2*ng
//+    p_m2_m1_cgd                    = w_m1onpoly*ng
//+    cgd1_m2_ply                    = a_m2_poly_cgd*nom_cpp_m2_ply_copied*nom_delr_cpp_m2_ply_copied+p_m2_poly_cgd*nom_cfr_m2_ply_copied*nom_delr_cfr_m2_ply_copied
//+    cgd2_m2_m1                     = a_m2_m1_cgd*nom_cpp_m2_m1_copied*nom_delr_cpp_m2_m1_copied+p_m2_m1_cgd*nom_cfr_m2_m1_copied*nom_delr_cfr_m2_m1_copied

//parasitic cgs from dut routing, should be flagged off
//+    a_m3_ply_cgs                   = 0.45*(w2ply_inner-w2m1_s+w_m1notonpoly)*ng
//+    p_m3_ply_cgs                   = (w2ply_inner-w2m1_s+w_m1notonpoly)*ng
//+    a_m3_m1_cgs_nsi                = 0.45*w_m1onpoly*nsi
//+    p_m3_m1_cgs_nsi                = w_m1onpoly*nsi
//+    a_m3_ply_cgs_nse               = 0.45*w_m1onpoly*nse
//+    p_m3_ply_cgs_nse               = w_m1onpoly*nse
//+    cgs2_m3_ply                    = (a_m3_ply_cgs+a_m3_ply_cgs_nse)*nom_cpp_m3_ply_copied*nom_delr_cpp_m3_ply_copied+(p_m3_ply_cgs+p_m3_ply_cgs_nse)*nom_cfr_m3_ply_copied*nom_delr_cfr_m3_ply_copied
//+    cgs3_m3_m1                     = a_m3_m1_cgs_nsi*nom_cpp_m3_m1_copied*nom_delr_cpp_m3_m1_copied+p_m3_m1_cgs_nsi*nom_cfr_m3_m1_copied*nom_delr_cfr_m3_m1_copied


//intrinsic cgd & cgs from pcell, they are not used, they are replaced by moscap. They should be flagged off.
//even should considering parasitic cap of test dut routing, they should be flagged off.
//+    lp2p_d                         = 3.59
//+    l_plyhole                      = 0.7
// calculation for parasitic Cgd from layout, migrated from pld100
//+ aply_fld_cgd                      = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d-(w+2*w2ply_inner*(1-fem))*l_plyhole*2.0-4.0*rnhv_daera-w*ldr1*2)/2*ng
//+ pply_fld_cgd                      = ((w+2*w2ply_inner*(1-fem))*6+l_plyhole*4*(1-fem)+lp2p_d*2*(1-fem)-w*2)/2*ng
//+ cgd_ply_fld_orig                  = (aply_fld_cgd*cpp_ply_fld+pply_fld_cgd*cfr_ply_fld)                              //using psp moscap to replace it
// parasitic capacitnace Cgd caused by dummy gate, migrated from pld100
//+ aply_fld_cgd_dmy                  = ((w+2*w2nhv*(1-fem))*lb2b_d-(w+2*w2ply_inner*(1-fem))*lp2p_d-(w+2*w2ply_inner*(1-fem))*l_plyhole*2.0-4.0*rnhv_daera-w*ldr1*2)/2*ng_dmy
//+ pply_fld_cgd_dmy                  = ((w+2*w2ply_inner*(1-fem))*6+l_plyhole*4*(1-fem)+lp2p_d*2*(1-fem)-w*2)/2*ng_dmy
//+ cgd_ply_fld_dmy_orig              = (aply_fld_cgd_dmy*cpp_ply_fld+pply_fld_cgd_dmy*cfr_ply_fld)                          //using psp moscap to replace it
// calculation for parasitic Cgs from layout. For dummy gate, g and s are shorted, so no cgs, migrated from pld100
//+ aply_fld_cgs                      = ((w+2*w2ply_outer*(1-fem))*(2*l+lb2b_d)-(w+2*w2nhv*(1-fem))*lb2b_d+4*rnhv_daera-l*w*2)/2*ng
//+ pply_fld_cgs                      = (2*w2ply_outer+2*l+lb2b_d)*ng*(1-fem)
//+ cgs_ply_fld_orig                  = (aply_fld_cgs*cpp_ply_fld+pply_fld_cgs*cfr_ply_fld)

//if not for data-playback, should turn off parasitic cap from dut routing. That is, change 1 to 0 in the following two lines(cgs_all & cgd_all lines), in final model.
//+ cgs_all                           = (cgs1_m1_ply+cgs2_m3_ply*1+cgs3_m3_m1*1+cgs_ply_fld)
//+ cgd_all                           = (cgd1_m2_ply*1+cgd2_m2_m1*1+cgd_ply_fld)
+ cgs_all                           = (cgs1_m1_ply+cgs_ply_fld)
+ cgd_all                           = (cgd_ply_fld)




// simple model factor
+ swdrlin             = (0)
+ fac_rshldd          = ((swdrlin==0)+(swdrlin==2)*0.9315)


// parameters for the BV diode
+ dcbv_pld65_10hv     = (90)

// multi-ng effect based on median
+ fac_a_ng_vfbo       = (ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*0.07364*(w/(w+1.55*(1-fem)))
+ fac_r_ng_rshldd     = (1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*0.18*(w/(w+1.9*(1-fem))))
+ fac_r_ng_thesato    = (1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*2.82*(w/(w+1.35*(1-fem))))
// multi-ng effect based on ng golden die
+ fac_r_ng_stvfbo     = (1)
+ fac_r_ng_stthesato  = 1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*0.3375*(w/(w+30*(1-fem))))
+ fac_r_ng_thesatgo   = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*3.5*(w/(w+8.4*(1-fem))))
+ fac_r_ng_ecrit      = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*0.195*(w/(w+5*(1-fem))))
+ fac_r_ng_ecorn      = (1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*4.1405*(w/(w+5*(1-fem)))))
+ fac_r_ng_tc1_ecrit  = (1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*3.85*(w/(w+1*(1-fem))))
+ fac_r_ng_tc1_ecorn  = 1/(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*15*(w/(w+5*(1-fem))))
+ tc1tc2_ecorn        = (1.0+70/w*(1-fem))
+ tfact_ecrit         = (1+(tc1_ecrit_pld65_sphv_10hv*fac_r_ng_tc1_ecrit+tc2_ecrit_pld65_sphv_10hv*(temp-tnom))*(temp-tnom))
+ tfact_ecorn         = (1+tc1tc2_ecorn*(tc1_ecorn_pld65_sphv_10hv*fac_r_ng_tc1_ecorn+tc2_ecorn_pld65_sphv_10hv*(temp-tnom))*(temp-tnom))
+ fact_r_w_temp_ikf   = 1

model dbodyBV diode
+ allow_scaling       = (yes)
+ jmax  	      = (1e12)
+ jmelt 	      = (1e12)
+ tnom  	      = (27)
+ is	              = (1e-30)
+ n		      = (1.0)
+ cj	              = (1e-30)
+ pta	              = (0)
+ tlevc 	      = (2)
+ tlev  	      = (2)
+ bv	              = (dcbv_pld65_10hv+bvdss_shift)
+ ibv	              = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (rd s) resistor r=0.01

// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w            = w
+ l            = l
+ ldrift       = ldrift
+ wdrift       = wdrift
+ ldr1         = ldr1
+ mult         = ng
+ ad           = ad
+ pd           = pd
+ as           = as
+ ps           = ps
+ ad2          = ad2
+ pd2          = pd2

model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec       = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi       = 1
+ swdrlin      = swdrlin
+ xvsat        = xvsat_pld65_sphv_10hv
+ qmc          = qmc_pld65_sphv_10hv
+ lvaro        = lvaro_pld65_sphv_10hv
+ lvarl        = lvarl_pld65_sphv_10hv
+ lvarw        = lvarw_pld65_sphv_10hv*(1-fem)
+ lap          = lap_pld65_sphv_10hv
+ wvaro        = wvaro_pld65_sphv_10hv*(1-fem)
+ wvarl        = wvarl_pld65_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld65_sphv_10hv*(1-fem)
+ wot          = wot_pld65_sphv_10hv*(1-fem)
+ dlq          = dlq_pld65_sphv_10hv
+ dwq          = dwq_pld65_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld65_sphv_10hv+dela_vfb_pld65_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld65_vthratio
+ vfbl         = vfbl_pld65_sphv_10hv
+ vfbw         = (vfbw_pld65_sphv_10hv+dela_vtw_pld65_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld65_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld65_sphv_10hv*fac_r_ng_stvfbo
+ stvfbl       = stvfbl_pld65_sphv_10hv
+ stvfbw       = stvfbw_pld65_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld65_sphv_10hv*(1-fem)
+ toxo         = toxo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ epsroxo      = epsroxo_pld65_sphv_10hv
+ nsubo        = nsubo_pld65_sphv_10hv*delr_nsub_pld65_sphv_10hv
+ nsubw        = nsubw_pld65_sphv_10hv*(1-fem)
+ wseg         = wseg_pld65_sphv_10hv
+ npck         = npck_pld65_sphv_10hv
+ npckw        = npckw_pld65_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld65_sphv_10hv
+ lpck         = lpck_pld65_sphv_10hv
+ lpckw        = lpckw_pld65_sphv_10hv*(1-fem)
+ fol1         = fol1_pld65_sphv_10hv
+ fol2         = fol2_pld65_sphv_10hv
+ facneffaco   = facneffaco_pld65_sphv_10hv
+ facneffacl   = facneffacl_pld65_sphv_10hv
+ facneffacw   = facneffacw_pld65_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld65_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld65_sphv_10hv
+ gfacnudl     = gfacnudl_pld65_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld65_sphv_10hv
+ gfacnudw     = gfacnudw_pld65_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld65_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld65_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld65_sphv_10hv
+ vnsubo       = vnsubo_pld65_sphv_10hv
+ nslpo        = nslpo_pld65_sphv_10hv
+ dnsubo       = dnsubo_pld65_sphv_10hv
+ dphibo       = dphibo_pld65_sphv_10hv
+ dphibl       = dphibl_pld65_sphv_10hv
+ dphiblexp    = dphiblexp_pld65_sphv_10hv
+ dphibw       = dphibw_pld65_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld65_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld65_sphv_10hv
+ delvtacl     = delvtacl_pld65_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld65_sphv_10hv
+ delvtacw     = delvtacw_pld65_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld65_sphv_10hv*(1-fem)
+ npo          = npo_pld65_sphv_10hv
+ npl          = npl_pld65_sphv_10hv
+ cto          = cto_pld65_sphv_10hv
+ ctl          = ctl_pld65_sphv_10hv
+ ctlexp       = ctlexp_pld65_sphv_10hv
+ ctw          = ctw_pld65_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld65_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld65_sphv_10hv
+ ctbo         = ctbo_pld65_sphv_10hv
+ stcto        = stcto_pld65_sphv_10hv
+ toxovo       = toxovo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ toxovdo      = toxovdo_pld65_sphv_10hv*delr_tox_pld65_sphv_10hv
+ lov          = lov_pld65_sphv_10hv
+ dlovd        = dlovd_pld65_sphv_10hv
+ novo         = novo_pld65_sphv_10hv
+ novdo        = novdo_pld65_sphv_10hv
+ cfl          = cfl_pld65_sphv_10hv
+ cflexp       = cflexp_pld65_sphv_10hv
+ cfw          = cfw_pld65_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld65_sphv_10hv
+ uo           = uo_pld65_sphv_10hv*delr_uch_pld65_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld65_sphv_10hv
+ fbet1w       = fbet1w_pld65_sphv_10hv*(1-fem)
+ lp1          = lp1_pld65_sphv_10hv
+ lp1w         = lp1w_pld65_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld65_sphv_10hv
+ lp2          = lp2_pld65_sphv_10hv
+ betw1        = betw1_pld65_sphv_10hv*(1-fem)
+ betw2        = betw2_pld65_sphv_10hv*(1-fem)
+ wbet         = wbet_pld65_sphv_10hv
+ stbeto       = stbeto_pld65_sphv_10hv
+ stbetl       = stbetl_pld65_sphv_10hv
+ stbetw       = stbetw_pld65_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld65_sphv_10hv*(1-fem)
+ mueo         = mueo_pld65_sphv_10hv
+ muew         = muew_pld65_sphv_10hv*(1-fem)
+ stmueo       = stmueo_pld65_sphv_10hv
+ themuo       = themuo_pld65_sphv_10hv
+ stthemuo     = stthemuo_pld65_sphv_10hv
+ cso          = cso_pld65_sphv_10hv
+ csl          = csl_pld65_sphv_10hv
+ cslexp       = cslexp_pld65_sphv_10hv
+ csw          = csw_pld65_sphv_10hv*(1-fem)
+ cslw         = cslw_pld65_sphv_10hv*(1-fem)
+ stcso        = stcso_pld65_sphv_10hv
+ xcoro        = xcoro_pld65_sphv_10hv
+ xcorl        = xcorl_pld65_sphv_10hv
+ xcorw        = xcorw_pld65_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld65_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld65_sphv_10hv
+ fetao        = fetao_pld65_sphv_10hv
+ rsw1         = rsw1_pld65_sphv_10hv
+ rsw2         = rsw2_pld65_sphv_10hv*(1-fem)
+ strso        = strso_pld65_sphv_10hv
+ rsbo         = rsbo_pld65_sphv_10hv
+ rsgo         = rsgo_pld65_sphv_10hv
+ thesato      = thesato_pld65_sphv_10hv*fac_r_ng_thesato
+ thesatl      = thesatl_pld65_sphv_10hv
+ thesatlexp   = thesatlexp_pld65_sphv_10hv
+ thesatw      = thesatw_pld65_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld65_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld65_sphv_10hv*fac_r_ng_stthesato
+ stthesatl    = stthesatl_pld65_sphv_10hv
+ stthesatw    = stthesatw_pld65_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld65_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld65_sphv_10hv
+ thesatgo     = thesatgo_pld65_sphv_10hv/fac_r_ng_thesatgo
+ thesatgl     = thesatgl_pld65_sphv_10hv
+ thesatgw     = thesatgw_pld65_sphv_10hv/(1+thesatgw2_pld65_sphv_10hv/w)*(1-fem)
+ vdscale      = vdscale_pld65_sphv_10hv*(1.0+vdscalew_pld65_sphv_10hv*(1-fem)/w)
+ vdscaleb     = vdscaleb_pld65_sphv_10hv
+ stvdscale    = stvdscale_pld65_sphv_10hv
+ axo          = axo_pld65_sphv_10hv
+ axl          = axl_pld65_sphv_10hv
+ alpl         = alpl_pld65_sphv_10hv
+ alplexp      = alplexp_pld65_sphv_10hv
+ alpw         = alpw_pld65_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld65_sphv_10hv
+ alp1lexp     = alp1lexp_pld65_sphv_10hv
+ alp1l2       = alp1l2_pld65_sphv_10hv
+ alp1w        = alp1w_pld65_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld65_sphv_10hv
+ alp2lexp     = alp2lexp_pld65_sphv_10hv
+ alp2l2       = alp2l2_pld65_sphv_10hv
+ alp2w        = alp2w_pld65_sphv_10hv*(1-fem)
+ vpo          = vpo_pld65_sphv_10hv
+ a1o          = a1o_pld65_sphv_10hv
+ a1l          = a1l_pld65_sphv_10hv
+ a1w          = a1w_pld65_sphv_10hv*(1-fem)
+ a2o          = a2o_pld65_sphv_10hv
+ sta2o        = sta2o_pld65_sphv_10hv
+ a3o          = a3o_pld65_sphv_10hv
+ a3l          = a3l_pld65_sphv_10hv
+ a3w          = a3w_pld65_sphv_10hv*(1-fem)
+ a4o          = a4o_pld65_sphv_10hv
+ a4l          = a4l_pld65_sphv_10hv
+ a4w          = a4w_pld65_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld65_sphv_10hv
+ iginvlw      = iginvlw_pld65_sphv_10hv
+ igovw        = igovw_pld65_sphv_10hv
+ igovdw       = igovdw_pld65_sphv_10hv
+ stigo        = stigo_pld65_sphv_10hv
+ gc2o         = gc2o_pld65_sphv_10hv
+ gc3o         = gc3o_pld65_sphv_10hv
+ chibo        = chibo_pld65_sphv_10hv
+ agidlw       = agidlw_pld65_sphv_10hv
+ agidldw      = agidldw_pld65_sphv_10hv
+ bgidlo       = bgidlo_pld65_sphv_10hv
+ bgidldo      = bgidldo_pld65_sphv_10hv
+ stbgidlo     = stbgidlo_pld65_sphv_10hv
+ stbgidldo    = stbgidldo_pld65_sphv_10hv
+ cgidlo       = cgidlo_pld65_sphv_10hv
+ cgidldo      = cgidldo_pld65_sphv_10hv
+ cgbovl       = cgbovl_pld65_sphv_10hv
+ cfrw         = cfrw_pld65_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld65_sphv_10hv*(1-fem)
+ fnto         = fnto_pld65_sphv_10hv
+ nfalw        = nfalw_pld65_sphv_10hv
+ nfblw        = nfblw_pld65_sphv_10hv
+ nfclw        = nfclw_pld65_sphv_10hv
+ efo          = efo_pld65_sphv_10hv
+ lintnoi      = lintnoi_pld65_sphv_10hv
+ alpnoi       = alpnoi_pld65_sphv_10hv
+ kvthoweo     = kvthoweo_pld65_sphv_10hv
+ kvthowel     = kvthowel_pld65_sphv_10hv
+ kvthowew     = kvthowew_pld65_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld65_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld65_sphv_10hv
+ kuowel       = kuowel_pld65_sphv_10hv
+ kuowew       = kuowew_pld65_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld65_sphv_10hv*(1-fem)
+ rgo          = rgo_pld65_sphv_10hv
+ rsh          = rsh_pld65_sphv_10hv
+ rbulko       = rbulko_pld65_sphv_10hv
+ rwello       = rwello_pld65_sphv_10hv
+ rjunso       = rjunso_pld65_sphv_10hv/(w+dwrjunso_pld65_sphv_10hv*(1-fem))
+ rjundo       = rjundo_pld65_sphv_10hv/(w+dwrjundo_pld65_sphv_10hv*(1-fem))
+ rint         = rint_pld65_sphv_10hv
+ rvpoly       = rvpoly_pld65_sphv_10hv
+ rshg         = rshg_pld65_sphv_10hv
+ dlsil        = dlsil_pld65_sphv_10hv
+ saref        = saref_pld65_sphv_10hv
+ sbref        = sbref_pld65_sphv_10hv
+ wlod         = wlod_pld65_sphv_10hv
+ kuo          = kuo_pld65_sphv_10hv
+ kvsat        = kvsat_pld65_sphv_10hv
+ tkuo         = tkuo_pld65_sphv_10hv
+ lkuo         = lkuo_pld65_sphv_10hv
+ wkuo         = wkuo_pld65_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld65_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld65_sphv_10hv
+ wlodkuo      = wlodkuo_pld65_sphv_10hv
+ kvtho        = kvtho_pld65_sphv_10hv
+ lkvtho       = lkvtho_pld65_sphv_10hv
+ wkvtho       = wkvtho_pld65_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld65_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld65_sphv_10hv
+ wlodvth      = wlodvth_pld65_sphv_10hv
+ stetao       = stetao_pld65_sphv_10hv
+ lodetao      = lodetao_pld65_sphv_10hv
+ scref        = scref_pld65_sphv_10hv
+ web          = web_pld65_sphv_10hv
+ wec          = wec_pld65_sphv_10hv
+ adr1o        = adr1o_pld65_sphv_10hv
+ adr1l        = adr1l_pld65_sphv_10hv
+ adr1w        = adr1w_pld65_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld65_sphv_10hv
+ stadr2o      = stadr2o_pld65_sphv_10hv
+ adr3o        = adr3o_pld65_sphv_10hv
+ adr3l        = adr3l_pld65_sphv_10hv
+ adr3w        = adr3w_pld65_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld65_sphv_10hv
+ adr4l        = adr4l_pld65_sphv_10hv
+ adr4w        = adr4w_pld65_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld65_sphv_10hv
+ adr5l        = adr5l_pld65_sphv_10hv
+ adr5w        = adr5w_pld65_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld65_sphv_10hv
+ bidr1l       = bidr1l_pld65_sphv_10hv
+ bidr1w       = bidr1w_pld65_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld65_sphv_10hv
+ bidr2w       = bidr2w_pld65_sphv_10hv*(1-fem)
+ rtho         = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld65_sphv_10hv
+ strthao      = strthao_pld65_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld65_sphv_10hv*delr_res_pld65_sphv_10hv*fac_r_ng_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld65_ronratio)*fac_rshldd)
+ xw           = (xw_pld65_sphv_10hv+dela_dwox_pld65_sphv_10hv)*(1-fem)
+ nwxw         = (nwxw_pld65_sphv_10hv)*(1-fem)
+ xl           = xl_pld65_sphv_10hv
+ xlw          = xlw_pld65_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld65_sphv_10hv
+ nst          = nst_pld65_sphv_10hv
+ ats          = ats_pld65_sphv_10hv
+ dfinf        = dfinf_pld65_sphv_10hv
+ dfw          = dfw_pld65_sphv_10hv*(1-fem)
+ dfl          = dfl_pld65_sphv_10hv
+ dflw         = dflw_pld65_sphv_10hv*(1-fem)
+ dp           = dp_pld65_sphv_10hv
+ ecrit        = ecrit_pld65_sphv_10hv*tfact_ecrit/(1+ecritw_pld65_sphv_10hv*(1-fem)/w+ecritw2_pld65_sphv_10hv/w/w*(1-fem))/fac_r_ng_ecrit*(tc1_ecrit_pld65_sphv_10hv*0+tc2_ecrit_pld65_sphv_10hv*0+1)
+ ecorn        = ecorn_pld65_sphv_10hv*tfact_ecorn/(1+ecornw_pld65_sphv_10hv*(1-fem)/w**1.5)/fac_r_ng_ecorn*(tc1_ecorn_pld65_sphv_10hv*0+tc2_ecorn_pld65_sphv_10hv*0+1)
+ du           = du_pld65_sphv_10hv
+ tc1          = tc1_pld65_sphv_10hv
+ tc2          = tc2_pld65_sphv_10hv
+ tc1l         = tc1l_pld65_sphv_10hv
+ tc2l         = tc2l_pld65_sphv_10hv
+ tc1w         = tc1w_pld65_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld65_sphv_10hv*(1-fem)
+ theacc       = theacc_pld65_sphv_10hv
+ theacc2      = theacc2_pld65_sphv_10hv
+ rva          = rva_pld65_sphv_10hv
+ dta          = dta_pld65_sphv_10hv
+ trj          = trj_pld65_sphv_10hv
+ cjarea       = cjarea_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlsti       = cjlsti_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlgat       = cjarea_pld65_sphv_10hv*djunc*delr_cj_pld65_sphv_10hv
+ vbiarea      = vbiarea_pld65_sphv_10hv
+ vbisti       = vbisti_pld65_sphv_10hv
+ vbigat       = vbigat_pld65_sphv_10hv
+ parea        = parea_pld65_sphv_10hv
+ psti         = psti_pld65_sphv_10hv
+ pgat         = pgat_pld65_sphv_10hv
+ is1area      = is1area_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttarea       = ttarea_pld65_sphv_10hv
+ is2area      = is2area_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irarea       = irarea_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1area    = stis1area_pld65_sphv_10hv
+ stis2area    = stis2area_pld65_sphv_10hv
+ stirarea     = stirarea_pld65_sphv_10hv
+ n1area       = n1area_pld65_sphv_10hv
+ n2area       = n2area_pld65_sphv_10hv
+ nrarea       = nrarea_pld65_sphv_10hv
+ is1lsti      = is1lsti_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlsti       = ttlsti_pld65_sphv_10hv
+ is2lsti      = is2lsti_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlsti       = irlsti_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1sti     = stis1sti_pld65_sphv_10hv
+ stis2sti     = stis2sti_pld65_sphv_10hv
+ stirsti      = stirsti_pld65_sphv_10hv
+ n1sti        = n1sti_pld65_sphv_10hv
+ n2sti        = n2sti_pld65_sphv_10hv
+ nrsti        = nrsti_pld65_sphv_10hv
+ is1lgat      = is1area_pld65_sphv_10hv*djunc*delr_is_pld65_sphv_10hv
+ ttlgat       = ttlgat_pld65_sphv_10hv
+ is2lgat      = is2area_pld65_sphv_10hv*djunc*delr_is2_pld65_sphv_10hv
+ irlgat       = irarea_pld65_sphv_10hv*djunc*delr_ir_pld65_sphv_10hv
+ stis1gat     = stis1gat_pld65_sphv_10hv
+ stis2gat     = stis2gat_pld65_sphv_10hv
+ stirgat      = stirgat_pld65_sphv_10hv
+ n1gat        = n1gat_pld65_sphv_10hv
+ n2gat        = n2gat_pld65_sphv_10hv
+ nrgat        = nrgat_pld65_sphv_10hv
+ cjaread      = cjaread_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlstid      = cjlstid_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlgatd      = cjlgatd_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ vbiaread     = vbiaread_pld65_sphv_10hv
+ vbistid      = vbistid_pld65_sphv_10hv
+ vbigatd      = vbigatd_pld65_sphv_10hv
+ paread       = paread_pld65_sphv_10hv
+ pstid        = pstid_pld65_sphv_10hv
+ pgatd        = pgatd_pld65_sphv_10hv
+ is1aread     = is1aread_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttaread      = ttaread_pld65_sphv_10hv
+ is2aread     = is2aread_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ iraread      = iraread_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1aread   = stis1aread_pld65_sphv_10hv
+ stis2aread   = stis2aread_pld65_sphv_10hv
+ stiraread    = stiraread_pld65_sphv_10hv
+ n1aread      = n1aread_pld65_sphv_10hv
+ n2aread      = n2aread_pld65_sphv_10hv
+ nraread      = nraread_pld65_sphv_10hv
+ is1lstid     = is1lstid_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlstid      = ttlstid_pld65_sphv_10hv
+ is2lstid     = is2lstid_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlstid      = irlstid_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1stid    = stis1stid_pld65_sphv_10hv
+ stis2stid    = stis2stid_pld65_sphv_10hv
+ stirstid     = stirstid_pld65_sphv_10hv
+ n1stid       = n1stid_pld65_sphv_10hv
+ n2stid       = n2stid_pld65_sphv_10hv
+ nrstid       = nrstid_pld65_sphv_10hv
+ is1lgatd     = is1lgatd_pld65_sphv_10hv*djunc*delr_is_pld65_sphv_10hv
+ ttlgatd      = ttlgatd_pld65_sphv_10hv
+ is2lgatd     = is2lgatd_pld65_sphv_10hv*djunc*delr_is2_pld65_sphv_10hv
+ irlgatd      = irlgatd_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1gatd    = stis1gatd_pld65_sphv_10hv
+ stis2gatd    = stis2gatd_pld65_sphv_10hv
+ stirgatd     = stirgatd_pld65_sphv_10hv
+ n1gatd       = n1gatd_pld65_sphv_10hv
+ n2gatd       = n2gatd_pld65_sphv_10hv
+ nrgatd       = nrgatd_pld65_sphv_10hv
+ cjaread2     = cjaread2_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ cjlstid2     = cjlstid2_pld65_sphv_10hv*delr_cj_pld65_sphv_10hv
+ vbiaread2    = vbiaread2_pld65_sphv_10hv
+ vbistid2     = vbistid2_pld65_sphv_10hv
+ paread2      = paread2_pld65_sphv_10hv
+ pstid2       = pstid2_pld65_sphv_10hv
+ is1aread2    = is1aread2_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttaread2     = ttaread2_pld65_sphv_10hv
+ is2aread2    = is2aread2_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ iraread2     = iraread2_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1aread2  = stis1aread2_pld65_sphv_10hv
+ stis2aread2  = stis2aread2_pld65_sphv_10hv
+ stiraread2   = stiraread2_pld65_sphv_10hv
+ n1aread2     = n1aread2_pld65_sphv_10hv
+ n2aread2     = n2aread2_pld65_sphv_10hv
+ nraread2     = nraread2_pld65_sphv_10hv
+ is1lstid2    = is1lstid2_pld65_sphv_10hv*delr_is_pld65_sphv_10hv
+ ttlstid2     = ttlstid2_pld65_sphv_10hv
+ is2lstid2    = is2lstid2_pld65_sphv_10hv*delr_is2_pld65_sphv_10hv
+ irlstid2     = irlstid2_pld65_sphv_10hv*delr_ir_pld65_sphv_10hv
+ stis1stid2   = stis1stid2_pld65_sphv_10hv
+ stis2stid2   = stis2stid2_pld65_sphv_10hv
+ stirstid2    = stirstid2_pld65_sphv_10hv
+ n1stid2      = n1stid2_pld65_sphv_10hv
+ n2stid2      = n2stid2_pld65_sphv_10hv
+ nrstid2      = nrstid2_pld65_sphv_10hv
+ aacc         = aacc_pld65_sphv_10hv
+ eais1area    = eais1area_pld65_sphv_10hv
+ eais2area    = eais2area_pld65_sphv_10hv
+ eairarea     = eairarea_pld65_sphv_10hv
+ eais1sti     = eais1sti_pld65_sphv_10hv
+ eais2sti     = eais2sti_pld65_sphv_10hv
+ eairsti      = eairsti_pld65_sphv_10hv
+ eais1gat     = eais1gat_pld65_sphv_10hv
+ eais2gat     = eais2gat_pld65_sphv_10hv
+ eairgat      = eairgat_pld65_sphv_10hv
+ eais1aread   = eais1aread_pld65_sphv_10hv
+ eais2aread   = eais2aread_pld65_sphv_10hv
+ eairaread    = eairaread_pld65_sphv_10hv
+ eais1stid    = eais1stid_pld65_sphv_10hv
+ eais2stid    = eais2stid_pld65_sphv_10hv
+ eairstid     = eairstid_pld65_sphv_10hv
+ eais1gatd    = eais1gatd_pld65_sphv_10hv
+ eais2gatd    = eais2gatd_pld65_sphv_10hv
+ eairgatd     = eairgatd_pld65_sphv_10hv
+ eais1aread2  = eais1aread2_pld65_sphv_10hv
+ eais2aread2  = eais2aread2_pld65_sphv_10hv
+ eairaread2   = eairaread2_pld65_sphv_10hv
+ eais1stid2   = eais1stid2_pld65_sphv_10hv
+ eais2stid2   = eais2stid2_pld65_sphv_10hv
+ eairstid2    = eairstid2_pld65_sphv_10hv
+ mumb         = mumb_pld65_sphv_10hv
+ ikfaread     = ikfaread_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikfaread2    = ikfaread2_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflstid     = ikflstid_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflstid2    = ikflstid2_pld65_sphv_10hv/fact_r_w_temp_ikf
+ ikflgatd     = ikflgatd_pld65_sphv_10hv/fact_r_w_temp_ikf

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr     = 27
+    toxo   = 3.20e-7
+    vfbo   = 3
+    stvfbo = stvfbo_pld65_sphv_10hv
+    nsubo  = 6.0e22
+    npck   = 1e22
+    lpck   = 1e-6
+    rtho   = 1e18
+    ctho   = 0
+    uo     = 0


//model pnpd_lateral bjt
//+ type           = (pnp)
//+ struct         = (lateral)
//+ tnom           = (27)
//+ imax           = (100)
//+ is             = (0.10e-18*(4.0+12.0)/(l+12.0)/(1.0+5e3*0.5/w))*50
//+ ikf            = 1e6*(4.0+12.0)/(l+12.0)*(1.0+0.5/w)
//+ ikr            = 1e6*(4.0+12.0)/(l+12.0)*(1.0+0.5/w)
//+ bf             = 1e8
//+ nf             = 1.04
//+ br             = 1e8
//+ nr             = 1.03
//+ xtb            = 0.0
//+ eg             = 1.11
//+ xti            = 4.5
//+ rb             = 0.0
//+ tf             = 54e-9
//+ tr             = 20e-9


mcgdcap (s gi s di dtemp) cgdfldmoscap l=(1.2) w=w+dwcgdfldmoscap mult=ng
avdclip (d di gi) vdclip vp=vp_pld65_10hv dvp=dvp_pld65_10hv type=type_pld65_10hv

//qsbd          (qsi qsi qdi)  pnpd_lateral  area=(w*2.5e-6*1e6) m=ng
//rs_qsbd       (s qsi)      resistor r=140e3/(1.0+1.2/w)/(1.0+50.0/sqrt(l))/(w*2.5e-6*1e6*ng)
//rd_qsbd       (d qdi)      resistor r=200e3/(1.0+1.2/w)/(1.0+28.0/sqrt(l))/(w*2.5e-6*1e6*ng)

cgd_fld (gi d) capacitor c=(cgd_all)
cgs_fld (gi s) capacitor c=(cgs_all)
rgate (g gi)   resistor  r=(r_gate)
xdsub (s sub)  cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)+1e-12) perim=(plnbl*(1-lpe)+1e-12) soa=1

if (ng_dmy>=2) {

amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=(1.2) w=w+dwcgdfldmoscap mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip  vp=vp_pld65_10hv dvp=dvp_pld65_10hv type=type_pld65_10hv
cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}

include "./smos10hv_ade_dfrt.scs" section=pld65_10hv_dfrt
ends

// pld120_10hv



subckt pld120_10hv (d g s sub)
parameters
+ l=0.5
+ w=10.0
+ ng=2
+ sti_dummy=0
+ fem=0
+ lpe=0
+ soa=1
+ selfheat=1
+ mode_rthcth=1


parameters
//+ nde=(fmod(ng,2))
+ nde              = (0)
+ nse              = (2-nde)
+ nd               = ((ng+nde)/2)
+ ns               = (1-nde+nd)
+ ndi              = (nd-nde)
+ nsi              = (ns-nse)

//dummy parameters
+ ng_dmy           = (2*sti_dummy)
+ ngeff            = (ng+ng_dmy)
+ ndi_eff          = (ngeff/2)
+ nsi_eff          = ((ngeff-2)/2)


//reliability parameters
+ dela_vth_relimo=0
+ dela_vth_relimo_mod=0
+ delr_u0_relimo=1
+ delr_rdsw_relimo=1
+ delr_a0_relimo=1
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld120_vthratio         = 1.0*(-0.0091*pow(1/l,2)+0.0634*1/l+0.9953)
+    presto_pld120_ronratio         = 0.01/1.0/(0.1652*l+0.9967)


//calculation of junction instance parameters
+    lacts    = 0.3
+    ldrift   = 8.4
+    wdrift   = (w)
+    w2nhv    = (13.4)
+    lactd    = 1.32
+    lsplit   = 0.35

+    ldr1=0.45
+    as_i=(lacts*w)*0
+    ps_i=2*(lacts+w)*0
+    ad_i=(((ldr1+lsplit)+ldrift/2)*(w+2*w2nhv*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)/2)
+    pd_i=(2*((ldr1+lsplit)+ldrift/2)*(1-fem)+w+2*w2nhv*(1-fem)+1.44*(1-fem)*(3.14159265358979323846-4))
+    ad2_i=(lactd/2+ldrift/2)*(w+2*w2nhv*(1-fem))
+    pd2_i=(lactd+ldrift)*(1-fem)

//calculation for lnbl/psub junction
+    lg2pepi_s    = 5.66     // dt to poly end
+    lp2p_d       = 19.72    // drain nhv end to nhv end
+    lb2b_s       = 0.99     // poly end to ploy at internal source
+    wg2pepi      = 19.9     // width active side to nhv end
+    xbody        = (lg2pepi_s*nse+l*ngeff+lp2p_d*ndi_eff+lb2b_s*nsi_eff)
+    ybody        = (wg2pepi*2*(1-fem)+w)
+    abody        = (xbody*ybody)
+    pbody        = (2*(xbody*(1-fem)+ybody))

//calculation of parasitic cap.
//+    aplyfld_d  		    = (lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)-14.12*(w+9.3*2*(1-fem))-0.7*(w+3.2*2*(1-fem))*2-ldr1*w*2+(w-1*2)*0.6*2)/2*ng
+    aplyfld_b  		    = ((lp2p_d+2*l)*(w+2*15.4*(1-fem))-(lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4))-2*w*l)/2*ng

//parasitic field c for dummy
//+    aplyfld_d_dmy  		    = (lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4)-14.12*(w+9.3*2*(1-fem))-0.7*(w+3.2*2*(1-fem))*2-ldr1*w*2)/2*ng_dmy
+    aplyfld_b_dmy  		    = ((lp2p_d+2*l)*(w+2*15.4*(1-fem))-(lp2p_d*(w+w2nhv*2*(1-fem))+1.44*1.44*(1-fem)*(3.14159265358979323846-4))-2*w*l)/2*ng_dmy

//--------------moscap for cgd & cgs
// calculation for poly over field parasitic capaciance
+ cgd_ply_fld_pp   = 2.7e-17*2.6
+ dwcgdfldmoscap   = 37.7*(1-fem)
+ dwcgd_ply_fld    = 37.4667*(1-fem)
+ cgd_ply_fld      = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng

// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy  = cgd_ply_fld_pp*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld120_10hv   = (32+4)
+ dvp_pld120_10hv  = (4.5+3)
+ type_pld120_10hv = (-1)


+ djunc=2.5e-6
+ tfact_ecrit=1+(tc1_ecrit_pld120_sphv_10hv+tc2_ecrit_pld120_sphv_10hv*(temp-tnom))*(temp-tnom)

//**parameters for multi ng

+ fac_r_ng_rshldd=(1+(ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*0.73*(l+0.9)/l)
+ fac_a_ng_vfbo= ((ngeff/(ngeff+1.0*(1-(fem>0)))-2/(2+1.0))*(-0.0052))
+ fac_r_ng_uo=(1+(ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*(0.459)*(l-5)/l)
+ fac_r_ng_thesato=(1+(ngeff/(ngeff+2*(1-(fem>0)))-2/(2+2))*(0.16)*(l-5)/l)
+ fac_a_ng_vdscale= ((ngeff/(ngeff+0.1*(1-(fem>0)))-2/(2+0.1))*(-0.47)*((l-4.2)/l)*((w+1.7*(1-fem))/w))




//**thermal res/cap calculation
+    w_heat=w
+    l_heat=(l*ng+lp2p_d*ndi+lb2b_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+    rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld120_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld120_sphv_10hv)*ngeff
+    cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff

//parasitic rgate calcultion
+ delt             = (temp+273.15-(27+273.15))
+ lflap 	   = (1.65)
+ length 	   = (l+ldr1+lflap)
+ w_ploycont2act   = (15.175)
+ rs_poly_gate     = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply             = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ r_gate           = (rply*((w+2*w_ploycont2act*(1-fem))/(length*3*ng)))

// parameters for process variations
+ nsmm_delr_tox_pld120_sphv_10hv  = tmp_nsmm_delr_tox_pld120_sphv_10hv
+ nsmm_delr_uch_pld120_sphv_10hv  = tmp_nsmm_delr_uch_pld120_sphv_10hv
+ nsmm_delr_res_pld120_sphv_10hv  = tmp_nsmm_delr_res_pld120_sphv_10hv
+ nsmm_dela_vfb_pld120_sphv_10hv  = tmp_nsmm_dela_vfb_pld120_sphv_10hv
+ nsmm_dela_vtw_pld120_sphv_10hv  = tmp_nsmm_dela_vtw_pld120_sphv_10hv
+ nsmm_delr_nsub_pld120_sphv_10hv = tmp_nsmm_delr_nsub_pld120_sphv_10hv
+ nsmm_dela_dw_pld120_sphv_10hv = tmp_nsmm_dela_dw_pld120_sphv_10hv
+ nsmm_dela_dwox_pld120_sphv_10hv = tmp_nsmm_dela_dwox_pld120_sphv_10hv

+ delr_tox_pld120_sphv_10hv  = (nom_delr_tox_pld120_sphv_10hv*(1+sig_delr_tox_pld120_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld120_sphv_10hv*smm_delr_tox_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_uch_pld120_sphv_10hv  = (nom_delr_uch_pld120_sphv_10hv*(1+sig_delr_uch_pld120_sphv_10hv*nsig_delr_uch_pld120_sphv_10hv+nsmm_delr_uch_pld120_sphv_10hv*smm_delr_uch_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld120_sphv_10hv  = (nom_delr_res_pld120_sphv_10hv*(1+sig_delr_res_pld120_sphv_10hv*nsig_delr_res_pld120_sphv_10hv+nsmm_delr_res_pld120_sphv_10hv*smm_delr_res_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld120_sphv_10hv  = (nom_dela_vfb_pld120_sphv_10hv+(sig_dela_vfb_pld120_sphv_10hv*nsig_dela_vfb_pld120_sphv_10hv)+nsmm_dela_vfb_pld120_sphv_10hv*smm_dela_vfb_pld120_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld120_sphv_10hv  = (nom_dela_vtw_pld120_sphv_10hv+(sig_dela_vtw_pld120_sphv_10hv*nsig_dela_vtw_pld120_sphv_10hv)+nsmm_dela_vtw_pld120_sphv_10hv*smm_dela_vtw_pld120_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtl_pld120_sphv_10hv  = (nom_dela_vtl_pld120_sphv_10hv+(sig_dela_vtl_pld120_sphv_10hv*nsig_dela_vtl_pld120_sphv_10hv))
+ dela_dw_pld120_sphv_10hv   = (nom_dela_dw_pld120_sphv_10hv+(sig_dela_dw_pld120_sphv_10hv*nsig_dela_dw_pld120_sphv_10hv)+(nsmm_dela_dw_pld120_sphv_10hv*smm_dela_dw_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld120_sphv_10hv = (nom_dela_dwox_pld120_sphv_10hv+(sig_dela_dwox_pld120_sphv_10hv*nsig_dela_dwox_pld120_sphv_10hv)+(nsmm_dela_dwox_pld120_sphv_10hv*smm_dela_dwox_pld120_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_mueo_pld120_sphv_10hv = (nom_dela_mueo_pld120_sphv_10hv+(sig_dela_mueo_pld120_sphv_10hv*nsig_dela_mueo_pld120_sphv_10hv))
+ delr_nsub_pld120_sphv_10hv = (1+nsmm_delr_nsub_pld120_sphv_10hv*smm_delr_nsub_pld120_sphv_10hv(l,w)/sqrt(ng/2))

+ dela_vdscale_pld120_sphv_10hv   =(nom_dela_vdscale_pld120_sphv_10hv+(sig_dela_vdscale_pld120_sphv_10hv*nsig_dela_vdscale_pld120_sphv_10hv))
+ dela_vdscalel_pld120_sphv_10hv  =(nom_dela_vdscalel_pld120_sphv_10hv+(sig_dela_vdscalel_pld120_sphv_10hv*nsig_dela_vdscalel_pld120_sphv_10hv))
+ dela_vdscalew_pld120_sphv_10hv  =(nom_dela_vdscalew_pld120_sphv_10hv+(sig_dela_vdscalew_pld120_sphv_10hv*nsig_dela_vdscalew_pld120_sphv_10hv))
+ dela_vdscalelw_pld120_sphv_10hv =(nom_dela_vdscalelw_pld120_sphv_10hv+(sig_dela_vdscalelw_pld120_sphv_10hv*nsig_dela_vdscalelw_pld120_sphv_10hv))

+ delr_cj_pld120_sphv_10hv   = (nom_delr_cj_pld120_sphv_10hv*(1+sig_delr_cj_pld120_sphv_10hv*nsig_delr_cj_pld120_sphv_10hv))
+ delr_is_pld120_sphv_10hv   = (nom_delr_is_pld120_sphv_10hv*exp(sig_delr_is_pld120_sphv_10hv*nsig_delr_is_pld120_sphv_10hv))
+ delr_is2_pld120_sphv_10hv  = (nom_delr_is2_pld120_sphv_10hv*exp(sig_delr_is2_pld120_sphv_10hv*nsig_delr_is2_pld120_sphv_10hv))
+ delr_ir_pld120_sphv_10hv   = (nom_delr_ir_pld120_sphv_10hv*exp(sig_delr_ir_pld120_sphv_10hv*nsig_delr_ir_pld120_sphv_10hv))


+    epsox         = (3.9*8.85e-12)
+    tox           = (1.316e-08*delr_tox_pld120_sphv_10hv)
+    cox           = (epsox/tox)
+    tn            = (27.0)
+    tkr           = (tn+273.15)
+    tkd           = (temp+273.15)

// simple model factor
+ swdrlin          = (0)
+ fac_rshldd       = ((swdrlin==0)+(swdrlin==2)*0.75)

// parameters for the BV diode
+ dcbv_pld120_10hv = (155)

model dbodyBV diode
+ allow_scaling    = (yes)
+ jmax  	   = (1e12)
+ jmelt 	   = (1e12)
+ tnom  	   = (27)
+ is		   = (1e-30)
+ n		   = (1.0)
+ cj		   = (1e-30)
+ pta		   = (0)
+ tlevc 	   = (2)
+ tlev  	   = (2)
+ bv		   = (dcbv_pld120_10hv+bvdss_shift)
+ ibv		   = (1e-5/1e-12)

dbodyBV (d rd) dbodyBV  area=((ad_i+ad2_i)*ngeff)
rlimit  (rd s) resistor r=0.01

// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr    = 27
//+    toxo  = 320e-9
+    toxo  = 160e-9
+    vfbo  = 0
+    nsubo = 1.4e23
+    npck  = 1e21
+    lpck  = 1e-6
+    rtho  = 1e18
+    ctho  = 0
+    uo    = 0

mcgdcap (s gi s di dtemp) cgdfldmoscap l=1.65 w=w+dwcgdfldmoscap mult=ng
avdclip (d di gi) vdclip vp=vp_pld120_10hv dvp=dvp_pld120_10hv type=type_pld120_10hv

cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cpp_ply_fld*aplyfld_b + 5e-15*ng)
rgate (g gi)   resistor  r=(r_gate)
xcdgoptub_box_sub_10hv (s sub) cdgoptub_box_sub_10hv area=(abody*(1-lpe)) perim=(pbody*(1-lpe)) soa=1

mamost (d gi s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i

if (ng_dmy >= 2) {

mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=1.65 w=w+dwcgdfldmoscap mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip  vp=vp_pld120_10hv dvp=dvp_pld120_10hv type=type_pld120_10hv
cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

mamost_dmy (d s s s dtemp) sphvt_simkit w=w l=l ldrift=ldrift wdrift=wdrift ldr1=ldr1 mult=ng_dmy ad=ad_i pd=pd_i as=as_i ps=ps_i ad2=ad2_i pd2=pd2_i


}


model sphvt_simkit sphvt
+ type           = p
+ tr             = 27
+ vdscale        = (vdscale_pld120_sphv_10hv+dela_vdscale_pld120_sphv_10hv+fac_a_ng_vdscale+(vdscalel_pld120_sphv_10hv+dela_vdscalel_pld120_sphv_10hv)/l+(vdscalew_pld120_sphv_10hv+dela_vdscalew_pld120_sphv_10hv)*(1-fem)/w+(vdscalelw_pld120_sphv_10hv+dela_vdscalelw_pld120_sphv_10hv)*(1-fem)/w/l)
+ vdscaleb       = (vdscaleb_pld120_sphv_10hv*(l+vdscalebl_pld120_sphv_10hv)/l)
+ stvdscale      = stvdscale_pld120_sphv_10hv
+ ctgo           = ctgo_pld120_sphv_10hv
+ ctbo           = ctbo_pld120_sphv_10hv
+ stcto          = stcto_pld120_sphv_10hv
+ mumb           = mumb_pld120_sphv_10hv
+ mumbexp        = mumbexp_pld120_sphv_10hv
+ mumbvclmp      = mumbvclmp_pld120_sphv_10hv
+ swdrlin        = (swdrlin)
+ swgeo        	 = 1
+ swigate      	 = 0
+ swimpact     	 = 1
+ swgidl       	 = 1
+ swjunc       	 = 2
+ swjunasym    	 = 1
+ swshe        	 = selfheat*enable_selfheat
+ swtcec      	 = 1
+ swimpdr      	 = 1
+ swexp        	 = 0
+ swdelvtac    	 = 1
+ swnud        	 = 0
+ swptest      	 = 0
+ swgedi      	 = 1
+ xvsat          = xvsat_pld120_sphv_10hv
+ qmc            = qmc_pld120_sphv_10hv
+ lvaro        	 = lvaro_pld120_sphv_10hv
+ lvarl        	 = lvarl_pld120_sphv_10hv
+ lvarw        	 = lvarw_pld120_sphv_10hv*(1-fem)
+ lap            = lap_pld120_sphv_10hv
+ wvaro        	 = (wvaro_pld120_sphv_10hv+1e-6*dela_dw_pld120_sphv_10hv)*(1-fem)
+ wvarl        	 = (wvarl_pld120_sphv_10hv)*(1-fem)
+ wvarw        	 = (wvarw_pld120_sphv_10hv)*(1-fem)
+ wot            = wot_pld120_sphv_10hv*(1-fem)
+ dlq            = dlq_pld120_sphv_10hv
+ dwq            = dwq_pld120_sphv_10hv*(1-fem)
+ vfbo           = (vfbo_pld120_sphv_10hv+fac_a_ng_vfbo+dela_vfb_pld120_sphv_10hv+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld120_vthratio)
+ vfbl           = (vfbl_pld120_sphv_10hv+36e-3/l+dela_vtl_pld120_sphv_10hv)
+ vfbw           = (vfbw_pld120_sphv_10hv+dela_vtw_pld120_sphv_10hv)*(1-fem)
+ vfblw        	 = (vfblw_pld120_sphv_10hv)*(1-fem)
+ stvfbo       	 = stvfbo_pld120_sphv_10hv
+ stvfbl       	 = stvfbl_pld120_sphv_10hv
+ stvfbw       	 = stvfbw_pld120_sphv_10hv*(1-fem)
+ stvfblw      	 = stvfblw_pld120_sphv_10hv*(1-fem)
+ toxo           = toxo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ epsroxo      	 = epsroxo_pld120_sphv_10hv
+ nsubo        	 = nsubo_pld120_sphv_10hv*delr_nsub_pld120_sphv_10hv
+ nsubw        	 = nsubw_pld120_sphv_10hv*(1-fem)
+ wseg           = wseg_pld120_sphv_10hv
+ npck           = npck_pld120_sphv_10hv
+ npckw        	 = npckw_pld120_sphv_10hv*(1-fem)
+ wsegp        	 = wsegp_pld120_sphv_10hv
+ lpck           = lpck_pld120_sphv_10hv
+ lpckw        	 = lpckw_pld120_sphv_10hv*(1-fem)
+ fol1           = fol1_pld120_sphv_10hv
+ fol2           = fol2_pld120_sphv_10hv
+ facneffaco   	 = facneffaco_pld120_sphv_10hv
+ facneffacl   	 = facneffacl_pld120_sphv_10hv
+ facneffacw   	 = facneffacw_pld120_sphv_10hv*(1-fem)
+ facneffaclw  	 = facneffaclw_pld120_sphv_10hv*(1-fem)
+ gfacnudo     	 = gfacnudo_pld120_sphv_10hv
+ gfacnudl     	 = gfacnudl_pld120_sphv_10hv
+ gfacnudlexp  	 = gfacnudlexp_pld120_sphv_10hv
+ gfacnudw     	 = gfacnudw_pld120_sphv_10hv*(1-fem)
+ gfacnudlw    	 = gfacnudlw_pld120_sphv_10hv*(1-fem)
+ vsbnudo      	 = vsbnudo_pld120_sphv_10hv
+ dvsbnudo     	 = dvsbnudo_pld120_sphv_10hv
+ vnsubo       	 = vnsubo_pld120_sphv_10hv
+ nslpo        	 = nslpo_pld120_sphv_10hv
+ dnsubo       	 = dnsubo_pld120_sphv_10hv
+ dphibo       	 = dphibo_pld120_sphv_10hv
+ dphibl       	 = dphibl_pld120_sphv_10hv
+ dphiblexp    	 = dphiblexp_pld120_sphv_10hv
+ dphibw       	 = (dphibw_pld120_sphv_10hv)*(1-fem)
+ dphiblw      	 = (dphiblw_pld120_sphv_10hv)*(1-fem)
+ delvtaco     	 = delvtaco_pld120_sphv_10hv
+ delvtacl     	 = delvtacl_pld120_sphv_10hv
+ delvtaclexp  	 = delvtaclexp_pld120_sphv_10hv
+ delvtacw     	 = delvtacw_pld120_sphv_10hv*(1-fem)
+ delvtaclw    	 = delvtaclw_pld120_sphv_10hv*(1-fem)
+ npo            = npo_pld120_sphv_10hv
+ npl            = npl_pld120_sphv_10hv
+ cto            = cto_pld120_sphv_10hv
+ ctl            = ctl_pld120_sphv_10hv
+ ctlexp       	 = ctlexp_pld120_sphv_10hv
+ ctw            = ctw_pld120_sphv_10hv*(1-fem)
+ ctlw           = ctlw_pld120_sphv_10hv*(1-fem)
+ toxovo       	 = toxovo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ toxovdo      	 = toxovdo_pld120_sphv_10hv*delr_tox_pld120_sphv_10hv
+ lov            = lov_pld120_sphv_10hv
+ dlovd        	 = dlovd_pld120_sphv_10hv
+ novo           = novo_pld120_sphv_10hv
+ novdo        	 = novdo_pld120_sphv_10hv
+ cfl            = cfl_pld120_sphv_10hv
+ cflexp       	 = cflexp_pld120_sphv_10hv
+ cfw            = cfw_pld120_sphv_10hv*(1-fem)
+ cfbo           = cfbo_pld120_sphv_10hv
+ uo             = (uo_pld120_sphv_10hv*delr_uch_pld120_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1        	 = fbet1_pld120_sphv_10hv
+ fbet1w       	 = fbet1w_pld120_sphv_10hv*(1-fem)
+ lp1            = lp1_pld120_sphv_10hv
+ lp1w           = lp1w_pld120_sphv_10hv*(1-fem)
+ fbet2        	 = fbet2_pld120_sphv_10hv
+ lp2            = lp2_pld120_sphv_10hv
+ betw1        	 = betw1_pld120_sphv_10hv*(1-fem)
+ betw2        	 = betw2_pld120_sphv_10hv*(1-fem)
+ wbet           = wbet_pld120_sphv_10hv
+ stbeto       	 = stbeto_pld120_sphv_10hv
+ stbetl       	 = stbetl_pld120_sphv_10hv
+ stbetw       	 = stbetw_pld120_sphv_10hv*(1-fem)
+ stbetlw      	 = stbetlw_pld120_sphv_10hv*(1-fem)
+ mueo           = (mueo_pld120_sphv_10hv+dela_mueo_pld120_sphv_10hv)
+ muew           = muew_pld120_sphv_10hv*(1-fem)
+ stmueo       	 = stmueo_pld120_sphv_10hv
+ themuo       	 = themuo_pld120_sphv_10hv
+ stthemuo     	 = stthemuo_pld120_sphv_10hv
+ cso            = cso_pld120_sphv_10hv
+ csl            = csl_pld120_sphv_10hv
+ cslexp       	 = cslexp_pld120_sphv_10hv
+ csw            = csw_pld120_sphv_10hv*(1-fem)
+ cslw           = cslw_pld120_sphv_10hv*(1-fem)
+ stcso        	 = stcso_pld120_sphv_10hv
+ xcoro        	 = xcoro_pld120_sphv_10hv
+ xcorl        	 = xcorl_pld120_sphv_10hv
+ xcorw        	 = xcorw_pld120_sphv_10hv*(1-fem)
+ xcorlw       	 = xcorlw_pld120_sphv_10hv*(1-fem)
+ stxcoro      	 = stxcoro_pld120_sphv_10hv
+ fetao        	 = fetao_pld120_sphv_10hv
+ rsw1           = rsw1_pld120_sphv_10hv
+ rsw2           = rsw2_pld120_sphv_10hv*(1-fem)
+ strso        	 = strso_pld120_sphv_10hv
+ rsbo           = rsbo_pld120_sphv_10hv
+ rsgo           = rsgo_pld120_sphv_10hv
+ thesato      	 = (thesato_pld120_sphv_10hv)*fac_r_ng_thesato
+ thesatl      	 = thesatl_pld120_sphv_10hv
+ thesatlexp   	 = thesatlexp_pld120_sphv_10hv
+ thesatw      	 = (thesatw_pld120_sphv_10hv*(1-fem))
+ thesatlw     	 = thesatlw_pld120_sphv_10hv*(1-fem)
+ stthesato    	 = stthesato_pld120_sphv_10hv
+ stthesatl    	 = stthesatl_pld120_sphv_10hv
+ stthesatw    	 = stthesatw_pld120_sphv_10hv*(1-fem)
+ stthesatlw   	 = stthesatlw_pld120_sphv_10hv*(1-fem)
+ thesatbo     	 = thesatbo_pld120_sphv_10hv
+ thesatgo     	 = thesatgo_pld120_sphv_10hv
+ thesatgl     	 = thesatgl_pld120_sphv_10hv
+ thesatgw     	 = thesatgw_pld120_sphv_10hv*(1-fem)
+ axo            = axo_pld120_sphv_10hv
+ axl            = axl_pld120_sphv_10hv
+ alpl           = alpl_pld120_sphv_10hv
+ alplexp      	 = alplexp_pld120_sphv_10hv
+ alpw           = alpw_pld120_sphv_10hv*(1-fem)
+ alp1l1       	 = alp1l1_pld120_sphv_10hv
+ alp1lexp     	 = alp1lexp_pld120_sphv_10hv
+ alp1l2       	 = alp1l2_pld120_sphv_10hv
+ alp1w        	 = alp1w_pld120_sphv_10hv*(1-fem)
+ alp2l1       	 = alp2l1_pld120_sphv_10hv
+ alp2lexp     	 = alp2lexp_pld120_sphv_10hv
+ alp2l2       	 = alp2l2_pld120_sphv_10hv
+ alp2w        	 = alp2w_pld120_sphv_10hv*(1-fem)
+ vpo            = vpo_pld120_sphv_10hv
+ a1o            = a1o_pld120_sphv_10hv
+ a1l            = a1l_pld120_sphv_10hv
+ a1w            = a1w_pld120_sphv_10hv*(1-fem)
+ a2o            = a2o_pld120_sphv_10hv
+ sta2o        	 = sta2o_pld120_sphv_10hv
+ a3o            = a3o_pld120_sphv_10hv
+ a3l            = a3l_pld120_sphv_10hv
+ a3w            = a3w_pld120_sphv_10hv*(1-fem)
+ a4o            = a4o_pld120_sphv_10hv
+ a4l            = a4l_pld120_sphv_10hv
+ a4w            = a4w_pld120_sphv_10hv*(1-fem)
+ gcoo           = gcoo_pld120_sphv_10hv
+ iginvlw      	 = iginvlw_pld120_sphv_10hv
+ igovw        	 = igovw_pld120_sphv_10hv
+ igovdw       	 = igovdw_pld120_sphv_10hv
+ stigo        	 = stigo_pld120_sphv_10hv
+ gc2o           = gc2o_pld120_sphv_10hv
+ gc3o           = gc3o_pld120_sphv_10hv
+ chibo        	 = chibo_pld120_sphv_10hv
+ agidlw       	 = agidlw_pld120_sphv_10hv
+ agidldw      	 = agidldw_pld120_sphv_10hv
+ bgidlo       	 = bgidlo_pld120_sphv_10hv
+ bgidldo      	 = bgidldo_pld120_sphv_10hv
+ stbgidlo     	 = stbgidlo_pld120_sphv_10hv
+ stbgidldo    	 = stbgidldo_pld120_sphv_10hv
+ cgidlo       	 = cgidlo_pld120_sphv_10hv
+ cgidldo      	 = cgidldo_pld120_sphv_10hv
+ cgbovl       	 = cgbovl_pld120_sphv_10hv
+ cfrw           = cfrw_pld120_sphv_10hv*(1-fem)
+ cfrdw        	 = cfrdw_pld120_sphv_10hv*(1-fem)
+ fnto           = fnto_pld120_sphv_10hv
+ nfalw        	 = nfalw_pld120_sphv_10hv
+ nfblw        	 = nfblw_pld120_sphv_10hv
+ nfclw        	 = nfclw_pld120_sphv_10hv
+ efo            = efo_pld120_sphv_10hv
+ lintnoi      	 = lintnoi_pld120_sphv_10hv
+ alpnoi       	 = alpnoi_pld120_sphv_10hv
+ kvthoweo     	 = kvthoweo_pld120_sphv_10hv
+ kvthowel     	 = kvthowel_pld120_sphv_10hv
+ kvthowew     	 = kvthowew_pld120_sphv_10hv*(1-fem)
+ kvthowelw    	 = kvthowelw_pld120_sphv_10hv*(1-fem)
+ kuoweo       	 = kuoweo_pld120_sphv_10hv
+ kuowel       	 = kuowel_pld120_sphv_10hv
+ kuowew       	 = kuowew_pld120_sphv_10hv*(1-fem)
+ kuowelw      	 = kuowelw_pld120_sphv_10hv*(1-fem)
+ rgo            = rgo_pld120_sphv_10hv
+ rsh            = rsh_pld120_sphv_10hv
+ rbulko       	 = rbulko_pld120_sphv_10hv
+ rwello       	 = rwello_pld120_sphv_10hv
+ rjunso       	 = rjunso_pld120_sphv_10hv/(w+dwrjunso_pld120_sphv_10hv*(1-fem))
+ rjundo       	 = rjundo_pld120_sphv_10hv/(w+dwrjundo_pld120_sphv_10hv*(1-fem))*sqrt(l)/(sqrt(l)+0.2)*(1+1.0e-3*(temp-27))
+ rint           = rint_pld120_sphv_10hv
+ rvpoly       	 = rvpoly_pld120_sphv_10hv
+ rshg           = rshg_pld120_sphv_10hv
+ dlsil        	 = dlsil_pld120_sphv_10hv
+ saref        	 = saref_pld120_sphv_10hv
+ sbref        	 = sbref_pld120_sphv_10hv
+ wlod           = wlod_pld120_sphv_10hv
+ kuo            = kuo_pld120_sphv_10hv
+ kvsat        	 = kvsat_pld120_sphv_10hv
+ tkuo           = tkuo_pld120_sphv_10hv
+ lkuo           = lkuo_pld120_sphv_10hv
+ wkuo           = wkuo_pld120_sphv_10hv*(1-fem)
+ pkuo           = pkuo_pld120_sphv_10hv*(1-fem)
+ llodkuo      	 = llodkuo_pld120_sphv_10hv
+ wlodkuo      	 = wlodkuo_pld120_sphv_10hv
+ kvtho        	 = kvtho_pld120_sphv_10hv
+ lkvtho       	 = lkvtho_pld120_sphv_10hv
+ wkvtho       	 = wkvtho_pld120_sphv_10hv*(1-fem)
+ pkvtho       	 = pkvtho_pld120_sphv_10hv*(1-fem)
+ llodvth      	 = llodvth_pld120_sphv_10hv
+ wlodvth      	 = wlodvth_pld120_sphv_10hv
+ stetao       	 = stetao_pld120_sphv_10hv
+ lodetao      	 = lodetao_pld120_sphv_10hv
+ scref        	 = scref_pld120_sphv_10hv
+ web            = web_pld120_sphv_10hv
+ wec            = wec_pld120_sphv_10hv
+ adr1o        	 = adr1o_pld120_sphv_10hv
+ adr1l        	 = adr1l_pld120_sphv_10hv
+ adr1w        	 = adr1w_pld120_sphv_10hv*(1-fem)
+ adr2o        	 = adr2o_pld120_sphv_10hv
+ stadr2o      	 = stadr2o_pld120_sphv_10hv
+ adr3o        	 = adr3o_pld120_sphv_10hv
+ adr3l        	 = adr3l_pld120_sphv_10hv
+ adr3w        	 = adr3w_pld120_sphv_10hv*(1-fem)
+ adr4o        	 = adr4o_pld120_sphv_10hv
+ adr4l        	 = adr4l_pld120_sphv_10hv
+ adr4w        	 = adr4w_pld120_sphv_10hv*(1-fem)
+ adr5o        	 = adr5o_pld120_sphv_10hv
+ adr5l        	 = adr5l_pld120_sphv_10hv
+ adr5w        	 = adr5w_pld120_sphv_10hv*(1-fem)
+ bidr1o       	 = bidr1o_pld120_sphv_10hv
+ bidr1l       	 = bidr1l_pld120_sphv_10hv
+ bidr1w       	 = bidr1w_pld120_sphv_10hv*(1-fem)
+ bidr2o       	 = bidr2o_pld120_sphv_10hv
+ bidr2w       	 = bidr2w_pld120_sphv_10hv*(1-fem)
+ rtho           = rth_f
+ rthl           = 0
+ rthw           = 0
+ rthlw        	 = 0
+ strtho       	 = strtho_pld120_sphv_10hv
+ strthao        = strthao_pld120_sphv_10hv
+ ctho           = cth_f
+ cthl           = 0
+ cthw           = 0
+ cthlw        	 = 0
+ rshldd       	 = (rshldd_pld120_sphv_10hv*fac_r_ng_rshldd*delr_res_pld120_sphv_10hv*fac_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld120_ronratio))
+ xw             = (xw_pld120_sphv_10hv*(1-fem))
+ nwxw           = ((nwxw_pld120_sphv_10hv+1e-12*dela_dwox_pld120_sphv_10hv)*(1-fem))
+ xl             = xl_pld120_sphv_10hv
+ xlw            = xlw_pld120_sphv_10hv*(1-fem)
+ dxlsat       	 = dxlsat_pld120_sphv_10hv
+ nst            = nst_pld120_sphv_10hv
+ ats            = ats_pld120_sphv_10hv
+ dfinf        	 = dfinf_pld120_sphv_10hv
+ dfw            = dfw_pld120_sphv_10hv*(1-fem)
+ dfl            = dfl_pld120_sphv_10hv
+ dflw           = dflw_pld120_sphv_10hv*(1-fem)
+ dp             = dp_pld120_sphv_10hv
+ ecrit        	 = ecrit_pld120_sphv_10hv*tfact_ecrit*(1+1*(1-fem)/w)
+ ecorn        	 = ecorn_pld120_sphv_10hv*tfact_ecrit*(1+1*(1-fem)/w)
+ du             = du_pld120_sphv_10hv
+ tc1            = tc1_pld120_sphv_10hv
+ tc2            = tc2_pld120_sphv_10hv
+ tc1l           = tc1l_pld120_sphv_10hv
+ tc2l           = tc2l_pld120_sphv_10hv
+ tc1w           = tc1w_pld120_sphv_10hv*(1-fem)
+ tc2w           = tc2w_pld120_sphv_10hv*(1-fem)
+ theacc       	 = theacc_pld120_sphv_10hv
+ theacc2      	 = theacc2_pld120_sphv_10hv
+ rva            = rva_pld120_sphv_10hv
+ dta            = dta_pld120_sphv_10hv
+ trj            = trj_pld120_sphv_10hv
+ cjarea       	 = cjarea_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlsti       	 = cjlsti_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlgat       	 = cjlgat_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiarea      	 = vbiarea_pld120_sphv_10hv
+ vbisti       	 = vbisti_pld120_sphv_10hv
+ vbigat       	 = vbigat_pld120_sphv_10hv
+ parea        	 = parea_pld120_sphv_10hv
+ psti           = psti_pld120_sphv_10hv
+ pgat           = pgat_pld120_sphv_10hv
+ is1area      	 = is1area_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttarea       	 = ttarea_pld120_sphv_10hv
+ is2area      	 = is2area_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irarea       	 = irarea_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1area    	 = stis1area_pld120_sphv_10hv
+ stis2area    	 = stis2area_pld120_sphv_10hv
+ stirarea     	 = stirarea_pld120_sphv_10hv
+ n1area       	 = n1area_pld120_sphv_10hv
+ n2area       	 = n2area_pld120_sphv_10hv
+ nrarea       	 = nrarea_pld120_sphv_10hv
+ is1lsti      	 = is1lsti_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttlsti       	 = ttlsti_pld120_sphv_10hv
+ is2lsti      	 = is2lsti_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irlsti       	 = irlsti_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1sti     	 = stis1sti_pld120_sphv_10hv
+ stis2sti     	 = stis2sti_pld120_sphv_10hv
+ stirsti      	 = stirsti_pld120_sphv_10hv
+ n1sti        	 = n1sti_pld120_sphv_10hv
+ n2sti        	 = n2sti_pld120_sphv_10hv
+ nrsti        	 = nrsti_pld120_sphv_10hv
+ is1lgat      	 = is1lgat_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttlgat       	 = ttlgat_pld120_sphv_10hv
+ is2lgat      	 = is2lgat_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ irlgat       	 = irlgat_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1gat     	 = stis1gat_pld120_sphv_10hv
+ stis2gat     	 = stis2gat_pld120_sphv_10hv
+ stirgat      	 = stirgat_pld120_sphv_10hv
+ n1gat        	 = n1gat_pld120_sphv_10hv
+ n2gat        	 = n2gat_pld120_sphv_10hv
+ nrgat        	 = nrgat_pld120_sphv_10hv
+ cjaread      	 = cjaread_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlstid      	 = cjlstid_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlgatd      	 = cjlgatd_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiaread     	 = vbiaread_pld120_sphv_10hv
+ vbistid      	 = vbistid_pld120_sphv_10hv
+ vbigatd      	 = vbigatd_pld120_sphv_10hv
+ paread       	 = paread_pld120_sphv_10hv
+ pstid        	 = pstid_pld120_sphv_10hv
+ pgatd        	 = pgatd_pld120_sphv_10hv
+ is1aread     	 = is1aread_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttaread      	 = ttaread_pld120_sphv_10hv
+ is2aread     	 = is2aread_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ iraread      	 = iraread_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1aread   	 = stis1aread_pld120_sphv_10hv
+ stis2aread   	 = stis2aread_pld120_sphv_10hv
+ stiraread    	 = stiraread_pld120_sphv_10hv
+ n1aread      	 = n1aread_pld120_sphv_10hv
+ n2aread      	 = n2aread_pld120_sphv_10hv
+ nraread      	 = nraread_pld120_sphv_10hv
+ is1lstid     	 = is1aread_pld120_sphv_10hv*djunc*1e-10*delr_is_pld120_sphv_10hv
+ ttlstid      	 = ttlstid_pld120_sphv_10hv
+ is2lstid     	 = is2aread_pld120_sphv_10hv*djunc*1e-10*delr_is2_pld120_sphv_10hv
+ irlstid      	 = irlstid_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1stid    	 = stis1stid_pld120_sphv_10hv
+ stis2stid    	 = stis2stid_pld120_sphv_10hv
+ stirstid     	 = stirstid_pld120_sphv_10hv
+ n1stid       	 = n1stid_pld120_sphv_10hv
+ n2stid       	 = n2stid_pld120_sphv_10hv
+ nrstid       	 = nrstid_pld120_sphv_10hv
+ is1lgatd     	 = is1aread_pld120_sphv_10hv*djunc*delr_is_pld120_sphv_10hv
+ ttlgatd      	 = ttlgatd_pld120_sphv_10hv
+ is2lgatd     	 = is2aread_pld120_sphv_10hv*djunc*delr_is2_pld120_sphv_10hv
+ irlgatd      	 = irlgatd_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1gatd    	 = stis1gatd_pld120_sphv_10hv
+ stis2gatd    	 = stis2gatd_pld120_sphv_10hv
+ stirgatd     	 = stirgatd_pld120_sphv_10hv
+ n1gatd       	 = n1gatd_pld120_sphv_10hv
+ n2gatd       	 = n2gatd_pld120_sphv_10hv
+ nrgatd       	 = nrgatd_pld120_sphv_10hv
+ cjaread2     	 = cjaread_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ cjlstid2     	 = cjlstid_pld120_sphv_10hv*delr_cj_pld120_sphv_10hv
+ vbiaread2    	 = vbiaread2_pld120_sphv_10hv
+ vbistid2     	 = vbistid2_pld120_sphv_10hv
+ paread2      	 = paread2_pld120_sphv_10hv
+ pstid2       	 = pstid2_pld120_sphv_10hv
+ is1aread2    	 = is1aread_pld120_sphv_10hv*delr_is_pld120_sphv_10hv
+ ttaread2     	 = ttaread2_pld120_sphv_10hv
+ is2aread2    	 = is2aread_pld120_sphv_10hv*delr_is2_pld120_sphv_10hv
+ iraread2     	 = iraread2_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1aread2  	 = stis1aread_pld120_sphv_10hv
+ stis2aread2  	 = stis2aread_pld120_sphv_10hv
+ stiraread2   	 = stiraread2_pld120_sphv_10hv
+ n1aread2     	 = n1aread2_pld120_sphv_10hv
+ n2aread2     	 = n2aread2_pld120_sphv_10hv
+ nraread2     	 = nraread2_pld120_sphv_10hv
+ is1lstid2    	 = is1aread_pld120_sphv_10hv*djunc*delr_is_pld120_sphv_10hv
+ ttlstid2     	 = ttlstid2_pld120_sphv_10hv
+ is2lstid2    	 = is2aread_pld120_sphv_10hv*djunc*delr_is2_pld120_sphv_10hv
+ irlstid2     	 = irlstid2_pld120_sphv_10hv*delr_ir_pld120_sphv_10hv
+ stis1stid2   	 = stis1stid2_pld120_sphv_10hv
+ stis2stid2   	 = stis2stid2_pld120_sphv_10hv
+ stirstid2    	 = stirstid2_pld120_sphv_10hv
+ n1stid2      	 = n1stid2_pld120_sphv_10hv
+ n2stid2      	 = n2stid2_pld120_sphv_10hv
+ nrstid2      	 = nrstid2_pld120_sphv_10hv
+ aacc           = aacc_pld120_sphv_10hv
+ eais1area      = eais1area_pld120_sphv_10hv
+ eais2area      = eais2area_pld120_sphv_10hv
+ eairarea       = eairarea_pld120_sphv_10hv
+ eais1sti       = eais1sti_pld120_sphv_10hv
+ eais2sti       = eais2sti_pld120_sphv_10hv
+ eairsti        = eairsti_pld120_sphv_10hv
+ eais1gat       = eais1gat_pld120_sphv_10hv
+ eais2gat       = eais2gat_pld120_sphv_10hv
+ eairgat        = eairgat_pld120_sphv_10hv
+ eais1aread     = eais1aread_pld120_sphv_10hv
+ eais2aread     = eais2aread_pld120_sphv_10hv
+ eairaread      = eairaread_pld120_sphv_10hv
+ eais1stid      = eais1stid_pld120_sphv_10hv
+ eais2stid      = eais2stid_pld120_sphv_10hv
+ eairstid       = eairstid_pld120_sphv_10hv
+ eais1gatd      = eais1gatd_pld120_sphv_10hv
+ eais2gatd      = eais2gatd_pld120_sphv_10hv
+ eairgatd       = eairgatd_pld120_sphv_10hv
+ eais1aread2    = eais1aread2_pld120_sphv_10hv
+ eais2aread2    = eais2aread2_pld120_sphv_10hv
+ eairaread2     = eairaread2_pld120_sphv_10hv
+ eais1stid2     = eais1stid2_pld120_sphv_10hv
+ eais2stid2     = eais2stid2_pld120_sphv_10hv
+ eairstid2      = eairstid2_pld120_sphv_10hv
+ ikfarea        = ikfarea_pld120_sphv_10hv
+ ikflsti        = ikfarea_pld120_sphv_10hv*djunc
+ ikflgat        = ikfarea_pld120_sphv_10hv*djunc
+ stikfarea      = stikfarea_pld120_sphv_10hv
+ stikfsti       = stikfarea_pld120_sphv_10hv
+ stikfgat       = stikfarea_pld120_sphv_10hv
+ ikfaread       = ikfaread_pld120_sphv_10hv*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflstid       = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflgatd       = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikfaread2      = ikfaread_pld120_sphv_10hv*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ ikflstid2      = ikfaread_pld120_sphv_10hv*djunc*(w/(w+dwikfaread_pld120_sphv_10hv*(1-fem)))
+ stikfaread     = stikfaread_pld120_sphv_10hv
+ stikfstid      = stikfaread_pld120_sphv_10hv
+ stikfgatd      = stikfaread_pld120_sphv_10hv
+ stikfaread2    = stikfaread_pld120_sphv_10hv
+ stikfstid2     = stikfaread_pld120_sphv_10hv

include "./smos10hv_ade_dfrt.scs" section=pld120_10hv_dfrt
ends

// pld90b_10hv

subckt pld90b_10hv (d g s sub)

parameters
+ w				 = (5)
+ ng				 = (2)
+ lpe				 = (0)
+ sti_dummy			 = (0)
+ fem				 = (0)
+ soa				 = (1)
+ selfheat			 = (1)
+ mode_rthcth			 = (1)
+ dela_vth_relimo		 = (0)
+ dela_vth_relimo_mod		 = (0)
+ delr_u0_relimo		 = (1)
+ delr_rdsw_relimo		 = (1)
+ delr_a0_relimo		 = (1)
+ presto_device_active           = (1)
+ nbtidamage		         = (0.0)
+ nbtivthdegr		         = (0.0)
+ pbtidamage		         = (0.0)
+ pbtivthdegr		         = (0.0)
+ hcirondegrfac 	         = (0.0)
+ offrondegrfac 	         = (0.0)
+ hvgsvthdegr		         = (0.0)
+ hcidamage1		         = (0.0)
+ hcidamage2		         = (0.0)
+ offdamage1		         = (0.0)
+ offdamage2		         = (0.0)
+ hvgsdamage		         = (0.0)
+ presto_pld90b_vthratio         = 1.0*(1.0/1.2052)
+ presto_pld90b_ronratio         = 0.01/1.0/1.0636
+ l				 = (0.5)
+ lovlap 			 = (0.5+0.55-0.913-0.078)
+ length 			 = (0.913+0.078+lovlap+2.65)
+ tn                             = (27+273.15)
+ delt                           = (temp+273.15-tn)
+ rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+ rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+ nsmm_delr_tox_pld90b_sphv_10hv    = tmp_nsmm_delr_tox_pld90b_sphv_10hv
+ nsmm_dela_vfb_pld90b_sphv_10hv    = tmp_nsmm_dela_vfb_pld90b_sphv_10hv
+ nsmm_dela_vtw_pld90b_sphv_10hv    = tmp_nsmm_dela_vtw_pld90b_sphv_10hv
+ nsmm_delr_uch_pld90b_sphv_10hv    = tmp_nsmm_delr_uch_pld90b_sphv_10hv
+ nsmm_delr_res_pld90b_sphv_10hv    = tmp_nsmm_delr_res_pld90b_sphv_10hv
+ nsmm_dela_dwox_pld90b_sphv_10hv   = tmp_nsmm_dela_dwox_pld90b_sphv_10hv
+ nsmm_delr_nsub_pld90b_sphv_10hv   = tmp_nsmm_delr_nsub_pld90b_sphv_10hv

//process parameters
//+ delr_tox_pld90b_sphv_10hv    = (nom_delr_tox_pld90b_sphv_10hv*(1+sig_delr_tox_pld90b_sphv_10hv*nsig_delr_tox_pld90b_sphv_10hv+nsmm_delr_tox_pld90b_sphv_10hv*smm_delr_tox_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_tox_pld90b_sphv_10hv      = (nom_delr_tox_pld90b_sphv_10hv*(1+sig_delr_tox_pld90b_sphv_10hv*nsig_delr_powermos_tox+nsmm_delr_tox_pld90b_sphv_10hv*smm_delr_tox_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_vfb_pld90b_sphv_10hv      = (nom_dela_vfb_pld90b_sphv_10hv+(sig_dela_vfb_pld90b_sphv_10hv*nsig_dela_vfb_pld90b_sphv_10hv)+nsmm_dela_vfb_pld90b_sphv_10hv*smm_dela_vfb_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ dela_vtw_pld90b_sphv_10hv      = (nom_dela_vtw_pld90b_sphv_10hv+(sig_dela_vtw_pld90b_sphv_10hv*nsig_dela_vtw_pld90b_sphv_10hv)+nsmm_dela_vtw_pld90b_sphv_10hv*smm_dela_vtw_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_uch_pld90b_sphv_10hv      = (nom_delr_uch_pld90b_sphv_10hv*(1+sig_delr_uch_pld90b_sphv_10hv*nsig_delr_uch_pld90b_sphv_10hv+nsmm_delr_uch_pld90b_sphv_10hv*smm_delr_uch_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ delr_res_pld90b_sphv_10hv      = (nom_delr_res_pld90b_sphv_10hv*(1+sig_delr_res_pld90b_sphv_10hv*nsig_delr_res_pld90b_sphv_10hv+nsmm_delr_res_pld90b_sphv_10hv*smm_delr_res_pld90b_sphv_10hv(l,w)/sqrt(ng/2)))
+ dela_dwox_pld90b_sphv_10hv     = (nom_dela_dwox_pld90b_sphv_10hv+(sig_dela_dwox_pld90b_sphv_10hv*nsig_dela_dwox_pld90b_sphv_10hv)+nsmm_dela_dwox_pld90b_sphv_10hv*smm_dela_dwox_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_nsub_pld90b_sphv_10hv     = (1+nsmm_delr_nsub_pld90b_sphv_10hv*smm_delr_nsub_pld90b_sphv_10hv(l,w)/sqrt(ng/2))
+ delr_cj_pld90b_sphv_10hv	 = (nom_delr_cj_pld90b_sphv_10hv*(1.0+nsig_delr_cj_pld90b_sphv_10hv*sig_delr_cj_pld90b_sphv_10hv))
+ delr_is_pld90b_sphv_10hv	 = (nom_delr_is_pld90b_sphv_10hv*exp(nsig_delr_is_pld90b_sphv_10hv*sig_delr_is_pld90b_sphv_10hv))
+ delr_is2_pld90b_sphv_10hv	 = (nom_delr_is2_pld90b_sphv_10hv*exp(nsig_delr_is2_pld90b_sphv_10hv*sig_delr_is2_pld90b_sphv_10hv))
+ delr_ir_pld90b_sphv_10hv	 = (nom_delr_ir_pld90b_sphv_10hv*exp(nsig_delr_ir_pld90b_sphv_10hv*sig_delr_ir_pld90b_sphv_10hv))

parameters
//+ nde=(fmod(ng,2))
+ nde=(0)
+ nse=(2-nde)
+ nd=((ng+nde)/2)
+ ns=(1-nde+nd)
+ ndi=(nd-nde)
+ nsi=(ns-nse)

//dummy parameters
+ ng_dmy=(2*sti_dummy)
+ ng_eff=(ng+ng_dmy)
+ ndi_eff=(ng_eff/2)
+ nsi_eff=((ng_eff-2)/2)

+ wdrift=(w)
+ ldrift=(6)
+ ldr1=(0.55)
+ lacts=(0.3)
+ lactd=(1.32)
+ lactg=(0.35)

// junction calculation
+ as=(w*lacts)
+ ps=((w+lacts)*2)
+ w2nhv=(9.9)*(1-fem)
+ rnhv=(1.6)
+ ad=((ldr1+lactg+ldrift/2-rnhv)*(w+2*w2nhv)+rnhv*(w+2*w2nhv-2*rnhv*(1-fem))+rnhv*rnhv*pi4models/2*(1-fem))
+ pd=(w+2*w2nhv-2*rnhv*(1-fem)+2*(ldr1+lactg+ldrift/2-rnhv)+rnhv*pi4models*(1-fem))
+ ad2=((ldrift/2+lactd/2)*(w+2*w2nhv))
+ pd2=(ldrift+lactd)

+ lb2b_d=(15.12)
+ lp2p_s=(0.99)
+ l2dt_s=(3.66)
+ w2dt=(13.4)*(1-fem)
+ xlnbl=(l2dt_s*nse+l*ng_eff+lb2b_d*ndi_eff+lp2p_s*nsi_eff)
+ ylnbl=(w+2*w2dt)
+ alnbl=(xlnbl*ylnbl)
+ plnbl=(2*(xlnbl+ylnbl))

+ w_heat=(w)
+ l_heat=(lacts*nse+l*ng+lb2b_d*ndi+lp2p_s*nsi)
+ dtemp__1__=temp-tnom
+ tcr__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ tcc__1__=1.0+dtemp__1__*((0)+dtemp__1__*(0))
+ area__1__=(w_heat)*(l_heat)
+ aspr__1__=max((w_heat),(l_heat))/min((w_heat),(l_heat))
+ rth0__1__=9493.2
+ c11__1__=-0.4301
+ c12__1__=-0.0266
+ c21__1__=-0.0358
+ c22__1__=-0.0769
+ term_area_1__1__ = c11__1__*log10(area__1__)
+ term_area_2__1__ = c12__1__*pow(log10(area__1__),2)
+ term_aspr_1__1__ = c21__1__*log10(aspr__1__)
+ term_aspr_2__1__ = c22__1__*pow(log10(aspr__1__),2)
+ rth=rth0__1__*pow(10,term_area_1__1__+term_area_2__1__+term_aspr_1__1__+term_aspr_2__1__)*tcr__1__
+ cth0__1__=1.264e-11
+ c11__2__=0.8994
+ c12__2__=0.0482
+ c2__1__=0.145
+ term_area_1__2__ = c11__2__*log10(area__1__)
+ term_area_2__2__ = c12__2__*pow(log10(area__1__),2)
+ cth=cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__
+ rth_f=((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld90b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld90b_sphv_10hv)*ng_eff
+ cth_f=((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ng_eff
+ djunc=(2.5*1e-06)
+ tfact_ecrit=1+(tc1_ecrit_pld90b_sphv_10hv+tc2_ecrit_pld90b_sphv_10hv*(temp-tnom))*(temp-tnom)

// calculation for poly over field parasitic capaciance
+ dwcgdfldmoscap=34*(1-fem)
+ dwcgd_ply_fld=20*(1-fem)
+ cgd_ply_fld=6.0e-17*(w+dwcgd_ply_fld)*ng
+ cgs_ply_fld=6.0e-15*(1-fem)*ng

// parasitic capacitnace caused by dummy gate
+ cgd_ply_fld_dmy=6.0e-17*(w+dwcgd_ply_fld)*ng_dmy

// parameters for veriloga
+ vp_pld90b_10hv = (32)
+ dvp_pld90b_10hv = (4)
+ type_pld90b_10hv = (-1)

// simple model factor
+ swdrlin  = (0)
+ fac_rshldd = ((swdrlin==0)+(swdrlin==2)*0.9255)


// parameters for the BV diode
+ dcbv_pld90b_10hv = (112)

model dbodyBV diode
+ allow_scaling = (yes)
+ jmax  	= (1e12)
+ jmelt 	= (1e12)
+ tnom  	= (27)
+ is		= (1e-30)
+ n		= (1.0)
+ cj		= (1e-30)
+ pta		= (0)
+ tlevc 	= (2)
+ tlev  	= (2)
+ bv		= (dcbv_pld90b_10hv+bvdss_shift)
+ ibv		= (1e-5/1e-12)

dbodyBV (d rd) dbodyBV area=((ad+ad2)*ng_eff)
rlimit (rd s) resistor r=0.01


// changed from 4-t to 5-t
amost (d gi s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

model sphvt_simkit sphvt
+ type         = p
+ tr           = 27
+ swgeo        = 1
+ swigate      = 0
+ swimpact     = 0
+ swgidl       = 0
+ swjunc       = 2
+ swjunasym    = 1
+ swshe        = selfheat*enable_selfheat
+ swtcec      = 1
+ swimpdr      = 0
+ swexp        = 0
+ swdelvtac    = 1
+ swnud        = 0
+ swgedi	     = 1
+ swdrlin	     = swdrlin
+ xvsat        = xvsat_pld90b_sphv_10hv
+ qmc          = qmc_pld90b_sphv_10hv
+ lvaro        = lvaro_pld90b_sphv_10hv
+ lvarl        = lvarl_pld90b_sphv_10hv
+ lvarw        = lvarw_pld90b_sphv_10hv*(1-fem)
+ lap          = lap_pld90b_sphv_10hv
+ wvaro        = wvaro_pld90b_sphv_10hv*(1-fem)
+ wvarl        = wvarl_pld90b_sphv_10hv*(1-fem)
+ wvarw        = wvarw_pld90b_sphv_10hv*(1-fem)
+ wot          = wot_pld90b_sphv_10hv*(1-fem)
+ dlq          = dlq_pld90b_sphv_10hv
+ dwq          = dwq_pld90b_sphv_10hv*(1-fem)
+ vfbo         = vfbo_pld90b_sphv_10hv+dela_vfb_pld90b_sphv_10hv+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*(0.028)+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld90b_vthratio
+ vfbl         = vfbl_pld90b_sphv_10hv
+ vfbw         = (vfbw_pld90b_sphv_10hv+dela_vtw_pld90b_sphv_10hv)*(1-fem)
+ vfblw        = vfblw_pld90b_sphv_10hv*(1-fem)
+ stvfbo       = stvfbo_pld90b_sphv_10hv
+ stvfbl       = stvfbl_pld90b_sphv_10hv
+ stvfbw       = stvfbw_pld90b_sphv_10hv*(1-fem)
+ stvfblw      = stvfblw_pld90b_sphv_10hv*(1-fem)
+ toxo         = toxo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ epsroxo      = epsroxo_pld90b_sphv_10hv
+ nsubo        = nsubo_pld90b_sphv_10hv*delr_nsub_pld90b_sphv_10hv
+ nsubw        = nsubw_pld90b_sphv_10hv*(1-fem)
+ wseg         = wseg_pld90b_sphv_10hv
+ npck         = npck_pld90b_sphv_10hv
+ npckw        = npckw_pld90b_sphv_10hv*(1-fem)
+ wsegp        = wsegp_pld90b_sphv_10hv
+ lpck         = lpck_pld90b_sphv_10hv
+ lpckw        = lpckw_pld90b_sphv_10hv*(1-fem)
+ fol1         = fol1_pld90b_sphv_10hv
+ fol2         = fol2_pld90b_sphv_10hv
+ facneffaco   = facneffaco_pld90b_sphv_10hv
+ facneffacl   = facneffacl_pld90b_sphv_10hv
+ facneffacw   = facneffacw_pld90b_sphv_10hv*(1-fem)
+ facneffaclw  = facneffaclw_pld90b_sphv_10hv*(1-fem)
+ gfacnudo     = gfacnudo_pld90b_sphv_10hv
+ gfacnudl     = gfacnudl_pld90b_sphv_10hv
+ gfacnudlexp  = gfacnudlexp_pld90b_sphv_10hv
+ gfacnudw     = gfacnudw_pld90b_sphv_10hv*(1-fem)
+ gfacnudlw    = gfacnudlw_pld90b_sphv_10hv*(1-fem)
+ vsbnudo      = vsbnudo_pld90b_sphv_10hv
+ dvsbnudo     = dvsbnudo_pld90b_sphv_10hv
+ vnsubo       = vnsubo_pld90b_sphv_10hv
+ nslpo        = nslpo_pld90b_sphv_10hv
+ dnsubo       = dnsubo_pld90b_sphv_10hv
+ dphibo       = dphibo_pld90b_sphv_10hv
+ dphibl       = dphibl_pld90b_sphv_10hv
+ dphiblexp    = dphiblexp_pld90b_sphv_10hv
+ dphibw       = dphibw_pld90b_sphv_10hv*(1-fem)
+ dphiblw      = dphiblw_pld90b_sphv_10hv*(1-fem)
+ delvtaco     = delvtaco_pld90b_sphv_10hv
+ delvtacl     = delvtacl_pld90b_sphv_10hv
+ delvtaclexp  = delvtaclexp_pld90b_sphv_10hv
+ delvtacw     = delvtacw_pld90b_sphv_10hv*(1-fem)
+ delvtaclw    = delvtaclw_pld90b_sphv_10hv*(1-fem)
+ npo          = npo_pld90b_sphv_10hv
+ npl          = npl_pld90b_sphv_10hv
+ cto          = cto_pld90b_sphv_10hv
+ ctl          = ctl_pld90b_sphv_10hv
+ ctlexp       = ctlexp_pld90b_sphv_10hv
+ ctw          = ctw_pld90b_sphv_10hv*(1-fem)
+ ctlw         = ctlw_pld90b_sphv_10hv*(1-fem)
+ ctgo         = ctgo_pld90b_sphv_10hv
+ ctbo         = ctbo_pld90b_sphv_10hv
+ stcto        = stcto_pld90b_sphv_10hv
+ toxovo       = toxovo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ toxovdo      = toxovdo_pld90b_sphv_10hv*delr_tox_pld90b_sphv_10hv
+ lov          = lov_pld90b_sphv_10hv
+ dlovd        = dlovd_pld90b_sphv_10hv
+ novo         = novo_pld90b_sphv_10hv
+ novdo        = novdo_pld90b_sphv_10hv
+ cfl          = cfl_pld90b_sphv_10hv
+ cflexp       = cflexp_pld90b_sphv_10hv
+ cfw          = cfw_pld90b_sphv_10hv*(1-fem)
+ cfbo         = cfbo_pld90b_sphv_10hv
+ uo           = uo_pld90b_sphv_10hv*delr_uch_pld90b_sphv_10hv*delr_u0_relimo
+ fbet1        = fbet1_pld90b_sphv_10hv
+ fbet1w       = fbet1w_pld90b_sphv_10hv*(1-fem)
+ lp1          = lp1_pld90b_sphv_10hv
+ lp1w         = lp1w_pld90b_sphv_10hv*(1-fem)
+ fbet2        = fbet2_pld90b_sphv_10hv
+ lp2          = lp2_pld90b_sphv_10hv
+ betw1        = betw1_pld90b_sphv_10hv*(1-fem)
+ betw2        = betw2_pld90b_sphv_10hv*(1-fem)
+ wbet         = wbet_pld90b_sphv_10hv
+ stbeto       = stbeto_pld90b_sphv_10hv
+ stbetl       = stbetl_pld90b_sphv_10hv
+ stbetw       = stbetw_pld90b_sphv_10hv*(1-fem)
+ stbetlw      = stbetlw_pld90b_sphv_10hv*(1-fem)
+ mueo         = mueo_pld90b_sphv_10hv
+ muew         = muew_pld90b_sphv_10hv*(1-fem)
+ stmueo       = stmueo_pld90b_sphv_10hv
+ themuo       = themuo_pld90b_sphv_10hv
+ stthemuo     = stthemuo_pld90b_sphv_10hv
+ cso          = cso_pld90b_sphv_10hv
+ csl          = csl_pld90b_sphv_10hv
+ cslexp       = cslexp_pld90b_sphv_10hv
+ csw          = csw_pld90b_sphv_10hv*(1-fem)
+ cslw         = cslw_pld90b_sphv_10hv*(1-fem)
+ stcso        = stcso_pld90b_sphv_10hv
+ xcoro        = xcoro_pld90b_sphv_10hv
+ xcorl        = xcorl_pld90b_sphv_10hv
+ xcorw        = xcorw_pld90b_sphv_10hv*(1-fem)
+ xcorlw       = xcorlw_pld90b_sphv_10hv*(1-fem)
+ stxcoro      = stxcoro_pld90b_sphv_10hv
+ fetao        = fetao_pld90b_sphv_10hv
+ rsw1         = rsw1_pld90b_sphv_10hv
+ rsw2         = rsw2_pld90b_sphv_10hv*(1-fem)
+ strso        = strso_pld90b_sphv_10hv
+ rsbo         = rsbo_pld90b_sphv_10hv
+ rsgo         = rsgo_pld90b_sphv_10hv
+ thesato      = thesato_pld90b_sphv_10hv*(1+(ng_eff/(ng_eff+1*(1-fem))-2/(2+1))*(0.3))
+ thesatl      = thesatl_pld90b_sphv_10hv
+ thesatlexp   = thesatlexp_pld90b_sphv_10hv
+ thesatw      = thesatw_pld90b_sphv_10hv*(1-fem)
+ thesatlw     = thesatlw_pld90b_sphv_10hv*(1-fem)
+ stthesato    = stthesato_pld90b_sphv_10hv
+ stthesatl    = stthesatl_pld90b_sphv_10hv
+ stthesatw    = stthesatw_pld90b_sphv_10hv*(1-fem)
+ stthesatlw   = stthesatlw_pld90b_sphv_10hv*(1-fem)
+ thesatbo     = thesatbo_pld90b_sphv_10hv
+ thesatgo     = thesatgo_pld90b_sphv_10hv
+ thesatgl     = thesatgl_pld90b_sphv_10hv
+ thesatgw     = thesatgw_pld90b_sphv_10hv*(1-fem)
+ vdscale      = vdscale_pld90b_sphv_10hv
+ vdscaleb     = vdscaleb_pld90b_sphv_10hv
+ stvdscale    = stvdscale_pld90b_sphv_10hv
+ axo          = axo_pld90b_sphv_10hv
+ axl          = axl_pld90b_sphv_10hv
+ alpl         = alpl_pld90b_sphv_10hv
+ alplexp      = alplexp_pld90b_sphv_10hv
+ alpw         = alpw_pld90b_sphv_10hv*(1-fem)
+ alp1l1       = alp1l1_pld90b_sphv_10hv
+ alp1lexp     = alp1lexp_pld90b_sphv_10hv
+ alp1l2       = alp1l2_pld90b_sphv_10hv
+ alp1w        = alp1w_pld90b_sphv_10hv*(1-fem)
+ alp2l1       = alp2l1_pld90b_sphv_10hv
+ alp2lexp     = alp2lexp_pld90b_sphv_10hv
+ alp2l2       = alp2l2_pld90b_sphv_10hv
+ alp2w        = alp2w_pld90b_sphv_10hv*(1-fem)
+ vpo          = vpo_pld90b_sphv_10hv
+ a1o          = a1o_pld90b_sphv_10hv
+ a1l          = a1l_pld90b_sphv_10hv
+ a1w          = a1w_pld90b_sphv_10hv*(1-fem)
+ a2o          = a2o_pld90b_sphv_10hv
+ sta2o        = sta2o_pld90b_sphv_10hv
+ a3o          = a3o_pld90b_sphv_10hv
+ a3l          = a3l_pld90b_sphv_10hv
+ a3w          = a3w_pld90b_sphv_10hv*(1-fem)
+ a4o          = a4o_pld90b_sphv_10hv
+ a4l          = a4l_pld90b_sphv_10hv
+ a4w          = a4w_pld90b_sphv_10hv*(1-fem)
+ gcoo         = gcoo_pld90b_sphv_10hv
+ iginvlw      = iginvlw_pld90b_sphv_10hv
+ igovw        = igovw_pld90b_sphv_10hv
+ igovdw       = igovdw_pld90b_sphv_10hv
+ stigo        = stigo_pld90b_sphv_10hv
+ gc2o         = gc2o_pld90b_sphv_10hv
+ gc3o         = gc3o_pld90b_sphv_10hv
+ chibo        = chibo_pld90b_sphv_10hv
+ agidlw       = agidlw_pld90b_sphv_10hv
+ agidldw      = agidldw_pld90b_sphv_10hv
+ bgidlo       = bgidlo_pld90b_sphv_10hv
+ bgidldo      = bgidldo_pld90b_sphv_10hv
+ stbgidlo     = stbgidlo_pld90b_sphv_10hv
+ stbgidldo    = stbgidldo_pld90b_sphv_10hv
+ cgidlo       = cgidlo_pld90b_sphv_10hv
+ cgidldo      = cgidldo_pld90b_sphv_10hv
+ cgbovl       = cgbovl_pld90b_sphv_10hv
+ cfrw         = cfrw_pld90b_sphv_10hv*(1-fem)
+ cfrdw        = cfrdw_pld90b_sphv_10hv*(1-fem)
+ fnto         = fnto_pld90b_sphv_10hv
+ nfalw        = nfalw_pld90b_sphv_10hv
+ nfblw        = nfblw_pld90b_sphv_10hv
+ nfclw        = nfclw_pld90b_sphv_10hv
+ efo          = efo_pld90b_sphv_10hv
+ lintnoi      = lintnoi_pld90b_sphv_10hv
+ alpnoi       = alpnoi_pld90b_sphv_10hv
+ kvthoweo     = kvthoweo_pld90b_sphv_10hv
+ kvthowel     = kvthowel_pld90b_sphv_10hv
+ kvthowew     = kvthowew_pld90b_sphv_10hv*(1-fem)
+ kvthowelw    = kvthowelw_pld90b_sphv_10hv*(1-fem)
+ kuoweo       = kuoweo_pld90b_sphv_10hv
+ kuowel       = kuowel_pld90b_sphv_10hv
+ kuowew       = kuowew_pld90b_sphv_10hv*(1-fem)
+ kuowelw      = kuowelw_pld90b_sphv_10hv*(1-fem)
+ rgo          = rgo_pld90b_sphv_10hv
+ rsh          = rsh_pld90b_sphv_10hv
+ rbulko       = rbulko_pld90b_sphv_10hv
+ rwello       = rwello_pld90b_sphv_10hv
+ rjunso       = rjunso_pld90b_sphv_10hv/(w+dwrjunso_pld90b_sphv_10hv*(1-fem))
+ rjundo       = rjundo_pld90b_sphv_10hv/(w+dwrjundo_pld90b_sphv_10hv*(1-fem))
+ rint         = rint_pld90b_sphv_10hv
+ rvpoly       = rvpoly_pld90b_sphv_10hv
+ rshg         = rshg_pld90b_sphv_10hv
+ dlsil        = dlsil_pld90b_sphv_10hv
+ saref        = saref_pld90b_sphv_10hv
+ sbref        = sbref_pld90b_sphv_10hv
+ wlod         = wlod_pld90b_sphv_10hv
+ kuo          = kuo_pld90b_sphv_10hv
+ kvsat        = kvsat_pld90b_sphv_10hv
+ tkuo         = tkuo_pld90b_sphv_10hv
+ lkuo         = lkuo_pld90b_sphv_10hv
+ wkuo         = wkuo_pld90b_sphv_10hv*(1-fem)
+ pkuo         = pkuo_pld90b_sphv_10hv*(1-fem)
+ llodkuo      = llodkuo_pld90b_sphv_10hv
+ wlodkuo      = wlodkuo_pld90b_sphv_10hv
+ kvtho        = kvtho_pld90b_sphv_10hv
+ lkvtho       = lkvtho_pld90b_sphv_10hv
+ wkvtho       = wkvtho_pld90b_sphv_10hv*(1-fem)
+ pkvtho       = pkvtho_pld90b_sphv_10hv*(1-fem)
+ llodvth      = llodvth_pld90b_sphv_10hv
+ wlodvth      = wlodvth_pld90b_sphv_10hv
+ stetao       = stetao_pld90b_sphv_10hv
+ lodetao      = lodetao_pld90b_sphv_10hv
+ scref        = scref_pld90b_sphv_10hv
+ web          = web_pld90b_sphv_10hv
+ wec          = wec_pld90b_sphv_10hv
+ adr1o        = adr1o_pld90b_sphv_10hv
+ adr1l        = adr1l_pld90b_sphv_10hv
+ adr1w        = adr1w_pld90b_sphv_10hv*(1-fem)
+ adr2o        = adr2o_pld90b_sphv_10hv
+ stadr2o      = stadr2o_pld90b_sphv_10hv
+ adr3o        = adr3o_pld90b_sphv_10hv
+ adr3l        = adr3l_pld90b_sphv_10hv
+ adr3w        = adr3w_pld90b_sphv_10hv*(1-fem)
+ adr4o        = adr4o_pld90b_sphv_10hv
+ adr4l        = adr4l_pld90b_sphv_10hv
+ adr4w        = adr4w_pld90b_sphv_10hv*(1-fem)
+ adr5o        = adr5o_pld90b_sphv_10hv
+ adr5l        = adr5l_pld90b_sphv_10hv
+ adr5w        = adr5w_pld90b_sphv_10hv*(1-fem)
+ bidr1o       = bidr1o_pld90b_sphv_10hv
+ bidr1l       = bidr1l_pld90b_sphv_10hv
+ bidr1w       = bidr1w_pld90b_sphv_10hv*(1-fem)
+ bidr2o       = bidr2o_pld90b_sphv_10hv
+ bidr2w       = bidr2w_pld90b_sphv_10hv*(1-fem)
+ rtho       = (selfheat*enable_selfheat>0)?rth_f:0.0
+ rthl         = 0
+ rthw         = 0
+ rthlw        = 0
+ strtho       = strtho_pld90b_sphv_10hv
+ strthao      = strthao_pld90b_sphv_10hv
+ ctho         = cth_f
+ cthl         = 0
+ cthw         = 0
+ cthlw        = 0
+ rshldd       = (rshldd_pld90b_sphv_10hv*delr_res_pld90b_sphv_10hv*(1+(ng_eff/(ng_eff+0.5*(1-fem))-2/(2+0.5))*(0.18))*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld90b_ronratio)*fac_rshldd)
+ xw           = xw_pld90b_sphv_10hv*(1-fem)
+ nwxw         = (nwxw_pld90b_sphv_10hv+1.0e-12*dela_dwox_pld90b_sphv_10hv)*(1-fem)
+ xl           = xl_pld90b_sphv_10hv
+ xlw          = xlw_pld90b_sphv_10hv*(1-fem)
+ dxlsat       = dxlsat_pld90b_sphv_10hv
+ nst          = nst_pld90b_sphv_10hv
+ ats          = ats_pld90b_sphv_10hv
+ dfinf        = dfinf_pld90b_sphv_10hv
+ dfw          = dfw_pld90b_sphv_10hv*(1-fem)
+ dfl          = dfl_pld90b_sphv_10hv
+ dflw         = dflw_pld90b_sphv_10hv*(1-fem)
+ dp           = dp_pld90b_sphv_10hv
+ ecrit        = ecrit_pld90b_sphv_10hv*tfact_ecrit
+ ecorn        = ecorn_pld90b_sphv_10hv*tfact_ecrit
+ du           = du_pld90b_sphv_10hv
+ tc1          = tc1_pld90b_sphv_10hv
+ tc2          = tc2_pld90b_sphv_10hv
+ tc1l         = tc1l_pld90b_sphv_10hv
+ tc2l         = tc2l_pld90b_sphv_10hv
+ tc1w         = tc1w_pld90b_sphv_10hv*(1-fem)
+ tc2w         = tc2w_pld90b_sphv_10hv*(1-fem)
+ theacc       = theacc_pld90b_sphv_10hv
+ theacc2      = theacc2_pld90b_sphv_10hv
+ rva          = rva_pld90b_sphv_10hv
+ dta          = dta_pld90b_sphv_10hv
+ trj          = trj_pld90b_sphv_10hv
+ cjarea       = cjarea_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlsti       = cjlsti_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlgat       = cjarea_pld90b_sphv_10hv*djunc*delr_cj_pld90b_sphv_10hv
+ vbiarea      = vbiarea_pld90b_sphv_10hv
+ vbisti       = vbisti_pld90b_sphv_10hv
+ vbigat       = vbigat_pld90b_sphv_10hv
+ parea        = parea_pld90b_sphv_10hv
+ psti         = psti_pld90b_sphv_10hv
+ pgat         = pgat_pld90b_sphv_10hv
+ is1area      = is1area_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttarea       = ttarea_pld90b_sphv_10hv
+ is2area      = is2area_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irarea       = irarea_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1area    = stis1area_pld90b_sphv_10hv
+ stis2area    = stis2area_pld90b_sphv_10hv
+ stirarea     = stirarea_pld90b_sphv_10hv
+ n1area       = n1area_pld90b_sphv_10hv
+ n2area       = n2area_pld90b_sphv_10hv
+ nrarea       = nrarea_pld90b_sphv_10hv
+ is1lsti      = is1lsti_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlsti       = ttlsti_pld90b_sphv_10hv
+ is2lsti      = is2lsti_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlsti       = irlsti_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1sti     = stis1sti_pld90b_sphv_10hv
+ stis2sti     = stis2sti_pld90b_sphv_10hv
+ stirsti      = stirsti_pld90b_sphv_10hv
+ n1sti        = n1sti_pld90b_sphv_10hv
+ n2sti        = n2sti_pld90b_sphv_10hv
+ nrsti        = nrsti_pld90b_sphv_10hv
+ is1lgat      = is1area_pld90b_sphv_10hv*djunc*delr_is_pld90b_sphv_10hv
+ ttlgat       = ttlgat_pld90b_sphv_10hv
+ is2lgat      = is2area_pld90b_sphv_10hv*djunc*delr_is2_pld90b_sphv_10hv
+ irlgat       = irarea_pld90b_sphv_10hv*djunc*delr_ir_pld90b_sphv_10hv
+ stis1gat     = stis1gat_pld90b_sphv_10hv
+ stis2gat     = stis2gat_pld90b_sphv_10hv
+ stirgat      = stirgat_pld90b_sphv_10hv
+ n1gat        = n1gat_pld90b_sphv_10hv
+ n2gat        = n2gat_pld90b_sphv_10hv
+ nrgat        = nrgat_pld90b_sphv_10hv
+ cjaread      = cjaread_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlstid      = cjlstid_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlgatd      = cjlgatd_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ vbiaread     = vbiaread_pld90b_sphv_10hv
+ vbistid      = vbistid_pld90b_sphv_10hv
+ vbigatd      = vbigatd_pld90b_sphv_10hv
+ paread       = paread_pld90b_sphv_10hv
+ pstid        = pstid_pld90b_sphv_10hv
+ pgatd        = pgatd_pld90b_sphv_10hv
+ is1aread     = is1aread_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttaread      = ttaread_pld90b_sphv_10hv
+ is2aread     = is2aread_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ iraread      = iraread_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1aread   = stis1aread_pld90b_sphv_10hv
+ stis2aread   = stis2aread_pld90b_sphv_10hv
+ stiraread    = stiraread_pld90b_sphv_10hv
+ n1aread      = n1aread_pld90b_sphv_10hv
+ n2aread      = n2aread_pld90b_sphv_10hv
+ nraread      = nraread_pld90b_sphv_10hv
+ is1lstid     = is1lstid_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlstid      = ttlstid_pld90b_sphv_10hv
+ is2lstid     = is2lstid_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlstid      = irlstid_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1stid    = stis1stid_pld90b_sphv_10hv
+ stis2stid    = stis2stid_pld90b_sphv_10hv
+ stirstid     = stirstid_pld90b_sphv_10hv
+ n1stid       = n1stid_pld90b_sphv_10hv
+ n2stid       = n2stid_pld90b_sphv_10hv
+ nrstid       = nrstid_pld90b_sphv_10hv
+ is1lgatd     = is1aread_pld90b_sphv_10hv*djunc*delr_is_pld90b_sphv_10hv
+ ttlgatd      = ttlgatd_pld90b_sphv_10hv
+ is2lgatd     = is2aread_pld90b_sphv_10hv*djunc*delr_is2_pld90b_sphv_10hv
+ irlgatd      = irlgatd_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1gatd    = stis1gatd_pld90b_sphv_10hv
+ stis2gatd    = stis2gatd_pld90b_sphv_10hv
+ stirgatd     = stirgatd_pld90b_sphv_10hv
+ n1gatd       = n1gatd_pld90b_sphv_10hv
+ n2gatd       = n2gatd_pld90b_sphv_10hv
+ nrgatd       = nrgatd_pld90b_sphv_10hv
+ cjaread2     = cjaread2_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ cjlstid2     = cjlstid2_pld90b_sphv_10hv*delr_cj_pld90b_sphv_10hv
+ vbiaread2    = vbiaread2_pld90b_sphv_10hv
+ vbistid2     = vbistid2_pld90b_sphv_10hv
+ paread2      = paread2_pld90b_sphv_10hv
+ pstid2       = pstid2_pld90b_sphv_10hv
+ is1aread2    = is1aread2_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttaread2     = ttaread2_pld90b_sphv_10hv
+ is2aread2    = is2aread2_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ iraread2     = iraread2_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1aread2  = stis1aread2_pld90b_sphv_10hv
+ stis2aread2  = stis2aread2_pld90b_sphv_10hv
+ stiraread2   = stiraread2_pld90b_sphv_10hv
+ n1aread2     = n1aread2_pld90b_sphv_10hv
+ n2aread2     = n2aread2_pld90b_sphv_10hv
+ nraread2     = nraread2_pld90b_sphv_10hv
+ is1lstid2    = is1lstid2_pld90b_sphv_10hv*delr_is_pld90b_sphv_10hv
+ ttlstid2     = ttlstid2_pld90b_sphv_10hv
+ is2lstid2    = is2lstid2_pld90b_sphv_10hv*delr_is2_pld90b_sphv_10hv
+ irlstid2     = irlstid2_pld90b_sphv_10hv*delr_ir_pld90b_sphv_10hv
+ stis1stid2   = stis1stid2_pld90b_sphv_10hv
+ stis2stid2   = stis2stid2_pld90b_sphv_10hv
+ stirstid2    = stirstid2_pld90b_sphv_10hv
+ n1stid2      = n1stid2_pld90b_sphv_10hv
+ n2stid2      = n2stid2_pld90b_sphv_10hv
+ nrstid2      = nrstid2_pld90b_sphv_10hv
+ aacc         = aacc_pld90b_sphv_10hv
+ eais1area    = eais1area_pld90b_sphv_10hv
+ eais2area    = eais2area_pld90b_sphv_10hv
+ eairarea     = eairarea_pld90b_sphv_10hv
+ eais1sti     = eais1sti_pld90b_sphv_10hv
+ eais2sti     = eais2sti_pld90b_sphv_10hv
+ eairsti      = eairsti_pld90b_sphv_10hv
+ eais1gat     = eais1gat_pld90b_sphv_10hv
+ eais2gat     = eais2gat_pld90b_sphv_10hv
+ eairgat      = eairgat_pld90b_sphv_10hv
+ eais1aread   = eais1aread_pld90b_sphv_10hv
+ eais2aread   = eais2aread_pld90b_sphv_10hv
+ eairaread    = eairaread_pld90b_sphv_10hv
+ eais1stid    = eais1stid_pld90b_sphv_10hv
+ eais2stid    = eais2stid_pld90b_sphv_10hv
+ eairstid     = eairstid_pld90b_sphv_10hv
+ eais1gatd    = eais1gatd_pld90b_sphv_10hv
+ eais2gatd    = eais2gatd_pld90b_sphv_10hv
+ eairgatd     = eairgatd_pld90b_sphv_10hv
+ eais1aread2  = eais1aread2_pld90b_sphv_10hv
+ eais2aread2  = eais2aread2_pld90b_sphv_10hv
+ eairaread2   = eairaread2_pld90b_sphv_10hv
+ eais1stid2   = eais1stid2_pld90b_sphv_10hv
+ eais2stid2   = eais2stid2_pld90b_sphv_10hv
+ eairstid2    = eairstid2_pld90b_sphv_10hv


// poly over field parasitic capacitance
model cgdfldmoscap psp103t type=n
+    tr = 27
+    toxo = 320e-9
+    vfbo = 0
+    nsubo = 2.35e22
+    npck = 1e22
+    lpck = 1e-6
+    rtho = 1e18
+    ctho = 0
+    uo   = 0

mcgdcap (s gi s di dtemp) cgdfldmoscap l=2.25 w=w+dwcgdfldmoscap mult=ng
avdclip (d di gi) vdclip vp=vp_pld90b_10hv dvp=dvp_pld90b_10hv type=type_pld90b_10hv

cgd_fld (gi d) capacitor c=(cgd_ply_fld)
cgs_fld (gi s) capacitor c=(cgs_ply_fld)
rgate (g gi) resistor r=(rply*((w+2*10.675*(1-fem))/(length*3*ng)))
xdsub (s sub) cdgoptub_box_sub_10hv area=(alnbl*(1-lpe)) perim=(plnbl*(1-lpe)) soa=1

if (ng_dmy>=2) {

amost_dmy (d s s s dtemp) sphvt_simkit
+ w          = w
+ l          = l
+ ldrift     = ldrift
+ wdrift     = wdrift
+ ldr1       = ldr1
+ mult       = ng_dmy
+ ad         = ad
+ pd         = pd
+ as         = as
+ ps         = ps
+ ad2        = ad2
+ pd2        = pd2

mcgdcap_dmy (s s s di_dmy dtemp) cgdfldmoscap l=2.25 w=w+dwcgdfldmoscap mult=ng_dmy
avdclip_dmy (d di_dmy s) vdclip  vp=vp_pld90b_10hv dvp=dvp_pld90b_10hv type=type_pld90b_10hv
cgd_fld_dmy (s d) capacitor  c=(cgd_ply_fld_dmy)

}

include "./smos10hv_ade_dfrt.scs" section=pld90b_10hv_dfrt
ends


//***********************************************************
endsection powermos
//***********************************************************

//***********************************************************
section powermos_simple
//***********************************************************

subckt nld30_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld30_10hv_gox       = tmp_nsmm_delr_nld30_10hv_gox
+    nsmm_dela_nld30_10hv_vfb       = tmp_nsmm_dela_nld30_10hv_vfb
+    nsmm_delr_nld30_10hv_nsub      = tmp_nsmm_delr_nld30_10hv_nsub
+    nsmm_dela_nld30_10hv_vtl       = tmp_nsmm_dela_nld30_10hv_vtl
+    nsmm_dela_nld30_10hv_dwox      = tmp_nsmm_dela_nld30_10hv_dwox
+    nsmm_delr_nld30_10hv_ubref     = tmp_nsmm_delr_nld30_10hv_ubref
+    nsmm_delr_nld30_10hv_rsh       = tmp_nsmm_delr_nld30_10hv_rsh
+    nsmm_dela_nld30_10hv_vtw       = tmp_nsmm_dela_nld30_10hv_vtw
+    l                              = (0.35)
+    delr_nld30_10hv_tox            = (nom_delr_nld30_10hv_tox*(1+sig_delr_nld30_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld30_10hv_gox*smm_delr_nld30_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld30_10hv_uch            = (nom_delr_nld30_10hv_uch*(1+sig_delr_nld30_10hv_uch*nsig_delr_nld30_10hv_uch+nsmm_delr_nld30_10hv_ubref*smm_delr_nld30_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld30_10hv_res            = (nom_delr_nld30_10hv_res*(1+sig_delr_nld30_10hv_res*nsig_delr_nld30_10hv_res+nsmm_delr_nld30_10hv_rsh*smm_delr_nld30_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld30_10hv_vfb            = (nom_dela_nld30_10hv_vfb+(sig_dela_nld30_10hv_vfb*nsig_dela_nld30_10hv_vfb)+nsmm_dela_nld30_10hv_vfb*smm_dela_nld30_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld30_10hv_vtl*smm_dela_nld30_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld30_10hv_vtw*smm_dela_nld30_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld30_10hv_vtm            = (nom_dela_nld30_10hv_vtm+(sig_dela_nld30_10hv_vtm*nsig_dela_nld30_10hv_vtm))
+    dela_nld30_10hv_dw             = (nom_dela_nld30_10hv_dw+(sig_dela_nld30_10hv_dw*nsig_dela_nld30_10hv_dw)+(nsmm_dela_nld30_10hv_dwox*smm_dela_nld30_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld30_10hv_dr             = (nom_dela_nld30_10hv_dr+(sig_dela_nld30_10hv_dr*nsig_dela_nld30_10hv_dr))
+    delr_nld30_10hv_nsub           = (1+nsmm_delr_nld30_10hv_nsub*smm_delr_nld30_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld30_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.35)
+    lch                            = (0.32)
+    lacc_drawn                     = (0.7)
+    lacc                           = (0.669)
+    ld                             = (1.265)
+    lsc_ply                        = (0.215)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.25)
+    xiso                           = (1.27)
+    yiso                           = (2.23)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.0001989364+(0/(w**0)))
+    lfrd                           = (0+(0.0855549/(w**1)))
+    dw_mos                         = (0.0)
+    dw_res                         = (4.03172+dela_nld30_10hv_dr)
+    lcheff                         = (0.32)
+    numbernplus                    = (2+(w>=2.375)+(w>=3.18)+(w>=3.975)+(w>=4.775)+(w>=5.58)+(w>=6.38)+(w>=7.18)+(w>=7.98)+(w>=8.775)+(w>=9.58)+(w>=10.38)+(w>=11.175)+(w>=11.98)+(w>=12.775)+(w>=13.58)+(w>=14.38)+(w>=15.175)+(w>=15.98)+(w>=16.775)*(1+int_round((w-16.775)/0.8)))
+    w_mos                          = (numbernplus*0.4+dw_mos*(1-fem))
+    w_res                          = (w+((dw_res)+(-2.87886)/(w**1.40503e-05))*(1-fem))
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*0.88)
+    ancom                          = (xncom*yncom*ng)
+    pncom                          = ((yncom+2*xncom)*ng)
+    rsda                           = (2673.825/ancom)
+    rsdp                           = (499800.2/pncom)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aholes                         = ((w+2*1.2)*(0.695+0.5)*ng)
+    aaccum                         = (lacc*w*ng)
+    aplyfld_d                      = (ancom-aholes-aaccum)
+    aplyfld_s                      = (2*((lch+lacc+ld)*0.145+lch*1.35)*ng)
+    area_accum                     = (lacc*w*ng)
+    lfring                         = (w*ng)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round((w-0.4)/0.8)*2+1))
+    lfr_ct_ply_d                   = (ng*0.18*(int_round(w/0.42)+int_round((w-0.42*int_round(w/0.42))/0.34)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    lm                             = (ld+0)
+    nd                             = (2.83783e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.0100186/delr_nld30_10hv_res)*(1+(-0.00585048*deltee)+(1.29442e-05*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00597862)
+    aphi_tnom                      = (aphi_junc_nld30_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld30_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld30_d_body)
+    pphi_tnom                      = (pphi_junc_nld30_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld30_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld30_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld30_d_body))*1.0e12)
+ n             = (ajnd_junc_nld30_d_body)
+ cj            = ((((acj0_junc_nld30_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld30_d_body)
+ xti           = (axti_junc_nld30_d_body)
+ bv            = (41.5+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld30_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld30_d_body)
+ gap2          = (abetaeg_junc_nld30_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld30_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld30_d_body)
+ cj            = ((((pcj0_junc_nld30_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld30_d_body)
+ xti           = (pxti_junc_nld30_d_body)
+ bv            = (41.5+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld30_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld30_d_body)
+ gap2          = (pbetaeg_junc_nld30_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld30_10hv_tox)
+ nch      = (4.63e+16*delr_nld30_10hv_nsub)
+ nsub     = (4e+16*delr_nld30_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-6.2487e-10+0.5e-6*dela_nld30_10hv_dw)*(1-fem))
+ wwl      = ((-1.9833e-20)*(1-fem))
+ wwn      = ((-1.99743)*(1-fem))
+ wln      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((1.35616+(1.45061/w))*(1+(0.0103398+(-0.00771991/w))*(temp-27)+(-5.87158e-05+(5.11549e-05/w))*(temp-27)*(temp-27)))
+ vfb      = (-0.619+dela_nld30_10hv_vfb)
+ a0       = (1.6)
+ a1       = (0)
+ a2       = (1)
+ b0       = (0.75e-7)
+ u0       = (269.494*delr_nld30_10hv_uch)
+ ua       = (1e-13)
+ ub       = (4.61232e-18)
+ vsat     = (300000)
+ drout    = (0.056)
+ pclm     = (0.2)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0)
+ wr       = (1)
+ prwg     = (0.0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voff     = (-0.22)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((-0.00104309+dela_nld30_10hv_vtm)*(1-fem))
+ dvt1w    = (987687)
+ k3       = ((2.62517)*(1-fem))
+ k3b      = (0)
+ nlx      = (6.8e-7)
+ dsub     = (0.7)
+ alpha0   = (0e-5)
+ alpha1   = (28.54)
+ nfactor  = (1.5)
+ beta0    = (300)
+ kt1      = (-0.361828)
+ ua1      = (4.45438e-09)
+ ub1      = (-5.54417e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-0.751311)
+ dlc      = (0)
+ dwc      = ((-5.5e-7+(-5.05e-7/w))-(w-(int_round(w/0.8))*0.4)*0.5e-6)
+ wwlc     = (9e-19)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg_s (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring*sDOTmult2+1e-20)
cgd_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring*sDOTmult2+1e-20)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld30_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld30_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld30_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld30_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*1.495)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd*0.8)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/17.0)
resdrift (d intd) resistor r=(lm/(1.270*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld30_10hv_dfrt
ends

subckt nld45_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_10hv_gox       = tmp_nsmm_delr_nld45_10hv_gox
+    nsmm_dela_nld45_10hv_vfb       = tmp_nsmm_dela_nld45_10hv_vfb
+    nsmm_delr_nld45_10hv_nsub      = tmp_nsmm_delr_nld45_10hv_nsub
+    nsmm_dela_nld45_10hv_vtl       = tmp_nsmm_dela_nld45_10hv_vtl
+    nsmm_dela_nld45_10hv_dwox      = tmp_nsmm_dela_nld45_10hv_dwox
+    nsmm_delr_nld45_10hv_ubref     = tmp_nsmm_delr_nld45_10hv_ubref
+    nsmm_delr_nld45_10hv_rsh       = tmp_nsmm_delr_nld45_10hv_rsh
+    nsmm_dela_nld45_10hv_vtw       = tmp_nsmm_dela_nld45_10hv_vtw
+    nsmm_dela_nld45_10hv_cit       = tmp_nsmm_dela_nld45_10hv_cit
+    nsmm_delr_nld45_10hv_vsat      = tmp_nsmm_delr_nld45_10hv_vsat
+    l                              = (0.4)
+    tc_vth_mm                      = (1+(temp-27)*(-1.7e-3)/3)
+    vth_mm                         = tc_vth_mm*(nsmm_dela_nld45_10hv_vfb*smm_dela_nld45_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_10hv_vtl*smm_dela_nld45_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_10hv_vtw*smm_dela_nld45_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    delr_nld45_10hv_tox            = (nom_delr_nld45_10hv_tox*(1+sig_delr_nld45_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_10hv_gox*smm_delr_nld45_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_10hv_uch            = (nom_delr_nld45_10hv_uch*(1+sig_delr_nld45_10hv_uch*nsig_delr_nld45_10hv_uch+nsmm_delr_nld45_10hv_ubref*smm_delr_nld45_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_10hv_res            = (nom_delr_nld45_10hv_res*(1+sig_delr_nld45_10hv_res*nsig_delr_nld45_10hv_res+nsmm_delr_nld45_10hv_rsh*smm_delr_nld45_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_10hv_vfb            = (nom_dela_nld45_10hv_vfb+(sig_dela_nld45_10hv_vfb*nsig_dela_nld45_10hv_vfb)+vth_mm)
+    dela_nld45_10hv_dw             = (nom_dela_nld45_10hv_dw+(sig_dela_nld45_10hv_dw*nsig_dela_nld45_10hv_dw)+(nsmm_dela_nld45_10hv_dwox*smm_dela_nld45_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld45_10hv_vtm            = (nom_dela_nld45_10hv_vtm+(sig_dela_nld45_10hv_vtm*nsig_dela_nld45_10hv_vtm))
+    dela_nld45_10hv_dr             = (nom_dela_nld45_10hv_dr+(sig_dela_nld45_10hv_dr*nsig_dela_nld45_10hv_dr))
+    delr_nld45_10hv_nsub           = (1+nsmm_delr_nld45_10hv_nsub*smm_delr_nld45_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_10hv_cit            = (0+nsmm_dela_nld45_10hv_cit*smm_dela_nld45_10hv_cit(l,w)/sqrt(1*ng))
+    delr_nld45_10hv_vsat           = (1+nsmm_delr_nld45_10hv_vsat*smm_delr_nld45_10hv_vsat(l,w)/sqrt(1*ng))
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_vthratio          = 1.0
+    presto_nld45_ronratio          = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld45_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.4)
+    lch                            = (0.352)
+    lacc_drawn                     = (0.6)
+    lacc                           = (0.594)
+    ld                             = (1.895)
+    wdel                           = (0.255)
+    lsc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.55)
+    xiso                           = (1.275)
+    yiso                           = (4.26)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrd                           = (0)
+    lfrs                           = (0.0)
+    dw_mos                         = (0.0598426+dela_nld45_10hv_dw)
+    dw_res                         = (1.14033+dela_nld45_10hv_dr)
+    lcheff                         = (0.352)
+    numbernplus                    = (3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+(dw_res+(1.47132)/(w**1.80191))*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+0.45)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsda                           = (175/(w+0.1))
+    rsdp                           = (205.8/(w+2.5))
+    rsdch                          = (10780/(w-0.2))
+    rsd                            = (1/(1/rsda+1/rsdp+1/rsdch))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (rpolyhole*(w-0.095*2)+0.5*pi4models*rpolyhole*rpolyhole)
+    apolyplushole                  = (rpoly*(w+0.225*2)+0.5*pi4models*rpoly*rpoly)
+    aplyfld_d                      = ((apolyplushole-ahole)*ng)
+    aplyfld_s                      = (2*(lch+lacc+ld)*0.5*ng)
+    area_accum                     = ((lacc*(w+2*0.255)+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*3.15)*ng)
+    lfring_d                       = ((w+2*0.255+pi4models*ld)*ng)
+    xmosend                        = (lch+lacc+ld)
+    ymosend                        = (w+2*3.15)
+    amosend                        = (((xmosend*ymosend)-(((w+2*0.255)*(ld+lacc))+0.5*pi4models*(ld+lacc)*(ld+lacc))-w*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round(w/(0.18+0.24))))
+    lfr_ct_ply_d                   = (ng*0.18*((int_round(w/(0.24+0.18))-1)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    lm                             = (ld+0)
+    nd                             = (5.53774e+19)
+    deltee                         = (temp+273.15-tn)
+    tc1uu                          = ((-0.00572981+(-0.000515482/w)*(1-fem))*0.97)
+    tc2uu                          = (1.40324e-05*0.83+(4.20996e-06/w)*(1-fem)*0.38)
+    uu                             = ((0.00732752/(delr_nld45_10hv_res*delr_rdsw_relimo))*(1+(tc1uu*deltee)+(tc2uu*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00226033)
+    aphi_tnom                      = (aphi_junc_nld45_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld45_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld45_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld45_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld45_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_d_body)
+    chphi_calc                     = (chphi_tnom-pta_junc_nld45_d_body*(temp-tnom))
+    chphi_temp                     = (maxmodels(0.1,chphi_calc))
+    chphi_tf                       = (chphi_tnom/chphi_temp)
+    chexm                          = (chexm_junc_nld45_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld45_d_body))*1.0e12)
+ n             = (ajnd_junc_nld45_d_body)
+ cj            = ((((acj0_junc_nld45_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld45_d_body)
+ xti           = (axti_junc_nld45_d_body)
+ bv            = (57+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_d_body)
+ gap2          = (abetaeg_junc_nld45_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld45_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld45_d_body)
+ cj            = ((((pcj0_junc_nld45_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld45_d_body)
+ xti           = (pxti_junc_nld45_d_body)
+ bv            = (57+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld45_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld45_d_body)
+ gap2          = (pbetaeg_junc_nld45_d_body)

model dbody_perimch diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((chjs_junc_nld45_d_body/sDOTmult))*1.0e12)
+ n             = (chjnd_junc_nld45_d_body)
+ cj            = ((((chcj0_junc_nld45_d_body/sDOTmult)*(chphi_tf**chexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,chphi_calc))
+ mj            = (chexm_junc_nld45_d_body)
+ xti           = (axti_junc_nld45_d_body)
+ bv            = (57+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_d_body)
+ gap2          = (abetaeg_junc_nld45_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld45_10hv_tox)
+ nch      = (4.36e+16*delr_nld45_10hv_nsub)
+ nsub     = (4.0e+16*delr_nld45_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-2.09066e-08)*(1-fem))
+ wwl      = ((13.96817e-15)*(1-fem))
+ wln      = ((0)*(1-fem))
+ wwn      = ((1.065)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-0.185207+(4.8/w))*(1+(0.000987603+(-0.00138034/w))*(temp-27)+(-9.8517e-06+(-9.81902e-06/w))*(temp-27)*(temp-27)))
+ vfb      = (-0.549658+dela_nld45_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_vthratio)
+ a0       = (1.57729*delr_a0_relimo)
+ b0       = (6e-7)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (334.869*delr_nld45_10hv_uch*delr_u0_relimo)
+ ua       = (1.28662e-13)
+ ub       = (1.9626e-19)
+ vsat     = (148346*delr_nld45_10hv_vsat)
+ drout    = (0.056)
+ pclm     = (0.25)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.146377)
+ prt      = (2.6393)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voff     = (-0.225)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.855777+dela_nld45_10hv_vtm)*(1-fem))
+ dvt1w    = (0.8e+06)
+ k3       = ((0)*(1-fem))
+ k3b      = (0)
+ nlx      = (7.59e-7)
+ dsub     = (0.7)
+ alpha0   = (0.0e-5)
+ alpha1   = (14.65)
+ nfactor  = (1.75)
+ beta0    = (325)
+ kt1      = (-0.359887)
+ ua1      = (1.00064e-11)
+ ub1      = (-3.99616e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.371)
+ dlc      = (0)
+ dwc      = ((-7.25e-7)-(w-(int_round(w/0.84))*0.42)*0.5e-6)
+ at       = (33000)
+ cit      = (0+dela_nld45_10hv_cit)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend+1e-20) m=(1)
cgs_frg (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring_s*sDOTmult2+1e-20)
cgd_frg (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2+1e-20)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.425)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
dsd_ch (s intdx) dbody_perimch area=(chncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/21.0)
resdrift (d intd) resistor r=(lm/(1.9055*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld45_10hv_dfrt
ends

subckt nld45_he_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_he_10hv_gox    = tmp_nsmm_delr_nld45_he_10hv_gox
+    nsmm_dela_nld45_he_10hv_vfb    = tmp_nsmm_dela_nld45_he_10hv_vfb
+    nsmm_delr_nld45_he_10hv_nsub   = tmp_nsmm_delr_nld45_he_10hv_nsub
+    nsmm_dela_nld45_he_10hv_vtl    = tmp_nsmm_dela_nld45_he_10hv_vtl
+    nsmm_dela_nld45_he_10hv_dwox   = tmp_nsmm_dela_nld45_he_10hv_dwox
+    nsmm_delr_nld45_he_10hv_ubref  = tmp_nsmm_delr_nld45_he_10hv_ubref
+    nsmm_delr_nld45_he_10hv_rsh    = tmp_nsmm_delr_nld45_he_10hv_rsh
+    nsmm_dela_nld45_he_10hv_vtw    = tmp_nsmm_dela_nld45_he_10hv_vtw
+    l                              = (0.55)
+    delr_nld45_he_10hv_tox         = (nom_delr_nld45_he_10hv_tox*(1+sig_delr_nld45_he_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_he_10hv_gox*smm_delr_nld45_he_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_he_10hv_uch         = (nom_delr_nld45_he_10hv_uch*(1+sig_delr_nld45_he_10hv_uch*nsig_delr_nld45_he_10hv_uch+nsmm_delr_nld45_he_10hv_ubref*smm_delr_nld45_he_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_he_10hv_res         = (nom_delr_nld45_he_10hv_res*(1+sig_delr_nld45_he_10hv_res*nsig_delr_nld45_he_10hv_res+nsmm_delr_nld45_he_10hv_rsh*smm_delr_nld45_he_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_he_10hv_vfb         = (nom_dela_nld45_he_10hv_vfb+(sig_dela_nld45_he_10hv_vfb*nsig_dela_nld45_he_10hv_vfb)+nsmm_dela_nld45_he_10hv_vfb*smm_dela_nld45_he_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_he_10hv_vtl*smm_dela_nld45_he_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_he_10hv_vtw*smm_dela_nld45_he_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld45_he_10hv_dw          = (nom_dela_nld45_he_10hv_dw+(sig_dela_nld45_he_10hv_dw*nsig_dela_nld45_he_10hv_dw)+(nsmm_dela_nld45_he_10hv_dwox*smm_dela_nld45_he_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld45_he_10hv_vtm         = (nom_dela_nld45_he_10hv_vtm+(sig_dela_nld45_he_10hv_vtm*nsig_dela_nld45_he_10hv_vtm))
+    dela_nld45_he_10hv_dr          = (nom_dela_nld45_he_10hv_dr+(sig_dela_nld45_he_10hv_dr*nsig_dela_nld45_he_10hv_dr))
+    delr_nld45_he_10hv_nsub        = (1+nsmm_delr_nld45_he_10hv_nsub*smm_delr_nld45_he_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_he_10hv_a0          = (nom_dela_nld45_he_10hv_a0+nsig_dela_nld45_he_10hv_a0*sig_dela_nld45_he_10hv_a0)
+    dela_nld45_he_10hv_b0          = (nom_dela_nld45_he_10hv_b0+nsig_dela_nld45_he_10hv_b0*sig_dela_nld45_he_10hv_b0)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_he_vthratio       = 1.0
+    presto_nld45_he_ronratio       = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.0*1e-10*delr_nld45_he_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.55)
+    lch                            = (0.475)
+    lacc_drawn                     = (0.55)
+    lacc                           = (0.552)
+    ld                             = (1.995)
+    wdel                           = (0.305)
+    lsc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (0.7)
+    xiso                           = (1.275)
+    yiso                           = (4.51)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrd                           = (0.001069232)
+    lfrs                           = (0.001)
+    dw_mos                         = (0.0680494)
+    dw_res                         = (0.784289+dela_nld45_he_10hv_dr)
+    lcheff                         = (0.475)
+    numbernplus                    = (3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+(dw_res+(1.88638)/(w**0.997457))*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+lacc_drawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (112.8416638/(w+1.4))
+    rsd_t                          = (rsd*(1+0.0019*(temp-27)))
+    lsc2sc                         = (0.36)
+    xsub                           = (2*xiso+(lcell*ng)+lsc2sc*(ng/2.0-1.0))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.795)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (rpolyhole*(w-0.125*2)+0.5*pi4models*rpolyhole*rpolyhole)
+    apolyplushole                  = (rpoly*(w+0.305*2)+0.5*pi4models*rpoly*rpoly)
+    aplyfld_d                      = ((apolyplushole-ahole)*ng)
+    aplyfld_s                      = (2*(lch+lacc+ld)*0.5*ng)
+    area_accum                     = ((lacc*(w+2*0.045)+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*3.4)*ng)
+    lfring_d                       = ((w+2*0.305+pi4models*ld)*ng)
+    xmosend                        = (lch+lacc+ld)
+    ymosend                        = (w+2*3.4)
+    amosend                        = (((xmosend*ymosend)-(((w+2*0.35)*(ld+lacc))+0.5*pi4models*(ld+lacc)*(ld+lacc))-w*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    lfr_ct_ply_s                   = (ng*0.18*(int_round(w/(0.24+0.18))))
+    lfr_ct_ply_d                   = (ng*0.18*((int_round(w/(0.24+0.18))-1)))
+    lfr_m1_ply_d                   = ((w+2*0.555)*ng-lfr_ct_ply_d)
+    lfr_m1_ply_s                   = ((w+2*0.555)*ng-lfr_ct_ply_s)
+    lm                             = (ld+0)
+    nd                             = (5.76331e+19)
+    deltee                         = (temp+273.15-tn)
+    tc1uu                          = (-0.00551801+(0.000328084/w)*(1-fem))
+    tc2uu                          = (1.1604e-05+(-1.03936e-05/w)*(1-fem))
+    uu                             = ((0.00756666/(delr_nld45_he_10hv_res*delr_rdsw_relimo))*(1+(tc1uu*deltee)+(tc2uu*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00238627)
+    aphi_tnom                      = (aphi_junc_nld45_he_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld45_he_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld45_he_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_he_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld45_he_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld45_he_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_he_d_body)
+    chphi_calc                     = (chphi_tnom-pta_junc_nld45_he_d_body*(temp-tnom))
+    chphi_temp                     = (maxmodels(0.1,chphi_calc))
+    chphi_tf                       = (chphi_tnom/chphi_temp)
+    chexm                          = (chexm_junc_nld45_he_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld45_he_d_body))*1.0e12)
+ n             = (ajnd_junc_nld45_he_d_body)
+ cj            = ((((acj0_junc_nld45_he_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld45_he_d_body)
+ xti           = (axti_junc_nld45_he_d_body)
+ bv            = (59+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_he_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_he_d_body)
+ gap2          = (abetaeg_junc_nld45_he_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld45_he_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld45_he_d_body)
+ cj            = ((((pcj0_junc_nld45_he_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld45_he_d_body)
+ xti           = (pxti_junc_nld45_he_d_body)
+ bv            = (59+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld45_he_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld45_he_d_body)
+ gap2          = (pbetaeg_junc_nld45_he_d_body)

model dbody_perimch diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((chjs_junc_nld45_he_d_body/sDOTmult))*1.0e12)
+ n             = (chjnd_junc_nld45_he_d_body)
+ cj            = ((((chcj0_junc_nld45_he_d_body/sDOTmult)*(chphi_tf**chexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,chphi_calc))
+ mj            = (chexm_junc_nld45_he_d_body)
+ xti           = (axti_junc_nld45_he_d_body)
+ bv            = (59+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_he_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_he_d_body)
+ gap2          = (abetaeg_junc_nld45_he_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.0*1e-10*delr_nld45_he_10hv_tox)
+ nch      = (6.32e+16*delr_nld45_he_10hv_nsub)
+ nsub     = (6.0e+16*delr_nld45_he_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-5.48238e-08+0.5e-6*dela_nld45_he_10hv_dw)*(1-fem))
+ wwl      = ((4.4462e-15)*(1-fem))
+ wln      = ((0)*(1-fem))
+ wwn      = ((1.10491)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-0.573942+(0.150219/w))*(1+-0.0117571*(temp-27)+0.000123134*(temp-27)*(temp-27)))
+ vfb      = (-0.248912+dela_nld45_he_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_he_vthratio)
+ a0       = ((1.1769+dela_nld45_he_10hv_a0)*delr_a0_relimo)
+ b0       = (6e-7+1.0e-6*dela_nld45_he_10hv_b0)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (411.268*delr_nld45_he_10hv_uch*delr_u0_relimo)
+ ua       = (6.05676e-13)
+ ub       = (3.53713e-18)
+ vsat     = (300000)
+ drout    = (0.056)
+ pclm     = (0.25)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.06)
+ rdsw     = (0*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.146377)
+ prt      = (2.6393)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ eta0     = (0.0028)
+ etab     = (0)
+ voff     = (-0.225)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.0570501+dela_nld45_he_10hv_vtm)*(1-fem))
+ dvt1w    = (41396.5)
+ k3       = ((0.9)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.27e-7)
+ dsub     = (0.7)
+ alpha0   = (0.0e-5)
+ alpha1   = (11.65)
+ nfactor  = (1.15)
+ beta0    = (325)
+ kt1      = (-0.448923)
+ ua1      = (1.00071e-11)
+ ub1      = (-4.84324e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.58312)
+ dlc      = (0)
+ dwc      = ((-9.49e-7)-(w-(int_round(w/0.84))*0.42)*0.5e-6)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend+1e-20) m=(1)
cgs_frg (intg s) capacitor c=(cox*(lovlap+lfrs)*lfring_s*sDOTmult2+1e-20)
cgd_frg (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2+1e-20)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+1e-20)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_he_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_he_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_he_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_he_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.675)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd_t) m=(ng)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
dsd_ch (s intdx) dbody_perimch area=(chncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/20.5)
resdrift (d intd) resistor r=(lm/(2.05*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld45_he_10hv_dfrt
ends

subckt nld45_tlp_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld45_tlp_10hv_gox   = tmp_nsmm_delr_nld45_tlp_10hv_gox
+    nsmm_dela_nld45_tlp_10hv_vfb   = tmp_nsmm_dela_nld45_tlp_10hv_vfb
+    nsmm_delr_nld45_tlp_10hv_nsub  = tmp_nsmm_delr_nld45_tlp_10hv_nsub
+    nsmm_dela_nld45_tlp_10hv_vtl   = tmp_nsmm_dela_nld45_tlp_10hv_vtl
+    nsmm_delr_nld45_tlp_10hv_ubref = tmp_nsmm_delr_nld45_tlp_10hv_ubref
+    nsmm_delr_nld45_tlp_10hv_rsh   = tmp_nsmm_delr_nld45_tlp_10hv_rsh
+    nsmm_dela_nld45_tlp_10hv_vtw   = tmp_nsmm_dela_nld45_tlp_10hv_vtw
+    l                              = (0.55)
+    delr_nld45_tlp_10hv_tox        = (nom_delr_nld45_tlp_10hv_tox*(1+sig_delr_nld45_tlp_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld45_tlp_10hv_gox*smm_delr_nld45_tlp_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld45_tlp_10hv_uch        = (nom_delr_nld45_tlp_10hv_uch*(1+sig_delr_nld45_tlp_10hv_uch*nsig_delr_nld45_tlp_10hv_uch+nsmm_delr_nld45_tlp_10hv_ubref*smm_delr_nld45_tlp_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld45_tlp_10hv_res        = (nom_delr_nld45_tlp_10hv_res*(1+sig_delr_nld45_tlp_10hv_res*nsig_delr_nld45_tlp_10hv_res+nsmm_delr_nld45_tlp_10hv_rsh*smm_delr_nld45_tlp_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld45_tlp_10hv_vfb        = (nom_dela_nld45_tlp_10hv_vfb+(sig_dela_nld45_tlp_10hv_vfb*nsig_dela_nld45_tlp_10hv_vfb)+nsmm_dela_nld45_tlp_10hv_vfb*smm_dela_nld45_tlp_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld45_tlp_10hv_vtl*smm_dela_nld45_tlp_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld45_tlp_10hv_vtw*smm_dela_nld45_tlp_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld45_tlp_10hv_dr         = (nom_dela_nld45_tlp_10hv_dr+(sig_dela_nld45_tlp_10hv_dr*nsig_dela_nld45_tlp_10hv_dr))
+    dela_nld45_tlp_10hv_dw         = (nom_dela_nld45_tlp_10hv_dw+(sig_dela_nld45_tlp_10hv_dw*nsig_dela_nld45_tlp_10hv_dw))
+    dela_nld45_tlp_10hv_vtm        = (nom_dela_nld45_tlp_10hv_vtm+(sig_dela_nld45_tlp_10hv_vtm*nsig_dela_nld45_tlp_10hv_vtm))
+    delr_nld45_tlp_10hv_nsub       = (1+nsmm_delr_nld45_tlp_10hv_nsub*smm_delr_nld45_tlp_10hv_nsub(l,w)/sqrt(1*ng))
+    dela_nld45_tlp_10hv_a0         = (nom_dela_nld45_tlp_10hv_a0+(sig_dela_nld45_tlp_10hv_a0*nsig_dela_nld45_tlp_10hv_a0))
+    dela_nld45_tlp_10hv_b0         = (nom_dela_nld45_tlp_10hv_b0+(sig_dela_nld45_tlp_10hv_b0*nsig_dela_nld45_tlp_10hv_b0))
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_nld45_tlp_vthratio      = 1.0
+    presto_nld45_tlp_ronratio      = 0.01
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (131.47*1e-10*delr_nld45_tlp_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.499)
+    lacc                           = (0.539)
+    lch                            = (0.499)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (2.395)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (1.05)
+    xiso                           = (1.275)
+    yiso                           = (5.11)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.058)
+    lfrs                           = (0)
+    lfrd                           = (0.015)
+    dw_mos                         = (0)
+    dw_res                         = (1.0484026+(1.4)/(w**0.65)+dela_nld45_tlp_10hv_dr)
+    lcheff                         = (0.499)
+    numbernplus                    = (3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+dw_res*(1-fem))/delr_rdsw_relimo/(1+(hcirondegrfac+offrondegrfac)*presto_nld45_tlp_ronratio))
+    wdel                           = (0.505)
+    xncom                          = (ld+laccdrawn)
+    yncom                          = (w+2*wdel)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = (((2*wdel)+pi4models*xncom)*ng)
+    chncom                         = (w*ng)
+    rsd                            = (134.0258302/(w+1.4))
+    rsd_t                          = (rsd*(1+0.0022*(temp-27)))
+    xsub                           = (2*xiso+(lcell*ng)+(0.36*(ng/2-1)))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (0.845)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*(-0.095))*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*(0.505))*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*0.505)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*4.0)*ng)
+    lfring_d                       = (((w+2*0.505)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (4.0)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*0.505+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.53*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.555)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*4.5)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*aplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    lm                             = (ld+0)
+    nd                             = (8.01048e+19)
+    deltee                         = (temp+273.15-tn)
+    tc1uu                          = (-0.00548284+(0.00343/w)*(1-fem))
+    tc2uu                          = (1.17567e-05+(-18.687e-06/w)*(1-fem))
+    uu                             = ((0.068764/delr_nld45_tlp_10hv_res)*(1+(tc1uu*deltee)+(tc2uu*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.000174569)
+    dw_res_simple                  = (1.0484026+(1.4)/(w**0.65))
+    w_res_simple                   = (w+dw_res_simple*(1-fem))
+    aphi_tnom                      = (aphi_junc_nld45_tlp_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld45_tlp_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld45_tlp_d_body)
+    pphi_tnom                      = (pphi_junc_nld45_tlp_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld45_tlp_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld45_tlp_d_body)
+    chphi_tnom                     = (chphi_junc_nld45_tlp_d_body)
+    chphi_calc                     = (chphi_tnom-pta_junc_nld45_tlp_d_body*(temp-tnom))
+    chphi_temp                     = (maxmodels(0.1,chphi_calc))
+    chphi_tf                       = (chphi_tnom/chphi_temp)
+    chexm                          = (chexm_junc_nld45_tlp_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld45_tlp_d_body))*1.0e12)
+ n             = (ajnd_junc_nld45_tlp_d_body)
+ cj            = ((((acj0_junc_nld45_tlp_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld45_tlp_d_body)
+ xti           = (axti_junc_nld45_tlp_d_body)
+ bv            = (69+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_tlp_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_tlp_d_body)
+ gap2          = (abetaeg_junc_nld45_tlp_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld45_tlp_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld45_tlp_d_body)
+ cj            = ((((pcj0_junc_nld45_tlp_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld45_tlp_d_body)
+ xti           = (pxti_junc_nld45_tlp_d_body)
+ bv            = (69+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld45_tlp_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld45_tlp_d_body)
+ gap2          = (pbetaeg_junc_nld45_tlp_d_body)

model dbody_perimch diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((chjs_junc_nld45_tlp_d_body/sDOTmult))*1.0e12)
+ n             = (chjnd_junc_nld45_tlp_d_body)
+ cj            = ((((chcj0_junc_nld45_tlp_d_body/sDOTmult)*(chphi_tf**chexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,chphi_calc))
+ mj            = (chexm_junc_nld45_tlp_d_body)
+ xti           = (axti_junc_nld45_tlp_d_body)
+ bv            = (69+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld45_tlp_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld45_tlp_d_body)
+ gap2          = (abetaeg_junc_nld45_tlp_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (131.47*1e-10*delr_nld45_tlp_10hv_tox)
+ nch      = (1.45e17*delr_nld45_tlp_10hv_nsub)
+ nsub     = (5.72451e+16*delr_nld45_tlp_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ lint     = (0)
+ wint     = ((-2.06054e-08+0.5e-6*(dela_nld45_tlp_10hv_dw))*(1-fem))
+ ww       = ((0e-14)*(1-fem))
+ wln      = ((0))
+ wwn      = ((1))
+ dwg      = ((-1e-07)*(1-fem))
+ ags      = ((0.74)*(1+(0.00469908)*(temp-27)+(-3.6975e-05)*(temp-27)*(temp-27))+((-0.49)/w))
+ vfb      = (-0.747293+dela_nld45_tlp_10hv_vfb+dela_vth_relimo+hvgsvthdegr*presto_nld45_tlp_vthratio)
+ a0       = (0.297102*delr_a0_relimo+dela_nld45_tlp_10hv_a0)
+ b0       = (6.051896e-07+1e-6*(dela_nld45_tlp_10hv_b0))
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (393.636*delr_nld45_tlp_10hv_uch*delr_u0_relimo)
+ ua       = (1e-21)
+ ub       = (1.002644e-20)
+ vsat     = ((176593+(11.95e4)/w)*(1+((0.011/w)*(temp-27))+((57e-6/w)*(temp-27)*(temp-27))))
+ drout    = (0.056)
+ pclm     = (0.000022839)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.053)
+ rdsw     = (223.042*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_nld45_tlp_ronratio))
+ wr       = (1)
+ prwg     = (0.45064)
+ prt      = (490.142)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.082649+dela_nld45_tlp_10hv_vtm)*(1-fem))
+ dvt1w    = (13888.2)
+ k3       = ((0.149961+dela_nld45_tlp_10hv_vtm)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0471407)
+ nfactor  = (2.06)
+ voff     = (-0.135)
+ beta0    = (95.6293)
+ kt1      = (-0.529075)
+ ua1      = (2.26711e-09)
+ ub1      = (-7.61e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.3)
+ dlc      = (0)
+ dwc      = (-43e-8)
+ wwc      = (0)
+ voffcv   = (-0.5)
+ acde     = (0.6)
+ moin     = (25)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgd_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld45_tlp_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld45_tlp_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld45_tlp_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld45_tlp_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd_t) m=(ng)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
dsd_ch (s intdx) dbody_perimch area=(chncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/17.5)
resdrift (d intd) resistor r=(lm/(2.4*w_res_simple*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld45_tlp_10hv_dfrt
ends

subckt pld5_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 1
+    sti_dummy                      = 0
+    ad                             = 0
+    pd                             = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    ring                           = 1
+    sa                             = 0
+    sb                             = 0
+    tsc1                           = 0
+    tsc2                           = 0
+    tsc3                           = 0
+    tsc4                           = 0
+    wsc1                           = 0
+    wsc2                           = 0
+    wsc3                           = 0
+    wsc4                           = 0
+    nsmm_delr_pld5_10hv_gox        = tmp_nsmm_delr_pld5_10hv_gox
+    nsmm_dela_pld5_10hv_vfb        = tmp_nsmm_dela_pld5_10hv_vfb
+    nsmm_delr_pld5_10hv_nsub       = tmp_nsmm_delr_pld5_10hv_nsub
+    nsmm_dela_pld5_10hv_vtl        = tmp_nsmm_dela_pld5_10hv_vtl
+    nsmm_dela_pld5_10hv_dwox       = tmp_nsmm_dela_pld5_10hv_dwox
+    nsmm_delr_pld5_10hv_ubref      = tmp_nsmm_delr_pld5_10hv_ubref
+    nsmm_delr_pld5_10hv_rsh        = tmp_nsmm_delr_pld5_10hv_rsh
+    nsmm_dela_pld5_10hv_vtw        = tmp_nsmm_dela_pld5_10hv_vtw
+    l                              = (0.4)
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    delr_pld5_10hv_tox             = (nom_delr_pld5_10hv_tox*(1.0+nsig_delr_powermos_tox*sig_delr_pld5_10hv_tox+nsmm_delr_pld5_10hv_gox*smm_delr_pld5_10hv_gox(l,w)/sqrt(1*ng)))
+    tox                            = (132.438*1e-10*delr_pld5_10hv_tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.4)
+    lch                            = (0.329)
+    ld                             = (0.88)
+    lsc_ply                        = (0.21)
+    ldc_ply                        = (0.21)
+    lcell                          = (lsc_ply+lch_drawn+ldc_ply)
+    xiso                           = (1.32)
+    yiso                           = (1.11)
+    ng_dmy                         = (2*sti_dummy)
+    ngeff                          = (ng+2*sti_dummy)
+    nde                            = (mod(ngeff,2))
+    nse                            = (2-nde)
+    nd                             = ((ngeff+nde)/2)
+    ns                             = (1-nde+nd)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngtotal                        = (ng)
+    lg2ct_s_pld5_10hv              = (0.12)
+    lg2ct_d_pld5_10hv              = (0.12)
+    lg2aa_d_pld5_10hv              = (0.42)
+    lg2g_d_pld5_10hv               = (0.42)
+    numbernplus                    = (int_round((w-1.69)/0.86+2))
+    w_mos                          = (w-numbernplus*0.43)
+    ad_i                           = ((ad/ngeff)+(ad==0)*(1-lpe)*((lg2aa_d_pld5_10hv*nde+lg2g_d_pld5_10hv*ndi)*w)+(lpe*1e-18))
+    pd_i                           = ((pd/ngeff)+(pd==0)*(1-lpe)*(2*(lg2aa_d_pld5_10hv*nde+lg2g_d_pld5_10hv*ndi)+2*nd*w)+(lpe*1e-18))
+    rsda                           = (1909.16*(1-1.3/w)/(ad_i+lpe*1e-3))
+    rsdp                           = (118578*(1-1.3/w)/(pd_i+lpe*1e-3))
+    nrs_i                          = (lg2ct_s_pld5_10hv/w)
+    nrd_i                          = (lg2ct_d_pld5_10hv/w)
+    xsub                           = (2*xiso+(lcell*ngeff))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lch*0.6*2*ng)
+    lfrd                           = ((w+62/w**0.820375)*ngeff*1e-15)
+    sa0                            = (0.42)
+    sb0                            = (0.42)
+    lg                             = (0.4)
+    pld5_astivfb                   = (0.001)
+    pld5_bstivfb                   = (0.0)
+    pld5_astinsub                  = (0.0)
+    pld5_astiubref                 = (0.02)
+    pld5_bstiubref                 = (0.13)
+    pld5_cstiubref                 = (0.6)
+    pld5_sapar0                    = (0.042+0.045*lg)
+    pld5_sapar1                    = (0.012+0.113*lg)
+    ng_i                           = (pld5_sapar0*(ngeff-1)+pld5_sapar1*(ngeff-1)*log(ngeff))
+    sa_i                           = (sa)
+    sb_i                           = (sb)
+    stress                         = (((sa_i==0)*(sb_i==0)*(1/(0.5*lg+sa0+ng_i)+1/(0.5*lg+sb0+ng_i))+(((-1)*((sa_i==0)-1))*((-1)*((sb_i==0)-1))*(1/(0.5*lg+sa_i)+1/(0.5*lg+sb_i))))*(fem==0))
+    stress0                        = ((1/(0.5*lg+sa0)+1/(0.5*lg+sb0))*(fem==0))
+    stimod_on                      = (enable_sti==1)
+    del_vfb_sti_final              = ((stimod_on)*((pld5_astivfb+pld5_bstivfb/sqrt(w))*(stress-stress0)))
+    fac_nsub_sti_final             = ((stimod_on)*((1+pld5_astinsub*stress)/(1+pld5_astinsub*stress0))+(1-stimod_on))
+    fac_ub_sti_final               = ((stimod_on)*(((1+(pld5_astiubref+l*pld5_bstiubref)*stress+(pld5_cstiubref/sqrt(w)))/(1+(pld5_astiubref+l*pld5_bstiubref)*stress0+(pld5_cstiubref/sqrt(w)))))+(1-stimod_on))
+    wscref                         = (1)
+    w2gdrain                       = (1.53)
+    w2gsource                      = (1.53)
+    w2gtop                         = (1.11)
+    w2gbottom                      = (1.11)
+    wsc1_i                         = ((wsc1)+(wsc1==0)*(w2gdrain))
+    wsc2_i                         = ((wsc2)+(wsc1==0)*(w2gbottom))
+    wsc3_i                         = ((wsc3)+(wsc1==0)*(w2gsource))
+    wsc4_i                         = ((wsc4)+(wsc1==0)*(w2gtop))
+    wsca                           = ((1/(l*w))*(w*wscref**2*(1/wsc1_i-(1/(wsc1_i+l)))+l*wscref**2*(1/wsc2_i-(1/(wsc2_i+w)))+w*wscref**2*(1/wsc3_i-(1/(wsc3_i+l)))+l*wscref**2*(1/wsc4_i-(1/(wsc4_i+w)))))
+    wscb                           = ((1/(l*w))*(w*wscref/100*((10*wsc1_i/wscref+1)*exp(-10*wsc1_i/wscref)-(10*(wsc1_i+l)/wscref+1)*exp(-10*(wsc1_i+l)/wscref))+l*wscref/100*((10*wsc2_i/wscref+1)*exp(-10*wsc2_i/wscref)-(10*(wsc2_i+w)/wscref+1)*exp(-10*(wsc2_i+w)/wscref))+w*wscref/100*((10*wsc3_i/wscref+1)*exp(-10*wsc3_i/wscref)-(10*(wsc3_i+l)/wscref+1)*exp(-10*(wsc3_i+l)/wscref))+l*wscref/100*((10*wsc4_i/wscref+1)*exp(-10*wsc4_i/wscref)-(10*(wsc4_i+w)/wscref+1)*exp(-10*(wsc4_i+w)/wscref))))
+    wscc                           = ((1/(l*w))*(w*wscref/400*((20*wsc1_i/wscref+1)*exp(-20*wsc1_i/wscref)-(20*(wsc1_i+l)/wscref+1)*exp(-20*(wsc1_i+l)/wscref))+l*wscref/400*((20*wsc2_i/wscref+1)*exp(-20*wsc2_i/wscref)-(20*(wsc2_i+w)/wscref+1)*exp(-20*(wsc2_i+w)/wscref))+w*wscref/400*((20*wsc3_i/wscref+1)*exp(-20*wsc3_i/wscref)-(20*(wsc3_i+l)/wscref+1)*exp(-20*(wsc3_i+l)/wscref))+l*wscref/400*((20*wsc4_i/wscref+1)*exp(-20*wsc4_i/wscref)-(20*(wsc4_i+w)/wscref+1)*exp(-20*(wsc4_i+w)/wscref))))
+    web                            = (1e+3)
+    wec                            = (1e+5)
+    kvfbwe                         = (-0.008521)
+    knsubwe                        = (0.01287)
+    kubrefwe                       = (0.01567)
+    wp_proxmod_on                  = (enable_wpe==1)
+    del_vfb_wpe                    = (kvfbwe*(wsca+web*wscb+wec*wscc))
+    fac_ub_wpe                     = (1+kubrefwe*(wsca+web*wscb+wec*wscc))
+    fac_nsub_wpe                   = (1+knsubwe*(wsca+web*wscb+wec*wscc))
+    wsc1_ref                       = (1.53)
+    wsc2_ref                       = (1.11)
+    wsc3_ref                       = (1.53)
+    wsc4_ref                       = (1.11)
+    wsca_ref                       = ((1/(l*w))*(w*wscref**2*(1/wsc1_ref-(1/(wsc1_ref+l)))+l*wscref**2*(1/wsc2_ref-(1/(wsc2_ref+w)))+w*wscref**2*(1/wsc3_ref-(1/(wsc3_ref+l)))+l*wscref**2*(1/wsc4_ref-(1/(wsc4_ref+w)))))
+    wscb_ref                       = ((1/(l*w))*(w*wscref/100*((10*wsc1_ref/wscref+1)*exp(-10*wsc1_ref/wscref)-(10*(wsc1_ref+l)/wscref+1)*exp(-10*(wsc1_ref+l)/wscref))+l*wscref/100*((10*wsc2_ref/wscref+1)*exp(-10*wsc2_ref/wscref)-(10*(wsc2_ref+w)/wscref+1)*exp(-10*(wsc2_ref+w)/wscref))+w*wscref/100*((10*wsc3_ref/wscref+1)*exp(-10*wsc3_ref/wscref)-(10*(wsc3_ref+l)/wscref+1)*exp(-10*(wsc3_ref+l)/wscref))+l*wscref/100*((10*wsc4_ref/wscref+1)*exp(-10*wsc4_ref/wscref)-(10*(wsc4_ref+w)/wscref+1)*exp(-10*(wsc4_ref+w)/wscref))))
+    wscc_ref                       = ((1/(l*w))*(w*wscref/400*((20*wsc1_ref/wscref+1)*exp(-20*wsc1_ref/wscref)-(20*(wsc1_ref+l)/wscref+1)*exp(-20*(wsc1_ref+l)/wscref))+l*wscref/400*((20*wsc2_ref/wscref+1)*exp(-20*wsc2_ref/wscref)-(20*(wsc2_ref+w)/wscref+1)*exp(-20*(wsc2_ref+w)/wscref))+w*wscref/400*((20*wsc3_ref/wscref+1)*exp(-20*wsc3_ref/wscref)-(20*(wsc3_ref+l)/wscref+1)*exp(-20*(wsc3_ref+l)/wscref))+l*wscref/400*((20*wsc4_ref/wscref+1)*exp(-20*wsc4_ref/wscref)-(20*(wsc4_ref+w)/wscref+1)*exp(-20*(wsc4_ref+w)/wscref))))
+    del_vfb_wpe_ref                = (kvfbwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_ub_wpe_ref                 = (1+kubrefwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    fac_nsub_wpe_ref               = (1+knsubwe*(wsca_ref+web*wscb_ref+wec*wscc_ref))
+    del_vfb_wpe_final              = ((del_vfb_wpe-del_vfb_wpe_ref)*wp_proxmod_on)
+    fac_ub_wpe_final               = (fac_ub_wpe/fac_ub_wpe_ref*wp_proxmod_on+(1-wp_proxmod_on))
+    fac_nsub_wpe_final             = (fac_nsub_wpe/fac_nsub_wpe_ref*wp_proxmod_on+(1-wp_proxmod_on))
+    dt2gdrain                      = (1.53)
+    dt2gsource                     = (1.53)
+    dt2gtop                        = (1.11)
+    dt2gbottom                     = (1.11)
+    tsc1_i                         = ((tsc1)+(tsc1==0)*(dt2gdrain))
+    tsc2_i                         = ((tsc2)+(tsc1==0)*(dt2gbottom))
+    tsc3_i                         = ((tsc3)+(tsc1==0)*(dt2gsource))
+    tsc4_i                         = ((tsc4)+(tsc1==0)*(dt2gtop))
+    adtnsub                        = (0.29)
+    adtvfb                         = (2.344)
+    bdtvfb                         = (2.253)
+    adtubref                       = (2.25)
+    bdtubref                       = (2.113)
+    cdtubref                       = (2.31)
+    consub                         = (0.0005)
+    covfb                          = (0.0005)
+    coubref                        = (0.0005)
+    dtpara1                        = (6)
+    dtpara2                        = (6)
+    dtpara3                        = (6)
+    dtpara4                        = (6)
+    dtstress                       = (dtpara1*1/(tsc1_i+0.5*l)+dtpara2*1/(tsc2_i+0.5*w)+dtpara3*1/(tsc3_i+0.5*l)+dtpara4*1/(tsc4_i+0.5*w))
+    dtstressref                    = (dtpara1*1/(dt2gdrain+0.5*l)+dtpara2*1/(dt2gbottom+0.5*w)+dtpara3*1/(dt2gsource+0.5*l)+dtpara4*1/(dt2gtop+0.5*w))
+    dt_proxmod_on                  = (enable_dte==1)
+    del_vfb_dte                    = (covfb*((adtvfb+bdtvfb/sqrt(w))*(dtstress-dtstressref)))
+    fac_nsub_dte_ref               = (1+consub)
+    fac_ub_dte_ref                 = (1+coubref)
+    fac_nsub_dte_final             = (dt_proxmod_on)*(1+consub*((1+adtnsub*dtstress*sqrt(l))/(1+adtnsub*dtstressref*sqrt(l))))/fac_nsub_dte_ref+(1-dt_proxmod_on)
+    del_vfb_dte_final              = (dt_proxmod_on*del_vfb_dte)
+    fac_ub_dte_final               = ((dt_proxmod_on)*(1+coubref*((1+(adtubref+l*bdtubref)*dtstress+(cdtubref/sqrt(w)))/(1+(adtubref+l*bdtubref)*dtstressref+(cdtubref/sqrt(w))))))/fac_ub_dte_ref+(1-dt_proxmod_on)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld5_vthratio           = 1.0
+    presto_pld5_betaratio          = 1.16
+    relimo_ratio1_a_hci_pld5_10hv  = (0.234436051)
+    relimo_ratio1_b_hci_pld5_10hv  = (-1.024442563)
+    cox                            = (epsox/tox)
+    dela_pld5_10hv_dw              = (nom_dela_pld5_10hv_dw+nsig_dela_pld5_10hv_dw*sig_dela_pld5_10hv_dw+nsmm_dela_pld5_10hv_dwox*smm_dela_pld5_10hv_dwox(l,w)/sqrt(1*ng))
+    dela_pld5_10hv_vfb             = (nom_dela_pld5_10hv_vfb+del_vfb_sti_final+del_vfb_wpe_final+del_vfb_dte_final+nsig_dela_pld5_10hv_vfb*sig_dela_pld5_10hv_vfb+nsmm_dela_pld5_10hv_vfb*smm_dela_pld5_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld5_10hv_vtl*smm_dela_pld5_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld5_10hv_vtw*smm_dela_pld5_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    delr_pld5_10hv_uch             = (nom_delr_pld5_10hv_uch*fac_ub_sti_final*fac_ub_wpe_final*fac_ub_dte_final*(1+nsig_delr_pld5_10hv_uch*sig_delr_pld5_10hv_uch+nsmm_delr_pld5_10hv_ubref*smm_delr_pld5_10hv_ubref(l,w)/sqrt(1*ng)))
+    dela_pld5_10hv_vtm             = (nom_dela_pld5_10hv_vtm+nsig_dela_pld5_10hv_vtm*sig_dela_pld5_10hv_vtm)
+    delr_pld5_10hv_res             = (1+nsmm_delr_pld5_10hv_rsh*smm_delr_pld5_10hv_rsh(l,w)/sqrt(1*ng))
+    delr_pld5_10hv_nsub            = (fac_nsub_sti_final*fac_nsub_wpe_final*fac_nsub_dte_final*(1+nsmm_delr_pld5_10hv_nsub*smm_delr_pld5_10hv_nsub(l,w)/sqrt(1*ng)))
+    aphi_tnom                      = (aphi_junc_pld5_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_pld5_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_pld5_d_body)
+    pphi_tnom                      = (pphi_junc_pld5_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_pld5_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_pld5_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_pld5_d_body))*1.0e12)
+ n             = (ajnd_junc_pld5_d_body)
+ cj            = ((((acj0_junc_pld5_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_pld5_d_body)
+ xti           = (axti_junc_pld5_d_body)
+ bv            = (7.3+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_pld5_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_pld5_d_body)
+ gap2          = (abetaeg_junc_pld5_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_pld5_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_pld5_d_body)
+ cj            = ((((pcj0_junc_pld5_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_pld5_d_body)
+ xti           = (pxti_junc_pld5_d_body)
+ bv            = (7.3+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_pld5_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_pld5_d_body)
+ gap2          = (pbetaeg_junc_pld5_d_body)

model pld5_10hv bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ capmod   = (3)
+ noimod   = (2)
+ cgbo     = (0)
+ cgso     = (5.3e-8*cox+0.5*cfr_pld5_s_ply_m1ct*1e6+(1-lpe)*cfr_pld5_s_ply_met*1e6-0.5*cfr_pld5_s_ply_met*1e6)
+ cgdo     = (4.635e-8*cox+0.5*cfr_pld5_d_ply_m1ct*1e6+(1-lpe)*cfr_pld5_d_ply_met*1e6-0.5*cfr_pld5_d_ply_met*1e6)
+ cf       = ((0.0+(62/w**0.820375)*(1-fem))*1e-12)
+ dlc      = (3.5e-8)
+ dwc      = ((-1.01195e-08)*(1-fem)-((int_round(w/0.86))*0.43)*0.5e-6)
+ acde     = (1.0)
+ moin     = (10)
+ noff     = (3.2)
+ voffcv   = (0.08)
+ cgsl     = (0.0e-11)
+ cgdl     = (6.80967912e-11)
+ cj       = (0)
+ cjsw     = (0)
+ js       = (0)
+ jsw      = (0)
+ ckappa   = (0.7898487)
+ llc      = (0)
+ lwc      = (0)
+ lwlc     = (0)
+ wlc      = (0)
+ wwc      = (0)
+ wwlc     = ((-3.9159e-20)*(1-fem))
+ mobmod   = (1)
+ rsh      = (8.4)
+ tox      = (132.438*1e-10*delr_pld5_10hv_tox)
+ pscbe1   = (400000000)
+ pscbe2   = (1e-10)
+ lint     = (1.775e-08)
+ wint     = ((1.713038e-08-0.5e-06*dela_pld5_10hv_dw)*(1-fem))
+ ww       = (((0)*1e-14)*(1-fem))
+ u0       = (326.671*delr_pld5_10hv_uch*delr_u0_relimo)
+ rdsw     = (290.411*delr_pld5_10hv_res*delr_rdsw_relimo)
+ wr       = (1)
+ nsub     = (1.00e17*delr_pld5_10hv_nsub)
+ nch      = (7.04e16*delr_pld5_10hv_nsub)
+ vfb      = (-0.425+dela_pld5_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld5_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_pld5_10hv-relimo_ratio1_b_hci_pld5_10hv))
+ nfactor  = (1.30)
+ vbm      = (-2.86)
+ xt       = (2.00189783373556e-07)
+ alpha1   = (2.6)
+ alpha0   = (3.88e-07)
+ a0       = (1.6*delr_a0_relimo)
+ ags      = ((-0.379+(1.0006927/w**1.14727)*(1-fem))*(1+(-0.00970674+(0.0522004/w)*(1-fem))*(temp-27)+(1.11914e-05+(-5.86479e-05/w)*(1-fem))*(temp-27)*(temp-27)))
+ keta     = (-0.00619931)
+ ua       = (6.414738e-11)
+ ub       = (2.181408975e-18)
+ uc       = (-6.50121e-11)
+ eta0     = (0.6+0.2)
+ etab     = (-0.5)
+ drout    = (0.869588)
+ nlx      = (2.5786e-07)
+ dvt0     = (1.55187)
+ dvt1     = (0.22012)
+ dvt2     = (0.08)
+ dvt0w    = ((0.00128983)*(1-fem))
+ dvt1w    = (0.4e+05)
+ dvt2w    = (0)
+ k3       = ((0.13518+dela_pld5_10hv_vtm)*(1-fem))
+ k3b      = ((0.554951)*(1-fem))
+ w0       = (0)
+ dwg      = ((0)*(1-fem))
+ dwb      = ((-9.45513e-09)*(1-fem))
+ b0       = (4.24614e-07)
+ b1       = (0)
+ prwg     = (0.0)
+ prwb     = (-0.174744)
+ pclm     = (1.27263)
+ pdiblc1  = (0.0390017)
+ pdiblc2  = (0.0478204)
+ pdiblcb  = (0.0160105)
+ delta    = (0.0453491)
+ vsat     = (207490)
+ ll       = (-2.78832e-13)
+ voff     = (-0.095-0.05)
+ wwl      = ((1.80798e-20)*(1-fem))
+ lwl      = (3.17082e-20)
+ lwn      = (0.974466)
+ wln      = ((0.963632)*(1-fem))
+ wl       = ((8.8917e-15)*(1-fem))
+ lw       = (-3.9100708e-16)
+ lln      = (0.885)
+ wwn      = ((1.0006)*(1-fem))
+ kt1      = (-0.423)
+ ute      = ((-0.73045)+(0/w)*(1-fem))
+ ua1      = ((3.16938e-09)+(-8.28563e-10/w)*(1-fem))
+ ub1      = ((-4.85954e-18)+(8.53449e-19/w)*(1-fem))
+ uc1      = (-5.6e-11)
+ prt      = ((-0)+(-0/w)*(1-fem))
+ kt1l     = (0.0e-08)
+ at       = (3.3e+04)
+ kt2      = (-0.0286)
+ noia     = (5.503e+19)
+ noib     = (75257)
+ noic     = (1.437e-12)
+ ef       = (1.0)

if (ng_dmy>=2) {
mpowermos_dmy (d s s s) pld5_10hv l=lch w=w_mos m=ng_dmy ad=(1e-18) pd=(1e-18)
}
mpld5_10hv (d g s s) pld5_10hv w=w_mos l=lch nrd=nrd_i nrs=nrs_i m=ngtotal ad=(1e-18) pd=(1e-18)
rxa (intdxa d) resistor r=(rsda)
rxp (intdxp d) resistor r=(rsdp)
dsd_a (intdxa s) dbody_area area=(ad_i)
dsd_p (intdxp s) dbody_perim area=(pd_i)
cgs_fld_s (g s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+1e-20)
xcdgoptub_sub (s sub) cnwtub_box_sub_10hv area=(((asub*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) perim=(((psub*(1-lpe)+lpe*0.001)*ring)+(1-ring)*0.001) soa=1

include "./smos10hv_ade_dfrt.scs" section=pld5_10hv_dfrt
ends

subckt nld65_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld65_10hv_gox       = tmp_nsmm_delr_nld65_10hv_gox
+    nsmm_dela_nld65_10hv_vfb       = tmp_nsmm_dela_nld65_10hv_vfb
+    nsmm_delr_nld65_10hv_nsub      = tmp_nsmm_delr_nld65_10hv_nsub
+    nsmm_dela_nld65_10hv_vtl       = tmp_nsmm_dela_nld65_10hv_vtl
+    nsmm_dela_nld65_10hv_dwox      = tmp_nsmm_dela_nld65_10hv_dwox
+    nsmm_delr_nld65_10hv_ubref     = tmp_nsmm_delr_nld65_10hv_ubref
+    nsmm_delr_nld65_10hv_rsh       = tmp_nsmm_delr_nld65_10hv_rsh
+    nsmm_dela_nld65_10hv_vtw       = tmp_nsmm_dela_nld65_10hv_vtw
+    l                              = (0.55)
+    delr_nld65_10hv_tox            = (nom_delr_nld65_10hv_tox*(1+sig_delr_nld65_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld65_10hv_gox*smm_delr_nld65_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld65_10hv_uch            = (nom_delr_nld65_10hv_uch*(1+sig_delr_nld65_10hv_uch*nsig_delr_nld65_10hv_uch+nsmm_delr_nld65_10hv_ubref*smm_delr_nld65_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld65_10hv_res            = (nom_delr_nld65_10hv_res*(1+sig_delr_nld65_10hv_res*nsig_delr_nld65_10hv_res+nsmm_delr_nld65_10hv_rsh*smm_delr_nld65_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld65_10hv_vfb            = (nom_dela_nld65_10hv_vfb+(sig_dela_nld65_10hv_vfb*nsig_dela_nld65_10hv_vfb)+nsmm_dela_nld65_10hv_vfb*smm_dela_nld65_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld65_10hv_vtl*smm_dela_nld65_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld65_10hv_vtw*smm_dela_nld65_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld65_10hv_dwres          = (nom_dela_nld65_10hv_dwres+(sig_dela_nld65_10hv_dwres*nsig_dela_nld65_10hv_dwres))
+    dela_nld65_10hv_dwmos          = (0+(nsmm_dela_nld65_10hv_dwox*smm_dela_nld65_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld65_10hv_vtw            = (nom_dela_nld65_10hv_vtw+(sig_dela_nld65_10hv_vtw*nsig_dela_nld65_10hv_vtw))
+    delr_nld65_10hv_nsub           = (1+nsmm_delr_nld65_10hv_nsub*smm_delr_nld65_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.008*1e-10*delr_nld65_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.55)
+    laccdrawn                      = (0.6)
+    lchtcad                        = (0.480)
+    lacc                           = (0.6)
+    lch                            = (0.480)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (3.095)
+    lsrc                           = (0.21)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (1.25)
+    xiso                           = (1.275)
+    yiso                           = (6.21)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.07)
+    lfrs                           = (0.0087)
+    lfrd                           = (0)
+    dw_mos                         = (0+dela_nld65_10hv_dwmos)
+    dw_res                         = (1.00803+(2.48254)/(w**1.24553)+dela_nld65_10hv_dwres)
+    lcheff                         = (0.480)
+    numbernplus                    = (int_round((w-1.77)/0.84)+2)
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = (w+dw_res*(1-fem))
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*(3.95+lacc-xncom))
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = ((yncom+pi4models*xncom)*ng)
+    rsda                           = (5343.866/ancom)
+    rsdp                           = (31503.7/pncom)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng)+0.36*(ng/2-1))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (1.345)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.155)*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*0.855)*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*0.855)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*5.1)*ng)
+    lfring_d                       = (((w+2*0.855)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (5.1)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*0.855+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.53*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.205)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*5.375)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*aplyfld_d/((lflap*ng)*(lflap*ng)*3))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    lm                             = (ld+0)
+    nd                             = (6.70781e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.0541878/delr_nld65_10hv_res)*(1+((-0.00483123+(0.00356246/w)*(1-fem))*deltee)+((8.95009e-06+(-2.08883e-05/w)*(1-fem))*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00020935)
+    dw_res_simple                  = (1.63798+(10.7523)/(w**1.69327)+dela_nld65_10hv_dwres)
+    w_res_simple                   = (w+dw_res_simple*(1-fem))
+    aphi_tnom                      = (aphi_junc_nld65_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld65_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld65_d_body)
+    pphi_tnom                      = (pphi_junc_nld65_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld65_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld65_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld65_d_body))*1.0e12)
+ n             = (ajnd_junc_nld65_d_body)
+ cj            = ((((acj0_junc_nld65_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld65_d_body)
+ xti           = (axti_junc_nld65_d_body)
+ bv            = (84+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld65_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld65_d_body)
+ gap2          = (abetaeg_junc_nld65_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld65_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld65_d_body)
+ cj            = ((((pcj0_junc_nld65_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld65_d_body)
+ xti           = (pxti_junc_nld65_d_body)
+ bv            = (84+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld65_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld65_d_body)
+ gap2          = (pbetaeg_junc_nld65_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.008*1e-10*delr_nld65_10hv_tox)
+ nch      = (1.45e17*delr_nld65_10hv_nsub)
+ nsub     = (9.85e16*delr_nld65_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-8.76544e-08)*(1-fem))
+ ww       = ((-5.7339e-13)*(1-fem))
+ wwl      = ((2.9527e-19)*(1-fem))
+ dwg      = ((0.0e-08)*(1-fem))
+ ags      = (0.279788*(1+(0.0271316)*(temp-27)+(-0.000130487)*(temp-27)*(temp-27))+((-0.5501)/w))
+ vfb      = (-0.7649808+dela_nld65_10hv_vfb)
+ a0       = (0.738133)
+ a1       = (0)
+ a2       = (1)
+ u0       = (371.758*delr_nld65_10hv_uch)
+ ua       = (0.6028e-10)
+ ub       = (9.4933e-19)
+ vsat     = (225000*(1+((-1e-2/w)*(temp-27))+((5.4975e-5/w)*(temp-27)*(temp-27))))
+ drout    = (0.056)
+ pclm     = (0.000022839)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.053)
+ rdsw     = (442.094)
+ prwg     = (0.266609)
+ prt      = (283.504)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0+dela_nld65_10hv_vtw)*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((0)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0218002)
+ nfactor  = (1.6)
+ beta0    = (78.5152)
+ kt1      = (-0.551641)
+ ua1      = (1e-11)
+ ub1      = (-8.88725e-19)
+ uc1      = (-5.6e-11)
+ ute      = (-1.795)
+ dlc      = (0)
+ dwc      = (-5.25e-7)
+ wwc      = (-5.95e-13)
+ acde     = (0.6)
+ moin     = (25)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld65_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld65_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld65_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld65_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/15)
resdrift (d intd) resistor r=(lm/(3.23716*w_res_simple*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld65_10hv_dfrt
ends

subckt nld90_10hv (d g s sub)

parameters
+    w                              = 2.5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld90_10hv_gox       = tmp_nsmm_delr_nld90_10hv_gox
+    nsmm_dela_nld90_10hv_vfb       = tmp_nsmm_dela_nld90_10hv_vfb
+    nsmm_delr_nld90_10hv_nsub      = tmp_nsmm_delr_nld90_10hv_nsub
+    nsmm_dela_nld90_10hv_vtl       = tmp_nsmm_dela_nld90_10hv_vtl
+    nsmm_delr_nld90_10hv_ubref     = tmp_nsmm_delr_nld90_10hv_ubref
+    nsmm_delr_nld90_10hv_rsh       = tmp_nsmm_delr_nld90_10hv_rsh
+    nsmm_dela_nld90_10hv_vtw       = tmp_nsmm_dela_nld90_10hv_vtw
+    l                              = (0.65)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    delr_nld90_10hv_tox            = (nom_delr_nld90_10hv_tox*(1+sig_delr_nld90_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld90_10hv_gox*smm_delr_nld90_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld90_10hv_uch            = (nom_delr_nld90_10hv_uch*(1+sig_delr_nld90_10hv_uch*nsig_delr_nld90_10hv_uch+nsmm_delr_nld90_10hv_ubref*smm_delr_nld90_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld90_10hv_res            = (nom_delr_nld90_10hv_res*(1+sig_delr_nld90_10hv_res*nsig_delr_nld90_10hv_res+nsmm_delr_nld90_10hv_rsh*smm_delr_nld90_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld90_10hv_vfb            = (nom_dela_nld90_10hv_vfb+(sig_dela_nld90_10hv_vfb*nsig_dela_nld90_10hv_vfb)+nsmm_dela_nld90_10hv_vfb*smm_dela_nld90_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld90_10hv_vtl*smm_dela_nld90_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld90_10hv_vtw*smm_dela_nld90_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld90_10hv_dwmos          = (nom_dela_nld90_10hv_dwmos+(sig_dela_nld90_10hv_dwmos*nsig_dela_nld90_10hv_dwmos))
+    dela_nld90_10hv_dwres          = (nom_dela_nld90_10hv_dwres+(sig_dela_nld90_10hv_dwres*nsig_dela_nld90_10hv_dwres))
+    dela_nld90_10hv_vtw            = (nom_dela_nld90_10hv_vtw+(sig_dela_nld90_10hv_vtw*nsig_dela_nld90_10hv_vtw))
+    delr_nld90_10hv_nsub           = (1+nsmm_delr_nld90_10hv_nsub*smm_delr_nld90_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.008*1e-10*delr_nld90_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.65)
+    laccdrawn                      = (0.6)
+    lchtcad                        = (0.582)
+    lacc                           = (0.601)
+    lch                            = (0.582)
+    lsovl                          = (lchdrawn+laccdrawn-lchtcad-lacc)
+    ld                             = (5.555)
+    lsrc                           = (0.2+0.18/2)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (2.7)
+    xiso                           = (1.275)
+    yiso                           = (9.46)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (0.067)
+    lfrs                           = (0.0125)
+    lfrd                           = (0)
+    dw_mos                         = (0)
+    dw_res                         = ((2.59217+(9.8)/(w))+dela_nld90_10hv_dwres)
+    lcheff                         = (0.582)
+    numbernplus                    = (3+(w>=3.335)+(w>=4.175)+(w>=5.02)+(w>=5.855)+(w>=6.695)+(w>=7.535)+(w>=8.375)+(w>=9.22)+(w>=10.06)+(w>=10.9)+(w>=11.74)+(w>=12.58)+(w>=13.42)+(w>=14.255)+(w>=15.095)+(w>=15.935)+(w>=16.78)*(1+int_round((w-16.78)/0.84)))
+    w_mos                          = (numbernplus*0.42+dw_mos*(1-fem))
+    w_res                          = ((w+dw_res*(1-fem))/delr_rdsw_relimo)
+    xncom                          = (ld+lacc)
+    yncom                          = (w+2*1.545)
+    ancom                          = ((xncom*yncom+0.5*pi4models*xncom*xncom)*ng)
+    pncom                          = ((yncom+pi4models*xncom)*ng)
+    rsda                           = (105983/ancom)
+    rsdp                           = (61758.6/pncom)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    rpolyhole                      = (2.355)
+    rpoly                          = (lflap+rpolyhole)
+    ahole                          = (((w+2*0.12)*rpolyhole+0.5*pi4models*rpolyhole*rpolyhole)*ng)
+    apoly                          = (((w+2*1.545)*rpoly+0.5*pi4models*rpoly*rpoly)*ng)
+    aplyfld_d                      = (apoly-ahole)
+    aplyfld_s                      = (2*(lsovl+lch+lacc+ld)*0.5*ng)
+    area_accum                     = (((w+2*1.545)*lacc+0.5*pi4models*((ld+lacc)*(ld+lacc)-(ld*ld)))*ng)
+    lfring_s                       = ((w+2*8.35)*ng)
+    lfring_d                       = (((w+2*1.545)+(pi4models*ld))*ng)
+    xmosend                        = (2*(lch+lacc+ld))
+    ymosend                        = (8.35)
+    amosend                        = (((xmosend*ymosend)-(2*(ld+lacc)*1.545+0.5*pi4models*(ld+lacc)*(ld+lacc))+(w-w_mos)*lch)*ng)
+    wmosend                        = (amosend/lcheff)
+    number_ct_s                    = (int_round((w-0.32*2)/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.74*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.17)-lfr_ct_ply_d)
+    rgateout                       = (rply*(w+2*8.625)/((lsovl+lch+lacc)*3*ng))
+    rgatein                        = (rply*(aplyfld_d/(lflap*ng))/(lflap*3*ng))
+    rgatetot                       = (rgatein*rgateout/(rgatein+rgateout))
+    lm                             = (ld+0)
+    nd                             = (4.8599e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.00963978*(1.009)/(delr_nld90_10hv_res*delr_rdsw_relimo))*(1+((-0.00556295+(0.000207998/w)*(1-fem))*deltee)+(1.20546e-05*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00122159)
+    dw_res_simple                  = ((1.97+(13.8)/(w))+dela_nld90_10hv_dwres)
+    w_res_simple                   = (w+dw_res_simple*(1-fem))
+    aphi_tnom                      = (aphi_junc_nld90_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld90_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld90_d_body)
+    pphi_tnom                      = (pphi_junc_nld90_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld90_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld90_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld90_d_body))*1.0e12)
+ n             = (ajnd_junc_nld90_d_body)
+ cj            = ((((acj0_junc_nld90_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_nld90_d_body)
+ xti           = (axti_junc_nld90_d_body)
+ bv            = (115+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld90_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld90_d_body)
+ gap2          = (abetaeg_junc_nld90_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld90_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld90_d_body)
+ cj            = ((((pcj0_junc_nld90_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_nld90_d_body)
+ xti           = (pxti_junc_nld90_d_body)
+ bv            = (115+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld90_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld90_d_body)
+ gap2          = (pbetaeg_junc_nld90_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.008*1e-10*delr_nld90_10hv_tox)
+ nch      = (1.50e17*delr_nld90_10hv_nsub)
+ nsub     = (3.61e16*delr_nld90_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-4.72781e-08*(0.6)-0.5e-06*dela_nld90_10hv_dwmos)*(1-fem))
+ ww       = ((2.06059e-14)*(1-fem))
+ wwl      = ((3.211e-21)*(1-fem))
+ dwg      = ((0.0e-08)*(1-fem))
+ ags      = ((0.2414*(1+(0.0318767)*(temp-27)+(-0.0001521)*(temp-27)*(temp-27))+((0.295295*(1+-0.0252791*(temp-27)+0.000203955*(temp-27)*(temp-27)))/w)))
+ vfb      = (-1.03799+(0.00067)+dela_nld90_10hv_vfb+dela_vth_relimo)
+ a0       = (0.28552823*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = ((361.809)*(1.003)*delr_nld90_10hv_uch*delr_u0_relimo)
+ ua       = (1e-15)
+ ub       = (3.032e-18)
+ vsat     = (1.15e+06)
+ drout    = (0.56)
+ pclm     = (0.13)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.0375)
+ rdsw     = (336.821*delr_rdsw_relimo)
+ prwg     = (0.566612*(1+(0.00457161*(1+(1-fem)*(1.07917/w)))*(temp-27)))
+ prt      = (400*(1+(0.0145945/w)*(1-fem)*(temp-27)+(-3.16206e-05/w)*(1-fem)*(temp-27)*(temp-27)))
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.000859111)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.641388+dela_nld90_10hv_vtw)*(1-fem))
+ dvt1w    = (361087)
+ k3       = ((1.52237-1.04+0.5955152)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (0.56)
+ alpha0   = (0.0e-5)
+ alpha1   = (0.0079265)
+ nfactor  = (1.86)
+ beta0    = (80.932)
+ kt1      = (-0.60491)
+ ua1      = (2.38202e-09)
+ ub1      = (-8.54066e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.55)
+ dlc      = (0)
+ dwc      = (-19.72781e-08)
+ wwc      = (0)
+ voffcv   = (-0.425)
+ acde     = (0.495)
+ moin     = (5)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mendcap (s intg s s) nmosmodel l=lcheff w=(wmosend) m=(1)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_nld90_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld90_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_nld90_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld90_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rgatetot)
rx (d intdx) resistor r=(rsd)
dsd_a (s intdx) dbody_area area=(ancom)
dsd_p (s intdx) dbody_perim area=(pncom)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/17.5)
resdrift (d intd) resistor r=(lm/(5.70588*w_res_simple*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld90_10hv_dfrt
ends

subckt pld90_10hv (d g s sub)

parameters
+    w                              = 5
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld90_10hv_gox       = tmp_nsmm_delr_pld90_10hv_gox
+    nsmm_dela_pld90_10hv_vfb       = tmp_nsmm_dela_pld90_10hv_vfb
+    nsmm_delr_pld90_10hv_nsub      = tmp_nsmm_delr_pld90_10hv_nsub
+    nsmm_dela_pld90_10hv_vtl       = tmp_nsmm_dela_pld90_10hv_vtl
+    nsmm_delr_pld90_10hv_ubref     = tmp_nsmm_delr_pld90_10hv_ubref
+    nsmm_delr_pld90_10hv_rsh       = tmp_nsmm_delr_pld90_10hv_rsh
+    nsmm_dela_pld90_10hv_vtw       = tmp_nsmm_dela_pld90_10hv_vtw
+    l                              = (0.5)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld90_vthratio          = 1.0
+    presto_pld90_betaratio         = 1
+    delr_pld90_10hv_tox            = (nom_delr_pld90_10hv_tox*(1+sig_delr_pld90_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld90_10hv_gox*smm_delr_pld90_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld90_10hv_uch            = (nom_delr_pld90_10hv_uch*(1+sig_delr_pld90_10hv_uch*nsig_delr_pld90_10hv_uch+nsmm_delr_pld90_10hv_ubref*smm_delr_pld90_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld90_10hv_res            = (nom_delr_pld90_10hv_res*(1+sig_delr_pld90_10hv_res*nsig_delr_pld90_10hv_res+nsmm_delr_pld90_10hv_rsh*smm_delr_pld90_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld90_10hv_vfb            = (nom_dela_pld90_10hv_vfb+(sig_dela_pld90_10hv_vfb*nsig_dela_pld90_10hv_vfb)+nsmm_dela_pld90_10hv_vfb*smm_dela_pld90_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld90_10hv_vtl*smm_dela_pld90_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld90_10hv_vtw*smm_dela_pld90_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld90_10hv_vtm            = (nom_dela_pld90_10hv_vtm+(sig_dela_pld90_10hv_vtm*nsig_dela_pld90_10hv_vtm))
+    delr_pld90_10hv_nsub           = (1+nsmm_delr_pld90_10hv_nsub*smm_delr_pld90_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.032*1e-10*delr_pld90_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lch_drawn                      = (0.5)
+    lch                            = (0.913)
+    lacc_drawn                     = (0.55)
+    lacc                           = (0.078)
+    ld                             = (7.01)
+    lsc_ply                        = (0.495)
+    lcell                          = (lsc_ply+lch_drawn+lacc_drawn+ld)
+    lflap                          = (2.65)
+    xiso                           = (3.165)
+    yiso                           = (13.4)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lovlap                         = (lch_drawn+lacc_drawn-lch-lacc)
+    lfrs                           = (0.021)
+    lfrd                           = (0.0157677+(2.64757)/(w**(2.2912)))
+    dw_mos                         = (0.141168)
+    dw_res                         = (0.611467)
+    lcheff                         = (0.913)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(0.865274/(w**0.092297)))*(1-fem))
+    nhvradius                      = (1.46)
+    xnhvhole                       = (ld+lacc_drawn)
+    ynhvhole                       = (w+2*(9.9-nhvradius))
+    apepi                          = ((xnhvhole*ynhvhole+2*nhvradius*(xnhvhole-nhvradius)+0.5*pi4models*nhvradius*nhvradius)*ng)
+    ppepi                          = ((ynhvhole+2*(xnhvhole-nhvradius)+pi4models*nhvradius)*ng)
+    rsda                           = (1.97464e+05/apepi)
+    rsdp                           = (4.98939e+06/ppepi)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    xplyplushole                   = (7.01)
+    yplyplushole                   = (w+2*(9+0.35))
+    apolyplushole                  = ((xplyplushole*yplyplushole)*ng)
+    xplyholein                     = (3.86)
+    yplyholein                     = (w+2*4.8)
+    apolyholein                    = ((xplyholein*yplyholein)*ng)
+    xplyholeout                    = (0.5)
+    yplyholeout                    = (w+2*3.2)
+    apolyholeout                   = ((xplyholeout*yplyholeout)*ng)
+    aplyfld_d                      = (apolyplushole-apolyholein-apolyholeout)
+    pplyfld_in_d                   = ((yplyholein+xplyholein*2)*ng)
+    xply                           = (lch+lacc+ld+lovlap)
+    yply                           = (w+2*10.9)
+    aply_s                         = (ng*xply*yply-apolyplushole)
+    aplyfld_s                      = (aply_s-(lch+lacc+lovlap)*w*ng)
+    pplyfld_s                      = ((yply+2*xply)*ng)
+    pm1fld_s                       = (14.34*ng)
+    area_accum                     = (w*lacc*ng)
+    lfring_s                       = ((w)*ng)
+    lfring_d                       = ((w)*ng)
+    number_ct_s                    = (int_round((w-0.25*2)/(0.18+0.18))+1)
+    lfr_ct_ply_s                   = (ng*number_ct_s*0.18)
+    number_ct_d                    = (int_round((w-0.1*2)/(0.18+0.24))+1)
+    lfr_ct_ply_d                   = (ng*number_ct_d*0.18)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w)-lfr_ct_ply_d)
+    lm                             = (7.01)
+    nd                             = (4.0196e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.00455431/delr_pld90_10hv_res)*(1+((-0.00477638+(0.00222722/w)*(1-fem))*deltee)+((1.007094e-05+(-5.80477e-06/w)*(1-fem))*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (5.5198e-05)
+    aphi_tnom                      = (aphi_junc_pld90_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_pld90_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_pld90_d_body)
+    pphi_tnom                      = (pphi_junc_pld90_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_pld90_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_pld90_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_pld90_d_body))*1.0e12)
+ n             = (ajnd_junc_pld90_d_body)
+ cj            = ((((acj0_junc_pld90_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_pld90_d_body)
+ xti           = (axti_junc_pld90_d_body)
+ bv            = (112+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_pld90_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_pld90_d_body)
+ gap2          = (abetaeg_junc_pld90_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_pld90_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_pld90_d_body)
+ cj            = ((((pcj0_junc_pld90_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_pld90_d_body)
+ xti           = (pxti_junc_pld90_d_body)
+ bv            = (112+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_pld90_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_pld90_d_body)
+ gap2          = (pbetaeg_junc_pld90_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.032*1e-10*delr_pld90_10hv_tox)
+ nch      = (8.82e16*delr_pld90_10hv_nsub)
+ nsub     = (1.47e17*delr_pld90_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((22e-8)*(1-fem))
+ ww       = ((2.5e-13)*(1-fem))
+ wwl      = ((0)*(1-fem))
+ dwg      = ((7.6e-08)*(1-fem))
+ ags      = ((0.65)*(1+0.0128548*(temp-27)+-5.3512e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.644188+dela_pld90_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld90_vthratio)
+ a0       = ((0.874)*delr_a0_relimo)
+ u0       = ((163.167*delr_pld90_10hv_uch)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld90_betaratio))
+ ua       = (1.25516e-11)
+ ub       = (8.01052e-20)
+ vsat     = (0.29e+06)
+ drout    = (55.6)
+ pclm     = (0.055)
+ pvag     = (0)
+ pdiblc1  = (0.000039)
+ pdiblc2  = (0.00086)
+ delta    = (0.0317479)
+ rdsw     = ((4136.24+(-7788.25/w)*(1-fem))*delr_rdsw_relimo)
+ prwg     = (0.0*(1+(-9.8901e-05+(1-fem)*(-4.16797e-06/w))*(temp-27)))
+ prt      = (8251.2+(1-fem)*(-9423.39/w))
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.00048)
+ etab     = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.0411441)*(1-fem))
+ dvt1w    = (2.18207)
+ k3       = ((0+dela_pld90_10hv_vtm)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (2.4)
+ alpha0   = (0e-8)
+ alpha1   = (0.00)
+ nfactor  = (1.35)
+ beta0    = (50)
+ kt1      = (-0.488519)
+ ua1      = (1.980738e-09)
+ ub1      = (-8.61e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.5)
+ dlc      = (0)
+ dwc      = (1e-7)
+ wwc      = (-13.5e-13)
+ at       = (33000)
+ voff     = (-0.08)
+ acde     = (0.7)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg_s (intg s) capacitor c=(cox*(lfrs+lovlap)*lfring_s*sDOTmult2)
cgs_frg_d (intg d) capacitor c=(cox*(lfrd)*lfring_d*sDOTmult2)
cgd_fld_d (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2+(cfr_ply_fld*(pplyfld_in_d))*sDOTmult)
cgs_fld_s (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2+(cfr_ply_fld*pplyfld_s)*sDOTmult)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_pld90_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_pld90_s_ply_m1ct*sDOTmult+cfr_m1_fld*pm1fld_s*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_pld90_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_pld90_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*10.675)/((lch+lacc)*3*ng)))
rx (intdx d) resistor r=(rsd)
dsd_a (intdx s) dbody_area area=(apepi)
dsd_p (intdx s) dbody_perim area=(ppepi)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/5.0)
resdrift (d intd) resistor r=(lm/(80.3392*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=pld90_10hv_dfrt
ends

subckt nld5_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld5_10hv_gox        = tmp_nsmm_delr_nld5_10hv_gox
+    nsmm_dela_nld5_10hv_vfb        = tmp_nsmm_dela_nld5_10hv_vfb
+    nsmm_delr_nld5_10hv_nsub       = tmp_nsmm_delr_nld5_10hv_nsub
+    nsmm_dela_nld5_10hv_vtl        = tmp_nsmm_dela_nld5_10hv_vtl
+    nsmm_dela_nld5_10hv_dwox       = tmp_nsmm_dela_nld5_10hv_dwox
+    nsmm_delr_nld5_10hv_ubref      = tmp_nsmm_delr_nld5_10hv_ubref
+    nsmm_delr_nld5_10hv_rsh        = tmp_nsmm_delr_nld5_10hv_rsh
+    nsmm_dela_nld5_10hv_vtw        = tmp_nsmm_dela_nld5_10hv_vtw
+    l                              = (0.4)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nld5_vthratio           = 1.0
+    presto_nld5_betaratio          = 1.24
+    relimo_ratio1_a_hci_nld5_10hv  = (0.163151796)
+    relimo_ratio1_b_hci_nld5_10hv  = (-0.461262665)
+    lg                             = (0.4)
+    stimod_on                      = (enable_sti==1)
+    ngeff                          = ng+2*sti_dummy
+    nld5_10hv_del_vfb_sti_final    = ((stimod_on)*((ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-0.65))*(w/(w+0.4*(1-fem))))
+    nld5_10hv_fac_nsub_sti_final   = (1)
+    nld5_10hv_fac_uch_sti_final    = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*0.73))
+    nld5_10hv_fac_res_sti_final    = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-1.3)))
+    delr_nld5_10hv_tox             = (nom_delr_nld5_10hv_tox*(1+sig_delr_nld5_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld5_10hv_gox*smm_delr_nld5_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld5_10hv_uch             = (nom_delr_nld5_10hv_uch*nld5_10hv_fac_uch_sti_final*(1+sig_delr_nld5_10hv_uch*nsig_delr_nld5_10hv_uch+nsmm_delr_nld5_10hv_ubref*smm_delr_nld5_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld5_10hv_res             = (nom_delr_nld5_10hv_res*nld5_10hv_fac_res_sti_final*(1+sig_delr_nld5_10hv_res*nsig_delr_nld5_10hv_res+nsmm_delr_nld5_10hv_rsh*smm_delr_nld5_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld5_10hv_vfb             = (nom_dela_nld5_10hv_vfb+nld5_10hv_del_vfb_sti_final+(sig_dela_nld5_10hv_vfb*nsig_dela_nld5_10hv_vfb)+nsmm_dela_nld5_10hv_vfb*smm_dela_nld5_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld5_10hv_vtl*smm_dela_nld5_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld5_10hv_vtw*smm_dela_nld5_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_nld5_10hv_dwmos           = (nom_dela_nld5_10hv_dwmos+(sig_dela_nld5_10hv_dwmos*nsig_dela_nld5_10hv_dwmos)+(nsmm_dela_nld5_10hv_dwox*smm_dela_nld5_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_nld5_10hv_vtw             = (nom_dela_nld5_10hv_vtw+(sig_dela_nld5_10hv_vtw*nsig_dela_nld5_10hv_vtw))
+    delr_nld5_10hv_vsat            = (nom_delr_nld5_10hv_vsat*(1+sig_delr_nld5_10hv_vsat*nsig_delr_nld5_10hv_vsat))
+    delr_nld5_10hv_nsub            = (nld5_10hv_fac_nsub_sti_final*(1+nsmm_delr_nld5_10hv_nsub*smm_delr_nld5_10hv_nsub(l,w)/sqrt(1*ng)))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.01*1e-10*delr_nld5_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.4)
+    lchtcad                        = (0.293)
+    lacc                           = (0.058)
+    lch                            = (0.293)
+    lsovl                          = (lchdrawn-lchtcad-lacc)
+    ld                             = (0.255)
+    lsrc                           = (0.29)
+    lcell                          = (lsrc+lchdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.20)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    d_cfr                          = (6.84647e-17)
+    lfr                            = (0.090191174+(0.11/w**2))
+    dw_mos                         = (0)
+    dw_res                         = (-5.12098)
+    lcheff                         = (0.293)
+    numbernplus                    = (int_round(w/0.8))
+    w_mos                          = (numbernplus*0.4+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(6.79401)/(w**1.00015))*(1-fem))
+    w_cap                          = (w)
+    xnsd                           = (ld+lacc)
+    ynsd                           = (w)
+    ansd                           = (xnsd*ynsd*ngeff)
+    pnsd                           = ((2*xnsd+ynsd)*ngeff)
+    rsda                           = (1.69544e+07/ansd)
+    rsdp                           = (3352.71/pnsd)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = ((2*xiso)+(lcell*ngeff))
+    ysub                           = (w+2*yiso)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (lchdrawn*0.585*ng)
+    area_accum                     = ((lacc+0.15824)*w*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = ((int_round((w-0.135*2)/(0.18+0.22)/2))*2+1)
+    nb_ct_ply_d                    = (int_round(w/(0.18+0.24)+0.2))
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*w-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*w-lfr_ct_ply_d)
+    lm1s                           = (0.6*2*n_src)
+    lm1d                           = (0.6*2*n_drn)
+    ng_dmy                         = (2*sti_dummy)
+    area_accum_dmy                 = ((lacc+0.15824)*w*ng_dmy)
+    lfring_dmy                     = (w*ng_dmy)
+    lfr_ct_ply_d_dmy               = (nb_ct_ply_d*0.18*ng_dmy)
+    lfr_m1_ply_d_dmy               = (ng_dmy*w-lfr_ct_ply_d_dmy)
+    n_drn_dmy                      = (ng_dmy/2)
+    lm1d_dmy                       = (0.6*2*n_drn_dmy)
+    sdotmult                       = (1)
+    sdotmult2                      = (1)
+    lm                             = (ld+0)
+    nd                             = (8.07053e+18)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.800201/delr_nld5_10hv_res)*(1+(0*deltee)+(0*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.005)
+    aphi_tnom                      = (aphi_junc_nld5_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_nld5_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_nld5_d_body)
+    pphi_tnom                      = (pphi_junc_nld5_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_nld5_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_nld5_d_body)

model nmosmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_10hv_tox)
+ nch      = (3.10e16*delr_nld5_10hv_nsub)
+ nsub     = (4.75e16*delr_nld5_10hv_nsub)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-1.36807e-07+0.5e-6*dela_nld5_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((6.44544e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((7.45381e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-10.5045+6.5/w)*(1+-0.00251007*(temp-27)+3.99712e-06*(temp-27)*(temp-27)))
+ vfb      = (0.2048228+dela_nld5_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_nld5_vthratio+hcibetdegrfac*(hcibetdegrfac*relimo_ratio1_a_hci_nld5_10hv-relimo_ratio1_b_hci_nld5_10hv))
+ a0       = (1.37362*delr_a0_relimo)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (768.188*delr_nld5_10hv_uch*delr_u0_relimo)
+ ua       = (1e-17)
+ ub       = (6.28673e-19)
+ vsat     = (459379*delr_nld5_10hv_vsat)
+ drout    = (0.56)
+ pclm     = (0.37)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.0785775)
+ rdsw     = (14.6748*delr_nld5_10hv_res*delr_rdsw_relimo)
+ wr       = (1.00)
+ prwg     = (2.85)
+ prt      = (18.0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1.0)
+ moin     = (10)
+ cgsl     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0+dela_nld5_10hv_vtw)*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = (4.8)
+ voff     = (-0.38)
+ beta0    = (50)
+ kt1      = (-0.55851)
+ ua1      = (1.31648e-10)
+ ub1      = (-9.04058e-20)
+ uc1      = (-5.6e-11)
+ ute      = (-1.25783)
+ dlc      = (0.140e-6)
+ dwc      = (0)
+ at       = (33000)
+ noia     = (1.0e21)
+ noib     = (5.0e4*5.0)
+ noic     = (0.0)
+ em       = (4.1e7)
+ af       = (1)
+ ef       = (1)
+ kf       = (0)

model nmcapmodel bsim3v3 type=n version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.01*1e-10*delr_nld5_10hv_tox)
+ nch      = (1.10e15)
+ nsub     = (4.75e16)
+ nlx      = (8.15e-7)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((-1.36807e-07)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((6.44544e-14)*(1-fem))
+ wwn      = (1)
+ wwl      = ((7.45381e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-10.5045+6.5/w)*(1+-0.00251007*(temp-27)+3.99712e-06*(temp-27)*(temp-27)))
+ vfb      = (0.30)
+ a0       = (1.37362)
+ b0       = (3.05282e-07)
+ b1       = (0)
+ a1       = (0)
+ a2       = (1)
+ u0       = (768.188)
+ ua       = (1e-17)
+ ub       = (6.28673e-19)
+ vsat     = (459379)
+ drout    = (0.56)
+ pclm     = (0.37)
+ pvag     = (0)
+ pdiblc1  = (0e-10)
+ pdiblc2  = (1.1849e-20)
+ delta    = (0.0785775)
+ rdsw     = (14.6748)
+ wr       = (1.00)
+ prwg     = (2.85)
+ prt      = (18.0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgdo     = (0)
+ acde     = (1)
+ moin     = (10)
+ cgsl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.2859111)
+ etab     = (0)
+ noff     = (4)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0*(1-fem))
+ dvt1w    = (5.3e+04)
+ k3       = ((5.0)*(1-fem))
+ k3b      = (0)
+ dsub     = (1.55)
+ alpha0   = (1.050e-4)
+ alpha1   = (0.04)
+ nfactor  = (4.8)
+ voff     = (-0.38)
+ beta0    = (50)
+ kt1      = (-0.55851)
+ ua1      = (1.31648e-10)
+ ub1      = (-9.04058e-20)
+ uc1      = (-5.6e-11)
+ ute      = (-1.25783)
+ dlc      = (0.0835e-6)
+ dwc      = (0)
+ at       = (33000)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_nld5_d_body))*1.0e12)
+ n             = (ajnd_junc_nld5_d_body)
+ cj            = ((((acj0_junc_nld5_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (aphi_temp)
+ mj            = (aexm_junc_nld5_d_body)
+ xti           = (axti_junc_nld5_d_body)
+ bv            = (8.5+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_nld5_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_nld5_d_body)
+ gap2          = (abetaeg_junc_nld5_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_nld5_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_nld5_d_body)
+ cj            = ((((pcj0_junc_nld5_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (pphi_temp)
+ mj            = (pexm_junc_nld5_d_body)
+ xti           = (pxti_junc_nld5_d_body)
+ bv            = (8.5+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_nld5_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_nld5_d_body)
+ gap2          = (pbetaeg_junc_nld5_d_body)

if (ng_dmy>=2) {
mpowermos_dmy (intd_dmy s s s) nmosmodel l=lcheff w=(w_mos) m=(ng_dmy) ad=(1e-18) pd=(1e-18)
cgd_frg_dmy (s d) capacitor c=(d_cfr*lfring_dmy*sdotmult)
cgd_m1_dmy (s d) capacitor c=(lfr_m1_ply_d_dmy*cfr_nld5_d_ply_met*sdotmult+lfr_ct_ply_d_dmy*cfr_nld5_d_ply_m1ct*sdotmult+lm1d_dmy*3.06679e-16*sdotmult)
capmos1_dmy (d s) capacitor c=(cox_accum*area_accum_dmy*sdotmult2*1e-12/2.5)
resdrift_dmy (d intd_dmy) resistor r=(lm/(20.0*w_res*xj*ng_dmy*qq*uu*nd))
}
mpowermos (intd intg s s) nmosmodel l=lcheff w=(w_mos) m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=(w_cap) m=(ng)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgs_frg (intg s) capacitor c=(cox*(lsovl+lfr)*lfring*sDOTmult2)
cgd_frg (intg d) capacitor c=(d_cfr*lfring*sDOTmult)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply_s*cfr_nld5_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_nld5_s_ply_m1ct*sDOTmult+lm1s*3.06679e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply_d*cfr_nld5_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_nld5_d_ply_m1ct*sDOTmult+lm1d*3.06679e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.36)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd)
dsd_a (s intdx) dbody_area area=(ansd)
dsd_p (s intdx) dbody_perim area=(pnsd)
xdsub (s sub) cdgontub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (d intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/2.5)
resdrift (d intd) resistor r=(lm/(20.0*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=nld5_10hv_dfrt
ends

subckt pld10_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld10_10hv_gox       = tmp_nsmm_delr_pld10_10hv_gox
+    nsmm_dela_pld10_10hv_vfb       = tmp_nsmm_dela_pld10_10hv_vfb
+    nsmm_delr_pld10_10hv_nsub      = tmp_nsmm_delr_pld10_10hv_nsub
+    nsmm_dela_pld10_10hv_vtl       = tmp_nsmm_dela_pld10_10hv_vtl
+    nsmm_dela_pld10_10hv_dwox      = tmp_nsmm_dela_pld10_10hv_dwox
+    nsmm_delr_pld10_10hv_ubref     = tmp_nsmm_delr_pld10_10hv_ubref
+    nsmm_delr_pld10_10hv_rsh       = tmp_nsmm_delr_pld10_10hv_rsh
+    nsmm_dela_pld10_10hv_vtw       = tmp_nsmm_dela_pld10_10hv_vtw
+    l                              = (0.2)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld10_vthratio          = 1.0
+    presto_pld10_betaratio         = 1
+    delr_pld10_10hv_tox            = (nom_delr_pld10_10hv_tox*(1+sig_delr_pld10_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld10_10hv_gox*smm_delr_pld10_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld10_10hv_uch            = (nom_delr_pld10_10hv_uch*(1+sig_delr_pld10_10hv_uch*nsig_delr_pld10_10hv_uch+nsmm_delr_pld10_10hv_ubref*smm_delr_pld10_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld10_10hv_res            = (nom_delr_pld10_10hv_res*(1+sig_delr_pld10_10hv_res*nsig_delr_pld10_10hv_res+nsmm_delr_pld10_10hv_rsh*smm_delr_pld10_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld10_10hv_vfb            = (nom_dela_pld10_10hv_vfb+(sig_dela_pld10_10hv_vfb*nsig_dela_pld10_10hv_vfb)+nsmm_dela_pld10_10hv_vfb*smm_dela_pld10_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld10_10hv_vtl*smm_dela_pld10_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld10_10hv_vtw*smm_dela_pld10_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld10_10hv_dwres          = (nom_dela_pld10_10hv_dwres+(sig_dela_pld10_10hv_dwres*nsig_dela_pld10_10hv_dwres))
+    dela_pld10_10hv_dwmos          = (nom_dela_pld10_10hv_dwmos+(sig_dela_pld10_10hv_dwmos*nsig_dela_pld10_10hv_dwmos)+(nsmm_dela_pld10_10hv_dwox*smm_dela_pld10_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_pld10_10hv_vtw            = (nom_dela_pld10_10hv_vtw+(sig_dela_pld10_10hv_vtw*nsig_dela_pld10_10hv_vtw))
+    delr_pld10_10hv_nsub           = (1+nsmm_delr_pld10_10hv_nsub*smm_delr_pld10_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld10_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.2)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.369)
+    lacc                           = (0.324)
+    lch                            = (0.369)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (0.525)
+    lsrc                           = (0.495)
+    lflap                          = (0.225)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    xiso                           = (1.275)
+    yiso                           = (1.35)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr_s                          = (0.00693216)
+    dw_mos                         = (0)
+    dw_res                         = (-0.502252+dela_pld10_10hv_dwres)
+    lcheff                         = (0.369)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(0.861359)/(w**(1.14813)))*(1-fem))
+    xnhvhole                       = (ld+lacc)
+    ynhvhole                       = (w+2*0.6)
+    anhvhole                       = (xnhvhole*ynhvhole*ng)
+    pnhvhole                       = ((ynhvhole+2*xnhvhole)*ng)
+    rsda                           = (99010.4/anhvhole)
+    rsdp                           = (150761/pnhvhole)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = (0.54*(lsovl+lch)*2*ng)
+    aplyfld_d                      = ((0.54*(lacc+lflap)*2+w*lflap)*ng)
+    area_accum                     = ((lacc+0.08424)*w*ng)
+    lfring_s                       = (w*ng)
+    nb_ct_ply                      = (int_round((w-(0.18+0.08*2))/(0.18*2))+1)
+    lfr_ct_ply                     = (nb_ct_ply*0.18*ng)
+    lfr_m1_ply                     = (ng*w-lfr_ct_ply)
+    lm1s                           = (0.96*2*n_src)
+    lm1d                           = (0.96*2*n_drn)
+    lm                             = (ld+0)
+    nd                             = (2.0267e+19)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.0033013/delr_pld10_10hv_res)*(1+(-0.00440614*deltee)+(9.38241e-06*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.00072989)
+    aphi_tnom                      = (aphi_junc_pld10_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_pld10_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_pld10_d_body)
+    pphi_tnom                      = (pphi_junc_pld10_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_pld10_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_pld10_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_pld10_d_body))*1.0e12)
+ n             = (ajnd_junc_pld10_d_body)
+ cj            = ((((acj0_junc_pld10_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_pld10_d_body)
+ xti           = (axti_junc_pld10_d_body)
+ bv            = (16+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_pld10_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_pld10_d_body)
+ gap2          = (abetaeg_junc_pld10_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_pld10_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_pld10_d_body)
+ cj            = ((((pcj0_junc_pld10_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_pld10_d_body)
+ xti           = (pxti_junc_pld10_d_body)
+ bv            = (16+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_pld10_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_pld10_d_body)
+ gap2          = (pbetaeg_junc_pld10_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld10_10hv_tox)
+ nch      = (7.19e16*delr_pld10_10hv_nsub)
+ nsub     = (8.77e16*delr_pld10_10hv_nsub)
+ xt       = (2.002e-7)
+ capmod   = (3)
+ wint     = ((-3.88988e-07+0.5e-6*dela_pld10_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-13)*(1-fem))
+ wwn      = (1.14665)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-4.89381)*(1+-0.00791271*(temp-27)+4.05173e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.385944+dela_pld10_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld10_vthratio)
+ a0       = (0.399319*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = (579.236*delr_pld10_10hv_uch*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld10_betaratio))
+ ua       = (7.95632e-09)
+ ub       = (1.77696e-18)
+ vsat     = (2.44887e+06)
+ drout    = (0.892638)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (0.003918138)
+ pdiblc2  = (0.00478204)
+ delta    = (0.12)
+ rdsw     = (771.216*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0.3)
+ prt      = (0.126802)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.0019111)
+ etab     = (0)
+ voffcv   = (0)
+ noff     = (4.0)
+ voff     = (-0.35)
+ w0       = (0)
+ dvt0     = (2.2)
+ dvt1     = (0.53)
+ dvt0w    = ((0.261316+dela_pld10_10hv_vtw)*(1-fem))
+ dvt1w    = (210481)
+ k3       = ((10.8148)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.42e-6)
+ dsub     = (1.89)
+ alpha0   = (5e-5)
+ alpha1   = (0.387818)
+ nfactor  = (2.75)
+ beta0    = (1000)
+ kt1      = (-0.587409)
+ ua1      = (1.00223e-12)
+ ub1      = (-2.06824e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.38925)
+ dlc      = (0.1725e-6)
+ dwc      = (0)
+ at       = (33000)

model nmcapmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld10_10hv_tox)
+ nch      = (1.05e16)
+ nsub     = (8.77e15)
+ xt       = (2.002e-7)
+ capmod   = (3)
+ wint     = ((-3.88988e-07)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1)
+ ww       = ((1e-13)*(1-fem))
+ wwn      = (1.14665)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((-4.89381)*(1+-0.00791271*(temp-27)+4.05173e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.385944)
+ a0       = (0.399319)
+ a1       = (0)
+ a2       = (1)
+ u0       = (579.236)
+ ua       = (7.95632e-09)
+ ub       = (1.77696e-18)
+ vsat     = (2.44887e+06)
+ drout    = (0.892638)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (0.003918138)
+ pdiblc2  = (0.00478204)
+ delta    = (0.12)
+ rdsw     = (771.216)
+ wr       = (1)
+ prwg     = (0.3)
+ prt      = (0.126802)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (4e8)
+ pscbe2   = (1e-10)
+ eta0     = (0.0019111)
+ etab     = (0)
+ voffcv   = (0)
+ noff     = (4.0)
+ voff     = (-0.35)
+ w0       = (0)
+ dvt0     = (2.2)
+ dvt1     = (0.53)
+ dvt0w    = ((0.261316)*(1-fem))
+ dvt1w    = (210481)
+ k3       = ((10.8148)*(1-fem))
+ k3b      = (0)
+ nlx      = (1.42e-6)
+ dsub     = (1.89)
+ alpha0   = (5e-5)
+ alpha1   = (0.387818)
+ nfactor  = (2.75)
+ beta0    = (1000)
+ kt1      = (-0.587409)
+ ua1      = (1.00223e-12)
+ ub1      = (-2.06824e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.38925)
+ dlc      = (0.08424*0.5e-6)
+ dwc      = (-5.09577e-07)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=w_mos m=(ng)
cgs_frg (intg s) capacitor c=(cox*(lfr_s+lsovl)*lfring_s*sDOTmult2)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply*cfr_pld10_s_ply_met*sDOTmult+lfr_ct_ply*cfr_pld10_s_ply_m1ct*sDOTmult+lm1s*1.846448e-16*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply*cfr_pld10_d_ply_met*sDOTmult+lfr_ct_ply*cfr_pld10_d_ply_m1ct*sDOTmult+lm1d*1.846448e-16*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*0.3)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd)
dsd_a (intdx s) dbody_area area=(anhvhole)
dsd_p (intdx s) dbody_perim area=(pnhvhole)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/6.0)
resdrift (d intd) resistor r=(lm/(14.0*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=pld10_10hv_dfrt
ends

subckt pld10b_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    selfheat                       = 1
+    mode_rthcth                    = 1
+    sti_dummy                      = 0
+    gt_90v                         = 0
+    nsmm_delr_gox_pld10b_sphv_10hv = tmp_nsmm_delr_gox_pld10b_sphv_10hv
+    nsmm_dela_dw_pld10b_sphv_10hv  = tmp_nsmm_dela_dw_pld10b_sphv_10hv
+    nsmm_dela_vfb_pld10b_sphv_10hv = tmp_nsmm_dela_vfb_pld10b_sphv_10hv
+    nsmm_delr_mobref_pld10b_sphv_10hv = tmp_nsmm_delr_mobref_pld10b_sphv_10hv
+    nsmm_delr_rshl_pld10b_sphv_10hv = tmp_nsmm_delr_rshl_pld10b_sphv_10hv
+    nsmm_delr_nsub_pld10b_sphv_10hv = tmp_nsmm_delr_nsub_pld10b_sphv_10hv
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcirondegrfac                  = (0.0)
+    offrondegrfac                  = (0.0)
+    hvgsvthdegr                    = (0.0)
+    hcidamage1                     = (0.0)
+    hcidamage2                     = (0.0)
+    offdamage1                     = (0.0)
+    offdamage2                     = (0.0)
+    hvgsdamage                     = (0.0)
+    presto_pld10b_vthratio         = 1.0
+    presto_pld10b_ronratio         = 0.01/0.6336
+    nde                            = (0)
+    nse                            = (2)
+    ns                             = ((ng+nse)/2)
+    nd                             = (ng/2)
+    ndi                            = (nd-nde)
+    nsi                            = (ns-nse)
+    ngeff                          = (ng+2*sti_dummy)
+    ng_dmy                         = (2*sti_dummy)
+    ndi_eff                        = (ngeff/2)
+    nsi_eff                        = ((ngeff-2)/2)
+    e_toxrel_10hv                  = (3.9)
+    fscale                         = (1)
+    l                              = (0.25)
+    wum                            = (w*fscale)
+    lum                            = (l*fscale)
+    wdrift_um                      = (w*fscale)
+    ldrift_um                      = (0.36*fscale)
+    ldr1_um                        = (0.5*fscale)
+    lacts                          = (0.66)
+    lactd                          = (0.33)
+    ldr1                           = (0.5)
+    ldrift                         = (0.36)
+    wg2nhv                         = (0.6)
+    as_xdr                         = (1e-18)
+    ps_xdr                         = (1e-18)
+    ad_xdr                         = ((ldr1-0.2)*(w+2*wg2nhv))
+    pd_xdr                         = (2*((ldr1-0.2)+(w+2*wg2nhv)))
+    ad2_xdr                        = ((lactd/2+ldr1+0.2)*(w+2*wg2nhv))
+    pd2_xdr                        = (2*(lactd/2+ldr1+0.2))
+    as_um                          = (as_xdr*fscale*fscale)
+    ps_um                          = (ps_xdr*fscale)
+    ad_um                          = (ad_xdr*fscale*fscale)
+    pd_um                          = (pd_xdr*fscale)
+    ad2_um                         = (ad2_xdr*fscale*fscale)
+    pd2_um                         = (pd2_xdr*fscale)
+    lg2dt                          = (1.77)
+    wg2dt                          = (1.35)
+    lg2g_d                         = (2*(ldr1+ldrift+lactd/2))
+    lg2g_s                         = (0.99)
+    xnbl_xdr                       = (lg2dt*nse+l*ngeff+lg2g_d*ndi_eff+lg2g_s*nsi_eff)
+    ynbl_xdr                       = (w+2*wg2dt)
+    dt_upsize                      = (0.75*2*gt_90v)
+    anbl_xdr                       = (xnbl_xdr*(ynbl_xdr+dt_upsize))
+    pnbl_xdr                       = (2*(xnbl_xdr+ynbl_xdr+dt_upsize))
+    djunc                          = (2.5*1e-06)
+    tfact_ecrit                    = (1+(tc1_ecrit_pld10b_sphv_10hv+tc2_ecrit_pld10b_sphv_10hv*(temp-tnom))*(temp-tnom))
+    perimeter__1__                 = ((((xnbl_xdr+t_dt))+((ynbl_xdr+t_dt)))*2)
+    w__1__                         = ((perimeter__1__)*1e-6)
+    l__1__                         = ((d_dt)*1e-6)
+    t_dielectric__1__              = ((t_ox_dt)*1e-6)
+    fac_cdt__1__                   = (1.820)
+    e0__1__                        = (8.854214871e-12)
+    df__1__                        = (t_dielectric__1__*(1+e0__1__*1e11*log(w__1__*l__1__*1e4+1))/3.14159265358979323846)
+    ctot__1__                      = (fac_cdt__1__*(w__1__+df__1__)*(l__1__+df__1__)*(e_toxrel_10hv)*e0__1__/t_dielectric__1__)
+    w_heat                         = (w)
+    l_heat                         = (lacts*nse+l*ng+lg2g_d*ndi+lg2g_s*nsi)
+    dtemp__1__                     = (temp-tnom)
+    tcr__1__                       = (1.0+dtemp__1__*((0)+dtemp__1__*(0)))
+    tcc__1__                       = (1.0+dtemp__1__*((0)+dtemp__1__*(0)))
+    area__1__                      = ((w_heat)*(l_heat))
+    aspr__1__                      = (max((w_heat),(l_heat))/min((w_heat),(l_heat)))
+    rth0__1__                      = (2150.6240)
+    c1__1__                        = (-0.5385)
+    c2__1__                        = (-0.2000)
+    rth                            = (rth0__1__*pow(area__1__,c1__1__)*pow(aspr__1__,c2__1__)*tcr__1__)
+    cth0__1__                      = (1.264e-11)
+    c11__2__                       = (0.8994)
+    c12__2__                       = (0.0482)
+    term_area_1__2__               = (c11__2__*log10(area__1__))
+    term_area_2__2__               = (c12__2__*pow(log10(area__1__),2))
+    cth                            = (cth0__1__*pow(10,term_area_1__2__+term_area_2__2__)*pow(aspr__1__,c2__1__)*tcc__1__)
+    rth_f                          = (((mode_rthcth==0)*1e12+(mode_rthcth==1)*rth*fac_rth_pld10b_sphv_10hv+(mode_rthcth==2)*rth*fac_rth_pld10b_sphv_10hv)*ngeff)
+    cth_f                          = (((mode_rthcth==1)*cth+(mode_rthcth==2)*cth)/ngeff)
+    delr_tox_pld10b_sphv_10hv      = (nom_delr_tox_pld10b_sphv_10hv*(1.0+nsig_delr_powermos_tox*sig_delr_tox_pld10b_sphv_10hv+nsmm_delr_gox_pld10b_sphv_10hv*smm_delr_gox_pld10b_sphv_10hv(l,w)/sqrt(ng/2)))
+    dela_dw_pld10b_sphv_10hv       = (nom_dela_dw_pld10b_sphv_10hv+nsig_dela_dw_pld10b_sphv_10hv*sig_dela_dw_pld10b_sphv_10hv+nsmm_dela_dw_pld10b_sphv_10hv*smm_dela_dw_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vfb_pld10b_sphv_10hv      = (nom_dela_vfb_pld10b_sphv_10hv+nsig_dela_vfb_pld10b_sphv_10hv*sig_dela_vfb_pld10b_sphv_10hv+nsmm_dela_vfb_pld10b_sphv_10hv*smm_dela_vfb_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dela_vtwl_pld10b_sphv_10hv     = (nom_dela_vtwl_pld10b_sphv_10hv+nsig_dela_vtwl_pld10b_sphv_10hv*sig_dela_vtwl_pld10b_sphv_10hv)
+    delr_mobref_pld10b_sphv_10hv   = (nom_delr_mobref_pld10b_sphv_10hv*(1.0+nsig_delr_mobref_pld10b_sphv_10hv*sig_delr_mobref_pld10b_sphv_10hv+nsmm_delr_mobref_pld10b_sphv_10hv*smm_delr_mobref_pld10b_sphv_10hv(l,w)/sqrt(ng/2)))
+    delr_rshl_pld10b_sphv_10hv     = (nom_delr_rshl_pld10b_sphv_10hv*(1.0+nsig_delr_rshl_pld10b_sphv_10hv*sig_delr_rshl_pld10b_sphv_10hv)+nsmm_delr_rshl_pld10b_sphv_10hv*smm_delr_rshl_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    delr_nsub_pld10b_sphv_10hv     = (1+nsmm_delr_nsub_pld10b_sphv_10hv*smm_delr_nsub_pld10b_sphv_10hv(l,w)/sqrt(ng/2))
+    dcbv_pld10b_10hv               = (16)
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    lchdrawn                       = (0.2)
+    laccdrawn                      = (0.55)
+    lchtcad                        = (0.369)
+    lacc                           = (0.324)
+    lflap                          = (0.225)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    swdrlin                        = (2)
+    fac_rshldd                     = ((swdrlin==0)+(swdrlin==2)*0.8529)
+    fac_a_ng_vfbo                  = -((ngeff/(ngeff+0.2)-2/(2+0.2))*0.48*(1-fem))
+    fac_r_ng_rshldd                = (1+(ngeff/(ngeff+1)-2/(2+1))*0.06*(1-fem))
+    fac_r_ng_uo                    = (1-(ngeff/(ngeff+1)-2/(2+1))*0.155*(1-fem))
+    fac_a_ng_thesato               = ((ngeff/(ngeff+2)-2/(2+2))*0.027*(1-fem)*0.7*w/(w+1.5*(1-fem)))

if (ng_dmy>=2) {
mamost_dmy (d s s s dtemp) sphvt_simkit w=wum l=lum ldrift=ldrift_um wdrift=wdrift_um ldr1=ldr1_um mult=ng_dmy ad=ad_um pd=pd_um as=as_um ps=ps_um ad2=ad2_um pd2=pd2_um
}

model sphvt_simkit sphvt
+ type     = (p)
+ tr       = (27)
+ swgeo    = (1)
+ swigate  = (0)
+ swimpact = (0)
+ swgidl   = (0)
+ swjunc   = (2)
+ swjunasym = (1)
+ swshe    = (selfheat*enable_selfheat)
+ swimpdr  = (0)
+ swdrlin  = (2)
+ swexp    = (0)
+ swdelvtac = (1)
+ swnud    = (0)
+ swptest  = (0)
+ swgedi   = (1)
+ qmc      = (qmc_pld10b_sphv_10hv)
+ lvaro    = (lvaro_pld10b_sphv_10hv)
+ lvarl    = (lvarl_pld10b_sphv_10hv)
+ lvarw    = (lvarw_pld10b_sphv_10hv*(1-fem))
+ lap      = (lap_pld10b_sphv_10hv)
+ wvaro    = (wvaro_pld10b_sphv_10hv*(1-fem))
+ wvarl    = (wvarl_pld10b_sphv_10hv*(1-fem))
+ wvarw    = (wvarw_pld10b_sphv_10hv*(1-fem))
+ wot      = ((wot_pld10b_sphv_10hv+0.5e-6*dela_dw_pld10b_sphv_10hv)*(1-fem))
+ dlq      = (dlq_pld10b_sphv_10hv)
+ dwq      = (dwq_pld10b_sphv_10hv*(1-fem))
+ vfbo     = (vfbo_pld10b_sphv_10hv+dela_vfb_pld10b_sphv_10hv+fac_a_ng_vfbo+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hvgsvthdegr)*presto_pld10b_vthratio)
+ vfbl     = (vfbl_pld10b_sphv_10hv)
+ vfbw     = (vfbw_pld10b_sphv_10hv*(1-fem))
+ vfblw    = ((vfblw_pld10b_sphv_10hv+dela_vtwl_pld10b_sphv_10hv)*(1-fem))
+ stvfbo   = (stvfbo_pld10b_sphv_10hv)
+ stvfbl   = (stvfbl_pld10b_sphv_10hv)
+ stvfbw   = (stvfbw_pld10b_sphv_10hv)
+ stvfblw  = (stvfblw_pld10b_sphv_10hv)
+ toxo     = (toxo_pld10b_sphv_10hv*delr_tox_pld10b_sphv_10hv)
+ epsroxo  = (epsroxo_pld10b_sphv_10hv)
+ nsubo    = (nsubo_pld10b_sphv_10hv*delr_nsub_pld10b_sphv_10hv)
+ nsubw    = (nsubw_pld10b_sphv_10hv*(1-fem))
+ wseg     = (wseg_pld10b_sphv_10hv)
+ npck     = (npck_pld10b_sphv_10hv)
+ npckw    = (npckw_pld10b_sphv_10hv*(1-fem))
+ wsegp    = (wsegp_pld10b_sphv_10hv)
+ lpck     = (lpck_pld10b_sphv_10hv)
+ lpckw    = (lpckw_pld10b_sphv_10hv*(1-fem))
+ fol1     = (fol1_pld10b_sphv_10hv)
+ fol2     = (fol2_pld10b_sphv_10hv)
+ facneffaco = (facneffaco_pld10b_sphv_10hv)
+ facneffacl = (facneffacl_pld10b_sphv_10hv)
+ facneffacw = (facneffacw_pld10b_sphv_10hv*(1-fem))
+ facneffaclw = (facneffaclw_pld10b_sphv_10hv*(1-fem))
+ gfacnudo = (gfacnudo_pld10b_sphv_10hv)
+ gfacnudl = (gfacnudl_pld10b_sphv_10hv)
+ gfacnudlexp = (gfacnudlexp_pld10b_sphv_10hv)
+ gfacnudw = (gfacnudw_pld10b_sphv_10hv*(1-fem))
+ gfacnudlw = (gfacnudlw_pld10b_sphv_10hv*(1-fem))
+ vsbnudo  = (vsbnudo_pld10b_sphv_10hv)
+ dvsbnudo = (dvsbnudo_pld10b_sphv_10hv)
+ vnsubo   = (vnsubo_pld10b_sphv_10hv)
+ nslpo    = (nslpo_pld10b_sphv_10hv)
+ dnsubo   = (dnsubo_pld10b_sphv_10hv)
+ dphibo   = (dphibo_pld10b_sphv_10hv)
+ dphibl   = (dphibl_pld10b_sphv_10hv)
+ dphiblexp = (dphiblexp_pld10b_sphv_10hv)
+ dphibw   = (dphibw_pld10b_sphv_10hv*(1-fem))
+ dphiblw  = (dphiblw_pld10b_sphv_10hv*(1-fem))
+ delvtaco = (delvtaco_pld10b_sphv_10hv)
+ delvtacl = (delvtacl_pld10b_sphv_10hv)
+ delvtaclexp = (delvtaclexp_pld10b_sphv_10hv)
+ delvtacw = (delvtacw_pld10b_sphv_10hv)
+ delvtaclw = (delvtaclw_pld10b_sphv_10hv)
+ npo      = (npo_pld10b_sphv_10hv)
+ npl      = (npl_pld10b_sphv_10hv)
+ cto      = (cto_pld10b_sphv_10hv)
+ ctl      = (ctl_pld10b_sphv_10hv)
+ ctlexp   = (ctlexp_pld10b_sphv_10hv)
+ ctw      = (ctw_pld10b_sphv_10hv*(1-fem))
+ ctlw     = (ctlw_pld10b_sphv_10hv*(1-fem))
+ toxovo   = (toxovo_pld10b_sphv_10hv)
+ toxovdo  = (toxovdo_pld10b_sphv_10hv)
+ lov      = (lov_pld10b_sphv_10hv)
+ dlovd    = (dlovd_pld10b_sphv_10hv)
+ novo     = (novo_pld10b_sphv_10hv)
+ novdo    = (novdo_pld10b_sphv_10hv)
+ cfl      = (cfl_pld10b_sphv_10hv)
+ cflexp   = (cflexp_pld10b_sphv_10hv)
+ cfw      = (cfw_pld10b_sphv_10hv*(1-fem))
+ cfbo     = (cfbo_pld10b_sphv_10hv)
+ uo       = (uo_pld10b_sphv_10hv*delr_mobref_pld10b_sphv_10hv*fac_r_ng_uo*delr_u0_relimo)
+ fbet1    = (fbet1_pld10b_sphv_10hv)
+ fbet1w   = (fbet1w_pld10b_sphv_10hv*(1-fem))
+ lp1      = (lp1_pld10b_sphv_10hv)
+ lp1w     = (lp1w_pld10b_sphv_10hv*(1-fem))
+ fbet2    = (fbet2_pld10b_sphv_10hv)
+ lp2      = (lp2_pld10b_sphv_10hv)
+ betw1    = (betw1_pld10b_sphv_10hv*(1-fem))
+ betw2    = (betw2_pld10b_sphv_10hv*(1-fem))
+ wbet     = (wbet_pld10b_sphv_10hv)
+ stbeto   = (stbeto_pld10b_sphv_10hv)
+ stbetl   = (stbetl_pld10b_sphv_10hv)
+ stbetw   = (stbetw_pld10b_sphv_10hv)
+ stbetlw  = (stbetlw_pld10b_sphv_10hv)
+ mueo     = (mueo_pld10b_sphv_10hv)
+ muew     = (muew_pld10b_sphv_10hv*(1-fem))
+ stmueo   = (stmueo_pld10b_sphv_10hv)
+ themuo   = (themuo_pld10b_sphv_10hv)
+ stthemuo = (stthemuo_pld10b_sphv_10hv)
+ cso      = (cso_pld10b_sphv_10hv)
+ csl      = (csl_pld10b_sphv_10hv)
+ cslexp   = (cslexp_pld10b_sphv_10hv)
+ csw      = (csw_pld10b_sphv_10hv*(1-fem))
+ cslw     = (cslw_pld10b_sphv_10hv*(1-fem))
+ stcso    = (stcso_pld10b_sphv_10hv)
+ xcoro    = (xcoro_pld10b_sphv_10hv)
+ xcorl    = (xcorl_pld10b_sphv_10hv)
+ xcorw    = (xcorw_pld10b_sphv_10hv)
+ xcorlw   = (xcorlw_pld10b_sphv_10hv)
+ stxcoro  = (stxcoro_pld10b_sphv_10hv)
+ fetao    = (fetao_pld10b_sphv_10hv)
+ rsw1     = (rsw1_pld10b_sphv_10hv)
+ rsw2     = (rsw2_pld10b_sphv_10hv)
+ strso    = (strso_pld10b_sphv_10hv)
+ rsbo     = (rsbo_pld10b_sphv_10hv)
+ rsgo     = (rsgo_pld10b_sphv_10hv)
+ thesato  = (thesato_pld10b_sphv_10hv*0.958+fac_a_ng_thesato)
+ thesatl  = (thesatl_pld10b_sphv_10hv)
+ thesatlexp = (thesatlexp_pld10b_sphv_10hv)
+ thesatw  = (thesatw_pld10b_sphv_10hv*0.972*(1-fem))
+ thesatlw = (thesatlw_pld10b_sphv_10hv*(1-fem))
+ stthesato = (stthesato_pld10b_sphv_10hv)
+ stthesatl = (stthesatl_pld10b_sphv_10hv)
+ stthesatw = (stthesatw_pld10b_sphv_10hv)
+ stthesatlw = (stthesatlw_pld10b_sphv_10hv)
+ thesatbo = (thesatbo_pld10b_sphv_10hv)
+ thesatgo = (thesatgo_pld10b_sphv_10hv)
+ thesatgl = (thesatgl_pld10b_sphv_10hv)
+ thesatgw = (thesatgw_pld10b_sphv_10hv*(1-fem))
+ axo      = (axo_pld10b_sphv_10hv)
+ axl      = (axl_pld10b_sphv_10hv)
+ alpl     = (alpl_pld10b_sphv_10hv)
+ alplexp  = (alplexp_pld10b_sphv_10hv)
+ alpw     = (alpw_pld10b_sphv_10hv*(1-fem))
+ alp1l1   = (alp1l1_pld10b_sphv_10hv)
+ alp1lexp = (alp1lexp_pld10b_sphv_10hv)
+ alp1l2   = (alp1l2_pld10b_sphv_10hv)
+ alp1w    = (alp1w_pld10b_sphv_10hv*(1-fem))
+ alp2l1   = (alp2l1_pld10b_sphv_10hv)
+ alp2lexp = (alp2lexp_pld10b_sphv_10hv)
+ alp2l2   = (alp2l2_pld10b_sphv_10hv)
+ alp2w    = (alp2w_pld10b_sphv_10hv*(1-fem))
+ vpo      = (vpo_pld10b_sphv_10hv)
+ a1o      = (a1o_pld10b_sphv_10hv)
+ a1l      = (a1l_pld10b_sphv_10hv)
+ a1w      = (a1w_pld10b_sphv_10hv*(1-fem))
+ a2o      = (a2o_pld10b_sphv_10hv)
+ sta2o    = (sta2o_pld10b_sphv_10hv)
+ a3o      = (a3o_pld10b_sphv_10hv)
+ a3l      = (a3l_pld10b_sphv_10hv)
+ a3w      = (a3w_pld10b_sphv_10hv*(1-fem))
+ a4o      = (a4o_pld10b_sphv_10hv)
+ a4l      = (a4l_pld10b_sphv_10hv)
+ a4w      = (a4w_pld10b_sphv_10hv*(1-fem))
+ gcoo     = (gcoo_pld10b_sphv_10hv)
+ iginvlw  = (iginvlw_pld10b_sphv_10hv)
+ igovw    = (igovw_pld10b_sphv_10hv)
+ igovdw   = (igovdw_pld10b_sphv_10hv)
+ stigo    = (stigo_pld10b_sphv_10hv)
+ gc2o     = (gc2o_pld10b_sphv_10hv)
+ gc3o     = (gc3o_pld10b_sphv_10hv)
+ chibo    = (chibo_pld10b_sphv_10hv)
+ agidlw   = (agidlw_pld10b_sphv_10hv)
+ agidldw  = (agidldw_pld10b_sphv_10hv)
+ bgidlo   = (bgidlo_pld10b_sphv_10hv)
+ bgidldo  = (bgidldo_pld10b_sphv_10hv)
+ stbgidlo = (stbgidlo_pld10b_sphv_10hv)
+ stbgidldo = (stbgidldo_pld10b_sphv_10hv)
+ cgidlo   = (cgidlo_pld10b_sphv_10hv)
+ cgidldo  = (cgidldo_pld10b_sphv_10hv)
+ cgbovl   = (cgbovl_pld10b_sphv_10hv)
+ cfrw     = (cfrw_pld10b_sphv_10hv*(1-fem))
+ cfrdw    = (cfrdw_pld10b_sphv_10hv*(1-fem))
+ fnto     = (fnto_pld10b_sphv_10hv)
+ nfalw    = (nfalw_pld10b_sphv_10hv)
+ nfblw    = (nfblw_pld10b_sphv_10hv)
+ nfclw    = (nfclw_pld10b_sphv_10hv)
+ efo      = (efo_pld10b_sphv_10hv)
+ lintnoi  = (lintnoi_pld10b_sphv_10hv)
+ alpnoi   = (alpnoi_pld10b_sphv_10hv)
+ kvthoweo = (kvthoweo_pld10b_sphv_10hv)
+ kvthowel = (kvthowel_pld10b_sphv_10hv)
+ kvthowew = (kvthowew_pld10b_sphv_10hv)
+ kvthowelw = (kvthowelw_pld10b_sphv_10hv)
+ kuoweo   = (kuoweo_pld10b_sphv_10hv)
+ kuowel   = (kuowel_pld10b_sphv_10hv)
+ kuowew   = (kuowew_pld10b_sphv_10hv)
+ kuowelw  = (kuowelw_pld10b_sphv_10hv)
+ rgo      = (rgo_pld10b_sphv_10hv)
+ rsh      = (rsh_pld10b_sphv_10hv)
+ rbulko   = (rbulko_pld10b_sphv_10hv)
+ rwello   = (rwello_pld10b_sphv_10hv)
+ rjunso   = (rjunso_pld10b_sphv_10hv/(wum+dwrjunso_pld10b_sphv_10hv))
+ rjundo   = (rjundo_pld10b_sphv_10hv/(wum+dwrjundo_pld10b_sphv_10hv))
+ rint     = (rint_pld10b_sphv_10hv)
+ rvpoly   = (rvpoly_pld10b_sphv_10hv)
+ rshg     = (rshg_pld10b_sphv_10hv)
+ dlsil    = (dlsil_pld10b_sphv_10hv)
+ saref    = (saref_pld10b_sphv_10hv)
+ sbref    = (sbref_pld10b_sphv_10hv)
+ wlod     = (wlod_pld10b_sphv_10hv)
+ kuo      = (kuo_pld10b_sphv_10hv)
+ kvsat    = (kvsat_pld10b_sphv_10hv)
+ tkuo     = (tkuo_pld10b_sphv_10hv)
+ lkuo     = (lkuo_pld10b_sphv_10hv)
+ wkuo     = (wkuo_pld10b_sphv_10hv)
+ pkuo     = (pkuo_pld10b_sphv_10hv)
+ llodkuo  = (llodkuo_pld10b_sphv_10hv)
+ wlodkuo  = (wlodkuo_pld10b_sphv_10hv)
+ kvtho    = (kvtho_pld10b_sphv_10hv)
+ lkvtho   = (lkvtho_pld10b_sphv_10hv)
+ wkvtho   = (wkvtho_pld10b_sphv_10hv)
+ pkvtho   = (pkvtho_pld10b_sphv_10hv)
+ llodvth  = (llodvth_pld10b_sphv_10hv)
+ wlodvth  = (wlodvth_pld10b_sphv_10hv)
+ stetao   = (stetao_pld10b_sphv_10hv)
+ lodetao  = (lodetao_pld10b_sphv_10hv)
+ scref    = (scref_pld10b_sphv_10hv)
+ web      = (web_pld10b_sphv_10hv)
+ wec      = (wec_pld10b_sphv_10hv)
+ adr1o    = (adr1o_pld10b_sphv_10hv)
+ adr1l    = (adr1l_pld10b_sphv_10hv)
+ adr1w    = (adr1w_pld10b_sphv_10hv)
+ adr2o    = (adr2o_pld10b_sphv_10hv)
+ stadr2o  = (stadr2o_pld10b_sphv_10hv)
+ adr3o    = (adr3o_pld10b_sphv_10hv)
+ adr3l    = (adr3l_pld10b_sphv_10hv)
+ adr3w    = (adr3w_pld10b_sphv_10hv)
+ adr4o    = (adr4o_pld10b_sphv_10hv)
+ adr4l    = (adr4l_pld10b_sphv_10hv)
+ adr4w    = (adr4w_pld10b_sphv_10hv)
+ adr5o    = (adr5o_pld10b_sphv_10hv)
+ adr5l    = (adr5l_pld10b_sphv_10hv)
+ adr5w    = (adr5w_pld10b_sphv_10hv)
+ bidr1o   = (bidr1o_pld10b_sphv_10hv)
+ bidr1l   = (bidr1l_pld10b_sphv_10hv)
+ bidr1w   = (bidr1w_pld10b_sphv_10hv)
+ bidr2o   = (bidr2o_pld10b_sphv_10hv)
+ bidr2w   = (bidr2w_pld10b_sphv_10hv)
+ rtho     = ((selfheat*enable_selfheat>0)?rth_f:0.0)
+ rthl     = (0)
+ rthw     = (0)
+ rthlw    = (0)
+ strtho   = (strtho_pld10b_sphv_10hv)
+ ctho     = (cth_f)
+ cthl     = (0)
+ cthw     = (0)
+ cthlw    = (0)
+ rshldd   = ((rshldd_pld10b_sphv_10hv*delr_rshl_pld10b_sphv_10hv*fac_r_ng_rshldd*delr_rdsw_relimo*(1+(hcirondegrfac+offrondegrfac)*presto_pld10b_ronratio))*fac_rshldd)
+ xw       = (xw_pld10b_sphv_10hv*(1-fem))
+ nwxw     = (nwxw_pld10b_sphv_10hv*(1-fem))
+ xl       = (xl_pld10b_sphv_10hv)
+ xlw      = (xlw_pld10b_sphv_10hv*(1-fem))
+ dxlsat   = (dxlsat_pld10b_sphv_10hv)
+ nst      = (nst_pld10b_sphv_10hv)
+ ats      = (ats_pld10b_sphv_10hv)
+ dfinf    = (dfinf_pld10b_sphv_10hv)
+ dfw      = (dfw_pld10b_sphv_10hv*(1-fem))
+ dfl      = (dfl_pld10b_sphv_10hv)
+ dflw     = (dflw_pld10b_sphv_10hv*(1-fem))
+ dp       = (dp_pld10b_sphv_10hv)
+ ecrit    = (ecrit_pld10b_sphv_10hv*tfact_ecrit)
+ ecorn    = (ecorn_pld10b_sphv_10hv*tfact_ecrit)
+ du       = (du_pld10b_sphv_10hv)
+ tc1      = (tc1_pld10b_sphv_10hv)
+ tc2      = (tc2_pld10b_sphv_10hv)
+ tc1l     = (tc1l_pld10b_sphv_10hv)
+ tc2l     = (tc2l_pld10b_sphv_10hv)
+ tc1w     = (tc1w_pld10b_sphv_10hv)
+ tc2w     = (tc2w_pld10b_sphv_10hv)
+ theacc   = (theacc_pld10b_sphv_10hv)
+ theacc2  = (theacc2_pld10b_sphv_10hv)
+ aacc     = (aacc_pld10b_sphv_10hv)
+ rva      = (rva_pld10b_sphv_10hv)
+ dta      = (dta_pld10b_sphv_10hv)
+ trj      = (trj_pld10b_sphv_10hv)
+ cjarea   = (cjarea_pld10b_sphv_10hv)
+ cjlsti   = (cjlsti_pld10b_sphv_10hv)
+ cjlgat   = (cjlgat_pld10b_sphv_10hv)
+ vbiarea  = (vbiarea_pld10b_sphv_10hv)
+ vbisti   = (vbisti_pld10b_sphv_10hv)
+ vbigat   = (vbigat_pld10b_sphv_10hv)
+ parea    = (parea_pld10b_sphv_10hv)
+ psti     = (psti_pld10b_sphv_10hv)
+ pgat     = (pgat_pld10b_sphv_10hv)
+ is1area  = (is1area_pld10b_sphv_10hv)
+ ttarea   = (ttarea_pld10b_sphv_10hv)
+ is2area  = (is2area_pld10b_sphv_10hv)
+ irarea   = (irarea_pld10b_sphv_10hv)
+ stis1area = (stis1area_pld10b_sphv_10hv)
+ stis2area = (stis2area_pld10b_sphv_10hv)
+ stirarea = (stirarea_pld10b_sphv_10hv)
+ n1area   = (n1area_pld10b_sphv_10hv)
+ n2area   = (n2area_pld10b_sphv_10hv)
+ nrarea   = (nrarea_pld10b_sphv_10hv)
+ is1lsti  = (is1lsti_pld10b_sphv_10hv)
+ ttlsti   = (ttlsti_pld10b_sphv_10hv)
+ is2lsti  = (is2lsti_pld10b_sphv_10hv)
+ irlsti   = (irlsti_pld10b_sphv_10hv)
+ stis1sti = (stis1sti_pld10b_sphv_10hv)
+ stis2sti = (stis2sti_pld10b_sphv_10hv)
+ stirsti  = (stirsti_pld10b_sphv_10hv)
+ n1sti    = (n1sti_pld10b_sphv_10hv)
+ n2sti    = (n2sti_pld10b_sphv_10hv)
+ nrsti    = (nrsti_pld10b_sphv_10hv)
+ is1lgat  = (is1lgat_pld10b_sphv_10hv)
+ ttlgat   = (ttlgat_pld10b_sphv_10hv)
+ is2lgat  = (is2lgat_pld10b_sphv_10hv)
+ irlgat   = (irlgat_pld10b_sphv_10hv)
+ stis1gat = (stis1gat_pld10b_sphv_10hv)
+ stis2gat = (stis2gat_pld10b_sphv_10hv)
+ stirgat  = (stirgat_pld10b_sphv_10hv)
+ n1gat    = (n1gat_pld10b_sphv_10hv)
+ n2gat    = (n2gat_pld10b_sphv_10hv)
+ nrgat    = (nrgat_pld10b_sphv_10hv)
+ cjaread  = (cjaread_pld10b_sphv_10hv*cj0_junc_pld10b_d_body)
+ cjlstid  = (cjaread_pld10b_sphv_10hv*djunc*cj0_junc_pld10b_d_body)
+ cjlgatd  = (cjaread_pld10b_sphv_10hv*djunc*cj0_junc_pld10b_d_body)
+ vbiaread = (vbiaread_pld10b_sphv_10hv)
+ vbistid  = (vbistid_pld10b_sphv_10hv)
+ vbigatd  = (vbigatd_pld10b_sphv_10hv)
+ paread   = (paread_pld10b_sphv_10hv)
+ pstid    = (pstid_pld10b_sphv_10hv)
+ pgatd    = (pgatd_pld10b_sphv_10hv)
+ is1aread = (is1aread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ ttaread  = (ttaread_pld10b_sphv_10hv)
+ is2aread = (is2aread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ iraread  = (iraread_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1aread = (stis1aread_pld10b_sphv_10hv)
+ stis2aread = (stis2aread_pld10b_sphv_10hv)
+ stiraread = (stiraread_pld10b_sphv_10hv)
+ n1aread  = (n1aread_pld10b_sphv_10hv)
+ n2aread  = (n2aread_pld10b_sphv_10hv)
+ nraread  = (nraread_pld10b_sphv_10hv)
+ is1lstid = (is1lstid_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ ttlstid  = (ttlstid_pld10b_sphv_10hv)
+ is2lstid = (is2aread_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ irlstid  = (irlstid_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1stid = (stis1stid_pld10b_sphv_10hv)
+ stis2stid = (stis2stid_pld10b_sphv_10hv)
+ stirstid = (stirstid_pld10b_sphv_10hv)
+ n1stid   = (n1stid_pld10b_sphv_10hv)
+ n2stid   = (n2stid_pld10b_sphv_10hv)
+ nrstid   = (nrstid_pld10b_sphv_10hv)
+ is1lgatd = (is1lgatd_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ ttlgatd  = (ttlgatd_pld10b_sphv_10hv)
+ is2lgatd = (is2aread_pld10b_sphv_10hv*djunc*js_junc_pld10b_d_body)
+ irlgatd  = (irlgatd_pld10b_sphv_10hv*js_junc_pld10b_d_body)
+ stis1gatd = (stis1gatd_pld10b_sphv_10hv)
+ stis2gatd = (stis2gatd_pld10b_sphv_10hv)
+ stirgatd = (stirgatd_pld10b_sphv_10hv)
+ n1gatd   = (n1gatd_pld10b_sphv_10hv)
+ n2gatd   = (n2gatd_pld10b_sphv_10hv)
+ nrgatd   = (nrgatd_pld10b_sphv_10hv)
+ cjaread2 = (cjaread_pld10b_sphv_10hv)
+ cjlstid2 = (cjaread_pld10b_sphv_10hv*djunc)
+ vbiaread2 = (vbiaread2_pld10b_sphv_10hv)
+ vbistid2 = (vbistid2_pld10b_sphv_10hv)
+ paread2  = (paread2_pld10b_sphv_10hv)
+ pstid2   = (pstid2_pld10b_sphv_10hv)
+ is1aread2 = (is1aread_pld10b_sphv_10hv)
+ ttaread2 = (ttaread2_pld10b_sphv_10hv)
+ is2aread2 = (is2aread_pld10b_sphv_10hv)
+ iraread2 = (iraread2_pld10b_sphv_10hv)
+ stis1aread2 = (stis1aread_pld10b_sphv_10hv)
+ stis2aread2 = (stis2aread_pld10b_sphv_10hv)
+ stiraread2 = (stiraread2_pld10b_sphv_10hv)
+ n1aread2 = (n1aread2_pld10b_sphv_10hv)
+ n2aread2 = (n2aread2_pld10b_sphv_10hv)
+ nraread2 = (nraread2_pld10b_sphv_10hv)
+ is1lstid2 = (is1aread_pld10b_sphv_10hv*djunc)
+ ttlstid2 = (ttlstid2_pld10b_sphv_10hv)
+ is2lstid2 = (is2aread_pld10b_sphv_10hv*djunc)
+ irlstid2 = (irlstid2_pld10b_sphv_10hv)
+ stis1stid2 = (stis1stid2_pld10b_sphv_10hv)
+ stis2stid2 = (stis2stid2_pld10b_sphv_10hv)
+ stirstid2 = (stirstid2_pld10b_sphv_10hv)
+ n1stid2  = (n1stid2_pld10b_sphv_10hv)
+ n2stid2  = (n2stid2_pld10b_sphv_10hv)
+ nrstid2  = (nrstid2_pld10b_sphv_10hv)
+ eais1area = (eais1area_pld10b_sphv_10hv)
+ eais2area = (eais2area_pld10b_sphv_10hv)
+ eairarea = (eairarea_pld10b_sphv_10hv)
+ eais1sti = (eais1sti_pld10b_sphv_10hv)
+ eais2sti = (eais2sti_pld10b_sphv_10hv)
+ eairsti  = (eairsti_pld10b_sphv_10hv)
+ eais1gat = (eais1gat_pld10b_sphv_10hv)
+ eais2gat = (eais2gat_pld10b_sphv_10hv)
+ eairgat  = (eairgat_pld10b_sphv_10hv)
+ eais1aread = (eais1aread_pld10b_sphv_10hv)
+ eais2aread = (eais2aread_pld10b_sphv_10hv)
+ eairaread = (eairaread_pld10b_sphv_10hv)
+ eais1stid = (eais1stid_pld10b_sphv_10hv)
+ eais2stid = (eais2stid_pld10b_sphv_10hv)
+ eairstid = (eairstid_pld10b_sphv_10hv)
+ eais1gatd = (eais1gatd_pld10b_sphv_10hv)
+ eais2gatd = (eais2gatd_pld10b_sphv_10hv)
+ eairgatd = (eairgatd_pld10b_sphv_10hv)
+ eais1aread2 = (eais1aread2_pld10b_sphv_10hv)
+ eais2aread2 = (eais2aread2_pld10b_sphv_10hv)
+ eairaread2 = (eairaread2_pld10b_sphv_10hv)
+ eais1stid2 = (eais1stid2_pld10b_sphv_10hv)
+ eais2stid2 = (eais2stid2_pld10b_sphv_10hv)
+ eairstid2 = (eairstid2_pld10b_sphv_10hv)
+ ikfarea  = (ikfarea_pld10b_sphv_10hv)
+ ikflsti  = (ikfarea_pld10b_sphv_10hv*djunc)
+ ikflgat  = (ikfarea_pld10b_sphv_10hv*djunc)
+ stikfarea = (stikfarea_pld10b_sphv_10hv)
+ stikfsti = (stikfarea_pld10b_sphv_10hv)
+ stikfgat = (stikfarea_pld10b_sphv_10hv)
+ ikfaread = (ikfaread_pld10b_sphv_10hv*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflstid = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflgatd = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikfaread2 = (ikfaread_pld10b_sphv_10hv*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ ikflstid2 = (ikfaread_pld10b_sphv_10hv*djunc*(w/(w+dwikfaread_pld10b_sphv_10hv)))
+ stikfaread = (stikfaread_pld10b_sphv_10hv)
+ stikfstid = (stikfaread_pld10b_sphv_10hv)
+ stikfgatd = (stikfaread_pld10b_sphv_10hv)
+ stikfaread2 = (stikfaread_pld10b_sphv_10hv)
+ stikfstid2 = (stikfaread_pld10b_sphv_10hv)

model dbodybv diode
+ allow_scaling = (yes)
+ jmax     = (1e12)
+ jmelt    = (1e12)
+ tnom     = (27)
+ is       = (1e-30)
+ n        = (1.0)
+ cj       = (1e-30)
+ pta      = (0)
+ tlevc    = (2)
+ tlev     = (2)
+ bv       = (dcbv_pld10b_10hv+bvdss_shift)
+ ibv      = (1e-5/1e-12)
xdsub (s sub) cdgoptub_box_sub_10hv area=(anbl_xdr*(1-lpe)) perim=(pnbl_xdr*(1-lpe)) soa=1
mamost (d intg s s dtemp) sphvt_simkit w=wum l=lum ldrift=ldrift_um wdrift=wdrift_um ldr1=ldr1_um mult=ng ad=ad_um pd=pd_um as=as_um ps=ps_um ad2=ad2_um pd2=pd2_um
rgate (g intg) resistor r=(rply*((w+2*0.3)/((lchdrawn+laccdrawn)*3*ng)))
dbodybv (d rd) dbodybv area=((ad_um+ad2_um)*ngeff)
rlimit (rd s) resistor r=0.01

include "./smos10hv_ade_dfrt.scs" section=pld10b_10hv_dfrt
ends

subckt pld30_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld30_10hv_gox       = tmp_nsmm_delr_pld30_10hv_gox
+    nsmm_dela_pld30_10hv_vfb       = tmp_nsmm_dela_pld30_10hv_vfb
+    nsmm_delr_pld30_10hv_nsub      = tmp_nsmm_delr_pld30_10hv_nsub
+    nsmm_dela_pld30_10hv_vtl       = tmp_nsmm_dela_pld30_10hv_vtl
+    nsmm_dela_pld30_10hv_dwox      = tmp_nsmm_dela_pld30_10hv_dwox
+    nsmm_delr_pld30_10hv_ubref     = tmp_nsmm_delr_pld30_10hv_ubref
+    nsmm_delr_pld30_10hv_rsh       = tmp_nsmm_delr_pld30_10hv_rsh
+    nsmm_dela_pld30_10hv_vtw       = tmp_nsmm_dela_pld30_10hv_vtw
+    l                              = (0.5)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld30_vthratio          = 1.0
+    presto_pld30_betaratio         = 1
+    delr_pld30_10hv_tox            = (nom_delr_pld30_10hv_tox*(1+sig_delr_pld30_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld30_10hv_gox*smm_delr_pld30_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_pld30_10hv_uch            = (nom_delr_pld30_10hv_uch*(1+sig_delr_pld30_10hv_uch*nsig_delr_pld30_10hv_uch+nsmm_delr_pld30_10hv_ubref*smm_delr_pld30_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_pld30_10hv_res            = (nom_delr_pld30_10hv_res*(1+sig_delr_pld30_10hv_res*nsig_delr_pld30_10hv_res+nsmm_delr_pld30_10hv_rsh*smm_delr_pld30_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_pld30_10hv_vfb            = (nom_dela_pld30_10hv_vfb+(sig_dela_pld30_10hv_vfb*nsig_dela_pld30_10hv_vfb)+nsmm_dela_pld30_10hv_vfb*smm_dela_pld30_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_pld30_10hv_vtl*smm_dela_pld30_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_pld30_10hv_vtw*smm_dela_pld30_10hv_vtw(l,w)/sqrt(1*ng)/w)
+    dela_pld30_10hv_dwmos          = (nom_dela_pld30_10hv_dwmos+(sig_dela_pld30_10hv_dwmos*nsig_dela_pld30_10hv_dwmos)+(nsmm_dela_pld30_10hv_dwox*smm_dela_pld30_10hv_dwox(l,w)/sqrt(1*ng)))
+    dela_pld30_10hv_vtw            = (nom_dela_pld30_10hv_vtw+(sig_dela_pld30_10hv_vtw*nsig_dela_pld30_10hv_vtw))
+    dela_pld30_10hv_dwres          = (nom_dela_pld30_10hv_dwres+(sig_dela_pld30_10hv_dwres*nsig_dela_pld30_10hv_dwres))
+    delr_pld30_10hv_nsub           = (1+nsmm_delr_pld30_10hv_nsub*smm_delr_pld30_10hv_nsub(l,w)/sqrt(1*ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld30_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    coxfieldfr                     = (cfr_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.5)
+    lchtcad                        = (0.645)
+    lch                            = (0.645)
+    laccdrawn                      = (0.6)
+    lacc                           = (0.398)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (0.88)
+    lsrc                           = (0.495)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (0.275)
+    xiso                           = (1.275)
+    yiso                           = (2.85)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr_s                          = (0.112161+(0.0644068/(w**1.58152)))
+    dw_mos                         = (0)
+    dw_res                         = (0.226705+dela_pld30_10hv_dwres)
+    lcheff                         = (0.645)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(1.021037e-1/(w**2)))*(1-fem))
+    xnhvhole                       = (ld+lacc)
+    ynhvhole                       = (w+2*1.55)
+    anhvhole                       = (xnhvhole*ynhvhole*ng)
+    pnhvhole                       = ((ynhvhole+2*xnhvhole)*ng)
+    rsda                           = (233012/anhvhole)
+    rsdp                           = (604855/pnhvhole)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    aplyfld_s                      = ((1.55*(lsovl+lch)+0.55*(ld+lacc))*2*ng)
+    aplyfld_d                      = (((1.55*lacc)*2+(w+2*1.55)*lflap+0.95*1.21)*ng)
+    area_accum                     = (lacc*w*ng)
+    lfring_s                       = (w*ng)
+    lfring_d                       = ((w+2*0.6+(ld-lflap)*2)*ng)
+    nb_ct_ply                      = (int_round((w-(0.18+0.08*2))/(0.18*2))+1)
+    lfr_ct_ply                     = (nb_ct_ply*0.18*ng)
+    lfr_m1_ply                     = (ng*w-lfr_ct_ply)
+    lm                             = (ld+0)
+    nd                             = (2.54866e+20)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.00204992/delr_pld30_10hv_res)*(1+(-0.0049126*deltee)+(1.14433e-05*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.000339417)
+    aphi_tnom                      = (aphi_junc_pld30_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_pld30_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_pld30_d_body)
+    pphi_tnom                      = (pphi_junc_pld30_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_pld30_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_pld30_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_pld30_d_body))*1.0e12)
+ n             = (ajnd_junc_pld30_d_body)
+ cj            = ((((acj0_junc_pld30_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_pld30_d_body)
+ xti           = (axti_junc_pld30_d_body)
+ bv            = (40+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_pld30_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_pld30_d_body)
+ gap2          = (abetaeg_junc_pld30_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_pld30_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_pld30_d_body)
+ cj            = ((((pcj0_junc_pld30_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_pld30_d_body)
+ xti           = (pxti_junc_pld30_d_body)
+ bv            = (40+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_pld30_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_pld30_d_body)
+ gap2          = (pbetaeg_junc_pld30_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld30_10hv_tox)
+ nch      = (5.66e16*delr_pld30_10hv_nsub)
+ nsub     = (5.23e16*delr_pld30_10hv_nsub)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((1.91508e-07+0.5e-6*dela_pld30_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = ((0.800112)*(1-fem))
+ ww       = ((-5.935754e-14)*(1-fem))
+ wwn      = ((0.99276)*(1-fem))
+ wwl      = ((3.37425e-21)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((3.14194+(1.728067/(w+-0.55))*(1-fem))*(1+0.00441443*(temp-27)+-2.88816e-05*(temp-27)*(temp-27)))
+ vfb      = (-0.548859+dela_pld30_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld30_vthratio)
+ a0       = (0.403104*delr_a0_relimo)
+ b0       = (8.93124e-11)
+ b1       = (0.0)
+ a1       = (0)
+ a2       = (1)
+ u0       = ((199.996*delr_pld30_10hv_uch)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld30_betaratio))
+ ua       = (6.47551e-10)
+ ub       = (8.97971e-18)
+ vsat     = (41441.7)
+ drout    = (0.6)
+ pclm     = (0.55)
+ pvag     = (0)
+ pdiblc1  = (0.000039)
+ pdiblc2  = (0.00086)
+ delta    = (0.0164987)
+ rdsw     = ((0)*delr_rdsw_relimo)
+ wr       = (1)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.00048)
+ etab     = (0)
+ voffcv   = (-0.125)
+ noff     = (4)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = ((0.14633+dela_pld30_10hv_vtw)*(1-fem))
+ dvt1w    = (75770)
+ k3       = ((1.5)*(1-fem))
+ k3b      = (0)
+ nlx      = (0)
+ dsub     = (2.4)
+ alpha0   = (0.9e-5)
+ alpha1   = (0.52)
+ nfactor  = (1.35)
+ voff     = (-0.12)
+ beta0    = (410)
+ kt1      = (-0.46871)
+ ua1      = (2.52048e-11)
+ ub1      = (-4.48256e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.69286)
+ dlc      = (4.15445e-08)
+ dwc      = (-2.7402e-07)
+ wwlc     = (-12.60385e-21)
+ at       = (33000)
+ noia     = (9.9e18)*4.5
+ noib     = (2.4e3)*90
+ noic     = (1.4e-12)*4
+ em       = (4.1e7)
+ af       = (1.0)
+ ef       = (1.0)
+ kf       = (0.0)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
cgs_frg (intg s) capacitor c=(cox*(lfr_s+lsovl)*lfring_s*sDOTmult2)
cgd_frg (intg d) capacitor c=(coxfieldfr*(0.1)*lfring_d*sDOTmult)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=(lfr_m1_ply*cfr_pld30_s_ply_met*sDOTmult+lfr_ct_ply*cfr_pld30_s_ply_m1ct*sDOTmult)
cgd_m1 (intg d) capacitor c=(lfr_m1_ply*cfr_pld30_d_ply_met*sDOTmult+lfr_ct_ply*cfr_pld30_d_ply_m1ct*sDOTmult)
rgate (g intg) resistor r=(rply*((w+2*1.875)/((lch+lacc)*3*ng)))
rx (intdx d) resistor r=(rsd)
dsd_a (intdx s) dbody_area area=(anhvhole)
dsd_p (intdx s) dbody_perim area=(pnhvhole)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)+1e-12) perim=(psub*(1-lpe)+1e-12) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/24.0)
resdrift (d intd) resistor r=(lm/(2.15*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=pld30_10hv_dfrt
ends

subckt pld45_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_pld45_10hv_gox       = tmp_nsmm_delr_pld45_10hv_gox
+    nsmm_dela_pld45_10hv_vfb       = tmp_nsmm_dela_pld45_10hv_vfb
+    nsmm_delr_pld45_10hv_nsub      = tmp_nsmm_delr_pld45_10hv_nsub
+    nsmm_dela_pld45_10hv_dwox      = tmp_nsmm_dela_pld45_10hv_dwox
+    nsmm_delr_pld45_10hv_ubref     = tmp_nsmm_delr_pld45_10hv_ubref
+    nsmm_delr_pld45_10hv_rsh       = tmp_nsmm_delr_pld45_10hv_rsh
+    l                              = (0.05)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_pld45_vthratio          = 1.0
+    presto_pld45_betaratio         = 1
+    delr_pld45_10hv_tox            = (nom_delr_pld45_10hv_tox*(1+sig_delr_pld45_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_pld45_10hv_gox*smm_delr_pld45_10hv_gox(l,w,ng)))
+    delr_pld45_10hv_uch            = (nom_delr_pld45_10hv_uch*(1+sig_delr_pld45_10hv_uch*nsig_delr_pld45_10hv_uch+nsmm_delr_pld45_10hv_ubref*smm_delr_pld45_10hv_ubref(l,w,ng)))
+    delr_pld45_10hv_res            = (nom_delr_pld45_10hv_res*(1+sig_delr_pld45_10hv_res*nsig_delr_pld45_10hv_res+nsmm_delr_pld45_10hv_rsh*smm_delr_pld45_10hv_rsh(l,w,ng)))
+    dela_pld45_10hv_vfb            = (nom_dela_pld45_10hv_vfb+(sig_dela_pld45_10hv_vfb*nsig_dela_pld45_10hv_vfb)+nsmm_dela_pld45_10hv_vfb*smm_dela_pld45_10hv_vfb(l,w,ng))
+    dela_pld45_10hv_dwmos          = (nom_dela_pld45_10hv_dwmos+(sig_dela_pld45_10hv_dwmos*nsig_dela_pld45_10hv_dwmos)+(nsmm_dela_pld45_10hv_dwox*smm_dela_pld45_10hv_dwox(l,w,ng)))
+    dela_pld45_10hv_dwres          = (nom_dela_pld45_10hv_dwres+(sig_dela_pld45_10hv_dwres*nsig_dela_pld45_10hv_dwres))
+    dela_pld45_10hv_vtw            = (nom_dela_pld45_10hv_vtw+(sig_dela_pld45_10hv_vtw*nsig_dela_pld45_10hv_vtw))
+    delr_pld45_10hv_nsub           = (1+nsmm_delr_pld45_10hv_nsub*smm_delr_pld45_10hv_nsub(l,w,ng))
+    tn                             = (27+273.15)
+    delt                           = (temp+273.15-tn)
+    epsox                          = (3.9*8.85e-12)
+    tox                            = (132.44*1e-10*delr_pld45_10hv_tox)
+    cox                            = (cpp_ply_sdt)
+    cox_accum                      = (epsox/tox)
+    coxfield                       = (cpp_ply_fld)
+    rs_poly_gate                   = (nom_rs_poly_silicide*nom_delr_rs_poly_silicide*(1+nsig_delr_rs_poly_silicide*sig_delr_rs_poly_silicide))
+    rply                           = (rs_poly_gate*(1+(delt*tcr_inf_poly_silicide)+(delt*delt*tcr2_inf_poly_silicide)))
+    lchdrawn                       = (0.05)
+    laccdrawn                      = (1.0)
+    lchtcad                        = (0.432)
+    lacc                           = (0.559)
+    dlacc                          = (0.310)
+    lch                            = (0.432)
+    lsovl                          = (lchdrawn+laccdrawn-lch-lacc)
+    ld                             = (1.745)
+    lsrc                           = (0.55)
+    lcell                          = (lsrc+lchdrawn+laccdrawn+ld)
+    lflap                          = (0.85)
+    xiso                           = (1.275)
+    yiso                           = (4.10)
+    n_drn                          = (ng/2)
+    n_src                          = ((ng+2)/2)
+    lfr                            = (0.0306142+(0.2/(w**1.0)))
+    dw_mos                         = (0)
+    dw_accum                       = (0.08)
+    dw_res                         = (0.293631+dela_pld45_10hv_dwres)
+    lcheff                         = (0.432)
+    w_mos                          = (w+dw_mos*(1-fem))
+    w_res                          = (w+(dw_res+(-0.101176)/(w**0.7889))*(1-fem))
+    rnhv                           = (1.36)
+    xnhvhole                       = (ld+laccdrawn)
+    ynhvhole                       = (w+2*1.725)
+    anhvhole                       = (((xnhvhole*ynhvhole)+(xnhvhole-rnhv)*rnhv*2+0.5*pi4models*rnhv*rnhv)*ng)
+    pnhvhole                       = ((ynhvhole+(xnhvhole-rnhv)*2+pi4models*rnhv)*ng)
+    rsda                           = (370355/anhvhole)
+    rsdp                           = (5229.8/pnhvhole)
+    rsd                            = (rsda*rsdp/(rsda+rsdp))
+    xsub                           = (2*xiso+(lcell*ng))
+    ysub                           = (2*yiso+w)
+    asub                           = (xsub*ysub)
+    psub                           = (2*(xsub+ysub))
+    lpoly                          = (lchdrawn+laccdrawn+lflap)
+    latdiff                        = (lch-lchdrawn)
+    rnhvdiff                       = (1.36-latdiff)
+    aplyfld_d_tab                  = ((0.5*pi4models*(rnhvdiff*rnhvdiff)+2*(lacc+ld-rnhvdiff)*rnhvdiff+2*(lacc+ld)*0.915+2*(lacc+lflap)*0.825)*ng)
+    aplyfld_d                      = (aplyfld_d_tab+lflap*w*ng)
+    aplytab                        = ((2.275*1.79+lpoly*3.55*2)*ng)
+    aplyfld_s                      = (aplytab-aplyfld_d_tab)
+    area_accum                     = ((lacc+dlacc)*(w+dw_accum*(1-fem))*ng)
+    lfring                         = (w*ng)
+    nb_ct_ply_s                    = (int_round((w-(0.18+0.16*2))/(0.18*2))+1)
+    nb_ct_ply_d                    = (int_round((w-(0.18+0.08*2))/(0.18+0.24))+1)
+    lfr_ct_ply_s                   = (nb_ct_ply_s*0.18*ng)
+    lfr_ct_ply_d                   = (nb_ct_ply_d*0.18*ng)
+    lfr_m1_ply_s                   = (ng*(w+2*0.555)-lfr_ct_ply_s)
+    lfr_m1_ply_d                   = (ng*(w+2*0.555)-lfr_ct_ply_d)
+    lm                             = (ld+0)
+    nd                             = (1.01458e+20)
+    deltee                         = (temp+273.15-tn)
+    uu                             = ((0.00163975/delr_pld45_10hv_res)*(1+(-0.00551081*0.939*deltee)+(1.50497e-05*0.740*deltee*deltee)))
+    qq                             = (1.602189e-19)
+    xj                             = (0.000274177)
+    aphi_tnom                      = (aphi_junc_pld45_d_body)
+    aphi_calc                      = (aphi_tnom-pta_junc_pld45_d_body*(temp-tnom))
+    aphi_temp                      = (maxmodels(0.1,aphi_calc))
+    aphi_tf                        = (aphi_tnom/aphi_temp)
+    aexm                           = (aexm_junc_pld45_d_body)
+    pphi_tnom                      = (pphi_junc_pld45_d_body)
+    pphi_calc                      = (pphi_tnom-ptp_junc_pld45_d_body*(temp-tnom))
+    pphi_temp                      = (maxmodels(0.1,pphi_calc))
+    pphi_tf                        = (pphi_tnom/pphi_temp)
+    pexm                           = (pexm_junc_pld45_d_body)

model dbody_area diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((ajs_junc_pld45_d_body))*1.0e12)
+ n             = (ajnd_junc_pld45_d_body)
+ cj            = ((((acj0_junc_pld45_d_body)*(aphi_tf**aexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,aphi_calc))
+ mj            = (aexm_junc_pld45_d_body)
+ xti           = (axti_junc_pld45_d_body)
+ bv            = (59+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (aeg_junc_pld45_d_body)
+ tlev          = (2)
+ gap1          = (aalphaeg_junc_pld45_d_body)
+ gap2          = (abetaeg_junc_pld45_d_body)

model dbody_perim diode
+ allow_scaling = (yes)
+ imax          = (1.0e12)
+ imelt         = (1.0e12)
+ tnom  = (27)
+ is            = (((pjs_junc_pld45_d_body/sDOTmult))*1.0e12)
+ n             = (pjnd_junc_pld45_d_body)
+ cj            = ((((pcj0_junc_pld45_d_body/sDOTmult)*(pphi_tf**pexm)))*1.0e12)
+ pta           = (0)
+ tlevc         = (2)
+ vj            = (maxmodels(0.1,pphi_calc))
+ mj            = (pexm_junc_pld45_d_body)
+ xti           = (pxti_junc_pld45_d_body)
+ bv            = (59+bvdss_shift)
+ ibv           = (((1e-5))*1.0e12)
+ fc            = (0.9)
+ eg            = (peg_junc_pld45_d_body)
+ tlev          = (2)
+ gap1          = (palphaeg_junc_pld45_d_body)
+ gap2          = (pbetaeg_junc_pld45_d_body)

model nmosmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld45_10hv_tox)
+ nch      = (2.2e16*delr_pld45_10hv_nsub)
+ nsub     = (2.47e16*delr_pld45_10hv_nsub)
+ nlx      = (4.41636e-6)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((3.9209e-8+0.5e-6*dela_pld45_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1.0)
+ ww       = ((0)*(1-fem))
+ wwn      = (1.0)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((4)*(1+-0.0242475*(temp-27)+-0.000151733*(temp-27)*(temp-27)))
+ vfb      = (0.20814+dela_pld45_10hv_vfb+dela_vth_relimo+(nbtivthdegr+pbtivthdegr+hcivthdegr)*presto_pld45_vthratio)
+ a0       = ((0.2)*delr_a0_relimo)
+ a1       = (0)
+ a2       = (1)
+ u0       = ((406.988*delr_pld45_10hv_uch)*delr_u0_relimo*(1.0-hcibetdegrfac*presto_pld45_betaratio))
+ ua       = (6.1892e-10)
+ ub       = (1.07097e-18)
+ vsat     = (47786.1)
+ drout    = (5.6)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.15)
+ rdsw     = ((50)*delr_rdsw_relimo)
+ wr       = (1)
+ prwg     = (0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.048)
+ etab     = (0)
+ noff     = (4.0)
+ voffcv   = (0)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0.01983+dela_pld45_10hv_vtw)
+ dvt1w    = (2.9e+05)
+ k3       = (12.6)
+ k3b      = (0)
+ dsub     = (1.4)
+ alpha0   = (0)
+ alpha1   = (0.00)
+ nfactor  = (7.2)
+ voff     = (-0.45)
+ beta0    = (0)
+ kt1      = (-0.628195)
+ ua1      = (2.83064e-10)
+ ub1      = (-8.99476e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.1891)
+ dlc      = (0.210e-6)
+ dwc      = (0)
+ at       = (33000)
+ noia     = (1.249e+20)
+ noib     = (726308)
+ noic     = (4.724e-11)
+ ef       = (1.0)

model nmcapmodel bsim3v3 type=p version=3.2
+ diomod   = (0)
+ minr     = (1e-4)
+ vbox     = (500)
+ tnom     = (27)
+ noimod   = (2)
+ wmax     = (10)
+ tox      = (132.44*1e-10*delr_pld45_10hv_tox)
+ nch      = (1.0e16)
+ nsub     = (2.47e14)
+ nlx      = (0)
+ xt       = (1.55e-7)
+ capmod   = (3)
+ wint     = ((3.9209e-8+0.5e-6*dela_pld45_10hv_dwmos)*(1-fem))
+ wl       = ((0)*(1-fem))
+ wln      = (1.0)
+ ww       = ((0)*(1-fem))
+ wwn      = (1.0)
+ wwl      = ((0)*(1-fem))
+ dwg      = ((0)*(1-fem))
+ ags      = ((4)*(1+-0.0242475*(temp-27)+-0.000151733*(temp-27)*(temp-27)))
+ vfb      = (-0.35+dela_pld45_10hv_vfb)
+ a0       = (0.2)
+ a1       = (0)
+ a2       = (1)
+ u0       = (406.988*delr_pld45_10hv_uch)
+ ua       = (6.1892e-10)
+ ub       = (1.07097e-18)
+ vsat     = (47786.1)
+ drout    = (5.6)
+ pclm     = (0.5)
+ pvag     = (0)
+ pdiblc1  = (3e-10)
+ pdiblc2  = (1.1849e-10)
+ delta    = (0.15)
+ rdsw     = (50)
+ wr       = (1)
+ prwg     = (0)
+ prt      = (0)
+ cgbo     = (0)
+ cgso     = (0)
+ cgsl     = (0)
+ cgdo     = (0)
+ cgdl     = (0)
+ cj       = (0)
+ cjsw     = (0)
+ cf       = (0)
+ pscbe1   = (1e-30)
+ pscbe2   = (1e-30)
+ eta0     = (0.048)
+ etab     = (0)
+ noff     = (4.0)
+ voffcv   = (0.1)
+ w0       = (0)
+ dvt0     = (0)
+ dvt0w    = (0.01983+dela_pld45_10hv_vtw)
+ dvt1w    = (2.9e+05)
+ k3       = (12.6)
+ k3b      = (0)
+ dsub     = (1.4)
+ alpha0   = (0)
+ alpha1   = (0.00)
+ nfactor  = (7.2)
+ voff     = (0)
+ beta0    = (0)
+ kt1      = (-0.628195)
+ ua1      = (2.83064e-10)
+ ub1      = (-8.99476e-18)
+ uc1      = (-5.6e-11)
+ ute      = (-1.1891)
+ dlc      = (1.5e-7)
+ dwc      = (0)
+ at       = (33000)

mpowermos (intd intg s s) nmosmodel l=lcheff w=w_mos m=(ng) ad=(1e-18) pd=(1e-18)
mpowercap (s intg s s) nmcapmodel l=lcheff w=w_mos m=(ng)
cgs_frg (intg s) capacitor c=(cox*(lfr+lsovl)*lfring*sDOTmult2)
cgs_fld (intg s) capacitor c=(coxfield*aplyfld_s*sDOTmult2)
cgd_fld (intg d) capacitor c=(coxfield*aplyfld_d*sDOTmult2)
cgs_m1 (intg s) capacitor c=((lfr_m1_ply_s*cfr_pld45_s_ply_met*sDOTmult+lfr_ct_ply_s*cfr_pld45_s_ply_m1ct*sDOTmult))
cgd_m1 (intg d) capacitor c=((lfr_m1_ply_d*cfr_pld45_d_ply_met*sDOTmult+lfr_ct_ply_d*cfr_pld45_d_ply_m1ct*sDOTmult))
rgate (g intg) resistor r=(rply*((w+2*3.325)/((lch+lacc)*3*ng)))
rx (d intdx) resistor r=(rsd)
dsd_a (intdx s) dbody_area area=(anhvhole)
dsd_p (intdx s) dbody_perim area=(pnhvhole)
xdsub (s sub) cdgoptub_box_sub_10hv area=(asub*(1-lpe)) perim=(psub*(1-lpe)) soa=1
capmos1 (intd intg) capacitor c=(cox_accum*area_accum*sDOTmult2*1e-12/50.0)
resdrift (d intd) resistor r=(lm/(10.65*w_res*xj*ng*qq*uu*nd))

include "./smos10hv_ade_dfrt.scs" section=pld45_10hv_dfrt
ends

subckt nld5_lvt_10hv (d g s sub)

parameters
+    w                              = 1.8
+    ng                             = 2
+    sti_dummy                      = 0
+    lpe                            = 0
+    fem                            = 0
+    soa                            = 1
+    nsmm_delr_nld5_lvt_10hv_gox    = tmp_nsmm_delr_nld5_lvt_10hv_gox
+    nsmm_dela_nld5_lvt_10hv_vfb    = tmp_nsmm_dela_nld5_lvt_10hv_vfb
+    nsmm_delr_nld5_lvt_10hv_nsub   = tmp_nsmm_delr_nld5_lvt_10hv_nsub
+    nsmm_dela_nld5_lvt_10hv_vtl    = tmp_nsmm_dela_nld5_lvt_10hv_vtl
+    nsmm_dela_nld5_lvt_10hv_dwox   = tmp_nsmm_dela_nld5_lvt_10hv_dwox
+    nsmm_delr_nld5_lvt_10hv_ubref  = tmp_nsmm_delr_nld5_lvt_10hv_ubref
+    nsmm_delr_nld5_lvt_10hv_rsh    = tmp_nsmm_delr_nld5_lvt_10hv_rsh
+    nsmm_dela_nld5_lvt_10hv_vtw    = tmp_nsmm_dela_nld5_lvt_10hv_vtw
+    l                              = (0.4)
+    dela_vth_relimo                = (0)
+    dela_vth_relimo_mod            = (0)
+    delr_u0_relimo                 = (1)
+    delr_rdsw_relimo               = (1)
+    delr_a0_relimo                 = (1)
+    presto_device_active           = (1)
+    nbtidamage                     = (0.0)
+    nbtivthdegr                    = (0.0)
+    pbtidamage                     = (0.0)
+    pbtivthdegr                    = (0.0)
+    hcidamage                      = (0.0)
+    hcivthdegr                     = (0.0)
+    hcibetdegrfac                  = (0.0)
+    presto_nld5_lvt_vthratio       = 1.0
+    presto_nld5_lvt_betaratio      = 1.286
+    relimo_ratio1_a_hci_nld5_lvt_10hv = (0.12244898)
+    relimo_ratio1_b_hci_nld5_lvt_10hv = (-1.02735102)
+    lg                             = (0.4)
+    stimod_on                      = (enable_sti==1)
+    nld5_lvt_10hv_del_vfb_sti_final = (0)
+    nld5_lvt_10hv_fac_nsub_sti_final = (1)
+    ngeff                          = ng+2*sti_dummy
+    nld5_lvt_10hv_fac_uch_sti_final = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*1.25))
+    nld5_lvt_10hv_fac_res_sti_final = ((1+(stimod_on)*(ngeff/(ngeff+0.2*(1-fem))-2/(2+0.2))*(-0.5)))
+    delr_nld5_lvt_10hv_tox         = (nom_delr_nld5_lvt_10hv_tox*(1+sig_delr_nld5_lvt_10hv_tox*nsig_delr_powermos_tox+nsmm_delr_nld5_lvt_10hv_gox*smm_delr_nld5_lvt_10hv_gox(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_uch         = (nom_delr_nld5_lvt_10hv_uch*nld5_lvt_10hv_fac_uch_sti_final*(1+sig_delr_nld5_lvt_10hv_uch*nsig_delr_nld5_lvt_10hv_uch+nsmm_delr_nld5_lvt_10hv_ubref*smm_delr_nld5_lvt_10hv_ubref(l,w)/sqrt(1*ng)))
+    delr_nld5_lvt_10hv_res         = (nom_delr_nld5_lvt_10hv_res*nld5_lvt_10hv_fac_res_sti_final*(1+sig_delr_nld5_lvt_10hv_res*nsig_delr_nld5_lvt_10hv_res+nsmm_delr_nld5_lvt_10hv_rsh*smm_delr_nld5_lvt_10hv_rsh(l,w)/sqrt(1*ng)))
+    dela_nld5_lvt_10hv_vfb         = (nom_dela_nld5_lvt_10hv_vfb+nld5_lvt_10hv_del_vfb_sti_final+(sig_dela_nld5_lvt_10hv_vfb*nsig_dela_nld5_lvt_10hv_vfb)+nsmm_dela_nld5_lvt_10hv_vfb*smm_dela_nld5_lvt_10hv_vfb(l,w)/sqrt(1*ng)+nsmm_dela_nld5_lvt_10hv_vtl*smm_dela_nld5_lvt_10hv_vtl(l,w)/sqrt(1*ng)/l+nsmm_dela_nld5_lvt_10hv_vtw*smm_dela_nld5_lvt_10hv_vtw(l,w)/sqrt(1*ng)/w)
