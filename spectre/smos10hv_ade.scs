



simulator lang=spectre

//******************************************************************
//*technology: smos10hv
//*
//*contacts:
//*=========
//*for modeling information contact:
//*
//*wuxia li
//*characterization manager
//*
//*analog design enablement (ade)
//*characterization and modeling group
//*
//*
//*technology information:
//*=======================
//*for device information contact:
//*smartmos technology center
//*smos development group
//*
//*qualified for simulator versions
//*==============================
//*mica	: 18.1.0
//*spectre: 23.10.562.isr11
//*simkit	: 6.1
//*afs 	: 2024.2_1 (siemens-amsv-)
//*
//*
//*revision history:
//*v3q_1  8/22/25    spice minor release v17.1 to include soa model udpates
//*                     soa rules updated based on v3.17er_06122025 provided by reliability team.
//*                       a>. temperature coefficient for diode fwd limits changes to 0.0006 from 0.006
//*                       b>. add fwd limit on v(b,d) for mos
//*                     updated parcheck2.va file to enable severity function for rpoly, rpoly0, rpoly_1meg.
//*v3q_0  10/21/24    final model release for v17
//*                     silicon based model update for nmos120
//*                     silicon based model update for pld120
//*                     silicon based model update for cfr120 and cfr120_m1m2m3
//*                     dc soa switched into multi-level method. some rules are updated including:
//*                         1, sub related soa rules are changed from -40v ~ 100v to -70v ~ 120v.
//*                         2, hv mos fwd voltage update from 1.2v to 5.5v for vsd/vds.
//*                         3, pmos10 and pld10b rules are updated for parameter gt_90v related.
//*                     esd soa rule update for nld90b
//*                     add fault model for npn_b.
//*                     add gt_90v instance parameter for pmos10 to support new soa rules
//*                     add 3rd temperature coefficient and statistical model for dz5b(tkt0633393)
//*                     add new model vms_105(keep vms_115 as it is,will remove vms_115 in future release, tkt0647379)
//*
//*v3p_2  02/23/24    final model release for v16.2
//*                     fixed a prestoplus aging model bug.
//*
//*v3p_1  01/31/24    final model release for v16.1
//*                     added new vms checkers vms_30, vms_60, vms_115 and vms_165.(tkt0636343)
//*
//*v3p_0  10/30/23    final model release for v16
//*                     updated paper model of nmos120 based on limited silicon(tkt0619047)
//*                     updated paper model of pld120 based on limited silicon(tkt0619048)
//*                     updated paper model of cfr120 and cfr120_m1m2m3 based on limited silicon, updated ppf parameters as well(tkt0619049)
//*                     added new instance parameter gt_90v for pld10b to support dt upsize pcell feature(tkt0624551)
//*                     added dc soa and esd soa for nmos120, pld120, cfr120 and cfr120_m1m2m3
//*                     updated some dc soa rules:
//*                       -in dc soa, mosfet v(g,d), v(d,s), v(s,b) rules are updated.
//*                       -in dc soa, v(well,t) and v(wll,b) rules are added for cfr devices.
//*
//*v3o_1  08/30/23    final model release for v15.1
//*                     added silicon based model for dpldd(tkt0619044).
//*                     added skeleton model for nmos120(tkt0619047).
//*                     added skeleton model for pld120(tkt0619048).
//*                     added skeleton model for cfr120 and cfr120_m1m2m3(tkt0619049).
//*                     fixed lpe flag issue which impact parasitic cap for nmos, pmos, nmos_ll, pmos_ll(tkt0618599).
//*
//*v3o_0  05/20/23    final model release for v15
//*                     updated wpe, cv and junction models for nmos_ull and pmos_ull(tkt0618189).
//*                     model re-casing for nmos_ull and pmos_ull(tkt0618190).
//*                     roll back dc soa model to old soa monitors(from multi-level check monitors).
//*
//* n/a   02/18/23    final model release for v14.2(patch version based on v14.1)
//*                     fixed two soa model issues(1.diode soa model implementation does not match with rule definition,
//*                                                2.vth polar type(pmosvthsign) is missing in soa implementation. )
//*v3n_1  11/15/22    final model release for v14.1
//*                     updated all soa models based on multi-check monitors(tkt0600934)
//*                     model re-casing for all fringe capacitors including: cfrlv, cfrlv_m1m2m3, cfr45, cfr45_m1m2m3, cfr90, cfr90_m1m2m3(tkt0598169)
//*                     updated pld65 based on silicon (tkt0600930)
//*                     corrected lpe flag for dz5b in post-layout circuit(action from pdk). corrected lpe flag equation for pld90, pld90b and pld100 in model(tkt0589015)
//*                     fixed the prestoplus unit issue(tkt0592876)
//*
//*v3n_0  05/05/22    final model release for v14
//*                     added paper model for pld65.
//*                     updated tc variation model for rpoly0 based on silicon(tkt055163).
//*                     added soa and esdsoa model for new component pld65. updated esdsoa rules for all components(tkt0587124).
//*
//*v3m_1  12/17/21    final model release for v13.1
//*                     re-casing of rpoly0, nld5_lvt, nld30b, pld30b, pld45b, pld90b, pmos_ana and cglv (tkt0573024).
//*                     re-casing of nmos_ull and pmos_ull (tkt0573025).
//*                     add tc variation guess model for rpoly0 based on smos90hv mapping data (tkt055163).
//*                     add prestoplus aging model for all devices. both relimo and prestoplus model systems co-exist (tkt0573023).
//*                         (two new sections, smos10hv_enable_aging and smos10hv_disable_aging were added for prestoplus model.)
//*
//*v3m_0  09/24/21    final model release for v13
//*                     updated nld100 and pld100 models with p39e si (tkt0573018).
//*                     fix nmos convergence issue by updated wphn a0 parameters (tkt570926).
//*                     updated setup file for fixed spectre cannot directly switch to afs in adel, only can first switch to mica, then switch to afs (tkt0552589).
//*                     re-casing pld45 (tkt0573021).
//*                     aging model switch to orestoplus from relimo (tkt0573023).
//*                     update pmos_ana pbti moel (tkt0536759).
//*                     fix nld10 cfrx model bug (tkt0573919).
//*                     removed ccdsub of rpoly, rpoly_1meg, rhvpw, rphv (dft0573665a).
//*
//*v3l_3  03/11/21    final model release for v12.1
//*                     add dummy gates models for all mosfets and powermos in v12.1 for nld10, nld30b, nld45b, nld45b_he, pld45b, pmoshs45b, nld65b, nld90b, nld45b_tlp, nmos45b, pmos45b, pld30b nmos90b, pmos90b, pld90b (dft0528978b).
//*                     improved cgd/cgg of nld90b and pld90b (tkt0551950).
//*                     add pnp and pnp_iso eb junction punch through models with global on/off switch default on (tkt0556323).
//*                     add againg model for pnp, pnp_iso (tkt0518157).
//*                     add aging model for pmos90b and pld90b (tkt0529813).
//*                     improved gate leakage model of nmos/pmos, nmos_ll/pmos_ll (tkt0547075).
//*                     updates to nmos and pmos sti, wpe, dte model based on n86y silicon (tkt0506853).
//*                     updates to nmos_ll and pmos_ll cgg to let the model have the same ratio as silicon between hvt and svt (tkt0556324).
//*                     updates to pmos_ll nsig & sig to get rid of the outlier in designer's monte carlo simulations (tkt0554283).
//*                     improved nmos5, pmos5 sti models (tkt0556326).
//*                     update nmos3_zvt sti model, update casing and dte model (tkt0542758).
//*                     re-casing nmos, pmos, nmos_ana, nmos3_zvt, nmos5, pmos90b (tkt0517435).
//*                     add print_function_nxp.va in order to print fault leakage model on/off info in simulation log file.
//*                     co-simulation c90lcfs 4m1t and s10hv 4m1t, flow team solved in cadence, no need additional co-sim model file (tkt0541060).
//*                     recasing rm2,rm3,rm4,cfrlv,cfrlv_m1m2m3,cfr45,cfr45_m1m2m3,cfr90,cfr90_m1m2m3,cdpf_m1m2m3,cghvf,cghvf_m1m2m3 required by device team due to backend process spec changed (tkt0557678).
//*
//*v3l_2  12/17/20    final model release for v12
//*                     update nmos_ull and pmos_ull based on re-cut n94x si (tkt0545702).
//*                     update nld10 off state aging model (tkt0552924).
//*
//*v3l_1  11/04/20    final model release for v12_ea3
//*                     add new device model nmos_ull and pmos_ull (tkt0545702).
//*                     add new device model nld100 and pld100 (tkt0545308).
//*                     add fault injection resistance model in nmos, nmos_ana, pmos, and pld5 (tkt0541466).
//*                     update pld5 sti moedel and added sti_dummy instance parameter with dummy_gate model (tkt052980).
//*                     added new model cpwtub_box_sub_float_10hv in both section substrate_cap and substrate_cap_simple to fix crashes or huge simulation time when pwell empty of pwtub (tkt0537895).
//*                     remove mosfet_legacy and powermos_legacy sections (tkt0537390)
//*                     add secton smos10hv_xpart_default/enable for nmos/pmos, nmos_ll/pmos_ll, nmos_ana, pmos_ana, nmos3_zvt, nmos5/pmos5, nmos_ull/pmos_ull (tkt0537460)
//*                     remove rpoly_compress=0 in base section (dft0532757a)
//*                     remove soa monitors variloga paths from sections of soa_disable, esdsoa_disable, relimo_disable, risk_assessment_disable. add new section risk_assessment_disable_afs (tkt0534632)
//*                     fix bug nmos10 delr_thesato_nmos10_sphv_10hv (tkt0539566)
//*                     fix all p-type pbti model of pld5,pld10,pld10b,pld30,pld30b,pld45,pld45b,pld90,pld90b,pmos5,pmos10,pmos45,pmos45b,pmoshs45,pmoshs45b,pmos90,pmos90b, model incorrectly uses gate-sub voltage instead of gate-body voltage for estmated the vth shift.   also correct pmos_ana pbti model (tkt0536759)
//*                     add noscale=1 in mosvar model of cghv,cghvf,cghvf_m1m2m3 (tkt0540713)
//*                     change all veriloga paths from absolute path to relative path for model modular release (tkt0520234).
//*                     remove model version number in release model folder for model modular release, but keep model version in model generation system for easy maintance (tkt0541511)
//*                     fixed bug which missed pld30b sphv nsig oarameters in section case (tkt0549522)
//*
//*
//*v3k_0  10/15/19    final model release for ams3.11
//*                     switch model to sphv from bsim,  nmos10, pmos10, nld10, pld30b, nld45b_he, nld45b_tlp, pld45b, pmos45b, pmoshs45b, nmos90b (tkt0512297)
//*                     dz5 ir=100ua bv model should be accuracy to bv=5.07v. (tkt0512099)
//*                     sphv junction model updated, (code already fix in simkit 5.1.1.1),  (dft0509716a).
//*                     currently soa cannot implement beta drift option in soa, need to add instance parameter for example drift=0 or 1 in npn,npn_b, pnp and pnp_iso,use this switch select different soa rule in drft file.(tkt0512307)
//*                     device team asks to re-casing drsf45b and drsf90b in ams3.11 in order to make cpk >1.67, currently about 1.55.(tkt0512097)
//*                     mm model check and fix if not good, cdp, cdpf, cglv,cghv,cdpf_m1m2m3, cghvf, cghvf_m1m2m3 (tkt393029)
//*                     update  pld10b pcell with  add dummy gate. model:  add dummy gate model (tkt0517260) (si n59y).
//*                     update pmos10 pcell with add dummy gate, model: add dummy gate model (tkt0517261) (si n94z)
//*                     npn_b as new device for leakage outlier fix,  release new pcell and model (tkt0517268) (si n94z)
//*                     update rphv mm model ( data on si n94z) ( tkt0521741).
//*                     fix npn drr scaling issue (tkt0517558).
//*                     pnp_iso mm, dc, cv drr  model update ( data on n86y). (tkt393028)
//*                     update bti model for all dgo devices (tkt0518153).
//*                     added aging models for pmos45b, pmoshs45b, pmos90b, pld10b,pld30b,pld45b,pld90b,new model with new equations (tkt0518154).
//*                     added aging models for nld10,nld90b,nmos90b with existing model with existing equations. (tkt0518156).
//*                     multi-ng model updated for nmos45b,nld45b, nld65b,pmos90b,nmos3_zvt, and nld30b (tkt0519901).
//*                     cth equation fix for powermos.(tkt0519426)
//*                     update dummy gate model for nld5 and nld5_lvt (tkt0520121)
//*                     add oxide risk assessment enable/disable section (tkt0524367)
//*                     add temperature function in aging model (both nbti and hci) (tkt356002).
//*                     dz5 pcell add 7um betwwen dpn to teench, but model didn't do any thing on this.(tkt0510438)
//*                     add new device dz5b model (tkt0521761).
//*                     model gisl for nmos45b and pmos90b (tkt0523289).
//*                     add scale factor to mosvar model (tkt0524761).
//*                     add fault_dz5_leakage_outlier in dz5 model instance parameter, and fault_dz5b_leakage_outlier in dz5b model instance parameter, but not link to cdf and use descover tool to simulate outliner.
//*                     change nmos_ll and pmos_ll as/np to as, ps/np to ps, ad/np to ad, pd/np to pd in as,ps,ad/pd equation for correct bug.
//*                     move as=0, ps=0, ad=0 and pd=0 of nmos10 and pmos10 from instance parameter to inside model due to nmos10 and pmos10 lpe will not extraction as,ps,ad,pd for sphv model.
//*
//*v3j_0   03/11/19     final model release for ams3.10
//*                     nmos_ll improvement, update sti, wpe,dte, 1/f noise (tkt393026)
//*                     pmos_ll improvement, add sub-vt kink, update sti, wpe,dte, 1/f noise (tkt393027)
//*                     pnp_iso ft fix, (tkt393028)
//*                     mismatch model update, nmos5,pmos5,nld5,pld30b,pld45, cfrlv,cfr45,cfr90,
//*                         cfrlv_m1m2m3,cfr45_m1m2m3,cfr90_m1m2m3,dpplus,dnplus(add new). (tkt393029).
//*                     1/f noise updated, nmos,pmos,nmos_ana,pmos_ana,nmos3_zvt,nmos5,pmos5,add nld5, nld5_lvt,pld5,pld30,pld45 noise model,updated rpoly,rpoly_1mg,rphv,
//*                         rphvw, updated npn, pnp, pnp_iso noise model. (tkt393030)
//*         	      validate model to 225c, pnp_iso, lgotub_sub,nwtub_sub,pwtub_sub (tkt393031)
//*        	      aging model update for nld65b,nmos45b,nld30b,pld45b and  pmos5 for nbti and pbti (tkt393032)
//*        	      add selfheat (default=1, option=0), in cdf parameters for pld10b,nld30b,nld45b,nld65b,nld90b,pld90b,nmos45b,pmos90b (tkt393034)
//*         	      remove lpe switch on rg for nld30b,pld10b,pld45b,pld30b,nld10,nld5,pld90b.  (tkt393740).
//*       	      add sti_dummy instance parameter in nld5 and nld5_lvt model, schematic cdf  (tkt368423).
//*	              pld45  of  powermos_simple section, cgd and cgg issue  (tkt393806). this ticket is applying for all simple models.
//*                     fix npn diode reverse recover (drr) model (tkt394045)
//*       	      knee current fix for nmos45b, pmos90b, nld30b, nld45b, nld65b and nld90b.(tkt0506081)
//*       	      add series resistance in dpplus and dnplus model. (tkt0506082).
//*       	      fix nld5_lvt sti and multi-ng model, improve nld5 sti and multi-ng model (tkt0513446).
//*       	      update rpoly_1meg mm model (tkt0512115).
//*                     update pld45b s sub area and perim model to micth with pld45b pcell (tkt0514363).
//*                     fixed nld30b,nld45b,nld65b s sub model to cdgontub (from cdgoptub) (tkt0514363).
//*                     update nld30b model with add bvdss_shift in bv parameter.
//*                     update nmos_ana delr_nsub_nmos_ana_10hv_bsim4.
//*                     reduced nmos_ana and pmos_ana cv parameters acj0, pcj0, chcj0 to half value.
//*                     update nmos_ll wdmu0_dte to 1.0e-7 from -1.6e-07, pmos_ll wdmu0_dte to 1.1e-7 from -1.1e-7 and wdvth_dte to -3.5e-8 from 2.5e-8.
//*
//*v3i_0   09/30/18     final model release for ams3.9
//*     	              add new pld30b, pld45b, nmos45b, pmos45b and pmoshs45b model, but only nmos45b will be sphv model,
//*                        other model will be tweaked from existing bsim3+ veriloga model and re-casing. (tkt384030)
//*                     add sti_dummy (dummy gate) instance parameters in nld5 and nld5_lvt. update sti model (tkt368423).
//*                     ddd series resistance in dnfet/dpfet (tkt375580).
//*                     npn exit saturation time model (tkt375043)
//*                     ade explorer prestoplus phase-1 user interface (tkt348444).
//*                     improve diode reverse recover model for nld5,nld5_lvt,nld10,nld45b,pld5,pld10b.pld45b (tkt381495).
//*                     sphv model re-extracted for nld45b, nld65b, nld30b, nld90b, pld90b, pmos90b (tkt386362).
//*                     update all devices cgg except pld10b and pld45 in powermos_simple section to match with corresponding devices cgg in powermos section (tkt383924)
//*                     improve pmos and nmos5 cgg (tkt384026)
//*                     nmos_ll and pmos_ll core and mm model re-extraction (tkt383922).
//*                     re-extract rm1 and rm3 models (tkt383921)
//*                     npn fix (reverse gammel) tkt385277
//*                     update nld45_he hci aging model and add nld45_tlp hci adding model (tkt386363).
//*                     add mosfet_legacy and powermos_legacy sections in ams3.9 and ams3.10 for backup new sphv models (tkt386680)
//*                     change int() to int_round
//*                     add rgate model to pld10b (tkt387460)
//*                     add lpe switch to all powermos parastic rgate resistance model (tkt389151), except nld45b,nld45b_he,nld45b_tlp,nld65b and nld90b because lpe cannot extract race track rg properly.
//*                     update cfr90 tc1 and tc2.
//*                     update cfr90_m1m2m3 tc1 and tc2.
//*                     change nsig_delr_mosfet_thick_tox_bsim3v3 to nsig_delr_mosfet_thick_tox
//*                     update npn mm model (tkt390228)
//*                     change rpoly, rhvpw, and rphv cdsub m=np to m=1.
//*                     update pnp ft model.
//*
//*v3h_0   06/25/18     final model release for ams3.8
//*                     add nld90b,pld90b,nmos90b, pmos90b, drsf45b and drsf90b models.
//*                     fix nld45_he and nld45b_he xsub parameter equation to align schematic and lpe source to sub capacitance simulation results.
//*                     fix pmos90 and pmos90b body to sub cap to align schematic and lpe source to sub capacitance simulation results.
//*                     update nld90b, nld45b, nld45b_he and nld45b_tlp (also nld90, nld45, nld45_he and nld45tlp) to fix source n+ stripe for pcells and model un-align issue.
//*                     update nld45b (also nld45) mm model.
//*                     update aging models of nld45b, nld45b_he (also nld45 and nld45_he) hci vgs>0.
//*                     tweaked rdson model and re-casing for pld90b.
//*                     updated nld5_lvt 3rd quadrat idvd model.
//*                     re-casing pmos90b model.
//*                     fix source nplus stripe equations of nld30 (nld30b), nld5_lvt, nld65 (nld65b) and pld5.
//*                     fix nld45_he (nld45b_he) lpe and schematic results difference of source to body cap.
//*                     update nmos10 and pmos10 body to sub cap due to pcell removed nga.
//*                     updated pld45 cgg both powermos and powermos_simple required by ivn team.
//*                     re-casing cdpf_m1m2m3, cghvf_m1m2m3, cfrlv_m1m2m3,cfr45_m1m2m3,cfr90_m1m2m3 and rulm dut to sgpc target shift.
//*                     add pmos90 and pld90 hci_tddb model in soa model.
//*
//*v3g_0   02/28/18    final model release for ams3.7
//*                    new devices nld30b, nld45b, nld45b_he, nld45b_tlp and nld65b models copied from nld30,nld45,nld45_he,nld45_tlp and nld65 models respectivily.
//*                    integarted lspb with model file.
//*                    update hci models of nmos,nmos_ll,nmos_ana,nmos3_zvt,nmos5,nld5,nld5_lvt,nmos10,nld45,nld45_he,pmos,pmos_ll,pmos_ana,pmos5,pld5,and pmos10.
//*                    add parasitic rpoly0 model in cdp and add w to instance parameter.
//*                    add s10hv_case_sweep_enable section and update section case.
//*                    move soa monitor veriloga path in section base of dfrt file to section smos10hv_enable_soa of model file to avoid un-necessary compile time.
//*                    fix sub_box cosh function.
//*                    fix nmos90 ib temperature issue.
//*                    add a switch (moscap_enable/moscap_disable) in cglv to chioce moscap model or mosvar model, default is moscap model.
//*                    enlarge cdp,cdpf.cdpf_m1m2m3 bottom to well parastic capacitance case sig to enlarge casing window from 19% to 30%.
//*                    pld10b ppf change to recmax=50.
//*                    rename cdp,cdpf, and cdpf_m1m2m3 parasitic rpoly0 casing parameter to nsig_delr_rs_rpoly0_r3_cdp.
//*                    dte and wpe models fix for nmos_ana, pmos_ana, nmos5, pmos5.
//*                    fix nld65 drain source diode temperature sweep issue (tkt360097) with update powermos diode model to 7p3.
//*                    validated nld45, nls45_he, nld45_tlp, and nld65 model for poly flap structures based on limited si data.
//*                    add dpplus mm peper model.
//*
//*v3f_1   01/08/18    final model release for ams3.6hf1
//*                     update powermos diode veriloga model to 7p3 to fix nld65 temperature sweep issue.
//*
//*v3f_1   10/13/17    final model release for ams3.6
//*
//*                     updated pmos_ll casing for solve digital cell ac timestep too small issue.
//*                     added rpoly0 resistance paper model in cdpf and cdpf_m1m2m3.
//*                     pmos90 recasing.
//*
//*v3f_0   09/10/17    final model release for ams3.5hf4
//*
//*
//*                     added lspb function in this release. the lspb doesn't need to integrate into model file. run lspb file will convert sgpc electrical parameters to model
//*                     parameters, and make another corner model.
//*                     all models validated to 200c.
//*                     re-extract nmos3_zvt mm model.
//*                     update powerdiodev7p2_forspectre.va file for fix hidden states issue.
//*                     added gate leakage model in nmos, pmos, nmos_ll, pmos_ll, nmos_ana, and pmos_ana models.
//*                     fix pnp high temperature  current bug.
//*                     remove xcoord and ycoord in the model, and remove x and y items in smm equations of all devices.
//*                     re-casing pmos_ana required by the device team for updated fab sgpc data.
//*                     add fem model and diode reverse recover model in pld10b.
//*                     fix rm1,rm2,rm3,rm4 smm equations for metal resistor minimum geometry mc issue.
//*                     fix dte models of nmos_ana,pmos_ana, and wpe models of nmos_ana and pmos_ana.
//*                     fix model (nbti) of pmos,pmos_ana,pmos_ll,pmos5,pld5,pmos10,pld10,pld10b,pld30,pmos45,pmoshs45,pld45,pmos90,pld90.
//*                     from this version, smos10hv_ade_dfrt.micalib, monitors_mica.va, relimo_mica.va, monitors_esd_mica.va will not be updated, only used as dummy model generate files.
//*
//*
//*v3e_0   05/07/17    final model release for ams3.5
//*
//*                     update pld10b cgg and cdg to align with pld10 junction cap. add pld10b junction current and cap casing.
//*                     update pnp_iso we and le values from 7 to 6.54 and from 13 to 11.85 in soa dfrt file due to we (le) is width not conts number.
//*                     remove sgn{} and change 1e-16 to 1e-12 in cglv leakage bsource equations.
//*                     updated maxa function and added mina function.
//*                     recasing all devices for pass r-gate.
//*                     re-extracted models nmos5, pmos5, nmos_ana, and pmos_ana with bsim4.
//*                     validated nld5_lvt model.
//*                     validated cfrxx_m1m2m3 model.
//*                     added new device model pld10b.
//*                     added new model pnp_iso
//*                     added estimated mm in dz5.
//*                     added cglv leakage model in both cap and cap_simple sections.
//*                     added dskip=no in all diode models.
//*                     update diode reverse recovery veriloga model version to 7p2.va.
//*                     fix npn high tempture low current test data and model match issue.
//*                     release only spectre model files. mica will read spectre model.
//*                     from this pdk, spectre will use spectre simkit because pld10b sphvt model needs simkit.
//*                     set rpv=0 for cghv, cghvf, cghvf_m1m2m3.
//*
//*v3d_1    02/15/17  regular final model release for ams3.4
//*                   mica model no change comparing with v3d_0.  spectre model added ade mc sections, and section no_stat_mis.
//*                   spectre model added section case
//*                   (for sensitivity analysis w.r.t model parameter nsig*) and section smos10hv_case_default (parameters case=0).
//*
//*v3d_0    11/7/16   regular final model release for ams3.3
//*                    added nmos_ll and pmos_ll models.
//*                    since no mm, noise, sti, wpe and dte structures for model extraction, those models copied from nmos and pmos.
//*                    update initial assign value code of veriloga model to remove bug and wraning messages.
//*                    verified all devices on mc simulation for descover with new mc tools.
//*                    change vms_15, vms45 r to 1e18 from 1e11.
//*                    added aging model paramters in nmos and pmos models, those againg model parameters missed in ams3.2.
//*                    add soa and esd soa models for nmos_ll and pmos_ll from smoke alarm and and esd smoke alarm files.
//*                    add aging model for nmos_ll and pmos_ll by copied one from nmos and pmos.
//*                    changed gmim=0 from gmim=1e-12 in rpoly0,rpoly, rhvpv,rphv, and rpoly_1meg models.
//*		     added maxa(x,y,a) function in base section, and replaced maxmodels() function with maxa() function in
//*		     powermos diode model ik parameters for nld65,nld90,pld90,nld45_tlp,nld10,nld30,nld45,nld45_he,pld10.
//*		     the purpose is to smooth diode current in high injection region.
//*
//*v3d_0    09/21/16   early final model release for ams3.3
//*                    swap le and we of npn and pnp.
//*                    use rbp=0 to replace rbp=0.01 to fix pnp topology convergence issue.
//*                    put .control msglimit inst_tempovr 0 .endc in mica base to stop show resist temp override warning message.
//*                    fixed soa monitor bug.
//*                    fixed esd soa monitor bug.
//*                    change nmos rsh=9.8 from 0, change pmos rsh=8.3 from 0.
//*                    update qrc file with metal resistors tc2=-xxx from 0.
//*
//*v3c_1    07/13/16   final model release for ams3.2p1.
//*                    fixed nmos and pmos monte carlo leakage simulation issue. no impact on corners simulation results.
//*                    updated soa model with rulm rules, dnplus, dpplus, dnfet, dpfet, nmos, pmos, rpoly, rpoly_1meg,rhvpw, rphv.
//*v3c_0    05/16/16   final model release for ams3.2.
//*                    the nmos and pmos models re-extracted with bsim4 model in order to improve leakage current model.
//*                    the sti and wpe models are re-extracted for nmos and pmos because core model changed to bsim4 from bsim3v3.
//*                    modified nmos5 model by add drain resistor due to nmos5 is asymmetry device it should have a drain resisitance.
//*                    pnp model has been improved for saturation and high injection region over the temperature. this allows to use the device at higher bias
//*                    condition than before.
//*v3b_0    04/04/16   final  model release for ams3.1.
//*                    add vms_15 and vms45 model.
//*                    replaced cglv mosvar model by cglv moscap veriloga model to fix tkt296383 on covergence issue.
//*v3b_0    11/25/15   final  model release for ams3.1.
//*                    added rulm model.
//*                    added new devices cdpf_m1m2m3, cghvf_m1m2m3, cfrlv_m1m2m3, cfr45_m1m2m3, and cfr90_m1m2m3 for both 4m0t and 4m1ut processes.
//*                    added rulm model in soa model.
//*v3b_0    11/19/15   skeleton release for ams3.1.
//*                    added rulm model.
//*                    updated cdpf, cghvf, cfrlv, cfr45, and cfr90 with ulm option.
//*                    added rulm model in soa model.
//*v3a_0    11/09/15   update for lpe only.  rpoly, rhvpw, rphv default model handling of m1 shield for lpe
//*v3a_0    10/15/15   final model for ams3.0.
//*                    added new model nld5_lvt_10hv.
//*                    updated rphv and rpoly with m1 shield models.
//*                    updated rpoly_1meg model with r3 and m1 shield model.
//*                    updated moscap model of cglv, cghv, cghvf to mosvar model.
//*                    recasing all device models.
//*                    specially for nmos/pmos, nmos_ana/pmos_ana recasing added casing corrlation dl first time.
//*
//*v3a_0    09/15/15   skeleton release for ams3.0. added new model nld5_lvt_10hv.
//*                    updated rphv and rpoly with m1 shield models.
//*                    updated rpoly_1meg model with r3 and m1 shield model.
//*                    updated moscap model of cglv, cghv, cghvf to mosvar model.
//*
//*v2e_0    08/12/2015 final model release for ams2.4
//*                     updated isolation cap model. improve diode rs model of powermos. verified pnp vj model.
//*v2e_0    07/23/2015 skeleton model for ams2.4
//*
//*v2d_0    05/26/2015 final model for ams2.3
//*                    pitch release for update all powermos junctions to fix rs.
//*                    refined the power diode iv model.
//*                    fixed a bug in the powermos diode hight temperture clamp equation.
//*                    increased the clamp value for vj from 1e-6v to 0.1v to clean spectre warning.
//*v2d_0    05/26/2015 final model for ams2.3
//*                    added libs of powermos_simple, capacitor_simple and resistor_simple.
//*                    added enable/disable sti, wpe, dte section to switch on/off sti wpe and dte models.
//*                    updated fem model in all powermos.
//*                    the rs fix for drain/body junction of powermos.
//*                    fix reff bug in powermos veriloga model.
//*                    update rhvpw dc and mm models with m1 shield effect.
//*                    improve model accuray of pnp at high temperature.
//*                    try the best to remove ahdl warning message.
//*                    added esd soa model in dfrt model library.
//*                    fixed nld90 3rd quadrant convergence issue.
//*
//*v2d_0    05/08/2015 skeleton model for ams2.3
//*                    added libs of powermos_simple, capacitor_simple and resistor_simple.
//*                    updated fem model in all powermos.
//*                    the rs fix for drain/body junction of powermos.
//*                    fix bug in powermos veriloga model.
//*                    update rhvpw dc and mm models with m1 shield effect.
//*
//*v2c_0    03/20/2015 model file for ams2.2p1
//*                    added lib substrate_cap_simple with 5 linear box cap models (clgo_box_sub,cnwtub_box_sub,cdgoptub_box_sub,
//*		     cdgontub_box_sub,cpwtub_box_sub).
//*		     re-extracted model for cdgoptub_box_sub, clgo_box_sub and cnwtub_box_sub to improve model accuracy.
//*		     add about +/- 10% casing window for the box cap devices in both section "substrate_cap" and "substrate_cap_simple".
//*		     add thermal clamps in powermos diodes inside powermos, antenna diodes, drsf diodes and zener diodes to
//*	             enable model function up to 225c.
//*v2b_1    12/08/2014 updated cghv and cghvf model to solve the unstable tran simulation issue. model targets
//*		     are unchanged.
//*v2b_0    8/01/2014  model file for ams2.1.
//*                    nld45_tlp model updated from from n75k silicon to replace its placeholder
//*                    in v2a_0 model; mismatch copied from nld45 data; reverse recovery model extracted.
//*		     removed simple models for capacitors and powermos devices.
//*                    updated sti models for nmos_ana, pmos_ana, nmos5, pmos5 and nmos10, based on the
//*                    data from n41n with additional granularity in active sizes. refined nmos10 and nmos45
//*                    models to increase accuracy on most-used geometries for analog designs.
//*v2a_0    5/20/2014  clamped value of metal resistors and antifuse for extreme mismatch and casing values.
//*v2a_0    5/16/2014  updated sram pload (psrampu) to reflect m2 pmos performance.  other minor updates
//*                    for improved lpe performance.  updated symmetric mosfet proximity models to reflect
//*                    the symmetry in lpe extractions.  corrected small errors in the nld65,nld90 templates.
//*                    added lpe switch on the dpfet.
//*v2a_0    4/28/2014  updated ppf file for nld5,pld5, nld10 limiting the maximum number of gates.
//*                    minor update in nmos90 casing affecting only ws rdson casing.
//*                    minor update in trench proximity model for the pmos5
//*v2a_0    4/7/2014   model file for ams2.0 pdk. m2 models based on 1800+ points from 3 masks, 9 lots using the frozen process.
//*                    updated casing for all models based on the frozen process data.
//*                    compared to ams1.1, pcells for all powermos devices significantly changed, and these models were re-extracted.
//*                    improved diode reverse recovery and mismatch models for all powermos devices.
//*                    the model for the nld45_tlp is a copy of the nld45_he.
//*                    added reliability/aging models for nmos,pmos,nmos_ana,pmos_ana,nmos3_zvt,nmos5,pmos5,nmos10,pmos10.
//*                    added well and trench proximity models for nmos,pmos,nmos_ana,pmos_ana,nmos3_zvt,nmos5,pmos5 and pld5.
//*                    the reference size is the pcell.  proximity effects are accurately modeled by using lpe only; no
//*                    schematic functionality because the layout is unknown at that time.
//*                    psrampu updated with re-casing due to idsat typical value decreased.
//*                    added sti modeling for the nld5,pld5, and nld10; sti model is focused on current scaling as a function of ng.
//*                    updated sti models for the nmos,pmos,nmos_ana,pmos_ana,nmos5,pmos5,nmos3_zvt and nmos10.
//*                    updated noise models for the nmos5, nmos45, pmos45, and pmos90 because the pcells changed.
//*                    updated core model for the nmos5, nmos10, nmos45, pmos45, pmoshs45, pmos90 because the pcells changed.
//*		     significant shifts in the typical values of the metal resistors and rpoly_1meg compared to ams1.0.
//*                    added very rough estimates of mismatch for the metal resistors and moscaps.
//*v2a_0     3/7/2014  skeleton model file for ams2.0 pdk.
//*v1c_0    2/27/2014  model file for ams2.0 early access.  complete model updates for nld10,nld30,nld45,nld65, and nld45_he.
//*                    mismatch and diode recovery models are estimated for this release and will be updated
//*                    in the next release.
//*                    bug fix for bjt models to enable functionality at temperatures beyond the spec limits.
//*v1c_0   11/08/2013  model file for ams2.0_ea1 release. added nld45_he device as a copy of the nld45 device.
//*v1b_1   10/25/2013  model changes for lpe only:
//*                    added parasitic capacitances for metal-metal matching pcell defaults for nmos10,nmos45,pmos45,
//*                    pmoshs45,nmos90,and pmos90.
//*v1b_1   10/15/2013  model changes for lpe only:
//*                    added lpe attribute to instance parameter lines for rphv and rhvpw to allow extraction of cdgoptub_box_sub.
//*                    updated calculations of cpwtub_box_sub for rpoly and rpoly0 resistors.
//*v1b_1   10/10/2013  model changes for lpe qa only:
//*                    pld90, pmos90 - removed lpe switch from cdgoptub;
//*                    pld5 - added ad/pd instance parameters and changed internal calculations to include these as inputs.
//*v1b_1   10/04/2013  re-extracted nmos5 model from silicon to reflect the device structure change from symmetric into asymmetric;
//*		     added estimates for mismatch for all powermos devices;
//*                    added mismatch models for nmos90, pmos90;
//*                    added reverse recovery simulation capability for 7 powermos devices;
//*                    replace mosfet casing libraries with separate libraries for thin oxide casing and thick oxide casing;
//*                    added noise models of npn, pnp, nmos10, pmos10, nmos45, pmos45, pmoshs45, nmos90 and pmos90;
//*                    corrected asymptotic behavior of stress models of nmos5, pmos_ana and nmos3_zvt;
//*                    updated time-dependent (behavioral) antifuse model;
//*                    added p terminal and pwell-nwell diode to clgo_box_sub isolation;
//*                    added fem parameter to nld/pld models to support fem+qrc use;
//*                    updated bv values of antenna diodes to support simulations past the smoke alarm values
//*v1b_1   09/10/2013  skeleton file for ams1.1 pdk release
//*v1a_2   08/02/2013  added substrate terminal to the bitcell models (nsrampg,nsrampd, and srampu) and corrected
//*                    asymptotic behavior of stress modeling for nmos,pmos,nmos_ana, pmos_ana, nmos5, pmos5,
//*                    nmos3_zvt and nmos10.
//*v1a_1   07/12/2013  updated nmos and nsrampd models to improve model accuracy in subthreshold and leakage regions.
//*v1a_0   06/25/2013  updated moscap veriloga code to remove extraneous small resistors to overcome convergence issues.
//*v1a_0   06/21/2013  corrected dz5 model for correct calculation of nc, corrected subcap size in
//*                    drsf45,drsf90,cglv,cghv models.  corrected base/emitter calculations for both bjts.
//*                    reduced drsf transit time parameter at request of design team.
//*v1a_0   05/24/2013  added ring attribute to antifuse models.  correct ppf file for drsf90 and pmos90.
//*v1a_0   05/06/2013  corrected connection of box cap for dnfet, drsf45, and drsf90.
//*v1a_0   04/26/2013  first models based on silicon measured data.  neither the devices nor the process is frozen.
//*                    models are based on n37h test mask. the released ams1.0 nmos5 device is asymmetric while the
//*                    model for nmos5 is symmetric.  the other ams1.0 devices may differ in small details.
//*                    models are valid -40c to 175c.  model typ is based on ~1000 points of data from atmc fab;
//*                    limits based on fab sigma + expected performance.
//*                    uniaxial stress (sti) is modeled in mosfets where needed. well proximity effects are not
//*                    modeled but data is available.  models include mismatch and noise for primary analog
//*                    devices but not all devices.  diode reverse recovery not included in any models.
//*
//*v1a_0   04/15/2013  added parasitic diode dnbl_pepi_tr_10hv to use for lpe
//*v1a_0   04/04/2013  added nmos5,pmos5 to nmos, pmos  models with sti for ddk development.
//*                    updated ppf parameters for capacitors as agreed to improve cdf calculation accuracy.
//*                    the other models are functional but are not finished and do not give accurate results.
//*v1a_0   03/29/2013  early release of nmos and pmos with sti model for ddk development.
//*                    the other models are functional but are not finished and do not give accurate results.
//*v1a_0   03/18/2013  skeleton release for v1a_0
//*evala_0 12/7/2012   paper model release
//*                    the nmos, pmos, nsrampg, nsrampd and psrampu paper models based on smos10w are released to sram team.
//
//*************************************************************************


library models

//***********************************************************
section base
//***********************************************************

modelOptions options scale=1u gmin=1e-14 tnom=(27) 

parameters
+    sDOTpercent                    = (0)
+    sDOTmult                       = (1)
+    sDOTmult2                      = (1)
+    pi4models                      = (3.141592654)
+    nil                            = (0)
+    proxenabled                    = (0)
+    fault_dz5_leakage_outlier_global = (0)
+    fault_dz5b_leakage_outlier_global = (0)
+    fault_injection_nmos_leakage_outlier_global = (0)
+    fault_injection_nmos_ana_leakage_outlier_global = (0)
+    fault_injection_pmos_leakage_outlier_global = (0)
+    fault_injection_pld5_leakage_outlier_global = (0)
+    fault_npn_b_beta_outlier_global = (0)

ahdl_include "./veriloga/vdclip_forspectre.va"


real mod(real a, real b) {
    return a-b*int((a+0.5)/b);    // a and b must be positive
}

real sgn(real a) {
    return ((a>0)-(a<0));
}

real shrnk(real udr, real sDOTmult) {
    return (udr*sDOTmult) ;
}

real pwr(real x, real y) {
    return (x**y) ;
}

real minmodels(real x, real y) {
    return (x-0.5*((x-y)+sqrt((x-y)*(x-y)))) ;
}

real maxmodels(real x, real y) {
    return (y+0.5*((x-y)+sqrt((x-y)*(x-y)))) ;
}

real maxa(real x, real y, real a) {
    return (x>=y?0.5*(x+y+sqrt((x-y)*(x-y)+a)):y-0.5*a/(x-y-sqrt((x-y)*(x-y)+a))) ;
}

real mina(real x, real y, real a) {
    return (x<=y?0.5*(x+y-sqrt((x-y)*(x-y)+a)):y-0.5*a/(x-y+sqrt((x-y)*(x-y)+a))) ;
}

real ln_cosh(real x) {
    return (x>=0?x+log((1+exp(-2.0*x))/2.0):-x+log((1+exp(2.0*x))/2.0)) ;
}

real int_round(real x) {
    return (int(x+1e-12)) ;
}

include "./smos10hv_ade_dfrt.scs" section=base
include "./smos10hv_ade_dfrt.scs" section=soa_report_header_dfrt
ahdl_include "./veriloga/print_version_nxp.va"

ahdl_include "./veriloga/print_function_nxp.va"

parameters
+ nxp_smos10hv_spice_version = "v17.1" 
aprintversion print_version
+ version = nxp_smos10hv_spice_version
+ package = "NXP_SMOS10HV_SPICE" 

//***********************************************************
endsection base
//***********************************************************


//***********************************************************
section smos10hv_case_default
parameters case=0
endsection smos10hv_case_default
//***********************************************************

//***********************************************************
section smos10hv_enable_case_sweep
parameters enable_case_sweep=1
endsection smos10hv_enable_case_sweep
//***********************************************************

//***********************************************************
section smos10hv_disable_case_sweep
parameters enable_case_sweep=0
endsection smos10hv_disable_case_sweep
//***********************************************************

//***********************************************************
section smos10hv_enable_soa
parameters enable_soa=1
ahdl_include "./veriloga/monitors.va"

endsection smos10hv_enable_soa
//***********************************************************

//***********************************************************
section smos10hv_disable_soa
parameters enable_soa=0
endsection smos10hv_disable_soa
//***********************************************************

//***********************************************************
section smos10hv_enable_sti
parameters enable_sti=1
endsection smos10hv_enable_sti
//***********************************************************

//***********************************************************
section smos10hv_disable_sti
parameters enable_sti=0
endsection smos10hv_disable_sti
//***********************************************************

//***********************************************************
section smos10hv_enable_wpe
parameters enable_wpe=1
endsection smos10hv_enable_wpe
//***********************************************************

//***********************************************************
section smos10hv_disable_wpe
parameters enable_wpe=0
endsection smos10hv_disable_wpe
//***********************************************************

//***********************************************************
section smos10hv_enable_dte
parameters enable_dte=1
endsection smos10hv_enable_dte
//***********************************************************

//***********************************************************
section smos10hv_disable_dte
parameters enable_dte=0
endsection smos10hv_disable_dte
//***********************************************************

//***********************************************************
section smos10hv_enable_esdsoa
parameters enable_esdsoa=1
ahdl_include "./veriloga/monitors.va"

ahdl_include "./veriloga/monitors_esd.va"

endsection smos10hv_enable_esdsoa
//***********************************************************

//***********************************************************
section smos10hv_disable_esdsoa
parameters enable_esdsoa=0
endsection smos10hv_disable_esdsoa
//***********************************************************

//***********************************************************
section smos10hv_enable_relimo
parameters enable_relimo=1
ahdl_include "./veriloga/relimo.va"

endsection smos10hv_enable_relimo
//***********************************************************

//***********************************************************
section smos10hv_disable_relimo
parameters enable_relimo=0
endsection smos10hv_disable_relimo
//***********************************************************

//***********************************************************
section smos10hv_enable_aging
parameters enable_aging=1
ahdl_include "./veriloga/hcilitesim2_nxp.va"

ahdl_include "./veriloga/nbtisim4_nxp.va"

ahdl_include "./veriloga/pbtisim4_nxp.va"

ahdl_include "./veriloga/hcihvsim5_nxp.va"

ahdl_include "./veriloga/rvbesim2_nxp.va"

endsection smos10hv_enable_aging
//***********************************************************

//***********************************************************
section smos10hv_disable_aging
parameters enable_aging=0
endsection smos10hv_disable_aging
//***********************************************************

//***********************************************************
section smos10hv_moscap_enable
parameters moscap=1
endsection smos10hv_moscap_enable
//***********************************************************

//***********************************************************
section smos10hv_moscap_disable
parameters moscap=0
endsection smos10hv_moscap_disable
//***********************************************************

//***********************************************************
section powermosbvdss_default
parameters bvdss_shift=0
endsection powermosbvdss_default
//***********************************************************

//***********************************************************
section powermosbvdss_off
parameters bvdss_shift=500
endsection powermosbvdss_off
//***********************************************************

//***********************************************************
section smos10hv_selfheat_enable
parameters enable_selfheat=1
endsection smos10hv_selfheat_enable
//***********************************************************

//***********************************************************
section smos10hv_selfheat_disable
parameters enable_selfheat=0
endsection smos10hv_selfheat_disable
//***********************************************************

//***********************************************************
section smos10hv_risk_assessment_enable
parameters enable_risk_assessment=1
ahdl_include "./veriloga/monitors.va"

ahdl_include "./veriloga/monitors_esd.va"

ahdl_include "./veriloga/relimo.va"

ahdl_include "./veriloga/hcilitesim2_nxp.va"

ahdl_include "./veriloga/nbtisim4_nxp.va"

ahdl_include "./veriloga/pbtisim4_nxp.va"

ahdl_include "./veriloga/hcihvsim5_nxp.va"

ahdl_include "./veriloga/rvbesim2_nxp.va"

endsection smos10hv_risk_assessment_enable
//***********************************************************

//***********************************************************
section smos10hv_risk_assessment_disable
parameters enable_risk_assessment=0
endsection smos10hv_risk_assessment_disable
//***********************************************************

//***********************************************************
section smos10hv_risk_assessment_disable_afs
parameters enable_risk_assessment=0
ahdl_include "./veriloga/monitors.va"

ahdl_include "./veriloga/monitors_esd.va"

ahdl_include "./veriloga/relimo.va"

ahdl_include "./veriloga/hcilitesim2_nxp.va"

ahdl_include "./veriloga/nbtisim4_nxp.va"

ahdl_include "./veriloga/pbtisim4_nxp.va"

ahdl_include "./veriloga/hcihvsim5_nxp.va"

ahdl_include "./veriloga/rvbesim2_nxp.va"

endsection smos10hv_risk_assessment_disable_afs
//***********************************************************

//***********************************************************
section smos10hv_xpart_default
parameters xpart_bsim_flag=0
endsection smos10hv_xpart_default
//***********************************************************

//***********************************************************
section smos10hv_xpart_enable
parameters xpart_bsim_flag=1
endsection smos10hv_xpart_enable
//***********************************************************

//***********************************************************
section smos10hv_bjt_punch_through_enable
parameters enable_punch_through=1
endsection smos10hv_bjt_punch_through_enable
//***********************************************************

//***********************************************************
section smos10hv_bjt_punch_through_disable
parameters enable_punch_through=0
endsection smos10hv_bjt_punch_through_disable
//***********************************************************

//***********************************************************
section smos10hv_res_tc_spread_disable
parameters enable_res_tc_spread=0
endsection smos10hv_res_tc_spread_disable
//***********************************************************

//***********************************************************
section smos10hv_res_tc_spread_enable
parameters enable_res_tc_spread=1
endsection smos10hv_res_tc_spread_enable
//***********************************************************

//***********************************************************

//***********************************************************
//***********************************************************

//***********************************************************
//***********************************************************

//***********************************************************
//***********************************************************

//***********************************************************
section power_process_params
//***********************************************************

parameters
+    nom_delr_nld65_10hv_tox        = (1.01933)
+    nom_dela_nld65_10hv_vfb        = (0.0718777)
+    nom_dela_nld65_10hv_vtw        = (0.00804778)
+    nom_delr_nld65_10hv_res        = (0.996227)
+    nom_delr_nld65_10hv_uch        = (1.02605)
+    nom_dela_nld65_10hv_dwres      = (-0.00923629)
+    sig_delr_nld65_10hv_tox        = (0.012)
+    sig_dela_nld65_10hv_vfb        = (0.0638272)
+    sig_dela_nld65_10hv_vtw        = (0.126854)
+    sig_delr_nld65_10hv_res        = (0.0401816)
+    sig_delr_nld65_10hv_uch        = (0.0662184)
+    sig_dela_nld65_10hv_dwres      = (0.302407)
+    nom_delr_nld90_10hv_tox        = (1.01933)
+    nom_dela_nld90_10hv_vfb        = (0.0484656)
+    nom_dela_nld90_10hv_vtw        = (0.01)
+    nom_delr_nld90_10hv_res        = (1.011)
+    nom_delr_nld90_10hv_uch        = (0.9975)
+    nom_dela_nld90_10hv_dwmos      = (-0.005)
+    nom_dela_nld90_10hv_dwres      = (0.99)
+    sig_delr_nld90_10hv_tox        = (0.012)
+    sig_dela_nld90_10hv_vfb        = (0.06005)
+    sig_dela_nld90_10hv_vtw        = (0.6015)
+    sig_delr_nld90_10hv_res        = (0.0458401)
+    sig_delr_nld90_10hv_uch        = (0.0409)
+    sig_dela_nld90_10hv_dwmos      = (0.0327366)
+    sig_dela_nld90_10hv_dwres      = (0.0327366)
+    nom_delr_pld90_10hv_tox        = (0.985443)
+    nom_dela_pld90_10hv_vfb        = (0.0170247)
+    nom_dela_pld90_10hv_vtm        = (-9.15107)
+    nom_delr_pld90_10hv_res        = (1.05393)
+    nom_delr_pld90_10hv_uch        = (1.04618)
+    sig_delr_pld90_10hv_tox        = (0.012)
+    sig_dela_pld90_10hv_vfb        = (0.0289816)
+    sig_dela_pld90_10hv_vtm        = (7.7075)
+    sig_delr_pld90_10hv_res        = (0.075665)
+    sig_delr_pld90_10hv_uch        = (0.0340078)
+    nom_delr_nld45_tlp_10hv_tox    = (1.0235)
+    nom_dela_nld45_tlp_10hv_vfb    = (0.04745)
+    nom_dela_nld45_tlp_10hv_vtm    = (0)
+    nom_delr_nld45_tlp_10hv_res    = (0.989481)
+    nom_delr_nld45_tlp_10hv_uch    = (0.975771)
+    nom_dela_nld45_tlp_10hv_dr     = (-0.112)
+    nom_dela_nld45_tlp_10hv_dw     = (0.0462262)
+    nom_dela_nld45_tlp_10hv_a0     = (0.283213)
+    nom_dela_nld45_tlp_10hv_b0     = (-0.161165)
+    sig_delr_nld45_tlp_10hv_tox    = (0.012)
+    sig_dela_nld45_tlp_10hv_vfb    = (0.0862978)
+    sig_dela_nld45_tlp_10hv_vtm    = (0.132135)
+    sig_delr_nld45_tlp_10hv_res    = (0.0234222)
+    sig_delr_nld45_tlp_10hv_uch    = (0.069729)
+    sig_dela_nld45_tlp_10hv_dr     = (0.222355)
+    sig_dela_nld45_tlp_10hv_dw     = (0.00001)
+    sig_dela_nld45_tlp_10hv_a0     = (0.350464)
+    sig_dela_nld45_tlp_10hv_b0     = (0.0592646)
+    nom_delr_nld30_10hv_tox        = (1.01939)
+    nom_dela_nld30_10hv_vfb        = (0.018)
+    nom_dela_nld30_10hv_vtm        = (-0.07)
+    nom_delr_nld30_10hv_res        = (0.965166)
+    nom_delr_nld30_10hv_uch        = (0.9995)
+    nom_dela_nld30_10hv_dw         = (-0.026)
+    nom_dela_nld30_10hv_dr         = (-0.10894)
+    sig_delr_nld30_10hv_tox        = (0.012)
+    sig_dela_nld30_10hv_vfb        = (0.0619707)
+    sig_dela_nld30_10hv_vtm        = (0.794541)
+    sig_delr_nld30_10hv_res        = (0)
+    sig_delr_nld30_10hv_uch        = (0.0423256)
+    sig_dela_nld30_10hv_dw         = (0.0246278)
+    sig_dela_nld30_10hv_dr         = (0)
+    nom_delr_nld45_10hv_tox        = (1.01939)
+    nom_dela_nld45_10hv_vfb        = (-0.0522634)
+    nom_dela_nld45_10hv_vtm        = (-3.83)
+    nom_delr_nld45_10hv_res        = (0.976315)
+    nom_delr_nld45_10hv_uch        = (0.956524)
+    nom_dela_nld45_10hv_dw         = (0.0144126)
+    nom_dela_nld45_10hv_dr         = (0.2504347)
+    sig_delr_nld45_10hv_tox        = (0.012)
+    sig_dela_nld45_10hv_vfb        = (0.069337)
+    sig_dela_nld45_10hv_vtm        = (0.428024)
+    sig_delr_nld45_10hv_res        = (0.02334)
+    sig_delr_nld45_10hv_uch        = (0.061874)
+    sig_dela_nld45_10hv_dw         = (0.0313533)
+    sig_dela_nld45_10hv_dr         = (0.0778939)
+    nom_delr_nld45_he_10hv_tox     = (1.01939)
+    nom_dela_nld45_he_10hv_vfb     = (0.0580476)
+    nom_dela_nld45_he_10hv_vtm     = (0.012)
+    nom_delr_nld45_he_10hv_res     = (1.05357)
+    nom_delr_nld45_he_10hv_uch     = (1.09605)
+    nom_dela_nld45_he_10hv_dw      = (0.15562)
+    nom_dela_nld45_he_10hv_dr      = (0.23)
+    nom_dela_nld45_he_10hv_a0      = (0.645173)
+    nom_dela_nld45_he_10hv_b0      = (-1.01635)
+    sig_delr_nld45_he_10hv_tox     = (0.012)
+    sig_dela_nld45_he_10hv_vfb     = (0.0725214)
+    sig_dela_nld45_he_10hv_vtm     = (0.097222)
+    sig_delr_nld45_he_10hv_res     = (0.0307225)
+    sig_delr_nld45_he_10hv_uch     = (0.0341504)
+    sig_dela_nld45_he_10hv_dw      = (0.00001)
+    sig_dela_nld45_he_10hv_dr      = (0.2178555)
+    sig_dela_nld45_he_10hv_a0      = (0.353012)
+    sig_dela_nld45_he_10hv_b0      = (0.0947028)
+    nom_delr_pld5_10hv_tox         = (1.00674)
+    nom_dela_pld5_10hv_vfb         = (0.01074+0.0045)
+    nom_dela_pld5_10hv_vtm         = (-1.68)
+    nom_delr_pld5_10hv_uch         = (1.02842)
+    nom_dela_pld5_10hv_dw          = (0.00118744)
+    sig_delr_pld5_10hv_tox         = (0.012)
+    sig_dela_pld5_10hv_vfb         = (0.0442389)
+    sig_dela_pld5_10hv_vtm         = (1.28331)
+    sig_delr_pld5_10hv_uch         = (0.0601767)
+    sig_dela_pld5_10hv_dw          = (0.026449)
+    nom_delr_nld5_10hv_tox         = (1.01932)
+    nom_dela_nld5_10hv_vfb         = (-0.036)
+    nom_delr_nld5_10hv_res         = (1.26579)
+    nom_delr_nld5_10hv_uch         = (1.15)
+    nom_delr_nld5_10hv_vsat        = (0.739866)
+    nom_dela_nld5_10hv_dwmos       = (0.02)
+    nom_dela_nld5_10hv_vtw         = (-0.036)
+    sig_delr_nld5_10hv_tox         = (0.012)
+    sig_dela_nld5_10hv_vfb         = (0.0788536)
+    sig_delr_nld5_10hv_res         = (0)
+    sig_delr_nld5_10hv_uch         = (0.0489991)
+    sig_delr_nld5_10hv_vsat        = (0.198844)
+    sig_dela_nld5_10hv_dwmos       = (0.0263316)
+    sig_dela_nld5_10hv_vtw         = (0.121508)
+    nom_delr_pld10_10hv_tox        = (1.0)
+    nom_dela_pld10_10hv_vfb        = (-0.0751361)
+    nom_delr_pld10_10hv_res        = (0.952313)
+    nom_delr_pld10_10hv_uch        = (0.947542)
+    nom_dela_pld10_10hv_vtw        = (-0.129167)
+    nom_dela_pld10_10hv_dwres      = (-0.0258223)
+    nom_dela_pld10_10hv_dwmos      = (-0.0277873)
+    sig_delr_pld10_10hv_tox        = (0.012)
+    sig_dela_pld10_10hv_vfb        = (0.0968265)
+    sig_delr_pld10_10hv_res        = (0.0904549)
+    sig_delr_pld10_10hv_uch        = (0.0219198)
+    sig_dela_pld10_10hv_vtw        = (0.270752)
+    sig_dela_pld10_10hv_dwres      = (0.0430638)
+    sig_dela_pld10_10hv_dwmos      = (0.0224861)
+    nom_delr_tox_pld10b_sphv_10hv  = (1.0)
+    nom_dela_dw_pld10b_sphv_10hv   = (0.0331566)
+    nom_dela_vfb_pld10b_sphv_10hv  = (0.104725)
+    nom_dela_vtwl_pld10b_sphv_10hv = (0.00377181)
+    nom_delr_mobref_pld10b_sphv_10hv = (1.03359)
+    nom_delr_rshl_pld10b_sphv_10hv = (1.04606)
+    sig_delr_tox_pld10b_sphv_10hv  = (0.012)
+    sig_dela_dw_pld10b_sphv_10hv   = (0.0187517)
+    sig_dela_vfb_pld10b_sphv_10hv  = (0.134718)
+    sig_dela_vtwl_pld10b_sphv_10hv = (0.0163252)
+    sig_delr_mobref_pld10b_sphv_10hv = (0.0238641)
+    sig_delr_rshl_pld10b_sphv_10hv = (0.0466098)
+    fac_rth_pld10b_sphv_10hv       = (2.5)
+    tc1_ecrit_pld10b_sphv_10hv     = (0.0015)
+    tc2_ecrit_pld10b_sphv_10hv     = (0.0)
+    dwrjundo_pld10b_sphv_10hv      = (0.0)
+    dwrjunso_pld10b_sphv_10hv      = (0.0)
+    qmc_pld10b_sphv_10hv           = (1.0)
+    lvaro_pld10b_sphv_10hv         = (0.0)
+    lvarl_pld10b_sphv_10hv         = (0.0)
+    lvarw_pld10b_sphv_10hv         = (0.0)
+    lap_pld10b_sphv_10hv           = (0.0)
+    wvaro_pld10b_sphv_10hv         = (-5e-08)
+    wvarl_pld10b_sphv_10hv         = (0.0)
+    wvarw_pld10b_sphv_10hv         = (0.0)
+    wot_pld10b_sphv_10hv           = (0.0)
+    dlq_pld10b_sphv_10hv           = (0.65e-07)
+    dwq_pld10b_sphv_10hv           = (3.5e-07)
+    vfbo_pld10b_sphv_10hv          = (-0.5)
+    vfbl_pld10b_sphv_10hv          = (0.0)
+    vfbw_pld10b_sphv_10hv          = (0.0)
+    vfblw_pld10b_sphv_10hv         = (0.0)
+    stvfbo_pld10b_sphv_10hv        = (0.0001)
+    stvfbl_pld10b_sphv_10hv        = (0.0)
+    stvfbw_pld10b_sphv_10hv        = (0.0)
+    stvfblw_pld10b_sphv_10hv       = (0.0)
+    toxo_pld10b_sphv_10hv          = (1.333e-08)
+    epsroxo_pld10b_sphv_10hv       = (3.9)
+    nsubo_pld10b_sphv_10hv         = (2.5e+21)
+    nsubw_pld10b_sphv_10hv         = (0.0)
+    wseg_pld10b_sphv_10hv          = (1e-08)
+    npck_pld10b_sphv_10hv          = (1e+23)
+    npckw_pld10b_sphv_10hv         = (0.0)
+    wsegp_pld10b_sphv_10hv         = (1e-08)
+    lpck_pld10b_sphv_10hv          = (0.0)
+    lpckw_pld10b_sphv_10hv         = (0.0)
+    fol1_pld10b_sphv_10hv          = (0.0)
+    fol2_pld10b_sphv_10hv          = (0.0)
+    facneffaco_pld10b_sphv_10hv    = (8.0)
+    facneffacl_pld10b_sphv_10hv    = (0.0)
+    facneffacw_pld10b_sphv_10hv    = (0.0)
+    facneffaclw_pld10b_sphv_10hv   = (0.0)
+    gfacnudo_pld10b_sphv_10hv      = (1.0)
+    gfacnudl_pld10b_sphv_10hv      = (0.0)
+    gfacnudlexp_pld10b_sphv_10hv   = (1.0)
+    gfacnudw_pld10b_sphv_10hv      = (0.0)
+    gfacnudlw_pld10b_sphv_10hv     = (0.0)
+    vsbnudo_pld10b_sphv_10hv       = (0.0)
+    dvsbnudo_pld10b_sphv_10hv      = (1.0)
+    vnsubo_pld10b_sphv_10hv        = (0.0)
+    nslpo_pld10b_sphv_10hv         = (0.05)
+    dnsubo_pld10b_sphv_10hv        = (0.0)
+    dphibo_pld10b_sphv_10hv        = (0.7)
+    dphibl_pld10b_sphv_10hv        = (0.0)
+    dphiblexp_pld10b_sphv_10hv     = (1.0)
+    dphibw_pld10b_sphv_10hv        = (0.0)
+    dphiblw_pld10b_sphv_10hv       = (0.0)
+    delvtaco_pld10b_sphv_10hv      = (-1.0)
+    delvtacl_pld10b_sphv_10hv      = (0.0)
+    delvtaclexp_pld10b_sphv_10hv   = (1.0)
+    delvtacw_pld10b_sphv_10hv      = (0.0)
+    delvtaclw_pld10b_sphv_10hv     = (0.0)
+    npo_pld10b_sphv_10hv           = (0.0)
+    npl_pld10b_sphv_10hv           = (0.0)
+    cto_pld10b_sphv_10hv           = (1.0)
+    ctl_pld10b_sphv_10hv           = (0.0)
+    ctlexp_pld10b_sphv_10hv        = (1.0)
+    ctw_pld10b_sphv_10hv           = (0.6)
+    ctlw_pld10b_sphv_10hv          = (0.0)
+    toxovo_pld10b_sphv_10hv        = (1.333e-08)
+    toxovdo_pld10b_sphv_10hv       = (1.333e-08)
+    lov_pld10b_sphv_10hv           = (0.0)
+    dlovd_pld10b_sphv_10hv         = (1.0e-08)
+    novo_pld10b_sphv_10hv          = (5e+25)
+    novdo_pld10b_sphv_10hv         = (8e+22)
+    cfl_pld10b_sphv_10hv           = (0.00025)
+    cflexp_pld10b_sphv_10hv        = (2.0)
+    cfw_pld10b_sphv_10hv           = (0.5)
+    cfbo_pld10b_sphv_10hv          = (0.0)
+    uo_pld10b_sphv_10hv            = (0.0165)
+    fbet1_pld10b_sphv_10hv         = (0.0)
+    fbet1w_pld10b_sphv_10hv        = (0.0)
+    lp1_pld10b_sphv_10hv           = (1e-08)
+    lp1w_pld10b_sphv_10hv          = (0.0)
+    fbet2_pld10b_sphv_10hv         = (0.0)
+    lp2_pld10b_sphv_10hv           = (1e-08)
+    betw1_pld10b_sphv_10hv         = (0.0)
+    betw2_pld10b_sphv_10hv         = (0.0)
+    wbet_pld10b_sphv_10hv          = (1e-09)
+    stbeto_pld10b_sphv_10hv        = (0.85)
+    stbetl_pld10b_sphv_10hv        = (0.0)
+    stbetw_pld10b_sphv_10hv        = (0.0)
+    stbetlw_pld10b_sphv_10hv       = (0.0)
+    mueo_pld10b_sphv_10hv          = (2.1)
+    muew_pld10b_sphv_10hv          = (0.3)
+    stmueo_pld10b_sphv_10hv        = (0.0)
+    themuo_pld10b_sphv_10hv        = (1.1)
+    stthemuo_pld10b_sphv_10hv      = (1.5)
+    cso_pld10b_sphv_10hv           = (0.0)
+    csl_pld10b_sphv_10hv           = (0.0)
+    cslexp_pld10b_sphv_10hv        = (0.0)
+    csw_pld10b_sphv_10hv           = (0.0)
+    cslw_pld10b_sphv_10hv          = (0.0)
+    stcso_pld10b_sphv_10hv         = (0.0)
+    xcoro_pld10b_sphv_10hv         = (0.0)
+    xcorl_pld10b_sphv_10hv         = (0.0)
+    xcorw_pld10b_sphv_10hv         = (0.0)
+    xcorlw_pld10b_sphv_10hv        = (0.0)
+    stxcoro_pld10b_sphv_10hv       = (0.0)
+    fetao_pld10b_sphv_10hv         = (1.0)
+    rsw1_pld10b_sphv_10hv          = (0.0)
+    rsw2_pld10b_sphv_10hv          = (0.0)
+    strso_pld10b_sphv_10hv         = (1.0)
+    rsbo_pld10b_sphv_10hv          = (0.0)
+    rsgo_pld10b_sphv_10hv          = (0.0)
+    thesato_pld10b_sphv_10hv       = (0.0555)
+    thesatl_pld10b_sphv_10hv       = (0.0)
+    thesatlexp_pld10b_sphv_10hv    = (1.0)
+    thesatw_pld10b_sphv_10hv       = (-0.6)
+    thesatlw_pld10b_sphv_10hv      = (0.0)
+    stthesato_pld10b_sphv_10hv     = (1.35)
+    stthesatl_pld10b_sphv_10hv     = (0.0)
+    stthesatw_pld10b_sphv_10hv     = (0.0)
+    stthesatlw_pld10b_sphv_10hv    = (0.0)
+    thesatbo_pld10b_sphv_10hv      = (0.0)
+    thesatgo_pld10b_sphv_10hv      = (22.6)
+    thesatgl_pld10b_sphv_10hv      = (0.0)
+    thesatgw_pld10b_sphv_10hv      = (0.0)
+    axo_pld10b_sphv_10hv           = (2.0)
+    axl_pld10b_sphv_10hv           = (0.0)
+    alpl_pld10b_sphv_10hv          = (0.0005)
+    alplexp_pld10b_sphv_10hv       = (1.0)
+    alpw_pld10b_sphv_10hv          = (0.0)
+    alp1l1_pld10b_sphv_10hv        = (0.0)
+    alp1lexp_pld10b_sphv_10hv      = (0.5)
+    alp1l2_pld10b_sphv_10hv        = (0.0)
+    alp1w_pld10b_sphv_10hv         = (0.0)
+    alp2l1_pld10b_sphv_10hv        = (0.0)
+    alp2lexp_pld10b_sphv_10hv      = (0.5)
+    alp2l2_pld10b_sphv_10hv        = (0.0)
+    alp2w_pld10b_sphv_10hv         = (0.0)
+    vpo_pld10b_sphv_10hv           = (0.05)
+    a1o_pld10b_sphv_10hv           = (1.0)
+    a1l_pld10b_sphv_10hv           = (0.0)
+    a1w_pld10b_sphv_10hv           = (0.0)
+    a2o_pld10b_sphv_10hv           = (10.0)
+    sta2o_pld10b_sphv_10hv         = (0.0)
+    a3o_pld10b_sphv_10hv           = (1.0)
+    a3l_pld10b_sphv_10hv           = (0.0)
+    a3w_pld10b_sphv_10hv           = (0.0)
+    a4o_pld10b_sphv_10hv           = (0.0)
+    a4l_pld10b_sphv_10hv           = (0.0)
+    a4w_pld10b_sphv_10hv           = (0.0)
+    gcoo_pld10b_sphv_10hv          = (0.0)
+    iginvlw_pld10b_sphv_10hv       = (0.0)
+    igovw_pld10b_sphv_10hv         = (0.0)
+    igovdw_pld10b_sphv_10hv        = (0.0)
+    stigo_pld10b_sphv_10hv         = (2.0)
+    gc2o_pld10b_sphv_10hv          = (0.375)
+    gc3o_pld10b_sphv_10hv          = (0.063)
+    chibo_pld10b_sphv_10hv         = (3.1)
+    agidlw_pld10b_sphv_10hv        = (0.0)
+    agidldw_pld10b_sphv_10hv       = (0.0)
+    bgidlo_pld10b_sphv_10hv        = (41.0)
+    bgidldo_pld10b_sphv_10hv       = (41.0)
+    stbgidlo_pld10b_sphv_10hv      = (0.0)
+    stbgidldo_pld10b_sphv_10hv     = (0.0)
+    cgidlo_pld10b_sphv_10hv        = (0.0)
+    cgidldo_pld10b_sphv_10hv       = (0.0)
+    cgbovl_pld10b_sphv_10hv        = (0.0)
+    cfrw_pld10b_sphv_10hv          = (0.0)
+    cfrdw_pld10b_sphv_10hv         = (7.0e-17)
+    fnto_pld10b_sphv_10hv          = (1.0)
+    nfalw_pld10b_sphv_10hv         = (1e+26)
+    nfblw_pld10b_sphv_10hv         = (0.0)
+    nfclw_pld10b_sphv_10hv         = (0.0)
+    efo_pld10b_sphv_10hv           = (1.0)
+    lintnoi_pld10b_sphv_10hv       = (0.0)
+    alpnoi_pld10b_sphv_10hv        = (2.0)
+    kvthoweo_pld10b_sphv_10hv      = (0.0)
+    kvthowel_pld10b_sphv_10hv      = (0.0)
+    kvthowew_pld10b_sphv_10hv      = (0.0)
+    kvthowelw_pld10b_sphv_10hv     = (0.0)
+    kuoweo_pld10b_sphv_10hv        = (0.0)
+    kuowel_pld10b_sphv_10hv        = (0.0)
+    kuowew_pld10b_sphv_10hv        = (0.0)
+    kuowelw_pld10b_sphv_10hv       = (0.0)
+    rgo_pld10b_sphv_10hv           = (0.0)
+    rsh_pld10b_sphv_10hv           = (0.0)
+    rbulko_pld10b_sphv_10hv        = (0.0)
+    rwello_pld10b_sphv_10hv        = (0.0)
+    rjunso_pld10b_sphv_10hv        = (0.0)
+    rjundo_pld10b_sphv_10hv        = (5.0e+02)
+    rint_pld10b_sphv_10hv          = (0.0)
+    rvpoly_pld10b_sphv_10hv        = (0.0)
+    rshg_pld10b_sphv_10hv          = (0.0)
+    dlsil_pld10b_sphv_10hv         = (0.0)
+    saref_pld10b_sphv_10hv         = (1e-06)
+    sbref_pld10b_sphv_10hv         = (1e-06)
+    wlod_pld10b_sphv_10hv          = (0.0)
+    kuo_pld10b_sphv_10hv           = (0.0)
+    kvsat_pld10b_sphv_10hv         = (0.0)
+    tkuo_pld10b_sphv_10hv          = (0.0)
+    lkuo_pld10b_sphv_10hv          = (0.0)
+    wkuo_pld10b_sphv_10hv          = (0.0)
+    pkuo_pld10b_sphv_10hv          = (0.0)
+    llodkuo_pld10b_sphv_10hv       = (0.0)
+    wlodkuo_pld10b_sphv_10hv       = (0.0)
+    kvtho_pld10b_sphv_10hv         = (0.0)
+    lkvtho_pld10b_sphv_10hv        = (0.0)
+    wkvtho_pld10b_sphv_10hv        = (0.0)
+    pkvtho_pld10b_sphv_10hv        = (0.0)
+    llodvth_pld10b_sphv_10hv       = (0.0)
+    wlodvth_pld10b_sphv_10hv       = (0.0)
+    stetao_pld10b_sphv_10hv        = (0.0)
+    lodetao_pld10b_sphv_10hv       = (1.0)
+    scref_pld10b_sphv_10hv         = (1e-05)
+    web_pld10b_sphv_10hv           = (0.0)
+    wec_pld10b_sphv_10hv           = (0.0)
+    adr1o_pld10b_sphv_10hv         = (0.0)
+    adr1l_pld10b_sphv_10hv         = (0.0)
+    adr1w_pld10b_sphv_10hv         = (0.0)
+    adr2o_pld10b_sphv_10hv         = (10.0)
+    stadr2o_pld10b_sphv_10hv       = (0.0)
+    adr3o_pld10b_sphv_10hv         = (0.0)
+    adr3l_pld10b_sphv_10hv         = (0.0)
+    adr3w_pld10b_sphv_10hv         = (0.0)
+    adr4o_pld10b_sphv_10hv         = (0.0)
+    adr4l_pld10b_sphv_10hv         = (0.0)
+    adr4w_pld10b_sphv_10hv         = (0.0)
+    adr5o_pld10b_sphv_10hv         = (0.0)
+    adr5l_pld10b_sphv_10hv         = (0.0)
+    adr5w_pld10b_sphv_10hv         = (0.0)
+    bidr1o_pld10b_sphv_10hv        = (0.0)
+    bidr1l_pld10b_sphv_10hv        = (0.0)
+    bidr1w_pld10b_sphv_10hv        = (0.0)
+    bidr2o_pld10b_sphv_10hv        = (0.0)
+    bidr2w_pld10b_sphv_10hv        = (0.0)
+    strtho_pld10b_sphv_10hv        = (0.0)
+    rshldd_pld10b_sphv_10hv        = (26000.0)
+    xw_pld10b_sphv_10hv            = (0.0)
+    nwxw_pld10b_sphv_10hv          = (0.0)
+    xl_pld10b_sphv_10hv            = (0.0)
+    xlw_pld10b_sphv_10hv           = (0.0)
+    dxlsat_pld10b_sphv_10hv        = (0.0)
+    nst_pld10b_sphv_10hv           = (1.0)
+    ats_pld10b_sphv_10hv           = (0.0)
+    dfinf_pld10b_sphv_10hv         = (0.01)
+    dfw_pld10b_sphv_10hv           = (0.0)
+    dfl_pld10b_sphv_10hv           = (0.0)
+    dflw_pld10b_sphv_10hv          = (0.0)
+    dp_pld10b_sphv_10hv            = (2.0)
+    ecrit_pld10b_sphv_10hv         = (17000000.0)
+    ecorn_pld10b_sphv_10hv         = (1500000.0)
+    du_pld10b_sphv_10hv            = (0.02)
+    tc1_pld10b_sphv_10hv           = (0.0033)
+    tc2_pld10b_sphv_10hv           = (6e-06)
+    tc1l_pld10b_sphv_10hv          = (0.0)
+    tc2l_pld10b_sphv_10hv          = (0.0)
+    tc1w_pld10b_sphv_10hv          = (0.0)
+    tc2w_pld10b_sphv_10hv          = (0.0)
+    theacc_pld10b_sphv_10hv        = (0.0)
+    theacc2_pld10b_sphv_10hv       = (0.028)
+    aacc_pld10b_sphv_10hv          = (36.0)
+    rva_pld10b_sphv_10hv           = (1000000.0)
+    dta_pld10b_sphv_10hv           = (0.0)
+    trj_pld10b_sphv_10hv           = (27.0)
+    cjarea_pld10b_sphv_10hv        = (0.001)
+    cjlsti_pld10b_sphv_10hv        = (1e-09)
+    cjlgat_pld10b_sphv_10hv        = (1e-09)
+    vbiarea_pld10b_sphv_10hv       = (1.0)
+    vbisti_pld10b_sphv_10hv        = (1.0)
+    vbigat_pld10b_sphv_10hv        = (1.0)
+    parea_pld10b_sphv_10hv         = (0.5)
+    psti_pld10b_sphv_10hv          = (0.5)
+    pgat_pld10b_sphv_10hv          = (0.5)
+    is1area_pld10b_sphv_10hv       = (1e-12)
+    ttarea_pld10b_sphv_10hv        = (0.0)
+    is2area_pld10b_sphv_10hv       = (0.0)
+    irarea_pld10b_sphv_10hv        = (0.0)
+    stis1area_pld10b_sphv_10hv     = (25.0)
+    stis2area_pld10b_sphv_10hv     = (15.0)
+    stirarea_pld10b_sphv_10hv      = (0.0)
+    n1area_pld10b_sphv_10hv        = (1.0)
+    n2area_pld10b_sphv_10hv        = (2.0)
+    nrarea_pld10b_sphv_10hv        = (100.0)
+    is1lsti_pld10b_sphv_10hv       = (1e-18)
+    ttlsti_pld10b_sphv_10hv        = (0.0)
+    is2lsti_pld10b_sphv_10hv       = (0.0)
+    irlsti_pld10b_sphv_10hv        = (0.0)
+    stis1sti_pld10b_sphv_10hv      = (25.0)
+    stis2sti_pld10b_sphv_10hv      = (15.0)
+    stirsti_pld10b_sphv_10hv       = (0.0)
+    n1sti_pld10b_sphv_10hv         = (1.0)
+    n2sti_pld10b_sphv_10hv         = (2.0)
+    nrsti_pld10b_sphv_10hv         = (100.0)
+    is1lgat_pld10b_sphv_10hv       = (1e-18)
+    ttlgat_pld10b_sphv_10hv        = (0.0)
+    is2lgat_pld10b_sphv_10hv       = (0.0)
+    irlgat_pld10b_sphv_10hv        = (0.0)
+    stis1gat_pld10b_sphv_10hv      = (25.0)
+    stis2gat_pld10b_sphv_10hv      = (15.0)
+    stirgat_pld10b_sphv_10hv       = (0.0)
+    n1gat_pld10b_sphv_10hv         = (1.0)
+    n2gat_pld10b_sphv_10hv         = (2.0)
+    nrgat_pld10b_sphv_10hv         = (100.0)
+    cjaread_pld10b_sphv_10hv       = (0.000135)
+    vbiaread_pld10b_sphv_10hv      = (0.85)
+    vbistid_pld10b_sphv_10hv       = (0.85)
+    vbigatd_pld10b_sphv_10hv       = (0.85)
+    paread_pld10b_sphv_10hv        = (0.35)
+    pstid_pld10b_sphv_10hv         = (0.35)
+    pgatd_pld10b_sphv_10hv         = (0.35)
+    is1aread_pld10b_sphv_10hv      = (5e-08)
+    is1lstid_pld10b_sphv_10hv      = (0.0001)
+    is1lgatd_pld10b_sphv_10hv      = (0.0001)
+    ttaread_pld10b_sphv_10hv       = (5.15e-09)
+    is2aread_pld10b_sphv_10hv      = (0.0)
+    iraread_pld10b_sphv_10hv       = (1e-10)
+    stis1aread_pld10b_sphv_10hv    = (1.0)
+    stis2aread_pld10b_sphv_10hv    = (1.0)
+    stiraread_pld10b_sphv_10hv     = (2800.0)
+    n1aread_pld10b_sphv_10hv       = (1.06)
+    n2aread_pld10b_sphv_10hv       = (2.0)
+    nraread_pld10b_sphv_10hv       = (200.0)
+    ttlstid_pld10b_sphv_10hv       = (7.15e-09)
+    irlstid_pld10b_sphv_10hv       = (1e-10)
+    stis1stid_pld10b_sphv_10hv     = (1.0)
+    stis2stid_pld10b_sphv_10hv     = (1.0)
+    stirstid_pld10b_sphv_10hv      = (2800.0)
+    n1stid_pld10b_sphv_10hv        = (1.06)
+    n2stid_pld10b_sphv_10hv        = (2.0)
+    nrstid_pld10b_sphv_10hv        = (200.0)
+    ttlgatd_pld10b_sphv_10hv       = (5.15e-09)
+    irlgatd_pld10b_sphv_10hv       = (1e-10)
+    stis1gatd_pld10b_sphv_10hv     = (1.0)
+    stis2gatd_pld10b_sphv_10hv     = (1.0)
+    stirgatd_pld10b_sphv_10hv      = (2800.0)
+    n1gatd_pld10b_sphv_10hv        = (1.06)
+    n2gatd_pld10b_sphv_10hv        = (2.0)
+    nrgatd_pld10b_sphv_10hv        = (200.0)
+    vbiaread2_pld10b_sphv_10hv     = (0.85)
+    vbistid2_pld10b_sphv_10hv      = (0.85)
+    paread2_pld10b_sphv_10hv       = (0.35)
+    pstid2_pld10b_sphv_10hv        = (0.35)
+    is1aread2_pld10b_sphv_10hv     = (0.0)
+    ttaread2_pld10b_sphv_10hv      = (5.15e-09)
+    is2aread2_pld10b_sphv_10hv     = (0.0)
+    iraread2_pld10b_sphv_10hv      = (1e-10)
+    stis1aread2_pld10b_sphv_10hv   = (1.0)
+    stis2aread2_pld10b_sphv_10hv   = (1.0)
+    stiraread2_pld10b_sphv_10hv    = (2800.0)
+    n1aread2_pld10b_sphv_10hv      = (1.0)
+    n2aread2_pld10b_sphv_10hv      = (2.0)
+    nraread2_pld10b_sphv_10hv      = (200.0)
+    is1lstid2_pld10b_sphv_10hv     = (0.0)
+    ttlstid2_pld10b_sphv_10hv      = (7.15e-09)
+    is2lstid2_pld10b_sphv_10hv     = (0.0)
+    irlstid2_pld10b_sphv_10hv      = (1e-10)
+    stis1stid2_pld10b_sphv_10hv    = (1.0)
+    stis2stid2_pld10b_sphv_10hv    = (1.0)
+    stirstid2_pld10b_sphv_10hv     = (2800.0)
+    n1stid2_pld10b_sphv_10hv       = (1.0)
+    n2stid2_pld10b_sphv_10hv       = (2.0)
+    nrstid2_pld10b_sphv_10hv       = (200.0)
+    eais1area_pld10b_sphv_10hv     = (1.12)
+    eais2area_pld10b_sphv_10hv     = (1.12)
+    eairarea_pld10b_sphv_10hv      = (1.12)
+    eais1sti_pld10b_sphv_10hv      = (1.12)
+    eais2sti_pld10b_sphv_10hv      = (1.12)
+    eairsti_pld10b_sphv_10hv       = (1.12)
+    eais1gat_pld10b_sphv_10hv      = (1.12)
+    eais2gat_pld10b_sphv_10hv      = (1.12)
+    eairgat_pld10b_sphv_10hv       = (1.12)
+    eais1aread_pld10b_sphv_10hv    = (0.896)
+    eais2aread_pld10b_sphv_10hv    = (0.896)
+    eairaread_pld10b_sphv_10hv     = (0.896)
+    eais1stid_pld10b_sphv_10hv     = (0.896)
+    eais2stid_pld10b_sphv_10hv     = (0.896)
+    eairstid_pld10b_sphv_10hv      = (0.896)
+    eais1gatd_pld10b_sphv_10hv     = (0.896)
+    eais2gatd_pld10b_sphv_10hv     = (0.896)
+    eairgatd_pld10b_sphv_10hv      = (0.896)
+    eais1aread2_pld10b_sphv_10hv   = (0.896)
+    eais2aread2_pld10b_sphv_10hv   = (0.896)
+    eairaread2_pld10b_sphv_10hv    = (0.896)
+    eais1stid2_pld10b_sphv_10hv    = (0.896)
+    eais2stid2_pld10b_sphv_10hv    = (0.896)
+    eairstid2_pld10b_sphv_10hv     = (0.896)
+    ikfarea_pld10b_sphv_10hv       = (0.0)
+    stikfarea_pld10b_sphv_10hv     = (0.0)
+    ikfaread_pld10b_sphv_10hv      = (0.0)
+    dwikfaread_pld10b_sphv_10hv    = (0.0)
+    stikfaread_pld10b_sphv_10hv    = (0.0)
+    nom_delr_pld30_10hv_tox        = (1.00674)
+    nom_dela_pld30_10hv_vfb        = (-0.0218721)
+    nom_dela_pld30_10hv_vtw        = (-0.0269407)
+    nom_delr_pld30_10hv_res        = (0.977527)
+    nom_delr_pld30_10hv_uch        = (0.982889)
+    nom_dela_pld30_10hv_dwmos      = (-0.0506448)
+    nom_dela_pld30_10hv_dwres      = (-0.0508536)
+    sig_delr_pld30_10hv_tox        = (0.012)
+    sig_dela_pld30_10hv_vfb        = (0.0242237)
+    sig_dela_pld30_10hv_vtw        = (0.029719)
+    sig_delr_pld30_10hv_res        = (0.0469342)
+    sig_delr_pld30_10hv_uch        = (0.0374414)
+    sig_dela_pld30_10hv_dwmos      = (0.0359082)
+    sig_dela_pld30_10hv_dwres      = (0.0369618)
+    nom_delr_pld45_10hv_tox        = (1.00674)
+    nom_dela_pld45_10hv_vfb        = (-0.097784)
+    nom_delr_pld45_10hv_res        = (1.06263)
+    nom_delr_pld45_10hv_uch        = (1.12821)
+    nom_dela_pld45_10hv_dwmos      = (0.0630377)
+    nom_dela_pld45_10hv_dwres      = (0.0)
+    nom_dela_pld45_10hv_vtw        = (0.252798)
+    sig_delr_pld45_10hv_tox        = (0.012)
+    sig_dela_pld45_10hv_vfb        = (0.117809)
+    sig_delr_pld45_10hv_res        = (0.0461252)
+    sig_delr_pld45_10hv_uch        = (0.0384698)
+    sig_dela_pld45_10hv_dwmos      = (0.0128571)
+    sig_dela_pld45_10hv_dwres      = (0.0)
+    sig_dela_pld45_10hv_vtw        = (0.0199137)
+    nom_delr_nld5_lvt_10hv_tox     = (1.01932)
+    nom_dela_nld5_lvt_10hv_vfb     = (0.118217)
+    nom_delr_nld5_lvt_10hv_res     = (0.989016)
+    nom_delr_nld5_lvt_10hv_uch     = (0.997286)
+    nom_delr_nld5_lvt_10hv_vsat    = (1)
+    nom_dela_nld5_lvt_10hv_dwmos   = (0.032621)
+    nom_dela_nld5_lvt_10hv_vtw     = (-0.0360793)
+    nom_delr_nld5_lvt_10hv_ub      = (1)
+    sig_delr_nld5_lvt_10hv_tox     = (0.012)
+    sig_dela_nld5_lvt_10hv_vfb     = (0.0889169)
+    sig_delr_nld5_lvt_10hv_res     = (0.0420186)
+    sig_delr_nld5_lvt_10hv_uch     = (0.0370481)
+    sig_delr_nld5_lvt_10hv_vsat    = (0)
+    sig_dela_nld5_lvt_10hv_dwmos   = (0.01858025)
+    sig_dela_nld5_lvt_10hv_vtw     = (0.018665033)
+    sig_delr_nld5_lvt_10hv_ub      = (0)

//***********************************************************
endsection power_process_params
//***********************************************************

//***********************************************************
section stat_mis
//***********************************************************

parameters
+    tmp_nsmm_delr_nld65_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld65_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld65_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld65_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld65_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld90_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld90_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vtl     = 0.0
+    tmp_nsmm_delr_nld90_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld90_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld90_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld90_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vtl     = 0.0
+    tmp_nsmm_delr_pld90_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld90_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vtl     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld30_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld30_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld30_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld30_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld30_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld45_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld45_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld45_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vtw     = 0.0
+    tmp_nsmm_dela_nld45_10hv_cit     = 0.0
+    tmp_nsmm_delr_nld45_10hv_vsat     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld5_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld5_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld5_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld5_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld5_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld5_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld5_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld5_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld5_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld5_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld10_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld10_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld10_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld10_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld10_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vtw     = 0.0
+    tmp_nsmm_delr_gox_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_dela_dw_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_dela_vfb_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_mobref_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_rshl_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_nsub_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_pld30_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld30_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld30_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld30_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld30_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld45_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld45_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld45_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld45_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld45_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld45_10hv_rsh     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vtw     = 0.0
+    tmp_nsmm_dela_bv_dz5_10hv     = 0.0
+    tmp_nsmm_delr_isr_dz5_10hv     = 0.0
+    tmp_nsmm_dela_bv_dz5b_10hv     = 0.0
+    tmp_nsmm_delr_isr_dz5b_10hv     = 0.0
+    tmp_nsmm_delr_is_dnplus_10hv     = 0.0
+    tmp_nsmm_delr_is_dpplus_10hv     = 0.0
+    tmp_nsmm_delr_cdp_10hv     = 0.0
+    tmp_nsmm_delr_cdpf_10hv     = 0.0
+    tmp_nsmm_delr_cdpf_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cglv_10hv_tox     = 0.0
+    tmp_nsmm_delr_cghv_10hv_tox     = 0.0
+    tmp_nsmm_delr_cghvf_10hv     = 0.0
+    tmp_nsmm_delr_cghvf_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfrlv_10hv     = 0.0
+    tmp_nsmm_delr_cfrlv_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr45_10hv     = 0.0
+    tmp_nsmm_delr_cfr45_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr90_10hv     = 0.0
+    tmp_nsmm_delr_cfr90_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr120_10hv     = 0.0
+    tmp_nsmm_delr_cfr120_m1m2m3_10hv     = 0.0
+    tmp_nsmm_dela_dle_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_npn_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_gox_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_voff_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rdsw_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_k1_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_jtss_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_k1_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_jtss_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly0_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rhvpw_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rphv_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly_1meg_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rm1_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm2_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm3_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm4_10hv     = 0.0
+    tmp_nsmm_delr_rsh_ralcap_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rulm_10hv     = 0.0

statistics {
    mismatch {
        vary tmp_nsmm_delr_nld65_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld65_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld65_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld65_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld65_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld65_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld65_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld65_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_nld90_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld90_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld90_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld90_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_delr_nld90_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld90_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld90_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_pld90_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_pld90_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_pld90_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_pld90_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_delr_pld90_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_pld90_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_pld90_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_tlp_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_tlp_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_tlp_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_tlp_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_tlp_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_tlp_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_tlp_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_nld30_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld30_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld30_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld30_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld30_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld30_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld30_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld30_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_10hv_cit     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_10hv_vsat     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_he_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_he_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_he_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_he_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_he_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_he_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld45_he_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld45_he_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_pld5_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_pld5_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_pld5_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_pld5_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_pld5_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_pld5_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_pld5_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_pld5_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_pld10_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_pld10_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_pld10_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_pld10_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_pld10_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_pld10_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_pld10_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_pld10_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_dela_dw_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_mobref_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rshl_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld10b_sphv_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_pld30_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_pld30_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_pld30_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_pld30_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_pld30_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_pld30_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_pld30_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_pld30_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_delr_pld45_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_pld45_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_pld45_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_pld45_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_pld45_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_pld45_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_lvt_10hv_gox     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_lvt_10hv_vfb     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_lvt_10hv_nsub     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_lvt_10hv_vtl     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_lvt_10hv_dwox     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_lvt_10hv_ubref     dist=gauss std=1
        vary tmp_nsmm_delr_nld5_lvt_10hv_rsh     dist=gauss std=1
        vary tmp_nsmm_dela_nld5_lvt_10hv_vtw     dist=gauss std=1
        vary tmp_nsmm_dela_bv_dz5_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_isr_dz5_10hv     dist=gauss std=1
        vary tmp_nsmm_dela_bv_dz5b_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_isr_dz5b_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_is_dnplus_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_is_dpplus_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cdp_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cdpf_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cdpf_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cglv_10hv_tox     dist=gauss std=1
        vary tmp_nsmm_delr_cghv_10hv_tox     dist=gauss std=1
        vary tmp_nsmm_delr_cghvf_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cghvf_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfrlv_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfrlv_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr45_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr45_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr90_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr90_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr120_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_cfr120_m1m2m3_10hv     dist=gauss std=1
        vary tmp_nsmm_dela_dle_npn_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psbe_npn_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psb_npn_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jbei_npn_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jben_npn_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_dela_dle_npn_b_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psbe_npn_b_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psb_npn_b_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jbei_npn_b_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jben_npn_b_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_dela_dle_pnp_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psbe_pnp_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psb_pnp_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jbei_pnp_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jben_pnp_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_dela_dle_pnp_iso_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psbe_pnp_iso_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_psb_pnp_iso_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jbei_pnp_iso_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_jben_pnp_iso_10hv_vbic     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_voff_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rdsw_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_k1_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_jtss_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_k1_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_jtss_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos5_10hv_bsim4     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmoshs45_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_ubref_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos90_10hv_bsim3v3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rpoly0_10hv_r3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rpoly_10hv_r3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rhvpw_10hv_r3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rphv_10hv_r3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rpoly_1meg_10hv_r3     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rm1_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rm2_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rm3_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rm4_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_ralcap_10hv     dist=gauss std=1
        vary tmp_nsmm_delr_rsh_rulm_10hv     dist=gauss std=1
    }
}

parameters
+    tmp_nsmm_dela_dta_dpldd_junc_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtl_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dl_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_vdscale_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_thesato_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_vdscale_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_thesato_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dxw_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfbo_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uo_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshldd_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld90b_sphv_10hv = 0.0

statistics {
    mismatch {
        vary tmp_nsmm_dela_dta_dpldd_junc_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dl_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtl_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rshl_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_gox_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtl_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dl_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pmos10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pmos45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pmos90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pmoshs45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rshl_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nld10_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_nld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_xw_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_vdscale_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_xw_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_thesato_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld45b_he_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_xw_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rsh_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_vdscale_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_thesato_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld45b_tlp_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_gox_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dxw_nld65b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_mobref_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rshl_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_nld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld100_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pld120_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfbo_pld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uo_pld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rshldd_pld30b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_gox_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dw_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_rshl_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld45b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld65_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_tox_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vfb_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_vtw_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_uch_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_res_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_dela_dwox_pld90b_sphv_10hv dist=gauss std=1
        vary tmp_nsmm_delr_nsub_pld90b_sphv_10hv dist=gauss std=1
    }
}

//***********************************************************
endsection stat_mis
//***********************************************************

//***********************************************************
section no_stat_mis
//***********************************************************

parameters
+    tmp_nsmm_delr_nld65_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld65_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld65_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld65_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld65_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld65_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld90_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld90_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vtl     = 0.0
+    tmp_nsmm_delr_nld90_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld90_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld90_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld90_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld90_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vtl     = 0.0
+    tmp_nsmm_delr_pld90_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld90_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld90_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vtl     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_tlp_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_tlp_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld30_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld30_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld30_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld30_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld30_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld30_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld45_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld45_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld45_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_10hv_vtw     = 0.0
+    tmp_nsmm_dela_nld45_10hv_cit     = 0.0
+    tmp_nsmm_delr_nld45_10hv_vsat     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld45_he_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld45_he_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld5_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld5_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld5_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld5_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld5_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld5_10hv_vtw     = 0.0
+    tmp_nsmm_delr_nld5_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld5_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld5_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld5_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld5_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld5_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld10_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld10_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld10_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld10_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld10_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld10_10hv_vtw     = 0.0
+    tmp_nsmm_delr_gox_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_dela_dw_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_dela_vfb_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_mobref_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_rshl_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_nsub_pld10b_sphv_10hv     = 0.0
+    tmp_nsmm_delr_pld30_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld30_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vtl     = 0.0
+    tmp_nsmm_dela_pld30_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld30_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld30_10hv_rsh     = 0.0
+    tmp_nsmm_dela_pld30_10hv_vtw     = 0.0
+    tmp_nsmm_delr_pld45_10hv_gox     = 0.0
+    tmp_nsmm_dela_pld45_10hv_vfb     = 0.0
+    tmp_nsmm_delr_pld45_10hv_nsub     = 0.0
+    tmp_nsmm_dela_pld45_10hv_dwox     = 0.0
+    tmp_nsmm_delr_pld45_10hv_ubref     = 0.0
+    tmp_nsmm_delr_pld45_10hv_rsh     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_gox     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vfb     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_nsub     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vtl     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_dwox     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_ubref     = 0.0
+    tmp_nsmm_delr_nld5_lvt_10hv_rsh     = 0.0
+    tmp_nsmm_dela_nld5_lvt_10hv_vtw     = 0.0
+    tmp_nsmm_dela_bv_dz5_10hv     = 0.0
+    tmp_nsmm_delr_isr_dz5_10hv     = 0.0
+    tmp_nsmm_dela_bv_dz5b_10hv     = 0.0
+    tmp_nsmm_delr_isr_dz5b_10hv     = 0.0
+    tmp_nsmm_delr_is_dnplus_10hv     = 0.0
+    tmp_nsmm_delr_is_dpplus_10hv     = 0.0
+    tmp_nsmm_delr_cdp_10hv     = 0.0
+    tmp_nsmm_delr_cdpf_10hv     = 0.0
+    tmp_nsmm_delr_cdpf_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cglv_10hv_tox     = 0.0
+    tmp_nsmm_delr_cghv_10hv_tox     = 0.0
+    tmp_nsmm_delr_cghvf_10hv     = 0.0
+    tmp_nsmm_delr_cghvf_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfrlv_10hv     = 0.0
+    tmp_nsmm_delr_cfrlv_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr45_10hv     = 0.0
+    tmp_nsmm_delr_cfr45_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr90_10hv     = 0.0
+    tmp_nsmm_delr_cfr90_m1m2m3_10hv     = 0.0
+    tmp_nsmm_delr_cfr120_10hv     = 0.0
+    tmp_nsmm_delr_cfr120_m1m2m3_10hv     = 0.0
+    tmp_nsmm_dela_dle_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_npn_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_npn_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_npn_b_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_pnp_10hv_vbic     = 0.0
+    tmp_nsmm_dela_dle_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psbe_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_psb_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jbei_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_jben_pnp_iso_10hv_vbic     = 0.0
+    tmp_nsmm_delr_gox_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_voff_nmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rdsw_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_k1_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_jtss_pmos_ll_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_k1_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_jtss_pmos_ull_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos_ana_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_tox_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos3_zvt_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nsrampg_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nsrampd_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_psrampu_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_nmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vfb_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_nsub_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtl_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dl_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_dwox_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_ubref_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_rsh_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_dela_vtw_pmos5_10hv_bsim4     = 0.0
+    tmp_nsmm_delr_gox_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmos45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmoshs45_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_nmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_gox_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vfb_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_nsub_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtl_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dl_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_dwox_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_ubref_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_dela_vtw_pmos90_10hv_bsim3v3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly0_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rhvpw_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rphv_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rpoly_1meg_10hv_r3     = 0.0
+    tmp_nsmm_delr_rsh_rm1_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm2_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm3_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rm4_10hv     = 0.0
+    tmp_nsmm_delr_rsh_ralcap_10hv     = 0.0
+    tmp_nsmm_delr_rsh_rulm_10hv     = 0.0



parameters
+    tmp_nsmm_dela_dta_dpldd_junc_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos120_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtl_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dl_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmos90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld10_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_nld10_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_nld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_vdscale_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_thesato_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_he_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_xw_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_rsh_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_vdscale_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_thesato_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld45b_tlp_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dxw_nld65b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_mobref_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_nld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld100_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld100_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld120_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld120_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfbo_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uo_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshldd_pld30b_sphv_10hv = 0.0
+    tmp_nsmm_delr_gox_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dw_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_rshl_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld45b_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld65_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld65_sphv_10hv = 0.0
+    tmp_nsmm_delr_tox_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vfb_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_vtw_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_uch_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_res_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_dela_dwox_pld90b_sphv_10hv = 0.0
+    tmp_nsmm_delr_nsub_pld90b_sphv_10hv = 0.0

//***********************************************************
endsection no_stat_mis
//***********************************************************


//***********************************************************
section case
real casedoe(real case,real casenr,real minpar,real nompar,real maxpar,real sigmapar) {
 return \
(abs(case+casenr)<1e-6?nompar-sigmapar*(nompar-minpar)/3:(abs(case-casenr)<1e-6?nompar+sigmapar*(maxpar-nompar)/3:nompar))
}

if (enable_case_sweep==1) {
//sensitivity_analysis altergroup {
parameters
+ nsig_delr_mosfet_thin_tox_bsim3v3 = casedoe(case,1,3,0,-3,3)
+ nsig_dela_cd_cmos_10hv_bsim3v3 = casedoe(case,2,0,0,0,3)
+ nsig_delr_mosfet_thin_tox_bsim4 = casedoe(case,3,3,0,-3,3)
+ nsig_dela_cd_cmos_10hv_bsim4 = casedoe(case,4,0,0,0,3)
+ nsig_dela_cd_cmos_ana_10hv_bsim4 = casedoe(case,5,0,0,0,3)
+ nsig_dela_dwox_nmos_10hv_bsim4 = casedoe(case,6,-4.9464,0,0.733524,3)
+ nsig_dela_od_nmos_10hv_bsim4 = casedoe(case,7,2.98574,0,-2.26425,3)
+ nsig_dela_vfb_nmos_10hv_bsim4 = casedoe(case,8,1.72352,0,-2.25474,3)
+ nsig_delr_ubref_nmos_10hv_bsim4 = casedoe(case,9,-1.5436,0,1.32229,3)
+ nsig_dela_vtl_nmos_10hv_bsim4 = casedoe(case,10,3.14346,0,-2.45749,3)
+ nsig_dela_vtw_nmos_10hv_bsim4 = casedoe(case,11,2.39546,0,-2.45708,3)
+ nsig_dela_vtm_nmos_10hv_bsim4 = casedoe(case,12,1.58563,0,-1.95063,3)
+ nsig_delr_a0_nmos_10hv_bsim4 = casedoe(case,13,3.19108,0,-2.52559,3)
+ nsig_delr_pvsat_nmos_10hv_bsim4 = casedoe(case,14,5.99312,0,-2.46183,3)
+ nsig_dela_lvoff_nmos_10hv_bsim4 = casedoe(case,15,-3,0,3,3)
+ nsig_dela_pvoff_nmos_10hv_bsim4 = casedoe(case,16,-3,0,3,3)
+ nsig_dela_dwox_nmos_ll_10hv_bsim4 = casedoe(case,17,-3,0,3,3)
+ nsig_dela_vfb_nmos_ll_10hv_bsim4 = casedoe(case,18,1.61466,0,-1.79712,3)
+ nsig_delr_ubref_nmos_ll_10hv_bsim4 = casedoe(case,19,-1.41339,0,1.11611,3)
+ nsig_dela_vtl_nmos_ll_10hv_bsim4 = casedoe(case,20,1.30951,0,-0.604759,3)
+ nsig_dela_vtw_nmos_ll_10hv_bsim4 = casedoe(case,21,1.94804,0,-2.11164,3)
+ nsig_dela_vtm_nmos_ll_10hv_bsim4 = casedoe(case,22,1.93798,0,-1.40494,3)
+ nsig_delr_vsat_nmos_ll_10hv_bsim4 = casedoe(case,23,0.73069,0,1.112225,3)
+ nsig_dela_od_nmos_ll_10hv_bsim4 = casedoe(case,24,6.13962,0,-4.57224,3)
+ nsig_dela_wwl_nmos_ll_10hv_bsim4 = casedoe(case,25,-0.235568,0,1.61405,3)
+ nsig_dela_a0_nmos_ll_10hv_bsim4 = casedoe(case,26,-1.96037,0,3.48912,3)
+ nsig_dela_jtss_nmos_ll_10hv_bsim4 = casedoe(case,27,-3,0,3,3)
+ nsig_dela_dwox_nmos_ull_10hv_bsim4 = casedoe(case,28,-3.37567,0,-1.10482,3)
+ nsig_dela_vfb_nmos_ull_10hv_bsim4 = casedoe(case,29,1.72112,0,-1.88378,3)
+ nsig_delr_ubref_nmos_ull_10hv_bsim4 = casedoe(case,30,-2.01695,0,0.717818,3)
+ nsig_dela_lu0_nmos_ull_10hv_bsim4 = casedoe(case,31,-1.90388,0,1.82955,3)
+ nsig_dela_vtl_nmos_ull_10hv_bsim4 = casedoe(case,32,0.802107,0,-0.73615,3)
+ nsig_dela_vtw_nmos_ull_10hv_bsim4 = casedoe(case,33,2.23472,0,-2.21373,3)
+ nsig_dela_vtm_nmos_ull_10hv_bsim4 = casedoe(case,34,0.485392,0,-0.342032,3)
+ nsig_dela_wwl_nmos_ull_10hv_bsim4 = casedoe(case,35,-2.08703,0,1.04295,3)
+ nsig_delr_vsat_nmos_ull_10hv_bsim4 = casedoe(case,36,1.63178,0,-1.27317,3)
+ nsig_delr_wvsat_nmos_ull_10hv_bsim4 = casedoe(case,37,0,0,0,3)
+ nsig_dela_od_nmos_ull_10hv_bsim4 = casedoe(case,38,0,0,0,3)
+ nsig_dela_a0_nmos_ull_10hv_bsim4 = casedoe(case,39,0,0,0,3)
+ nsig_dela_b0_nmos_ull_10hv_bsim4 = casedoe(case,40,0,0,0,3)
+ nsig_dela_jtss_nmos_ull_10hv_bsim4 = casedoe(case,41,-3.5,0,3,3)
+ nsig_dela_agidl_nmos_ull_10hv_bsim4 = casedoe(case,42,-3.5,0,3,3)
+ nsig_dela_wagidl_nmos_ull_10hv_bsim4 = casedoe(case,43,-3.5,0,3,3)
+ nsig_dela_pvoff_nmos_ull_10hv_bsim4 = casedoe(case,44,-3,0,3,3)
+ nsig_dela_dwox_nmos_ana_10hv_bsim4 = casedoe(case,45,-1.71386,0,1.270136,3)
+ nsig_dela_od_nmos_ana_10hv_bsim4 = casedoe(case,46,1.57866,0,-1.27677,3)
+ nsig_delr_ubref_nmos_ana_10hv_bsim4 = casedoe(case,47,-1.60087,0,1.43123,3)
+ nsig_dela_vfb_nmos_ana_10hv_bsim4 = casedoe(case,48,1.94135,0,-1.91177,3)
+ nsig_dela_vtl_nmos_ana_10hv_bsim4 = casedoe(case,49,1.33274,0,-1.29176,3)
+ nsig_dela_vtw_nmos_ana_10hv_bsim4 = casedoe(case,50,1.37925,0,-1.54289,3)
+ nsig_dela_vtm_nmos_ana_10hv_bsim4 = casedoe(case,51,1.6593,0,-1.87067,3)
+ nsig_delr_vsat_nmos_ana_10hv_bsim4 = casedoe(case,52,-2.33686,0,1.919614,3)
+ nsig_delr_pvsat_nmos_ana_10hv_bsim4 = casedoe(case,53,1.407808,0,-2.35408,3)
+ nsig_dela_wwl_nmos_ana_10hv_bsim4 = casedoe(case,54,1.56829,0,-1.89794,3)
+ nsig_dela_voff_nmos_ana_10hv_bsim4 = casedoe(case,55,-3,0,3,3)
+ nsig_dela_lvoff_nmos_ana_10hv_bsim4 = casedoe(case,56,-3,0,3,3)
+ nsig_dela_pvoff_nmos_ana_10hv_bsim4 = casedoe(case,57,3,0,-3,3)
+ nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = casedoe(case,58,2.40918,0,-2.4258,3)
+ nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = casedoe(case,59,1.1648,0,-0.58551,3)
+ nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = casedoe(case,60,0.676859,0,1.37833,3)
+ nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = casedoe(case,61,1.38093,0,2.86052,3)
+ nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = casedoe(case,62,-1.00515,0,-4.83143,3)
+ nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = casedoe(case,63,0.683,0,-0.339956,3)
+ nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = casedoe(case,64,-0.171126,0,1.98001,3)
+ nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = casedoe(case,65,0.376381,0,0.385337,3)
+ nsig_dela_dwox_nsrampg_10hv_bsim3v3 = casedoe(case,66,-3,0,3,3)
+ nsig_delr_ubref_nsrampg_10hv_bsim3v3 = casedoe(case,67,-1.73015,0,1.55775,3)
+ nsig_dela_vtw_nsrampg_10hv_bsim3v3 = casedoe(case,68,2.65672,0,-2.87925,3)
+ nsig_dela_vtm_nsrampg_10hv_bsim3v3 = casedoe(case,69,-1.14055,0,0.997128,3)
+ nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = casedoe(case,70,1.27703,0,-2.06836,3)
+ nsig_dela_dwox_nsrampd_10hv_bsim3v3 = casedoe(case,71,1.667,0,-0.6037,3)
+ nsig_dela_vfb_nsrampd_10hv_bsim3v3 = casedoe(case,72,-1.939,0,0.6181,3)
+ nsig_delr_ubref_nsrampd_10hv_bsim3v3 = casedoe(case,73,-2.87,0,2.329,3)
+ nsig_dela_b0_nsrampd_10hv_bsim3v3 = casedoe(case,74,-3.221,0,2.309,3)
+ nsig_dela_a0_nsrampd_10hv_bsim3v3 = casedoe(case,75,0,0,0,3)
+ nsig_dela_dl_nsrampd_10hv_bsim3v3 = casedoe(case,76,0.5075,0,-0.2479,3)
+ nsig_dela_vtl_nsrampd_10hv_bsim3v3 = casedoe(case,77,-3.395,0,2.622,3)
+ nsig_dela_vtw_nsrampd_10hv_bsim3v3 = casedoe(case,78,5.056,0,-3.207,3)
+ nsig_dela_vtm_nsrampd_10hv_bsim3v3 = casedoe(case,79,0,0,0,3)
+ nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = casedoe(case,80,1.856,0,-0.9379,3)
+ nsig_delr_vsat_nsrampd_10hv_bsim3v3 = casedoe(case,81,0,0,0,3)
+ nsig_dela_dwox_pmos_10hv_bsim4 = casedoe(case,82,-2.35902,0,1.585144,3)
+ nsig_dela_od_pmos_10hv_bsim4 = casedoe(case,83,3.13242,0,-1.75749,3)
+ nsig_dela_vfb_pmos_10hv_bsim4 = casedoe(case,84,1.79837,0,-2.01187,3)
+ nsig_delr_ubref_pmos_10hv_bsim4 = casedoe(case,85,-3.17742,0,2.21534,3)
+ nsig_dela_vtl_pmos_10hv_bsim4 = casedoe(case,86,3.54336,0,-1.93843,3)
+ nsig_dela_vtw_pmos_10hv_bsim4 = casedoe(case,87,2.11678,0,-2.26426,3)
+ nsig_dela_vtm_pmos_10hv_bsim4 = casedoe(case,88,-2.267076,0,2.206395,3)
+ nsig_dela_a0_pmos_10hv_bsim4 = casedoe(case,89,-3.14416,0,5.54516,3)
+ nsig_dela_pu0_pmos_10hv_bsim4 = casedoe(case,90,-3.56498,0,1.314842,3)
+ nsig_dela_agidl_pmos_10hv_bsim4 = casedoe(case,91,-3,0,3,3)
+ nsig_dela_dwox_pmos_ll_10hv_bsim4 = casedoe(case,92,-3.87318,0,2.005866,3)
+ nsig_dela_vfb_pmos_ll_10hv_bsim4 = casedoe(case,93,-1.9671,0,1.96296,3)
+ nsig_delr_ubref_pmos_ll_10hv_bsim4 = casedoe(case,94,-1.31442,0,1.11197,3)
+ nsig_dela_vtl_pmos_ll_10hv_bsim4 = casedoe(case,95,2.614506,0,-1.098066,3)
+ nsig_dela_vtw_pmos_ll_10hv_bsim4 = casedoe(case,96,1.88567,0,-2.11854,3)
+ nsig_dela_vtm_pmos_ll_10hv_bsim4 = casedoe(case,97,-1.27882,0,1.41581,3)
+ nsig_dela_od_pmos_ll_10hv_bsim4 = casedoe(case,98,3.46231,0,-1.3821,3)
+ nsig_dela_ags_pmos_ll_10hv_bsim4 = casedoe(case,99,3.41338,0,-5.28858,3)
+ nsig_dela_jtss_pmos_ll_10hv_bsim4 = casedoe(case,100,-3,0,3,3)
+ nsig_dela_dwox_pmos_ull_10hv_bsim4 = casedoe(case,101,0,0,0,3)
+ nsig_dela_vfb_pmos_ull_10hv_bsim4 = casedoe(case,102,-2.05347,0,2.12392,3)
+ nsig_delr_ubref_pmos_ull_10hv_bsim4 = casedoe(case,103,-1.56503,0,1.13602,3)
+ nsig_dela_wwl_pmos_ull_10hv_bsim4 = casedoe(case,104,2.969965,0,3.86039,3)
+ nsig_dela_vtl_pmos_ull_10hv_bsim4 = casedoe(case,105,1.78719,0,-1.6491,3)
+ nsig_dela_vtw_pmos_ull_10hv_bsim4 = casedoe(case,106,2.05659,0,-2.23624,3)
+ nsig_dela_vtm_pmos_ull_10hv_bsim4 = casedoe(case,107,0.810168,0,-3.7995,3)
+ nsig_dela_od_pmos_ull_10hv_bsim4 = casedoe(case,108,1.18787,0,-0.887552,3)
+ nsig_dela_a0_pmos_ull_10hv_bsim4 = casedoe(case,109,-0.541051,0,2.48551,3)
+ nsig_dela_la0_pmos_ull_10hv_bsim4 = casedoe(case,110,-0.80914,0,3.29119,3)
+ nsig_dela_pa0_pmos_ull_10hv_bsim4 = casedoe(case,111,0,0,0,3)
+ nsig_dela_b0_pmos_ull_10hv_bsim4 = casedoe(case,112,0,0,0,3)
+ nsig_dela_jtss_pmos_ull_10hv_bsim4 = casedoe(case,113,-3.5,0,3,3)
+ nsig_dela_agidl_pmos_ull_10hv_bsim4 = casedoe(case,114,-3.5,0,3,3)
+ nsig_dela_wagidl_pmos_ull_10hv_bsim4 = casedoe(case,115,-3.5,0,3,3)
+ nsig_dela_vfb_pmos_ana_10hv_bsim4 = casedoe(case,116,2.20673,0,-2.2452,3)
+ nsig_delr_ubref_pmos_ana_10hv_bsim4 = casedoe(case,117,-2.579,0,2.0049,3)
+ nsig_dela_vtl_pmos_ana_10hv_bsim4 = casedoe(case,118,-2.605395,0,2.682515,3)
+ nsig_dela_od_pmos_ana_10hv_bsim4 = casedoe(case,119,3.04066,0,-2.2975,3)
+ nsig_dela_vtw_pmos_ana_10hv_bsim4 = casedoe(case,120,0.785292,0,-2.971372,3)
+ nsig_dela_dwox_pmos_ana_10hv_bsim4 = casedoe(case,121,-2.32098,0,1.750732,3)
+ nsig_dela_vtm_pmos_ana_10hv_bsim4 = casedoe(case,122,-2.524892,0,3.05408,3)
+ nsig_dela_lwl_pmos_ana_10hv_bsim4 = casedoe(case,123,-2.891529,0,-0.3504555,3)
+ nsig_dela_a0_pmos_ana_10hv_bsim4 = casedoe(case,124,-1.6845,0,2.57446,3)
+ nsig_dela_wvoff_pmos_ana_10hv_bsim4 = casedoe(case,125,3,0,-3,3)
+ nsig_dela_pvoff_pmos_ana_10hv_bsim4 = casedoe(case,126,3,0,-3,3)
+ nsig_dela_dwox_psrampu_10hv_bsim3v3 = casedoe(case,127,-0.496,0,-1.376,3)
+ nsig_dela_vfb_psrampu_10hv_bsim3v3 = casedoe(case,128,2.133,0,-2.301,3)
+ nsig_delr_ubref_psrampu_10hv_bsim3v3 = casedoe(case,129,-1.527,0,1.258,3)
+ nsig_dela_dl_psrampu_10hv_bsim3v3 = casedoe(case,130,1.665,0,-1.12,3)
+ nsig_dela_vtl_psrampu_10hv_bsim3v3 = casedoe(case,131,1.877,0,-1.451,3)
+ nsig_dela_vtw_psrampu_10hv_bsim3v3 = casedoe(case,132,1.801,0,-1.763,3)
+ nsig_dela_vtm_psrampu_10hv_bsim3v3 = casedoe(case,133,0.01371,0,0.3214,3)
+ nsig_dela_a0_psrampu_10hv_bsim3v3 = casedoe(case,134,-2.305,0,4.346,3)
+ nsig_dela_wwl_psrampu_10hv_bsim3v3 = casedoe(case,135,0.3462,0,-0.1326,3)
+ nsig_delr_mosfet_thick_tox = casedoe(case,136,3,0,-3,3)
+ nsig_dela_vfb_nmos5_10hv_bsim4 = casedoe(case,137,2.04617,0,-2.04424,3)
+ nsig_dela_vtl_nmos5_10hv_bsim4 = casedoe(case,138,1.57385,0,-1.57989,3)
+ nsig_dela_k3_nmos5_10hv_bsim4 = casedoe(case,139,-0.309007,0,0.11537,3)
+ nsig_dela_vtm_nmos5_10hv_bsim4 = casedoe(case,140,0.573726,0,-0.138234,3)
+ nsig_delr_ubref_nmos5_10hv_bsim4 = casedoe(case,141,-1.57757,0,1.37075,3)
+ nsig_dela_dl_nmos5_10hv_bsim4 = casedoe(case,142,2.35735,0,-1.75337,3)
+ nsig_dela_dwox_nmos5_10hv_bsim4 = casedoe(case,143,-1.50407,0,1.28923,3)
+ nsig_dela_pu0_nmos5_10hv_bsim4 = casedoe(case,144,2.24303,0,-0.225125,3)
+ nsig_dela_ags_nmos5_10hv_bsim4 = casedoe(case,145,0.970468,0,-1.38678,3)
+ nsig_delr_vsat_nmos5_10hv_bsim4 = casedoe(case,146,6.77519,0,-3.95237,3)
+ nsig_dela_b0_nmos5_10hv_bsim4 = casedoe(case,147,-0.544194,0,0.803969,3)
+ nsig_delr_pvsat_nmos5_10hv_bsim4 = casedoe(case,148,-1.44713,0,-1.88573,3)
+ nsig_dela_jts_nmos5_10hv_bsim4 = casedoe(case,149,-3,0,3,3)
+ nsig_dela_vfb_nmos10_10hv_bsim3v3 = casedoe(case,150,2.34413,0,-2.37528,3)
+ nsig_delr_ubref_nmos10_10hv_bsim3v3 = casedoe(case,151,-1.22866,0,1.09365,3)
+ nsig_dela_ags_nmos10_10hv_bsim3v3 = casedoe(case,152,-0.284196,0,-0.411964,3)
+ nsig_dela_vtl_nmos10_10hv_bsim3v3 = casedoe(case,153,2.77366,0,4.28408,3)
+ nsig_dela_dl_nmos10_10hv_bsim3v3 = casedoe(case,154,3.39864,0,-2.05622,3)
+ nsig_delr_vsat_nmos10_10hv_bsim3v3 = casedoe(case,155,2.46465,0,-0.346249,3)
+ nsig_dela_k3_nmos10_10hv_bsim3v3 = casedoe(case,156,-0.151007,0,-0.00218096,3)
+ nsig_dela_b0_nmos10_10hv_bsim3v3 = casedoe(case,157,-0.823273,0,1.14442,3)
+ nsig_dela_dwox_nmos10_10hv_bsim3v3 = casedoe(case,158,-0.596193,0,0.435824,3)
+ nsig_dela_vtm_nmos10_10hv_bsim3v3 = casedoe(case,159,0.873838,0,-0.555343,3)
+ nsig_dela_pu0_nmos10_10hv_bsim3v3 = casedoe(case,160,-0.327584,0,0.642841,3)
+ nsig_dela_vfb_nmos45_10hv_bsim3v3 = casedoe(case,161,2.26554,0,-2.35909,3)
+ nsig_delr_ubref_nmos45_10hv_bsim3v3 = casedoe(case,162,-1.86548,0,1.16321,3)
+ nsig_dela_dl_nmos45_10hv_bsim3v3 = casedoe(case,163,1.41694,0,-1.57185,3)
+ nsig_dela_vtl_nmos45_10hv_bsim3v3 = casedoe(case,164,0.845969,0,-0.451929,3)
+ nsig_dela_vtw_nmos45_10hv_bsim3v3 = casedoe(case,165,0.365386,0,-0.292768,3)
+ nsig_dela_vtm_nmos45_10hv_bsim3v3 = casedoe(case,166,0.550358,0,0.495944,3)
+ nsig_dela_a0_nmos45_10hv_bsim3v3 = casedoe(case,167,0.240476,0,0.815741,3)
+ nsig_dela_la0_nmos45_10hv_bsim3v3 = casedoe(case,168,-1.31622,0,2.2441,3)
+ nsig_dela_dwox_nmos45_10hv_bsim3v3 = casedoe(case,169,-0.434998,0,0.219333,3)
+ nsig_dela_b0_nmos45_10hv_bsim3v3 = casedoe(case,170,0.752381,0,0.0608014,3)
+ nsig_delr_vsat_nmos45_10hv_bsim3v3 = casedoe(case,171,5.55541,0,-3.00159,3)
+ nsig_dela_pa0_nmos45_10hv_bsim3v3 = casedoe(case,172,0.142766,0,-1.39461,3)
+ nsig_dela_vfb_nmos45b_10hv_bsim3v3 = casedoe(case,173,2.26554,0,-2.35909,3)
+ nsig_delr_ubref_nmos45b_10hv_bsim3v3 = casedoe(case,174,-1.86548,0,1.16321,3)
+ nsig_dela_dl_nmos45b_10hv_bsim3v3 = casedoe(case,175,1.41694,0,-1.57185,3)
+ nsig_dela_vtl_nmos45b_10hv_bsim3v3 = casedoe(case,176,0.845969,0,-0.451929,3)
+ nsig_dela_vtw_nmos45b_10hv_bsim3v3 = casedoe(case,177,0.365386,0,-0.292768,3)
+ nsig_dela_vtm_nmos45b_10hv_bsim3v3 = casedoe(case,178,0.550358,0,0.495944,3)
+ nsig_dela_a0_nmos45b_10hv_bsim3v3 = casedoe(case,179,0.240476,0,0.815741,3)
+ nsig_dela_la0_nmos45b_10hv_bsim3v3 = casedoe(case,180,-1.31622,0,2.2441,3)
+ nsig_dela_dwox_nmos45b_10hv_bsim3v3 = casedoe(case,181,-0.434998,0,0.219333,3)
+ nsig_dela_b0_nmos45b_10hv_bsim3v3 = casedoe(case,182,0.752381,0,0.0608014,3)
+ nsig_delr_vsat_nmos45b_10hv_bsim3v3 = casedoe(case,183,5.55541,0,-3.00159,3)
+ nsig_dela_pa0_nmos45b_10hv_bsim3v3 = casedoe(case,184,0.142766,0,-1.39461,3)
+ nsig_delr_tox_nmos90_10hv_bsim3v3 = casedoe(case,185,3,0,-3,3)
+ nsig_dela_dwox_nmos90_10hv_bsim3v3 = casedoe(case,186,0.11929,0,-0.279217,3)
+ nsig_dela_vfb_nmos90_10hv_bsim3v3 = casedoe(case,187,2.15151,0,-2.40499,3)
+ nsig_delr_ubref_nmos90_10hv_bsim3v3 = casedoe(case,188,-1.76356,0,1.62783,3)
+ nsig_dela_dl_nmos90_10hv_bsim3v3 = casedoe(case,189,0.993659,0,-0.806101,3)
+ nsig_dela_vtl_nmos90_10hv_bsim3v3 = casedoe(case,190,0.961763,0,0.83878,3)
+ nsig_dela_vtw_nmos90_10hv_bsim3v3 = casedoe(case,191,0.286005,0,-0.455793,3)
+ nsig_dela_vtm_nmos90_10hv_bsim3v3 = casedoe(case,192,-4.63256,0,-4.59913,3)
+ nsig_dela_a0_nmos90_10hv_bsim3v3 = casedoe(case,193,5.33737,0,-7.41483,3)
+ nsig_delr_rdsw_nmos90_10hv_bsim3v3 = casedoe(case,194,-1.19704,0,-0.971681,3)
+ nsig_dela_wwl_nmos90_10hv_bsim3v3 = casedoe(case,195,0.580746,0,0.274579,3)
+ nsig_delr_tox_nmos90b_10hv_bsim3v3 = casedoe(case,196,3,0,-3,3)
+ nsig_dela_dwox_nmos90b_10hv_bsim3v3 = casedoe(case,197,0.11929,0,-0.279217,3)
+ nsig_dela_vfb_nmos90b_10hv_bsim3v3 = casedoe(case,198,2.15151,0,-2.40499,3)
+ nsig_delr_ubref_nmos90b_10hv_bsim3v3 = casedoe(case,199,-1.76356,0,1.62783,3)
+ nsig_dela_dl_nmos90b_10hv_bsim3v3 = casedoe(case,200,0.993659,0,-0.806101,3)
+ nsig_dela_vtl_nmos90b_10hv_bsim3v3 = casedoe(case,201,0.961763,0,0.83878,3)
+ nsig_dela_vtw_nmos90b_10hv_bsim3v3 = casedoe(case,202,0.286005,0,-0.455793,3)
+ nsig_dela_vtm_nmos90b_10hv_bsim3v3 = casedoe(case,203,-4.63256,0,-4.59913,3)
+ nsig_dela_a0_nmos90b_10hv_bsim3v3 = casedoe(case,204,5.33737,0,-7.41483,3)
+ nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = casedoe(case,205,-1.19704,0,-0.971681,3)
+ nsig_dela_wwl_nmos90b_10hv_bsim3v3 = casedoe(case,206,0.580746,0,0.274579,3)
+ nsig_dela_vfb_pmos5_10hv_bsim4 = casedoe(case,207,1.89563,0,-2.05112,3)
+ nsig_delr_ubref_pmos5_10hv_bsim4 = casedoe(case,208,-1.54061,0,1.14585,3)
+ nsig_dela_a0_pmos5_10hv_bsim4 = casedoe(case,209,0.218193,0,0.640187,3)
+ nsig_dela_vtl_pmos5_10hv_bsim4 = casedoe(case,210,1.60734,0,-0.1428,3)
+ nsig_dela_dl_pmos5_10hv_bsim4 = casedoe(case,211,1.38681,0,-1.07065,3)
+ nsig_dela_vsat_pmos5_10hv_bsim4 = casedoe(case,212,0.678351,0,-0.186741,3)
+ nsig_dela_vtw_pmos5_10hv_bsim4 = casedoe(case,213,-1.05085,0,0.508717,3)
+ nsig_dela_dwox_pmos5_10hv_bsim4 = casedoe(case,214,-1.0178,0,0.894453,3)
+ nsig_dela_wags_pmos5_10hv_bsim4 = casedoe(case,215,6.93143,0,-2.37752,3)
+ nsig_dela_vtm_pmos5_10hv_bsim4 = casedoe(case,216,0.324473,0,0.17376,3)
+ nsig_dela_wwl_pmos5_10hv_bsim4 = casedoe(case,217,0.623428,0,-0.432524,3)
+ nsig_delr_agidl_pmos5_10hv_bsim4 = casedoe(case,218,-3,0,3,3)
+ nsig_dela_vfb_pmos10_10hv_bsim3v3 = casedoe(case,219,1.86642,0,-1.92192,3)
+ nsig_delr_ubref_pmos10_10hv_bsim3v3 = casedoe(case,220,-1.4521,0,1.23843,3)
+ nsig_dela_dl_pmos10_10hv_bsim3v3 = casedoe(case,221,2.49262,0,-1.7282,3)
+ nsig_dela_vtw_pmos10_10hv_bsim3v3 = casedoe(case,222,0.654892,0,-0.67775,3)
+ nsig_dela_vtm_pmos10_10hv_bsim3v3 = casedoe(case,223,-0.13819,0,0.136426,3)
+ nsig_dela_a0_pmos10_10hv_bsim3v3 = casedoe(case,224,-0.438097,0,0.98511,3)
+ nsig_dela_lw_pmos10_10hv_bsim3v3 = casedoe(case,225,-0.506404,0,0.458457,3)
+ nsig_dela_dwox_pmos45_10hv_bsim3v3 = casedoe(case,226,-1.04117,0,0.90877,3)
+ nsig_dela_vfb_pmos45_10hv_bsim3v3 = casedoe(case,227,1.70565,0,-1.71923,3)
+ nsig_delr_ubref_pmos45_10hv_bsim3v3 = casedoe(case,228,-1.54815,0,1.30494,3)
+ nsig_dela_dl_pmos45_10hv_bsim3v3 = casedoe(case,229,0.824405,0,-0.473002,3)
+ nsig_dela_vtl_pmos45_10hv_bsim3v3 = casedoe(case,230,0.695301,0,-0.898824,3)
+ nsig_dela_vtw_pmos45_10hv_bsim3v3 = casedoe(case,231,0.383955,0,-0.424276,3)
+ nsig_dela_vtm_pmos45_10hv_bsim3v3 = casedoe(case,232,0.349959,0,0.0453067,3)
+ nsig_dela_a0_pmos45_10hv_bsim3v3 = casedoe(case,233,-0.765825,0,1.28444,3)
+ nsig_dela_b0_pmos45_10hv_bsim3v3 = casedoe(case,234,-0.384888,0,0.514149,3)
+ nsig_dela_wwl_pmos45_10hv_bsim3v3 = casedoe(case,235,0.282616,0,-0.111216,3)
+ nsig_delr_prsh_pmos45_10hv_bsim3v3 = casedoe(case,236,1.91539,0,-2.21048,3)
+ nsig_dela_dwox_pmos45b_10hv_bsim3v3 = casedoe(case,237,-0.248356,0,0.315682,3)
+ nsig_dela_vfb_pmos45b_10hv_bsim3v3 = casedoe(case,238,1.77506,0,-1.80148,3)
+ nsig_delr_ubref_pmos45b_10hv_bsim3v3 = casedoe(case,239,-1.78263,0,1.48633,3)
+ nsig_dela_dl_pmos45b_10hv_bsim3v3 = casedoe(case,240,1.15768,0,-0.811163,3)
+ nsig_dela_vtl_pmos45b_10hv_bsim3v3 = casedoe(case,241,0.770893,0,-0.82043,3)
+ nsig_dela_vtw_pmos45b_10hv_bsim3v3 = casedoe(case,242,0.352168,0,-0.349849,3)
+ nsig_dela_vtm_pmos45b_10hv_bsim3v3 = casedoe(case,243,0.182073,0,-0.0260309,3)
+ nsig_dela_a0_pmos45b_10hv_bsim3v3 = casedoe(case,244,-10.5899,0,12.9951,3)
+ nsig_dela_b0_pmos45b_10hv_bsim3v3 = casedoe(case,245,0.263859,0,-0.0867154,3)
+ nsig_dela_wwl_pmos45b_10hv_bsim3v3 = casedoe(case,246,1.17575,0,-0.895939,3)
+ nsig_delr_prsh_pmos45b_10hv_bsim3v3 = casedoe(case,247,1.82346,0,-2.17337,3)
+ nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = casedoe(case,248,-0.829482,0,0.67167,3)
+ nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = casedoe(case,249,1.69858,0,-1.71306,3)
+ nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = casedoe(case,250,-1.55233,0,1.31024,3)
+ nsig_dela_dl_pmoshs45_10hv_bsim3v3 = casedoe(case,251,0.817031,0,-0.474836,3)
+ nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = casedoe(case,252,0.709981,0,-0.896897,3)
+ nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = casedoe(case,253,0.351858,0,-0.377743,3)
+ nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = casedoe(case,254,0.427424,0,0.128735,3)
+ nsig_dela_a0_pmoshs45_10hv_bsim3v3 = casedoe(case,255,-0.782574,0,1.30792,3)
+ nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = casedoe(case,256,0.295057,0,-0.0935394,3)
+ nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = casedoe(case,257,1.96163,0,-2.23852,3)
+ nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = casedoe(case,258,-0.829482,0,0.67167,3)
+ nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = casedoe(case,259,1.69858,0,-1.71306,3)
+ nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = casedoe(case,260,-1.55233,0,1.31024,3)
+ nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = casedoe(case,261,0.817031,0,-0.474836,3)
+ nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = casedoe(case,262,0.709981,0,-0.896897,3)
+ nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = casedoe(case,263,0.351858,0,-0.377743,3)
+ nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = casedoe(case,264,0.427424,0,0.128735,3)
+ nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = casedoe(case,265,-0.782574,0,1.30792,3)
+ nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = casedoe(case,266,0.295057,0,-0.0935394,3)
+ nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = casedoe(case,267,1.96163,0,-2.23852,3)
+ nsig_delr_tox_pmos90_10hv_bsim3v3 = casedoe(case,268,3,0,-3,3)
+ nsig_dela_dwox_pmos90_10hv_bsim3v3 = casedoe(case,269,-3.789,0,5.477,3)
+ nsig_dela_vfb_pmos90_10hv_bsim3v3 = casedoe(case,270,2.065,0,-2.105,3)
+ nsig_delr_ubref_pmos90_10hv_bsim3v3 = casedoe(case,271,-0.438,0,0.2836,3)
+ nsig_dela_dl_pmos90_10hv_bsim3v3 = casedoe(case,272,3.294,0,-1.919,3)
+ nsig_dela_vtl_pmos90_10hv_bsim3v3 = casedoe(case,273,1.026,0,-0.5312,3)
+ nsig_dela_vtw_pmos90_10hv_bsim3v3 = casedoe(case,274,0.3818,0,-1.14,3)
+ nsig_dela_vtm_pmos90_10hv_bsim3v3 = casedoe(case,275,0.3988,0,-0.03572,3)
+ nsig_dela_a0_pmos90_10hv_bsim3v3 = casedoe(case,276,-1.467,0,1.661,3)
+ nsig_dela_b0_pmos90_10hv_bsim3v3 = casedoe(case,277,0.812,0,0.1532,3)
+ nsig_dela_wwl_pmos90_10hv_bsim3v3 = casedoe(case,278,-1.703,0,3.43,3)
+ nsig_delr_tox_pmos90b_10hv_bsim3v3 = casedoe(case,279,3,0,-3,3)
+ nsig_dela_dwox_pmos90b_10hv_bsim3v3 = casedoe(case,280,-3.789,0,5.477,3)
+ nsig_dela_vfb_pmos90b_10hv_bsim3v3 = casedoe(case,281,2.065*1.1,0,-2.105*1.1,3)
+ nsig_delr_ubref_pmos90b_10hv_bsim3v3 = casedoe(case,282,-0.438*3,0,0.2836*1.8,3)
+ nsig_dela_dl_pmos90b_10hv_bsim3v3 = casedoe(case,283,3.294*1.1,0,-1.919*0.9,3)
+ nsig_dela_vtl_pmos90b_10hv_bsim3v3 = casedoe(case,284,1.026*1.3,0,-0.5312,3)
+ nsig_dela_vtw_pmos90b_10hv_bsim3v3 = casedoe(case,285,0.3818*2,0,-1.14,3)
+ nsig_dela_vtm_pmos90b_10hv_bsim3v3 = casedoe(case,286,0.3988*5,0,-0.03572*20,3)
+ nsig_dela_a0_pmos90b_10hv_bsim3v3 = casedoe(case,287,-1.467*1.1,0,1.661*0.9,3)
+ nsig_dela_b0_pmos90b_10hv_bsim3v3 = casedoe(case,288,0.812,0,0.1532*5,3)
+ nsig_dela_wwl_pmos90b_10hv_bsim3v3 = casedoe(case,289,-1.703*1.1,0,3.43,3)
+ nsig_delr_tox_pmos90b_sphv_10hv = casedoe(case,290,3.0,0.0,-3.0,3)
+ nsig_delr_uch_pmos90b_sphv_10hv = casedoe(case,291,-1.3392857,0.0,1.3392857,3)
+ nsig_delr_res_pmos90b_sphv_10hv = casedoe(case,292,3.64705882,0.0,-3.64705882,3)
+ nsig_dela_vfb_pmos90b_sphv_10hv = casedoe(case,293,2.0079,0.0,-2.0079,3)
+ nsig_dela_vtw_pmos90b_sphv_10hv = casedoe(case,294,-3.0,0.0,3.0,3)
+ nsig_dela_vtl_pmos90b_sphv_10hv = casedoe(case,295,-2.1075269,0.0,3.4021505,3)
+ nsig_dela_mueo_pmos90b_sphv_10hv = casedoe(case,296,-2.6769231,0.0,3.6,3)
+ nsig_dela_dw_pmos90b_sphv_10hv = casedoe(case,297,0.0,0.0,0.0,3)
+ nsig_dela_vdscale_pmos90b_sphv_10hv = casedoe(case,298,-3.0,0.0,3.0,3)
+ nsig_dela_vdscalel_pmos90b_sphv_10hv = casedoe(case,299,3.0,0.0,-0.816,3)
+ nsig_dela_vdscalew_pmos90b_sphv_10hv = casedoe(case,300,0.0,0.0,0.0,3)
+ nsig_dela_vdscalelw_pmos90b_sphv_10hv = casedoe(case,301,0.0,0.0,0.0,3)
+ nsig_delr_cj_pmos90b_sphv_10hv = casedoe(case,302,3.0,0.0,-3.0,3)
+ nsig_delr_is_pmos90b_sphv_10hv = casedoe(case,303,-3.0,0.0,3.0,3)
+ nsig_delr_is2_pmos90b_sphv_10hv = casedoe(case,304,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pmos90b_sphv_10hv = casedoe(case,305,-3.0,0.0,3.0,3)
+ nsig_delr_tox_pmoshs45b_sphv_10hv = casedoe(case,306,3.0,0.0,-3.0,3)
+ nsig_delr_uch_pmoshs45b_sphv_10hv = casedoe(case,307,-3.0,0.0,2.99898,3)
+ nsig_delr_res_pmoshs45b_sphv_10hv = casedoe(case,308,3.0,0.0,-3.0,3)
+ nsig_dela_vfb_pmoshs45b_sphv_10hv = casedoe(case,309,2.0,0.0,-2.011,3)
+ nsig_dela_vtw_pmoshs45b_sphv_10hv = casedoe(case,310,0.0,0.0,0.0,3)
+ nsig_dela_vtl_pmoshs45b_sphv_10hv = casedoe(case,311,-1.82,0.0,1.65,3)
+ nsig_dela_vtm_pmoshs45b_sphv_10hv = casedoe(case,312,0.0,0.0,0.0,3)
+ nsig_dela_dw_pmoshs45b_sphv_10hv = casedoe(case,313,0.0,0.0,0.0,3)
+ nsig_dela_dl_pmoshs45b_sphv_10hv = casedoe(case,314,2.45,0.0,-1.1,3)
+ nsig_dela_dlw_pmoshs45b_sphv_10hv = casedoe(case,315,-4.361,0.0,2.111,3)
+ nsig_delr_cjs_pmoshs45b_sphv_10hv = casedoe(case,316,3.0,0.0,-3.0,3)
+ nsig_delr_cjd_pmoshs45b_sphv_10hv = casedoe(case,317,3.0,0.0,-3.0,3)
+ nsig_delr_jsideal_pmoshs45b_sphv_10hv = casedoe(case,318,-3.608,0.0,3.0,3)
+ nsig_delr_jdideal_pmoshs45b_sphv_10hv = casedoe(case,319,-3.608,0.0,3.0,3)
+ nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = casedoe(case,320,-3.0,0.0,3.0,3)
+ nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = casedoe(case,321,-3.0,0.0,3.0,3)
+ nsig_delr_jsdideal_pmoshs45b_sphv_10hv = casedoe(case,322,-3.608,0.0,3.0,3)
+ nsig_delr_tox_nmos10_sphv_10hv = casedoe(case,323,3.0,0.0,-3.0,3)
+ nsig_delr_uch_nmos10_sphv_10hv = casedoe(case,324,-1.75,0.0,1.5,3)
+ nsig_dela_vfb_nmos10_sphv_10hv = casedoe(case,325,2.57,0.0,-2.45,3)
+ nsig_dela_vtl_nmos10_sphv_10hv = casedoe(case,326,-1.88888889,0.0,1.05555556,3)
+ nsig_dela_vtw_nmos10_sphv_10hv = casedoe(case,327,-0.17,0.0,0.17,3)
+ nsig_delr_thesatl_nmos10_sphv_10hv = casedoe(case,328,-6.0,0.0,2.9,3)
+ nsig_delr_thesatlw_nmos10_sphv_10hv = casedoe(case,329,3.0,0.0,-3.0,3)
+ nsig_dela_vdscale_nmos10_sphv_10hv = casedoe(case,330,0.33,0.0,-0.66,3)
+ nsig_dela_lvaro_nmos10_sphv_10hv = casedoe(case,331,2.95,0.0,-1.93,3)
+ nsig_delr_cj_nmos10_sphv_10hv = casedoe(case,332,3.0,0.0,-3.0,3)
+ nsig_delr_is_nmos10_sphv_10hv = casedoe(case,333,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nmos10_sphv_10hv = casedoe(case,334,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nmos10_sphv_10hv = casedoe(case,335,-3.0,0.0,3.0,3)
+ nsig_delr_tox_pmos45b_sphv_10hv = casedoe(case,336,3.0,0.0,-3.0,3)
+ nsig_delr_uch_pmos45b_sphv_10hv = casedoe(case,337,-2.931,0.0,2.931,3)
+ nsig_delr_res_pmos45b_sphv_10hv = casedoe(case,338,3.0,0.0,-3.0,3)
+ nsig_dela_vfb_pmos45b_sphv_10hv = casedoe(case,339,1.998,0.0,-2.005,3)
+ nsig_dela_vtw_pmos45b_sphv_10hv = casedoe(case,340,0.0,0.0,0.0,3)
+ nsig_dela_vtl_pmos45b_sphv_10hv = casedoe(case,341,-2.47,0.0,2.15,3)
+ nsig_dela_vtm_pmos45b_sphv_10hv = casedoe(case,342,0.0,0.0,0.0,3)
+ nsig_dela_dw_pmos45b_sphv_10hv = casedoe(case,343,0.0,0.0,0.0,3)
+ nsig_dela_dl_pmos45b_sphv_10hv = casedoe(case,344,2.89,0.0,-1.54545,3)
+ nsig_dela_dlw_pmos45b_sphv_10hv = casedoe(case,345,-3.1,0.0,1.8,3)
+ nsig_delr_cjs_pmos45b_sphv_10hv = casedoe(case,346,3.0,0.0,-3.0,3)
+ nsig_delr_cjd_pmos45b_sphv_10hv = casedoe(case,347,3.0,0.0,-3.0,3)
+ nsig_delr_jsideal_pmos45b_sphv_10hv = casedoe(case,348,-3.608,0.0,3.0,3)
+ nsig_delr_jdideal_pmos45b_sphv_10hv = casedoe(case,349,-3.608,0.0,3.0,3)
+ nsig_delr_jsnonideal_pmos45b_sphv_10hv = casedoe(case,350,-3.0,0.0,3.0,3)
+ nsig_delr_jdnonideal_pmos45b_sphv_10hv = casedoe(case,351,-3.0,0.0,3.0,3)
+ nsig_delr_jsdideal_pmos45b_sphv_10hv = casedoe(case,352,-3.608,0.0,3.0,3)
+ nsig_dela_dw_nmos45b_sphv_10hv = casedoe(case,353,0.0,0.0,0.0,3)
+ nsig_dela_dl_nmos45b_sphv_10hv = casedoe(case,354,0.0,0.0,3.0,3)
+ nsig_dela_dlw_nmos45b_sphv_10hv = casedoe(case,355,0.0,0.0,0.0,3)
+ nsig_dela_vfb_nmos45b_sphv_10hv = casedoe(case,356,2.6781,0.0,-2.6881,3)
+ nsig_dela_vtw_nmos45b_sphv_10hv = casedoe(case,357,3.0,0.0,-2.51328,3)
+ nsig_dela_vtl_nmos45b_sphv_10hv = casedoe(case,358,3.0,0.0,-0.8154,3)
+ nsig_dela_vtm_nmos45b_sphv_10hv = casedoe(case,359,3.0,0.0,-2.33977,3)
+ nsig_delr_mobref_nmos45b_sphv_10hv = casedoe(case,360,-3.0,0.0,0.83333,3)
+ nsig_delr_satl_nmos45b_sphv_10hv = casedoe(case,361,0.0,0.0,0.0,3)
+ nsig_delr_rshl_nmos45b_sphv_10hv = casedoe(case,362,3.0,0.0,-3.0,3)
+ nsig_delr_cjs_nmos45b_sphv_10hv = casedoe(case,363,3.0,0.0,-3.0,3)
+ nsig_delr_cjd_nmos45b_sphv_10hv = casedoe(case,364,3.0,0.0,-3.0,3)
+ nsig_delr_jsideal_nmos45b_sphv_10hv = casedoe(case,365,-3.608,0.0,3.0,3)
+ nsig_delr_jdideal_nmos45b_sphv_10hv = casedoe(case,366,-3.608,0.0,3.0,3)
+ nsig_delr_jsnonideal_nmos45b_sphv_10hv = casedoe(case,367,-3.0,0.0,3.0,3)
+ nsig_delr_jdnonideal_nmos45b_sphv_10hv = casedoe(case,368,-3.0,0.0,3.0,3)
+ nsig_delr_tox_pmos10_sphv_10hv = casedoe(case,369,3.0,0.0,-3.0,3)
+ nsig_delr_uch_pmos10_sphv_10hv = casedoe(case,370,-1.52,0.0,0.96,3)
+ nsig_delr_res_pmos10_sphv_10hv = casedoe(case,371,0.0,0.0,0.0,3)
+ nsig_dela_vfb_pmos10_sphv_10hv = casedoe(case,372,2.347,0.0,-2.328,3)
+ nsig_dela_vtl_pmos10_sphv_10hv = casedoe(case,373,2.727,0.0,-2.565,3)
+ nsig_dela_vtw_pmos10_sphv_10hv = casedoe(case,374,-0.462,0.0,2.366,3)
+ nsig_dela_vtlw_pmos10_sphv_10hv = casedoe(case,375,-5.035,0.0,2.66,3)
+ nsig_dela_dl_pmos10_sphv_10hv = casedoe(case,376,2.399,0.0,-1.9,3)
+ nsig_dela_dw_pmos10_sphv_10hv = casedoe(case,377,-3.563,0.0,1.805,3)
+ nsig_dela_dlw_pmos10_sphv_10hv = casedoe(case,378,-1.264,0.0,0.527,3)
+ nsig_dela_thesato_pmos10_sphv_10hv = casedoe(case,379,0.0,0.0,0.0,3)
+ nsig_dela_thesatl_pmos10_sphv_10hv = casedoe(case,380,0.0,0.0,0.0,3)
+ nsig_dela_thesatw_pmos10_sphv_10hv = casedoe(case,381,0.0,0.0,0.0,3)
+ nsig_dela_thesatlw_pmos10_sphv_10hv = casedoe(case,382,0.0,0.0,0.0,3)
+ nsig_dela_vdscalel_pmos10_sphv_10hv = casedoe(case,383,0.0,0.0,0.0,3)
+ nsig_dela_vdscaleo_pmos10_sphv_10hv = casedoe(case,384,2.602,0.0,-2.974,3)
+ nsig_delr_cj_pmos10_sphv_10hv = casedoe(case,385,3.0,0.0,-3.0,3)
+ nsig_delr_is_pmos10_sphv_10hv = casedoe(case,386,-3.0,0.0,3.0,3)
+ nsig_delr_is2_pmos10_sphv_10hv = casedoe(case,387,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pmos10_sphv_10hv = casedoe(case,388,-3.0,0.0,3.0,3)
+ nsig_delr_tox_nmos90b_sphv_10hv = casedoe(case,389,3.0,0.0,-3.0,3)
+ nsig_delr_uch_nmos90b_sphv_10hv = casedoe(case,390,-1.7,0.0,1.6,3)
+ nsig_delr_res_nmos90b_sphv_10hv = casedoe(case,391,3.0,0.0,-3.0,3)
+ nsig_dela_vfb_nmos90b_sphv_10hv = casedoe(case,392,2.8333333,0.0,-2.4583333,3)
+ nsig_dela_vtw_nmos90b_sphv_10hv = casedoe(case,393,4.0,0.0,-3.0,3)
+ nsig_dela_vtl_nmos90b_sphv_10hv = casedoe(case,394,-3.0,0.0,3.0,3)
+ nsig_dela_dw_nmos90b_sphv_10hv = casedoe(case,395,3.0,0.0,-4.0,3)
+ nsig_dela_thesato_nmos90b_sphv_10hv = casedoe(case,396,-2.0,0.0,2.0,3)
+ nsig_dela_lvaro_nmos90b_sphv_10hv = casedoe(case,397,3.0,0.0,-3.5,3)
+ nsig_dela_vdscalel_nmos90b_sphv_10hv = casedoe(case,398,-3.0,0.0,2.6,3)
+ nsig_delr_cj_nmos90b_sphv_10hv = casedoe(case,399,3.0,0.0,-3.0,3)
+ nsig_delr_is_nmos90b_sphv_10hv = casedoe(case,400,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nmos90b_sphv_10hv = casedoe(case,401,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nmos90b_sphv_10hv = casedoe(case,402,-3.0,0.0,3.0,3)
+ nsig_delr_tox_nmos120_sphv_10hv = casedoe(case,403,3.0,0.0,-3.0,3)
+ nsig_delr_uch_nmos120_sphv_10hv = casedoe(case,404,-2.601,0.0,1.53,3)
+ nsig_delr_res_nmos120_sphv_10hv = casedoe(case,405,2.831,0.0,-3.0476,3)
+ nsig_dela_vfb_nmos120_sphv_10hv = casedoe(case,406,1.62,0.0,-1.78666666667,3)
+ nsig_dela_vtw_nmos120_sphv_10hv = casedoe(case,407,-3.36666666667,0.0,0.8,3)
+ nsig_dela_vtl_nmos120_sphv_10hv = casedoe(case,408,-3.02857142857,0.0,1.74857142857,3)
+ nsig_dela_vtlw_nmos120_sphv_10hv = casedoe(case,409,1.86666666667,0.0,2.93333333333,3)
+ nsig_dela_dw_nmos120_sphv_10hv = casedoe(case,410,-3.0,0.0,2.30769230769,3)
+ nsig_dela_thesato_nmos120_sphv_10hv = casedoe(case,411,1.104,0.0,0.88,3)
+ nsig_dela_lvaro_nmos120_sphv_10hv = casedoe(case,412,-3.0,0.0,1.515,3)
+ nsig_dela_vdscale_nmos120_sphv_10hv = casedoe(case,413,-0.966666666667,0.0,0.9,3)
+ nsig_dela_vdscalel_nmos120_sphv_10hv = casedoe(case,414,-0.4375,0.0,1.08125,3)
+ nsig_dela_vdscalew_nmos120_sphv_10hv = casedoe(case,415,-0.75,0.0,-1.05,3)
+ nsig_dela_vdscalelw_nmos120_sphv_10hv = casedoe(case,416,1.62,0.0,-3.0,3)
+ nsig_dela_xw_nmos120_sphv_10hv = casedoe(case,417,-0.714333333333,0.0,1.03,3)
+ nsig_dela_lvarw_nmos120_sphv_10hv = casedoe(case,418,0.0,0.0,3.0,3)
+ nsig_dela_thesatw_nmos120_sphv_10hv = casedoe(case,419,0.0,0.0,0.0,3)
+ nsig_dela_thesatl_nmos120_sphv_10hv = casedoe(case,420,0.0,0.0,0.0,3)
+ nsig_dela_thesatlw_nmos120_sphv_10hv = casedoe(case,421,0.0,0.0,0.0,3)
+ nsig_delr_cj_nmos120_sphv_10hv = casedoe(case,422,3.0,0.0,-3.0,3)
+ nsig_delr_is_nmos120_sphv_10hv = casedoe(case,423,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nmos120_sphv_10hv = casedoe(case,424,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nmos120_sphv_10hv = casedoe(case,425,-3.0,0.0,3.0,3)
+ nsig_delr_rs_poly_silicide = casedoe(case,426,-2.832,0,2.124,3)
+ nsig_dela_dw_poly_silicide = casedoe(case,427,3.0,0,-3.0,3)
+ nsig_dela_dl_poly_silicide = casedoe(case,428,3.0,0,-3.0,3)
+ nsig_delr_rs_poly0_r3 = casedoe(case,429,-3.097,0,3.097,3)
+ nsig_dela_dw_poly0_r3 = casedoe(case,430,3.121,0,-2.135,3)
+ nsig_dela_dl_poly0_r3 = casedoe(case,431,3.085,0,-2.15,3)
+ nsig_dela_dlw_poly0_r3 = casedoe(case,432,-3.499,0,2.397,3)
+ nsig_dela_tc1_poly0_r3 = casedoe(case,433,3.0,0,-3.0,3)
+ nsig_dela_tc2_poly0_r3 = casedoe(case,434,-3.0,0,3.0,3)
+ nsig_delr_rs_poly_r3 = casedoe(case,435,-2.9607,0,2.96653,3)
+ nsig_dela_dw_poly_r3 = casedoe(case,436,1.76318,0,-1.10026,3)
+ nsig_dela_dl_poly_r3 = casedoe(case,437,-1.39144,0,0.871801,3)
+ nsig_delr_rs_phv_nbl_r3 = casedoe(case,438,-2.85292,0,2.86461,3)
+ nsig_dela_dw_phv_nbl_r3 = casedoe(case,439,1.2327,0,-1.00589,3)
+ nsig_dela_dl_phv_nbl_r3 = casedoe(case,440,-1.5308,0,1.2662,3)
+ nsig_delr_rs_hvpw_nbl_r3 = casedoe(case,441,-2.75879,0,2.77341,3)
+ nsig_dela_dw_hvpw_nbl_r3 = casedoe(case,442,2.23038,0,-1.82363,3)
+ nsig_dela_dl_hvpw_nbl_r3 = casedoe(case,443,-2.03314,0,1.88051,3)
+ nsig_delr_rs_nwell_pepi = casedoe(case,444,-2.54033,0,2.58402,3)
+ nsig_dela_dw_nwell_pepi = casedoe(case,445,1.44963,0,-1.17251,3)
+ nsig_dela_dl_nwell_pepi = casedoe(case,446,-1.74287,0,1.45351,3)
+ nsig_delr_rs_poly_1meg_r3 = casedoe(case,447,-3.00001,0,3.00001,3)
+ nsig_delr_rs_m1 = casedoe(case,448,-2.99996,0,3.00006,3)
+ nsig_dela_dw_m1 = casedoe(case,449,3.0,0,-3.0,3)
+ nsig_dela_dl_m1 = casedoe(case,450,-3.0,0,3.0,3)
+ nsig_delr_rs_m2 = casedoe(case,451,-2.9993,0,3.00081,3)
+ nsig_dela_dw_m2 = casedoe(case,452,3.0,0,-3.0,3)
+ nsig_dela_dl_m2 = casedoe(case,453,-3.0,0,3.0,3)
+ nsig_delr_rs_m3 = casedoe(case,454,-2.999767,0,3.00125,3)
+ nsig_dela_dw_m3 = casedoe(case,455,3.0,0,-3.0,3)
+ nsig_dela_dl_m3 = casedoe(case,456,-3.0,0,3.0,3)
+ nsig_delr_rs_m4 = casedoe(case,457,-2.998587,0,3.00142,3)
+ nsig_dela_dw_m4 = casedoe(case,458,3.0,0,-3.0,3)
+ nsig_dela_dl_m4 = casedoe(case,459,-3.0,0,3.0,3)
+ nsig_delr_rs_alcap = casedoe(case,460,-2.99999,0,2.99999,3)
+ nsig_dela_dw_alcap = casedoe(case,461,0.0,0,0.0,3)
+ nsig_dela_dl_alcap = casedoe(case,462,0.0,0,0.0,3)
+ nsig_delr_rs_ulm = casedoe(case,463,-2.993,0,3.0,3)
+ nsig_dela_dw_ulm = casedoe(case,464,3.0,0,-3.0,3)
+ nsig_dela_dl_ulm = casedoe(case,465,-3.0,0,3.0,3)
+ nsig_on_antifuse_t = casedoe(case,466,-2.0,0,6.0,3)
+ nsig_off_antifuse_t = casedoe(case,467,-2.5,0,3.0,3)
+ nsig_delr_psbe_npn_10hv_vbic = casedoe(case,468,3.56914,0,-2.55192,3)
+ nsig_delr_psb_npn_10hv_vbic = casedoe(case,469,0,0,0,3)
+ nsig_dela_dle_npn_10hv_vbic = casedoe(case,470,0.435879,0,-1.88316,3)
+ nsig_delr_jbei_npn_10hv_vbic = casedoe(case,471,-1.1797,0,4.5901,3)
+ nsig_delr_jben_npn_10hv_vbic = casedoe(case,472,-3.14523,0,2.39782,3)
+ nsig_delr_x_col_npn_10hv_vbic = casedoe(case,473,0,0,0,3)
+ nsig_delr_n_epi_npn_10hv_vbic = casedoe(case,474,0,0,0,3)
+ nsig_delr_psbe_npn_b_10hv_vbic = casedoe(case,475,3.56914,0,-3.65,3)
+ nsig_delr_psb_npn_b_10hv_vbic = casedoe(case,476,0,0,0,3)
+ nsig_dela_dle_npn_b_10hv_vbic = casedoe(case,477,2.4,0,-3.52,3)
+ nsig_delr_jbei_npn_b_10hv_vbic = casedoe(case,478,-1.55,0,6.5,3)
+ nsig_delr_jben_npn_b_10hv_vbic = casedoe(case,479,-5,0,2,3)
+ nsig_delr_x_col_npn_b_10hv_vbic = casedoe(case,480,0,0,0,3)
+ nsig_delr_n_epi_npn_b_10hv_vbic = casedoe(case,481,0,0,0,3)
+ nsig_dela_dle_pnp_10hv_vbic = casedoe(case,482,0.779259,0,-1.07102,3)
+ nsig_delr_psbe_pnp_10hv_vbic = casedoe(case,483,2.93787,0,-2.86139,3)
+ nsig_delr_psb_pnp_10hv_vbic = casedoe(case,484,0,0,0,3)
+ nsig_delr_jbei_pnp_10hv_vbic = casedoe(case,485,-3.27743,0,3.01096,3)
+ nsig_delr_jben_pnp_10hv_vbic = casedoe(case,486,-1.19334,0,2.02297,3)
+ nsig_delr_n_col_pnp_10hv_vbic = casedoe(case,487,0,0,0,3)
+ nsig_delr_x_col_pnp_10hv_vbic = casedoe(case,488,0,0,0,3)
+ nsig_dela_dle_pnp_iso_10hv_vbic = casedoe(case,489,0.77206,0,-1.06999,3)
+ nsig_delr_psbe_pnp_iso_10hv_vbic = casedoe(case,490,2.94139,0,-2.86096,3)
+ nsig_delr_psb_pnp_iso_10hv_vbic = casedoe(case,491,0,0,0,3)
+ nsig_delr_jbei_pnp_iso_10hv_vbic = casedoe(case,492,-3.21654,0,2.94956,3)
+ nsig_delr_jben_pnp_iso_10hv_vbic = casedoe(case,493,-1.34593,0,1.98474,3)
+ nsig_delr_n_col_pnp_iso_10hv_vbic = casedoe(case,494,0,0,0,3)
+ nsig_delr_x_col_pnp_iso_10hv_vbic = casedoe(case,495,0,0,0,3)
+ nsig_delr_cpp_cdp_10hv = casedoe(case,496,-3,0.0,3.0,3)
+ nsig_delr_cfr_cdp_10hv = casedoe(case,497,-3,0.0,3.0,3)
+ nsig_delr_rs_poly0_r3_cdp_10hv = casedoe(case,498,-2.9058,0,2.91083,3)
+ nsig_delr_cpp_cdpf_10hv = casedoe(case,499,-3,0.0,3.0,3)
+ nsig_delr_cfr_cdpf_10hv = casedoe(case,500,-3,0.0,3.0,3)
+ nsig_delr_cfrlv_cdpf_10hv = casedoe(case,501,-3,0.0,3.0,3)
+ nsig_delr_rs_poly0_r3_cdpf_10hv = casedoe(case,502,-2.9058,0,2.91083,3)
+ nsig_delr_cpp_cdpf_m1m2m3_10hv = casedoe(case,503,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_cdpf_m1m2m3_10hv = casedoe(case,504,-3.0,0.0,3.0,3)
+ nsig_delr_cfrlv_cdpf_m1m2m3_10hv = casedoe(case,505,-2.9822,0.0,3.0253,3)
+ nsig_delr_rs_poly0_r3_cdpf_m1m2m3_10hv = casedoe(case,506,-2.9058,0,2.91083,3)
+ nsig_delr_cglv_10hv_tox = casedoe(case,507,3.0,0.0,-3.00763,3)
+ nsig_dela_cglv_10hv_vfb = casedoe(case,508,3.0,0.0,-3.0,3)
+ nsig_delr_cglv_10hv_ileak = casedoe(case,509,-3.0,0.0,3.0,3)
+ nsig_delr_tox_cghv_10hv = casedoe(case,510,3.0,0.0,-2.7,3)
+ nsig_dela_vfb_cghv_10hv = casedoe(case,511,3.0,0.0,-3.0,3)
+ nsig_delr_tox_cghvf_10hv = casedoe(case,512,3.0,0.0,-3.0,3)
+ nsig_dela_vfb_cghvf_10hv = casedoe(case,513,3.0,0.0,-3.0,3)
+ nsig_delr_cfrlv_cghvf_10hv = casedoe(case,514,-1.6753,0.0,1.4078,3)
+ nsig_delr_tox_cghvf_m1m2m3_10hv = casedoe(case,515,3.2,0.0,-2.92,3)
+ nsig_dela_vfb_cghvf_m1m2m3_10hv = casedoe(case,516,3.0,0.0,-3.0,3)
+ nsig_delr_cfrlv_cghvf_m1m2m3_10hv = casedoe(case,517,-3.057,0.0,2.896,3)
+ nsig_delr_cfrlv_10hv = casedoe(case,518,-3.0,0.0,3.0,3)
+ nsig_delr_cfrlv_m1m2m3_10hv = casedoe(case,519,-3.0,0.0,3.0,3)
+ nsig_delr_cfr45_10hv = casedoe(case,520,-3.0,0.0,3.0,3)
+ nsig_delr_cfr45_m1m2m3_10hv = casedoe(case,521,-3.0,0.0,3.0,3)
+ nsig_delr_cfr90_10hv = casedoe(case,522,-3.0,0.0,3.0,3)
+ nsig_delr_cfr90_m1m2m3_10hv = casedoe(case,523,-3.0,0.0,3.0,3)
+ nsig_delr_cfr120_10hv = casedoe(case,524,-3.0,0.0,3.0,3)
+ nsig_delr_cfr120_m1m2m3_10hv = casedoe(case,525,-3.0,0.0,3.0,3)
+ nsig_delr_isr_dz5_10hv = casedoe(case,526,3,0,-2.948,3)
+ nsig_dela_bv_dz5_10hv = casedoe(case,527,-3,0,3,3)
+ nsig_delr_isr_dz5b_10hv = casedoe(case,528,3,0,-3,3)
+ nsig_dela_bv_dz5b_10hv = casedoe(case,529,-3,0,3,3)
+ nsig_dela_bv_tc2_dz5b_10hv = casedoe(case,530,-3,0,3,3)
+ nsig_delr_isr_drsf45_10hv = casedoe(case,531,2.3207255,0,-3,3)
+ nsig_delr_isf_drsf45_10hv = casedoe(case,532,2.1421639,0,-3,3)
+ nsig_delr_isr_drsf45b_10hv = casedoe(case,533,1.845,0,-3,3)
+ nsig_delr_isf_drsf45b_10hv = casedoe(case,534,2.36,0,-3,3)
+ nsig_dela_dw_isf_drsf45b_10hv = casedoe(case,535,1.791,0,-3,3)
+ nsig_delr_isr_drsf90_10hv = casedoe(case,536,2.5739878,0,-3,3)
+ nsig_delr_isf_drsf90_10hv = casedoe(case,537,2.1783498,0,-3,3)
+ nsig_delr_isr_drsf90b_10hv = casedoe(case,538,2.549,0,-3,3)
+ nsig_delr_isf_drsf90b_10hv = casedoe(case,539,2.345,0,-3,3)
+ nsig_dela_dw_isf_drsf90b_10hv = casedoe(case,540,1.612,0,-3,3)
+ nsig_delr_powermos_tox = casedoe(case,541,3,0,-3,3)
+ nsig_dela_nld65_10hv_vfb = casedoe(case,542,2.42887,0,-2.503,3)
+ nsig_dela_nld65_10hv_vtw = casedoe(case,543,-0.995173,0,1.02661,3)
+ nsig_delr_nld65_10hv_res = casedoe(case,544,1.63926,0,-2.41829,3)
+ nsig_delr_nld65_10hv_uch = casedoe(case,545,-1.70291,0,-0.702791,3)
+ nsig_dela_nld65_10hv_dwres = casedoe(case,546,-0.269039,0,5.57802,3)
+ nsig_dela_nld65b_10hv_vfb = casedoe(case,547,2.42887,0,-2.503,3)
+ nsig_dela_nld65b_10hv_vtw = casedoe(case,548,-0.995173,0,1.02661,3)
+ nsig_delr_nld65b_10hv_res = casedoe(case,549,1.63926,0,-2.41829,3)
+ nsig_delr_nld65b_10hv_uch = casedoe(case,550,-1.70291,0,-0.702791,3)
+ nsig_dela_nld65b_10hv_dwres = casedoe(case,551,-0.269039,0,5.57802,3)
+ nsig_dela_nld90_10hv_vfb = casedoe(case,552,2.1208,0,-2.2538,3)
+ nsig_dela_nld90_10hv_vtw = casedoe(case,553,-2.545,0,4.23,3)
+ nsig_delr_nld90_10hv_res = casedoe(case,554,-0.47,0,-3.58,3)
+ nsig_delr_nld90_10hv_uch = casedoe(case,555,-4.32,0,-2.075,3)
+ nsig_dela_nld90_10hv_dwmos = casedoe(case,556,-0.85,0,5.95,3)
+ nsig_dela_nld90_10hv_dwres = casedoe(case,557,-3,0,3,3)
+ nsig_dela_nld90b_10hv_vfb = casedoe(case,558,2.1208,0,-2.2538,3)
+ nsig_dela_nld90b_10hv_vtw = casedoe(case,559,-2.545,0,4.23,3)
+ nsig_delr_nld90b_10hv_res = casedoe(case,560,-0.47,0,-3.58,3)
+ nsig_delr_nld90b_10hv_uch = casedoe(case,561,-4.32,0,-2.075,3)
+ nsig_dela_nld90b_10hv_dwmos = casedoe(case,562,-0.85,0,5.95,3)
+ nsig_dela_nld90b_10hv_dwres = casedoe(case,563,-3,0,3,3)
+ nsig_dela_pld90_10hv_vfb = casedoe(case,564,2.47088,0,-2.55608,3)
+ nsig_dela_pld90_10hv_vtm = casedoe(case,565,0.997529,0,-0.941822,3)
+ nsig_delr_pld90_10hv_res = casedoe(case,566,2.95375,0,-3.04783,3)
+ nsig_delr_pld90_10hv_uch = casedoe(case,567,0.0278847,0,-0.569241,3)
+ nsig_dela_pld90b_10hv_vfb = casedoe(case,568,2.219,0,-2.20818,3)
+ nsig_dela_pld90b_10hv_vtm = casedoe(case,569,0.989562,0,-1.15876,3)
+ nsig_delr_pld90b_10hv_res = casedoe(case,570,3.05228,0,-3.06868,3)
+ nsig_delr_pld90b_10hv_uch = casedoe(case,571,-0.06096,0,-0.329111,3)
+ nsig_dela_nld10_10hv_vfb = casedoe(case,572,2.64209,0,-2.35189,3)
+ nsig_delr_nld10_10hv_res = casedoe(case,573,0,0,0,3)
+ nsig_delr_nld10_10hv_uch = casedoe(case,574,-0.802489,0,0.86838,3)
+ nsig_dela_nld10_10hv_dw = casedoe(case,575,0.919832,0,-0.622818,3)
+ nsig_dela_nld10_10hv_vtm = casedoe(case,576,-0.378303,0,0.480593,3)
+ nsig_dela_nld30_10hv_vfb = casedoe(case,577,2.51873,0,-2.31086,3)
+ nsig_dela_nld30_10hv_vtm = casedoe(case,578,-0.877835,0,0.962098,3)
+ nsig_delr_nld30_10hv_res = casedoe(case,579,0,0,0,3)
+ nsig_delr_nld30_10hv_uch = casedoe(case,580,-1.09065,0,0.900285,3)
+ nsig_dela_nld30_10hv_dw = casedoe(case,581,0.585028,0,-0.119906,3)
+ nsig_dela_nld30_10hv_dr = casedoe(case,582,0,0,0,3)
+ nsig_dela_nld30b_10hv_vfb = casedoe(case,583,2.51873,0,-2.31086,3)
+ nsig_dela_nld30b_10hv_vtm = casedoe(case,584,-0.877835,0,0.962098,3)
+ nsig_delr_nld30b_10hv_res = casedoe(case,585,0,0,0,3)
+ nsig_delr_nld30b_10hv_uch = casedoe(case,586,-1.09065,0,0.900285,3)
+ nsig_dela_nld30b_10hv_dw = casedoe(case,587,0.585028,0,-0.119906,3)
+ nsig_dela_nld30b_10hv_dr = casedoe(case,588,0,0,0,3)
+ nsig_dela_nld45_10hv_vfb = casedoe(case,589,2.68697,0,-2.64427,3)
+ nsig_dela_nld45_10hv_vtm = casedoe(case,590,-0.428239,0,0.698606,3)
+ nsig_delr_nld45_10hv_res = casedoe(case,591,2.34508,0,-2.50653,3)
+ nsig_delr_nld45_10hv_uch = casedoe(case,592,-0.373762,0,0.149169,3)
+ nsig_dela_nld45_10hv_dw = casedoe(case,593,-0.985639,0,0.286407,3)
+ nsig_dela_nld45_10hv_dr = casedoe(case,594,-0.335047,0,4.44653,3)
+ nsig_dela_nld45b_10hv_vfb = casedoe(case,595,2.68697,0,-2.64427,3)
+ nsig_dela_nld45b_10hv_vtm = casedoe(case,596,-0.428239,0,0.698606,3)
+ nsig_delr_nld45b_10hv_res = casedoe(case,597,2.34508,0,-2.50653,3)
+ nsig_delr_nld45b_10hv_uch = casedoe(case,598,-0.373762,0,0.149169,3)
+ nsig_dela_nld45b_10hv_dw = casedoe(case,599,-0.985639,0,0.286407,3)
+ nsig_dela_nld45b_10hv_dr = casedoe(case,600,-0.335047,0,4.44653,3)
+ nsig_dela_nld45_he_10hv_vfb = casedoe(case,601,2.59235,0,-2.68376,3)
+ nsig_dela_nld45_he_10hv_vtm = casedoe(case,602,-0.836959,0,0.967454,3)
+ nsig_delr_nld45_he_10hv_res = casedoe(case,603,3.35791,0,-1.71475,3)
+ nsig_delr_nld45_he_10hv_uch = casedoe(case,604,3.13072,0,0.376732,3)
+ nsig_dela_nld45_he_10hv_dw = casedoe(case,605,3,0,-3,3)
+ nsig_dela_nld45_he_10hv_dr = casedoe(case,606,-2.0232,0,1.000406667,3)
+ nsig_dela_nld45_he_10hv_a0 = casedoe(case,607,3.65267,0,-0.160097,3)
+ nsig_dela_nld45_he_10hv_b0 = casedoe(case,608,0.69151,0,0.0741165,3)
+ nsig_dela_nld45b_he_10hv_vfb = casedoe(case,609,2.59235,0,-2.68376,3)
+ nsig_dela_nld45b_he_10hv_vtm = casedoe(case,610,-0.836959,0,0.967454,3)
+ nsig_delr_nld45b_he_10hv_res = casedoe(case,611,3.35791,0,-1.71475,3)
+ nsig_delr_nld45b_he_10hv_uch = casedoe(case,612,3.13072,0,0.376732,3)
+ nsig_dela_nld45b_he_10hv_dw = casedoe(case,613,3,0,-3,3)
+ nsig_dela_nld45b_he_10hv_dr = casedoe(case,614,-2.0232,0,1.000406667,3)
+ nsig_dela_nld45b_he_10hv_a0 = casedoe(case,615,3.65267,0,-0.160097,3)
+ nsig_dela_nld45b_he_10hv_b0 = casedoe(case,616,0.69151,0,0.0741165,3)
+ nsig_dela_nld45_tlp_10hv_vfb = casedoe(case,617,2.14947,0,-2.43531,3)
+ nsig_dela_nld45_tlp_10hv_vtm = casedoe(case,618,-0.894278,0,1.30396,3)
+ nsig_delr_nld45_tlp_10hv_res = casedoe(case,619,5.37374,0,-2.08334,3)
+ nsig_delr_nld45_tlp_10hv_uch = casedoe(case,620,1.35073,0,1.13024,3)
+ nsig_dela_nld45_tlp_10hv_dr = casedoe(case,621,-1.09392,0,1.82558,3)
+ nsig_dela_nld45_tlp_10hv_dw = casedoe(case,622,3,0,-3,3)
+ nsig_dela_nld45_tlp_10hv_a0 = casedoe(case,623,3.3772,0,1.16786,3)
+ nsig_dela_nld45_tlp_10hv_b0 = casedoe(case,624,3.61657,0,1.146,3)
+ nsig_dela_nld45b_tlp_10hv_vfb = casedoe(case,625,2.14947,0,-2.43531,3)
+ nsig_dela_nld45b_tlp_10hv_vtm = casedoe(case,626,-0.894278,0,1.30396,3)
+ nsig_delr_nld45b_tlp_10hv_res = casedoe(case,627,5.37374,0,-2.08334,3)
+ nsig_delr_nld45b_tlp_10hv_uch = casedoe(case,628,1.35073,0,1.13024,3)
+ nsig_dela_nld45b_tlp_10hv_dr = casedoe(case,629,-1.09392,0,1.82558,3)
+ nsig_dela_nld45b_tlp_10hv_dw = casedoe(case,630,3,0,-3,3)
+ nsig_dela_nld45b_tlp_10hv_a0 = casedoe(case,631,3.3772,0,1.16786,3)
+ nsig_dela_nld45b_tlp_10hv_b0 = casedoe(case,632,3.61657,0,1.146,3)
+ nsig_dela_pld5_10hv_vfb = casedoe(case,633,2.41312,0,-1.79791,3)
+ nsig_dela_pld5_10hv_vtm = casedoe(case,634,0.410529,0,-1.5299,3)
+ nsig_delr_pld5_10hv_uch = casedoe(case,635,-1.69102,0,2.39203,3)
+ nsig_dela_pld5_10hv_dw = casedoe(case,636,-0.913495,0,0.0471789,3)
+ nsig_dela_nld5_10hv_vfb = casedoe(case,637,2.5389,0,-2.50833,3)
+ nsig_delr_nld5_10hv_res = casedoe(case,638,0,0,0,3)
+ nsig_delr_nld5_10hv_uch = casedoe(case,639,-1.15492,0,2.82881,3)
+ nsig_delr_nld5_10hv_vsat = casedoe(case,640,-0.95811,0,-0.79576,3)
+ nsig_dela_nld5_10hv_dwmos = casedoe(case,641,0.685519,0,-1.29756,3)
+ nsig_dela_nld5_10hv_vtw = casedoe(case,642,-1.14984,0,1.18919,3)
+ nsig_dela_pld10_10hv_vfb = casedoe(case,643,2.74903,0,-2.78759,3)
+ nsig_delr_pld10_10hv_res = casedoe(case,644,1.56,0,-2.125,3)
+ nsig_delr_pld10_10hv_uch = casedoe(case,645,-0.553808,0,-1.98118,3)
+ nsig_dela_pld10_10hv_vtw = casedoe(case,646,-0.348708,0,0.456194,3)
+ nsig_dela_pld10_10hv_dwres = casedoe(case,647,-0.323,0,6.12,3)
+ nsig_dela_pld10_10hv_dwmos = casedoe(case,648,1.56025,0,5.5,3)
+ nsig_dela_dw_pld10b_sphv_10hv = casedoe(case,649,1.58382,0,0.868317,3)
+ nsig_dela_vfb_pld10b_sphv_10hv = casedoe(case,650,2.99973,0,-2.99922,3)
+ nsig_dela_vtwl_pld10b_sphv_10hv = casedoe(case,651,4.48525,0,0.113052,3)
+ nsig_delr_mobref_pld10b_sphv_10hv = casedoe(case,652,1.68936,0,-1.0367,3)
+ nsig_delr_rshl_pld10b_sphv_10hv = casedoe(case,653,2.70734,0,-2.7151,3)
+ nsig_dela_pld30_10hv_vfb = casedoe(case,654,2.40316,0,-2.4408,3)
+ nsig_delr_pld30_10hv_res = casedoe(case,655,2.35408,0,-2.60527,3)
+ nsig_delr_pld30_10hv_uch = casedoe(case,656,-0.938002,0,0.605154,3)
+ nsig_dela_pld30_10hv_dwmos = casedoe(case,657,1.06596,0,-0.947679,3)
+ nsig_dela_pld30_10hv_dwres = casedoe(case,658,0.369033,0,0.117798,3)
+ nsig_dela_pld30_10hv_vtw = casedoe(case,659,-0.443778,0,0.222473,3)
+ nsig_dela_pld30b_10hv_vfb = casedoe(case,660,2.176923,0,-2.466923,3)
+ nsig_delr_pld30b_10hv_res = casedoe(case,661,2.933,0,-3.203,3)
+ nsig_delr_pld30b_10hv_uch = casedoe(case,662,-3.72,0,2.20,3)
+ nsig_dela_pld30b_10hv_dwmos = casedoe(case,663,3.34,0,-2.73,3)
+ nsig_dela_pld30b_10hv_dwres = casedoe(case,664,3.6316,0,-2.3,3)
+ nsig_dela_pld30b_10hv_vtw = casedoe(case,665,-2.5,0,1.4975,3)
+ nsig_dela_pld45_10hv_vfb = casedoe(case,666,2.80087,0,-2.8923,3)
+ nsig_delr_pld45_10hv_res = casedoe(case,667,2.70785,0,-2.99343,3)
+ nsig_delr_pld45_10hv_uch = casedoe(case,668,-0.133154,0,-3.55062,3)
+ nsig_dela_pld45_10hv_dwmos = casedoe(case,669,2.40056,0,0.100411,3)
+ nsig_dela_pld45_10hv_dwres = casedoe(case,670,0.0,0,0.0,3)
+ nsig_dela_pld45_10hv_vtw = casedoe(case,671,-1.32806,0,1.82366,3)
+ nsig_dela_pld45b_10hv_vfb = casedoe(case,672,2.66638,0,-2.87316,3)
+ nsig_delr_pld45b_10hv_res = casedoe(case,673,2.6,0,-2.8,3)
+ nsig_delr_pld45b_10hv_uch = casedoe(case,674,1.7,0,-3.5,3)
+ nsig_dela_pld45b_10hv_dwmos = casedoe(case,675,3.0,0,0.344936,3)
+ nsig_dela_pld45b_10hv_dwres = casedoe(case,676,3.0,0,0.423546,3)
+ nsig_dela_pld45b_10hv_vtw = casedoe(case,677,-0.200107,0,0.695975,3)
+ nsig_dela_nld5_lvt_10hv_vfb = casedoe(case,678,2.78919,0,-2.53329,3)
+ nsig_delr_nld5_lvt_10hv_res = casedoe(case,679,4.00613,0,-2.37441,3)
+ nsig_delr_nld5_lvt_10hv_uch = casedoe(case,680,-0.416862,0,3.48034,3)
+ nsig_dela_nld5_lvt_10hv_dwmos = casedoe(case,681,1.035292,0,-2.93214,3)
+ nsig_dela_nld5_lvt_10hv_vtw = casedoe(case,682,2.586,0,-2.734551,3)
+ nsig_delr_nld5_lvt_10hv_vsat = casedoe(case,683,0,0,0,3)
+ nsig_delr_nld5_lvt_10hv_ub = casedoe(case,684,0,0,0,3)
+ nsig_delr_tox_nld45b_sphv_10hv = casedoe(case,685,3.0,0.0,-3.0,3)
+ nsig_dela_xw_nld45b_sphv_10hv = casedoe(case,686,-2.635,0.0,4.021,3)
+ nsig_dela_vfb_nld45b_sphv_10hv = casedoe(case,687,2.04121735337,0.0,-2.11522169663,3)
+ nsig_delr_mobref_nld45b_sphv_10hv = casedoe(case,688,3.893,0.0,0.1544,3)
+ nsig_delr_rsh_nld45b_sphv_10hv = casedoe(case,689,3.677,0.0,-3.437,3)
+ nsig_dela_vtw_nld45b_sphv_10hv = casedoe(case,690,-3.74851401668,0.0,2.4784263337,3)
+ nsig_delr_vdscale_nld45b_sphv_10hv = casedoe(case,691,-4.46785627967,0.0,-1.588,3)
+ nsig_delr_cj_nld45b_sphv_10hv = casedoe(case,692,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld45b_sphv_10hv = casedoe(case,693,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld45b_sphv_10hv = casedoe(case,694,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld45b_sphv_10hv = casedoe(case,695,-3.0,0.0,3.0,3)
+ nsig_dela_vfb_pld65_sphv_10hv = casedoe(case,696,2.201,0.0,-2.339,3)
+ nsig_dela_vtw_pld65_sphv_10hv = casedoe(case,697,-2.9,0.0,1.907,3)
+ nsig_delr_uch_pld65_sphv_10hv = casedoe(case,698,-2.565,0.0,1.573,3)
+ nsig_delr_res_pld65_sphv_10hv = casedoe(case,699,2.538462,0.0,-2.714769,3)
+ nsig_dela_dwox_pld65_sphv_10hv = casedoe(case,700,-1.422571,0.0,2.142857,3)
+ nsig_delr_cj_pld65_sphv_10hv = casedoe(case,701,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld65_sphv_10hv = casedoe(case,702,-3.608,0.0,3.0,3)
+ nsig_delr_is2_pld65_sphv_10hv = casedoe(case,703,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld65_sphv_10hv = casedoe(case,704,-3.0,0.0,3.0,3)
+ nsig_dela_dw_nld90b_sphv_10hv = casedoe(case,705,2.92144133334,0.0,-6.00735412058,3)
+ nsig_dela_xw_nld90b_sphv_10hv = casedoe(case,706,-3.02284725262,0.0,3.43786682386,3)
+ nsig_dela_vfb_nld90b_sphv_10hv = casedoe(case,707,2.99862202567,0.0,-3.0052408551,3)
+ nsig_delr_mobref_nld90b_sphv_10hv = casedoe(case,708,-3.0,0.0,3.0,3)
+ nsig_delr_ids_nld90b_sphv_10hv = casedoe(case,709,-3.0,0.0,3.0,3)
+ nsig_delr_rshl_nld90b_sphv_10hv = casedoe(case,710,3.02251168512,0.0,-3.22668920861,3)
+ nsig_dela_vtwl_nld90b_sphv_10hv = casedoe(case,711,-2.97949255762,0.0,2.47353175951,3)
+ nsig_delr_cj_nld90b_sphv_10hv = casedoe(case,712,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld90b_sphv_10hv = casedoe(case,713,-3.608,0.0,3.0,3)
+ nsig_delr_is2_nld90b_sphv_10hv = casedoe(case,714,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld90b_sphv_10hv = casedoe(case,715,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_s_ply_met_nld90b_sphv_10hv = casedoe(case,716,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_d_ply_met_nld90b_sphv_10hv = casedoe(case,717,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_s_ply_m1ct_nld90b_sphv_10hv = casedoe(case,718,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_d_ply_m1ct_nld90b_sphv_10hv = casedoe(case,719,3.0,0.0,-3.0,3)
+ nsig_delr_tox_nld45b_tlp_sphv_10hv = casedoe(case,720,3.0,0.0,-3.0,3)
+ nsig_dela_xw_nld45b_tlp_sphv_10hv = casedoe(case,721,-2.771,0.0,3.0,3)
+ nsig_dela_vfb_nld45b_tlp_sphv_10hv = casedoe(case,722,2.589,0.0,-2.757,3)
+ nsig_delr_mobref_nld45b_tlp_sphv_10hv = casedoe(case,723,1.5,0.0,3.0,3)
+ nsig_delr_rsh_nld45b_tlp_sphv_10hv = casedoe(case,724,4.0,0.0,-1.5,3)
+ nsig_dela_vtw_nld45b_tlp_sphv_10hv = casedoe(case,725,-3.808,0.0,2.6916551842,3)
+ nsig_delr_vdscale_nld45b_tlp_sphv_10hv = casedoe(case,726,-4.3,0.0,-3.5,3)
+ nsig_delr_thesato_nld45b_tlp_sphv_10hv = casedoe(case,727,-3.0,0.0,3.6,3)
+ nsig_dela_vfb_nld45b_tlp_mosb_10hv = casedoe(case,728,-3.5,0.0,2.5,3)
+ nsig_delr_cj_nld45b_tlp_sphv_10hv = casedoe(case,729,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld45b_tlp_sphv_10hv = casedoe(case,730,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld45b_tlp_sphv_10hv = casedoe(case,731,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld45b_tlp_sphv_10hv = casedoe(case,732,-3.0,0.0,3.0,3)
+ nsig_delr_tox_pld120_sphv_10hv = casedoe(case,733,3.0,0.0,-3.0,3)
+ nsig_delr_uch_pld120_sphv_10hv = casedoe(case,734,-1.1,0.0,1.3,3)
+ nsig_delr_res_pld120_sphv_10hv = casedoe(case,735,2.511,0.0,-2.875,3)
+ nsig_dela_vfb_pld120_sphv_10hv = casedoe(case,736,1.8,0.0,-1.95,3)
+ nsig_dela_vtw_pld120_sphv_10hv = casedoe(case,737,-3.0,0.0,3.0,3)
+ nsig_dela_vtl_pld120_sphv_10hv = casedoe(case,738,-1.167,0.0,1.167,3)
+ nsig_dela_mueo_pld120_sphv_10hv = casedoe(case,739,0.0,0.0,0.0,3)
+ nsig_dela_dw_pld120_sphv_10hv = casedoe(case,740,0.0,0.0,0.0,3)
+ nsig_dela_dwox_pld120_sphv_10hv = casedoe(case,741,-3.376,0.0,3.0,3)
+ nsig_dela_vdscale_pld120_sphv_10hv = casedoe(case,742,3.0,0.0,-3.0,3)
+ nsig_dela_vdscalel_pld120_sphv_10hv = casedoe(case,743,-1.669,0.0,0.885,3)
+ nsig_dela_vdscalew_pld120_sphv_10hv = casedoe(case,744,0.0,0.0,0.0,3)
+ nsig_dela_vdscalelw_pld120_sphv_10hv = casedoe(case,745,0.0,0.0,0.0,3)
+ nsig_delr_cj_pld120_sphv_10hv = casedoe(case,746,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld120_sphv_10hv = casedoe(case,747,-3.0,0.0,3.0,3)
+ nsig_delr_is2_pld120_sphv_10hv = casedoe(case,748,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld120_sphv_10hv = casedoe(case,749,-3.0,0.0,3.0,3)
+ nsig_delr_tox_nld45b_he_sphv_10hv = casedoe(case,750,3.0,0.0,-3.0,3)
+ nsig_dela_xw_nld45b_he_sphv_10hv = casedoe(case,751,-2.733,0.0,3.2,3)
+ nsig_dela_vfb_nld45b_he_sphv_10hv = casedoe(case,752,2.88,0.0,-2.85842511315,3)
+ nsig_delr_mobref_nld45b_he_sphv_10hv = casedoe(case,753,-0.3215,0.0,2.8,3)
+ nsig_delr_rsh_nld45b_he_sphv_10hv = casedoe(case,754,4.083,0.0,-2.0,3)
+ nsig_dela_vtw_nld45b_he_sphv_10hv = casedoe(case,755,-4.574,0.0,2.45657910998,3)
+ nsig_delr_thesato_nld45b_he_sphv_10hv = casedoe(case,756,5.236,0.0,2.56664174108,3)
+ nsig_delr_cj_nld45b_he_sphv_10hv = casedoe(case,757,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld45b_he_sphv_10hv = casedoe(case,758,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld45b_he_sphv_10hv = casedoe(case,759,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld45b_he_sphv_10hv = casedoe(case,760,-3.0,0.0,3.0,3)
+ nsig_delr_tox_nld30b_sphv_10hv = casedoe(case,761,3.0,0.0,-3.0,3)
+ nsig_dela_dw_nld30b_sphv_10hv = casedoe(case,762,0.0,0.0,0.0,3)
+ nsig_dela_xw_nld30b_sphv_10hv = casedoe(case,763,-3.0,0.0,3.0,3)
+ nsig_dela_vfb_nld30b_sphv_10hv = casedoe(case,764,2.18,0.0,-2.2,3)
+ nsig_delr_mobref_nld30b_sphv_10hv = casedoe(case,765,-2.2,0.0,1.35,3)
+ nsig_delr_rshl_nld30b_sphv_10hv = casedoe(case,766,0.8,0.0,-2.9,3)
+ nsig_dela_vtwl_nld30b_sphv_10hv = casedoe(case,767,-4.1,0.0,3.1,3)
+ nsig_delr_cj_nld30b_sphv_10hv = casedoe(case,768,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld30b_sphv_10hv = casedoe(case,769,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld30b_sphv_10hv = casedoe(case,770,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld30b_sphv_10hv = casedoe(case,771,-3.0,0.0,3.0,3)
+ nsig_dela_vfb_pld100_sphv_10hv = casedoe(case,772,2.07,0.0,-2.205,3)
+ nsig_dela_vtw_pld100_sphv_10hv = casedoe(case,773,-1.125,0.0,3.6,3)
+ nsig_delr_uch_pld100_sphv_10hv = casedoe(case,774,-2.3,0.0,1.0,3)
+ nsig_delr_res_pld100_sphv_10hv = casedoe(case,775,3.0693,0.0,-3.1283,3)
+ nsig_dela_dwox_pld100_sphv_10hv = casedoe(case,776,-3.4833,0.0,1.8333,3)
+ nsig_delr_cj_pld100_sphv_10hv = casedoe(case,777,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld100_sphv_10hv = casedoe(case,778,-3.608,0.0,3.0,3)
+ nsig_delr_is2_pld100_sphv_10hv = casedoe(case,779,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld100_sphv_10hv = casedoe(case,780,-3.0,0.0,3.0,3)
+ nsig_dela_dw_pld100_sphv_10hv = casedoe(case,781,0.0,0.0,0.0,3)
+ nsig_delr_thesat_pld100_sphv_10hv = casedoe(case,782,0.0,0.0,0.0,3)
+ nsig_delr_vdscale_pld100_sphv_10hv = casedoe(case,783,0.0,0.0,0.0,3)
+ nsig_delr_vdscalew_pld100_sphv_10hv = casedoe(case,784,0.0,0.0,0.0,3)
+ nsig_delr_theacc2_pld100_sphv_10hv = casedoe(case,785,0.0,0.0,0.0,3)
+ nsig_delr_tox_nld10_sphv_10hv = casedoe(case,786,3.0,0.0,-3.0,3)
+ nsig_dela_dw_nld10_sphv_10hv = casedoe(case,787,2.5,0.0,-1.0,3)
+ nsig_dela_xw_nld10_sphv_10hv = casedoe(case,788,-0.8333,0.0,2.5,3)
+ nsig_dela_vfb_nld10_sphv_10hv = casedoe(case,789,2.48,0.0,-2.4675,3)
+ nsig_delr_mobref_nld10_sphv_10hv = casedoe(case,790,-1.5,0.0,2.5,3)
+ nsig_delr_rshl_nld10_sphv_10hv = casedoe(case,791,2.5,0.0,0.0,3)
+ nsig_delr_thesato_nld10_sphv_10hv = casedoe(case,792,2.5,0.0,0.5556,3)
+ nsig_dela_vtwl_nld10_sphv_10hv = casedoe(case,793,-2.436,0.0,1.761,3)
+ nsig_delr_cj_nld10_sphv_10hv = casedoe(case,794,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld10_sphv_10hv = casedoe(case,795,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld10_sphv_10hv = casedoe(case,796,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld10_sphv_10hv = casedoe(case,797,-3.0,0.0,3.0,3)
+ nsig_delr_tox_nld100_sphv_10hv = casedoe(case,798,3.0,0.0,-3.0,3)
+ nsig_dela_xw_nld100_sphv_10hv = casedoe(case,799,-3.0,0.0,4.2,3)
+ nsig_dela_vfb_nld100_sphv_10hv = casedoe(case,800,2.0,0.0,-2.0,3)
+ nsig_dela_vfbw_nld100_sphv_10hv = casedoe(case,801,-3.04,0.0,2.55,3)
+ nsig_dela_vdscale_nld100_sphv_10hv = casedoe(case,802,3.2,0.0,-3.2,3)
+ nsig_dela_vdscalew_nld100_sphv_10hv = casedoe(case,803,3.5,0.0,-2.8,3)
+ nsig_dela_thesatgo_nld100_sphv_10hv = casedoe(case,804,3.0,0.0,-3.0,3)
+ nsig_delr_rshl_nld100_sphv_10hv = casedoe(case,805,3.0,0.0,-3.0,3)
+ nsig_delr_cj_nld100_sphv_10hv = casedoe(case,806,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld100_sphv_10hv = casedoe(case,807,-3.608,0.0,3.0,3)
+ nsig_delr_is2_nld100_sphv_10hv = casedoe(case,808,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld100_sphv_10hv = casedoe(case,809,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_s_ply_met_nld100_sphv_10hv = casedoe(case,810,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_d_ply_met_nld100_sphv_10hv = casedoe(case,811,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_s_ply_m1ct_nld100_sphv_10hv = casedoe(case,812,3.0,0.0,-3.0,3)
+ nsig_delr_cfr_d_ply_m1ct_nld100_sphv_10hv = casedoe(case,813,3.0,0.0,-3.0,3)
+ nsig_dela_dw_pld45b_sphv_10hv = casedoe(case,814,3.08212,0.0,1.01018,3)
+ nsig_dela_vfb_pld45b_sphv_10hv = casedoe(case,815,2.60329,0.0,-2.62526,3)
+ nsig_delr_uch_pld45b_sphv_10hv = casedoe(case,816,2.977221,0.0,-1.549806,3)
+ nsig_delr_rshl_pld45b_sphv_10hv = casedoe(case,817,2.9001,0.0,-2.9085,3)
+ nsig_dela_vtwl_pld45b_sphv_10hv = casedoe(case,818,-2.7717,0.0,1.358695,3)
+ nsig_dela_nwxw_pld45b_sphv_10hv = casedoe(case,819,-1.133742,0.0,3.1764,3)
+ nsig_delr_cj_pld45b_sphv_10hv = casedoe(case,820,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld45b_sphv_10hv = casedoe(case,821,-3.0,0.0,3.0,3)
+ nsig_delr_is2_pld45b_sphv_10hv = casedoe(case,822,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld45b_sphv_10hv = casedoe(case,823,-3.0,0.0,3.0,3)
+ nsig_dela_vfb_pld90b_sphv_10hv = casedoe(case,824,1.92225005533,0.0,-1.9541806841,3)
+ nsig_dela_vtw_pld90b_sphv_10hv = casedoe(case,825,-3.0,0.0,2.83461497634,3)
+ nsig_delr_uch_pld90b_sphv_10hv = casedoe(case,826,-0.543635864934,0.0,0.12928447286,3)
+ nsig_delr_res_pld90b_sphv_10hv = casedoe(case,827,3.01007273263,0.0,-3.04725343214,3)
+ nsig_dela_dwox_pld90b_sphv_10hv = casedoe(case,828,-1.8451988772,0.0,3.0,3)
+ nsig_delr_cj_pld90b_sphv_10hv = casedoe(case,829,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld90b_sphv_10hv = casedoe(case,830,-3.608,0.0,3.0,3)
+ nsig_delr_is2_pld90b_sphv_10hv = casedoe(case,831,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld90b_sphv_10hv = casedoe(case,832,-3.0,0.0,3.0,3)
+ nsig_delr_uch_nld65b_sphv_10hv = casedoe(case,833,-3.0,0.0,-0.4307,3)
+ nsig_delr_res_nld65b_sphv_10hv = casedoe(case,834,0.6,0.0,-3.0,3)
+ nsig_dela_vfb_nld65b_sphv_10hv = casedoe(case,835,2.871,0.0,-3.001,3)
+ nsig_dela_vtw_nld65b_sphv_10hv = casedoe(case,836,-3.015,0.0,1.822,3)
+ nsig_dela_xw_nld65b_sphv_10hv = casedoe(case,837,1.565,0.0,3.0,3)
+ nsig_dela_thesatw_nld65b_sphv_10hv = casedoe(case,838,3.0,0.0,0.75,3)
+ nsig_delr_cj_nld65b_sphv_10hv = casedoe(case,839,3.0,0.0,-3.0,3)
+ nsig_delr_is_nld65b_sphv_10hv = casedoe(case,840,-3.0,0.0,3.0,3)
+ nsig_delr_is2_nld65b_sphv_10hv = casedoe(case,841,-3.0,0.0,3.0,3)
+ nsig_delr_ir_nld65b_sphv_10hv = casedoe(case,842,-3.0,0.0,3.0,3)
+ nsig_dela_vfbo_pld30b_sphv_10hv = casedoe(case,843,2.066,0.0,-2.243,3)
+ nsig_dela_vfbw_pld30b_sphv_10hv = casedoe(case,844,-2.7,0.0,2.8,3)
+ nsig_delr_rshldd_pld30b_sphv_10hv = casedoe(case,845,2.715,0.0,-2.842,3)
+ nsig_dela_nwxw_pld30b_sphv_10hv = casedoe(case,846,-2.7,0.0,3.9,3)
+ nsig_dela_vdscale_pld30b_sphv_10hv = casedoe(case,847,-1.694444,0.0,1.5,3)
+ nsig_dela_vdscalew_pld30b_sphv_10hv = casedoe(case,848,0.0,0.0,-0.8,3)
+ nsig_delr_cj_pld30b_sphv_10hv = casedoe(case,849,3.0,0.0,-3.0,3)
+ nsig_delr_is_pld30b_sphv_10hv = casedoe(case,850,-3.608,0.0,3.0,3)
+ nsig_delr_is2_pld30b_sphv_10hv = casedoe(case,851,-3.0,0.0,3.0,3)
+ nsig_delr_ir_pld30b_sphv_10hv = casedoe(case,852,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_m4 = casedoe(case,853,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_m4 = casedoe(case,854,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_m3 = casedoe(case,855,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_m3 = casedoe(case,856,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_m2 = casedoe(case,857,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_m2 = casedoe(case,858,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_m1 = casedoe(case,859,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_m1 = casedoe(case,860,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_ply = casedoe(case,861,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_ply = casedoe(case,862,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_sd = casedoe(case,863,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_sd = casedoe(case,864,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_alcap_fld = casedoe(case,865,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_alcap_fld = casedoe(case,866,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_m3 = casedoe(case,867,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_m3 = casedoe(case,868,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_m2 = casedoe(case,869,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_m2 = casedoe(case,870,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_m1 = casedoe(case,871,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_m1 = casedoe(case,872,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_ply = casedoe(case,873,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_ply = casedoe(case,874,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_sd = casedoe(case,875,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_sd = casedoe(case,876,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m4_fld = casedoe(case,877,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m4_fld = casedoe(case,878,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m3_m2 = casedoe(case,879,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m3_m2 = casedoe(case,880,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m3_m1 = casedoe(case,881,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m3_m1 = casedoe(case,882,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m3_ply = casedoe(case,883,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m3_ply = casedoe(case,884,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m3_sd = casedoe(case,885,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m3_sd = casedoe(case,886,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m3_fld = casedoe(case,887,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m3_fld = casedoe(case,888,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m2_m1 = casedoe(case,889,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m2_m1 = casedoe(case,890,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m2_ply = casedoe(case,891,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m2_ply = casedoe(case,892,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m2_sd = casedoe(case,893,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m2_sd = casedoe(case,894,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m2_fld = casedoe(case,895,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m2_fld = casedoe(case,896,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m1_ply = casedoe(case,897,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m1_ply = casedoe(case,898,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m1_sd = casedoe(case,899,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m1_sd = casedoe(case,900,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_m1_fld = casedoe(case,901,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_m1_fld = casedoe(case,902,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply_ply0 = casedoe(case,903,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply_ply0 = casedoe(case,904,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply_sd = casedoe(case,905,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply_sd = casedoe(case,906,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply_fld = casedoe(case,907,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply_fld = casedoe(case,908,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply_sdt = casedoe(case,909,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply_sdt = casedoe(case,910,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply0_fld = casedoe(case,911,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply0_fld_cdp = casedoe(case,912,-3.0,0.0,3.0,3)
+ nsig_delr_cpp_ply0_fld_cdp = casedoe(case,913,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_ply0_fld = casedoe(case,914,-3.0,0.0,3.0,3)
+ nsig_delr_cfr_nld90_s_ply_m1ct = casedoe(case,915,-2.4,0,3,3)
+ nsig_delr_cfr_pmoshs45b_s_ply_met = casedoe(case,916,-2.5,0,3,3)
+ nsig_delr_cfr_pld5_s_ply_m1ct = casedoe(case,917,-2.9,0,3,3)
+ nsig_delr_cfr_nsrampd_s_ply_met = casedoe(case,918,-2.5,0,3,3)
+ nsig_delr_cfr_psrampu_d_ply_m1ct = casedoe(case,919,-3.0,0,3,3)
+ nsig_delr_cfr_nld45b_tlp_d_ply_met = casedoe(case,920,-2.8,0,3,3)
+ nsig_delr_cfr_pmos_ll_s_ply_met = casedoe(case,921,-2.5,0,3,3)
+ nsig_delr_cfr_nmos_ull_s_ply_met = casedoe(case,922,-2.5,0,3,3)
+ nsig_delr_cfr_pmos_ana_s_ply_met = casedoe(case,923,-2.4,0,3,3)
+ nsig_delr_cfr_pld45_d_ply_met = casedoe(case,924,-2.8,0,3,3)
+ nsig_delr_cfr_nld65_d_ply_met = casedoe(case,925,-3.0,0,3,3)
+ nsig_delr_cfr_pmos45b_d_ply_met = casedoe(case,926,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_d_ply_m1ct = casedoe(case,927,-3.0,0,3,3)
+ nsig_delr_cfr_nld65b_s_ply_met = casedoe(case,928,-2.4,0,3,3)
+ nsig_delr_cfr_pmos90b_d_ply_met = casedoe(case,929,-3.0,0,3,3)
+ nsig_delr_cfr_nmos3_zvt_d_ply_m1ct = casedoe(case,930,-2.9,0,3,3)
+ nsig_delr_cfr_pmoshs45_s_ply_m1ct = casedoe(case,931,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_ull_d_ply_ct = casedoe(case,932,-3.0,0,3,3)
+ nsig_delr_cfr_pld10_s_ply_m1ct = casedoe(case,933,-2.5,0,3,3)
+ nsig_delr_cfr_pld30b_d_ply_m1ct = casedoe(case,934,-2.5,0,3,3)
+ nsig_delr_cfr_nmos90b_s_ply_m1ct = casedoe(case,935,-2.9,0,3,3)
+ nsig_delr_cfr_nld45b_d_ply_met = casedoe(case,936,-2.7,0,3,3)
+ nsig_delr_cfr_pmos45_d_ply_met = casedoe(case,937,-3.0,0,3,3)
+ nsig_delr_cfr_pld45_s_ply_met = casedoe(case,938,-2.6,0,3,3)
+ nsig_delr_cfr_nld45b_he_d_ply_met = casedoe(case,939,-2.7,0,3,3)
+ nsig_delr_cfr_nld90b_d_ply_m1ct = casedoe(case,940,-3.0,0,3,3)
+ nsig_delr_cfr_pld30_s_ply_met = casedoe(case,941,-2.6,0,3,3)
+ nsig_delr_cfr_nmos_ull_s_ply_m1ct = casedoe(case,942,-3.0,0,3,3)
+ nsig_delr_cfr_nld90_d_ply_met = casedoe(case,943,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_s_ply_met = casedoe(case,944,-2.5,0,3,3)
+ nsig_delr_cfr_nld45_s_ply_m1ct = casedoe(case,945,-2.5,0,3,3)
+ nsig_delr_cfr_pmos_ll_s_ply_m1ct = casedoe(case,946,-3.0,0,3,3)
+ nsig_delr_cfr_nsrampg_s_ply_m1ct = casedoe(case,947,-3.0,0,3,3)
+ nsig_delr_cfr_nsrampd_d_ply_met = casedoe(case,948,-2.5,0,3,3)
+ nsig_delr_cfr_pmos45b_d_ply_m1ct = casedoe(case,949,-3.0,0,3,3)
+ nsig_delr_cfr_nmos_ull_d_ply_met = casedoe(case,950,-2.5,0,3,3)
+ nsig_delr_cfr_nld10_s_ply_met = casedoe(case,951,-2.5,0,3,3)
+ nsig_delr_cfr_psrampu_d_ply_met = casedoe(case,952,-2.5,0,3,3)
+ nsig_delr_cfr_pld45b_s_ply_met = casedoe(case,953,-2.6,0,3,3)
+ nsig_delr_cfr_nsrampg_s_ply_met = casedoe(case,954,-2.5,0,3,3)
+ nsig_delr_cfr_nld90b_d_ply_met = casedoe(case,955,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ll_d_ply_met = casedoe(case,956,-2.5,0,3,3)
+ nsig_delr_cfr_pld45b_s_ply_m1ct = casedoe(case,957,-2.5,0,3,3)
+ nsig_delr_cfr_pmoshs45b_s_ply_m1ct = casedoe(case,958,-2.9,0,3,3)
+ nsig_delr_cfr_pmos_ull_s_ply_ct_end = casedoe(case,959,-3.0,0,3,3)
+ nsig_delr_cfr_nld10_s_ply_m1ct = casedoe(case,960,-2.9,0,3,3)
+ nsig_delr_cfr_nmos5_s_ply_met = casedoe(case,961,-2.5,0,3,3)
+ nsig_delr_cfr_nld30b_s_ply_m1ct = casedoe(case,962,-2.5,0,3,3)
+ nsig_delr_cfr_nld5_s_ply_m1ct = casedoe(case,963,-2.6,0,3,3)
+ nsig_delr_cfr_pmos45_d_ply_m1ct = casedoe(case,964,-3.0,0,3,3)
+ nsig_delr_cfr_nmos45b_d_ply_met = casedoe(case,965,-3.0,0,3,3)
+ nsig_delr_cfr_pld90b_d_ply_m1ct = casedoe(case,966,-3.0,0,3,3)
+ nsig_delr_cfr_nld45b_he_d_ply_m1ct = casedoe(case,967,-2.6,0,3,3)
+ nsig_delr_cfr_nmos10_s_ply_met = casedoe(case,968,-2.5,0,3,3)
+ nsig_delr_cfr_nld45b_tlp_s_ply_m1ct = casedoe(case,969,-2.5,0,3,3)
+ nsig_delr_cfr_pmos_ull_s_ply_ct = casedoe(case,970,-3.0,0,3,3)
+ nsig_delr_cfr_nld45_he_s_ply_m1ct = casedoe(case,971,-2.5,0,3,3)
+ nsig_delr_cfr_nld45_tlp_s_ply_m1ct = casedoe(case,972,-2.5,0,3,3)
+ nsig_delr_cfr_nmos_ull_s_ply_met_end = casedoe(case,973,-2.5,0,3,3)
+ nsig_delr_cfr_nsrampd_s_ply_m1ct = casedoe(case,974,-3.0,0,3,3)
+ nsig_delr_cfr_psrampu_s_ply_met = casedoe(case,975,-2.5,0,3,3)
+ nsig_delr_cfr_nmos90_d_ply_m1ct = casedoe(case,976,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ull_d_ply_met = casedoe(case,977,-2.5,0,3,3)
+ nsig_delr_cfr_pld5_d_ply_m1ct = casedoe(case,978,-2.9,0,3,3)
+ nsig_delr_cfr_nld30_d_ply_met = casedoe(case,979,-2.6,0,3,3)
+ nsig_delr_cfr_pmos_ana_d_ply_m1ct = casedoe(case,980,-3.0,0,3,3)
+ nsig_delr_cfr_nld45b_s_ply_met = casedoe(case,981,-2.3,0,3,3)
+ nsig_delr_cfr_pmoshs45b_d_ply_met = casedoe(case,982,-3.0,0,3,3)
+ nsig_delr_cfr_nld65_s_ply_m1ct = casedoe(case,983,-2.7,0,3,3)
+ nsig_delr_cfr_nld90_d_ply_m1ct = casedoe(case,984,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_d_ply_met = casedoe(case,985,-2.5,0,3,3)
+ nsig_delr_cfr_nld5_lvt_s_ply_met = casedoe(case,986,-2.3,0,3,3)
+ nsig_delr_cfr_nmos_ll_d_ply_m1ct = casedoe(case,987,-3.0,0,3,3)
+ nsig_delr_cfr_nmos10_d_ply_met = casedoe(case,988,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_s_ply_m1ct = casedoe(case,989,-3.0,0,3,3)
+ nsig_delr_cfr_nmos5_d_ply_m1ct = casedoe(case,990,-3.0,0,3,3)
+ nsig_delr_cfr_nld10_d_ply_met = casedoe(case,991,-2.5,0,3,3)
+ nsig_delr_cfr_pmos90b_s_ply_m1ct = casedoe(case,992,-2.9,0,3,3)
+ nsig_delr_cfr_nld45b_tlp_s_ply_met = casedoe(case,993,-2.3,0,3,3)
+ nsig_delr_cfr_pld10_d_ply_m1ct = casedoe(case,994,-2.4,0,3,3)
+ nsig_delr_cfr_nmos90_s_ply_m1ct = casedoe(case,995,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_ana_d_ply_m1ct = casedoe(case,996,-3.0,0,3,3)
+ nsig_delr_cfr_pmos90_s_ply_met = casedoe(case,997,-2.5,0,3,3)
+ nsig_delr_cfr_nmos3_zvt_d_ply_met = casedoe(case,998,-2.8,0,3,3)
+ nsig_delr_cfr_pmos5_d_ply_m1ct = casedoe(case,999,-2.9,0,3,3)
+ nsig_delr_cfr_pmos_ull_s_ply_m1ct = casedoe(case,1000,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ana_d_ply_met = casedoe(case,1001,-2.4,0,3,3)
+ nsig_delr_cfr_nmos90b_s_ply_met = casedoe(case,1002,-2.6,0,3,3)
+ nsig_delr_cfr_nmos45_s_ply_m1ct = casedoe(case,1003,-2.9,0,3,3)
+ nsig_delr_cfr_nld45b_he_s_ply_m1ct = casedoe(case,1004,-2.5,0,3,3)
+ nsig_delr_cfr_nsrampg_d_ply_m1ct = casedoe(case,1005,-3.0,0,3,3)
+ nsig_delr_cfr_nld45_d_ply_met = casedoe(case,1006,-2.7,0,3,3)
+ nsig_delr_cfr_nmos_ll_s_ply_m1ct = casedoe(case,1007,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ull_d_ply_met_end = casedoe(case,1008,-2.5,0,3,3)
+ nsig_delr_cfr_nld45b_tlp_d_ply_m1ct = casedoe(case,1009,-2.7,0,3,3)
+ nsig_delr_cfr_nmos90_s_ply_met = casedoe(case,1010,-2.6,0,3,3)
+ nsig_delr_cfr_nmos_ana_d_ply_met = casedoe(case,1011,-2.4,0,3,3)
+ nsig_delr_cfr_pld10_d_ply_met = casedoe(case,1012,-2.3,0,3,3)
+ nsig_delr_cfr_nld5_d_ply_m1ct = casedoe(case,1013,-2.6,0,3,3)
+ nsig_delr_cfr_nmos_s_ply_met = casedoe(case,1014,-2.5,0,3,3)
+ nsig_delr_cfr_pmos_ull_s_ply_met_end = casedoe(case,1015,-2.5,0,3,3)
+ nsig_delr_cfr_pmos90_d_ply_m1ct = casedoe(case,1016,-3.0,0,3,3)
+ nsig_delr_cfr_nld65b_s_ply_m1ct = casedoe(case,1017,-2.7,0,3,3)
+ nsig_delr_cfr_nld30b_d_ply_m1ct = casedoe(case,1018,-2.5,0,3,3)
+ nsig_delr_cfr_nmos_ana_s_ply_m1ct = casedoe(case,1019,-3.0,0,3,3)
+ nsig_delr_cfr_nld65b_d_ply_met = casedoe(case,1020,-3.0,0,3,3)
+ nsig_delr_cfr_nmos_ll_d_ply_met = casedoe(case,1021,-2.5,0,3,3)
+ nsig_delr_cfr_pld10_s_ply_met = casedoe(case,1022,-2.6,0,3,3)
+ nsig_delr_cfr_nmos10_s_ply_m1ct = casedoe(case,1023,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_ull_s_ply_ct = casedoe(case,1024,-3.0,0,3,3)
+ nsig_delr_cfr_pmos90b_s_ply_met = casedoe(case,1025,-2.5,0,3,3)
+ nsig_delr_cfr_pld5_s_ply_met = casedoe(case,1026,-2.4,0,3,3)
+ nsig_delr_cfr_pmos_ull_d_ply_ct_end = casedoe(case,1027,-3.0,0,3,3)
+ nsig_delr_cfr_pmos45b_s_ply_m1ct = casedoe(case,1028,-2.9,0,3,3)
+ nsig_delr_cfr_nld90b_s_ply_met = casedoe(case,1029,-2.4,0,3,3)
+ nsig_delr_cfr_pmos45b_s_ply_met = casedoe(case,1030,-2.5,0,3,3)
+ nsig_delr_cfr_pmoshs45b_d_ply_m1ct = casedoe(case,1031,-3.0,0,3,3)
+ nsig_delr_cfr_pld90_d_ply_met = casedoe(case,1032,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ll_d_ply_m1ct = casedoe(case,1033,-3.0,0,3,3)
+ nsig_delr_cfr_pmos5_s_ply_met = casedoe(case,1034,-2.5,0,3,3)
+ nsig_delr_cfr_pld90_s_ply_m1ct = casedoe(case,1035,-2.5,0,3,3)
+ nsig_delr_cfr_nld90_s_ply_met = casedoe(case,1036,-2.4,0,3,3)
+ nsig_delr_cfr_pmos_ull_s_ply_met = casedoe(case,1037,-2.5,0,3,3)
+ nsig_delr_cfr_pmos10_s_ply_met = casedoe(case,1038,-2.5,0,3,3)
+ nsig_delr_cfr_nld65_d_ply_m1ct = casedoe(case,1039,-3.0,0,3,3)
+ nsig_delr_cfr_nld45b_s_ply_m1ct = casedoe(case,1040,-2.5,0,3,3)
+ nsig_delr_cfr_pmos90_d_ply_met = casedoe(case,1041,-3.0,0,3,3)
+ nsig_delr_cfr_nld10_d_ply_m1ct = casedoe(case,1042,-2.5,0,3,3)
+ nsig_delr_cfr_pld5_d_ply_met = casedoe(case,1043,-2.4,0,3,3)
+ nsig_delr_cfr_pmos5_s_ply_m1ct = casedoe(case,1044,-2.9,0,3,3)
+ nsig_delr_cfr_nld30b_d_ply_met = casedoe(case,1045,-2.6,0,3,3)
+ nsig_delr_cfr_nmos_ll_s_ply_met = casedoe(case,1046,-2.5,0,3,3)
+ nsig_delr_cfr_nld90b_s_ply_m1ct = casedoe(case,1047,-2.4,0,3,3)
+ nsig_delr_cfr_pld45_s_ply_m1ct = casedoe(case,1048,-2.5,0,3,3)
+ nsig_delr_cfr_nld65b_d_ply_m1ct = casedoe(case,1049,-3.0,0,3,3)
+ nsig_delr_cfr_nsrampg_d_ply_met = casedoe(case,1050,-2.5,0,3,3)
+ nsig_delr_cfr_nmos90b_d_ply_m1ct = casedoe(case,1051,-3.0,0,3,3)
+ nsig_delr_cfr_nld5_lvt_d_ply_m1ct = casedoe(case,1052,-2.6,0,3,3)
+ nsig_delr_cfr_pmos10_s_ply_m1ct = casedoe(case,1053,-2.9,0,3,3)
+ nsig_delr_cfr_nld5_d_ply_met = casedoe(case,1054,-2.3,0,3,3)
+ nsig_delr_cfr_nld30b_s_ply_met = casedoe(case,1055,-2.3,0,3,3)
+ nsig_delr_cfr_nld65_s_ply_met = casedoe(case,1056,-2.4,0,3,3)
+ nsig_delr_cfr_nld45_he_d_ply_met = casedoe(case,1057,-2.7,0,3,3)
+ nsig_delr_cfr_pld30_s_ply_m1ct = casedoe(case,1058,-2.6,0,3,3)
+ nsig_delr_cfr_pld90_d_ply_m1ct = casedoe(case,1059,-3.0,0,3,3)
+ nsig_delr_cfr_nmos90b_d_ply_met = casedoe(case,1060,-3.0,0,3,3)
+ nsig_delr_cfr_pmos45_s_ply_met = casedoe(case,1061,-2.5,0,3,3)
+ nsig_delr_cfr_pmoshs45_d_ply_m1ct = casedoe(case,1062,-3.0,0,3,3)
+ nsig_delr_cfr_nmos_ull_d_ply_m1ct = casedoe(case,1063,-3.0,0,3,3)
+ nsig_delr_cfr_pmos5_d_ply_met = casedoe(case,1064,-2.5,0,3,3)
+ nsig_delr_cfr_pld45_d_ply_m1ct = casedoe(case,1065,-2.7,0,3,3)
+ nsig_delr_cfr_nmos45b_s_ply_met = casedoe(case,1066,-2.5,0,3,3)
+ nsig_delr_cfr_nld45_tlp_d_ply_met = casedoe(case,1067,-2.8,0,3,3)
+ nsig_delr_cfr_nmos_ull_d_ply_met_end = casedoe(case,1068,-2.5,0,3,3)
+ nsig_delr_cfr_nmos45b_d_ply_m1ct = casedoe(case,1069,-2.9,0,3,3)
+ nsig_delr_cfr_nld45_tlp_d_ply_m1ct = casedoe(case,1070,-2.7,0,3,3)
+ nsig_delr_cfr_pld90_s_ply_met = casedoe(case,1071,-2.5,0,3,3)
+ nsig_delr_cfr_nld30_d_ply_m1ct = casedoe(case,1072,-2.5,0,3,3)
+ nsig_delr_cfr_nmos5_d_ply_met = casedoe(case,1073,-2.5,0,3,3)
+ nsig_delr_cfr_nmos3_zvt_s_ply_met = casedoe(case,1074,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_d_ply_met = casedoe(case,1075,-2.5,0,3,3)
+ nsig_delr_cfr_pld30b_d_ply_met = casedoe(case,1076,-2.6,0,3,3)
+ nsig_delr_cfr_nld30_s_ply_met = casedoe(case,1077,-2.3,0,3,3)
+ nsig_delr_cfr_pmoshs45_d_ply_met = casedoe(case,1078,-3.0,0,3,3)
+ nsig_delr_cfr_nmos5_s_ply_m1ct = casedoe(case,1079,-3.0,0,3,3)
+ nsig_delr_cfr_pmos10_d_ply_met = casedoe(case,1080,-2.5,0,3,3)
+ nsig_delr_cfr_pld30b_s_ply_m1ct = casedoe(case,1081,-2.6,0,3,3)
+ nsig_delr_cfr_nmos45_s_ply_met = casedoe(case,1082,-2.5,0,3,3)
+ nsig_delr_cfr_pmoshs45_s_ply_met = casedoe(case,1083,-2.5,0,3,3)
+ nsig_delr_cfr_nld5_lvt_s_ply_m1ct = casedoe(case,1084,-2.6,0,3,3)
+ nsig_delr_cfr_pld90b_s_ply_m1ct = casedoe(case,1085,-2.5,0,3,3)
+ nsig_delr_cfr_pld90b_s_ply_met = casedoe(case,1086,-2.5,0,3,3)
+ nsig_delr_cfr_nmos45_d_ply_met = casedoe(case,1087,-3.0,0,3,3)
+ nsig_delr_cfr_nld5_s_ply_met = casedoe(case,1088,-2.3,0,3,3)
+ nsig_delr_cfr_pld30_d_ply_met = casedoe(case,1089,-2.6,0,3,3)
+ nsig_delr_cfr_pmos_s_ply_m1ct = casedoe(case,1090,-3.0,0,3,3)
+ nsig_delr_cfr_pmos90b_d_ply_m1ct = casedoe(case,1091,-3.0,0,3,3)
+ nsig_delr_cfr_nld5_lvt_d_ply_met = casedoe(case,1092,-2.3,0,3,3)
+ nsig_delr_cfr_nmos10_d_ply_m1ct = casedoe(case,1093,-2.9,0,3,3)
+ nsig_delr_cfr_pmos10_d_ply_m1ct = casedoe(case,1094,-2.6,0,3,3)
+ nsig_delr_cfr_nld30_s_ply_m1ct = casedoe(case,1095,-2.5,0,3,3)
+ nsig_delr_cfr_pmos_ull_d_ply_ct = casedoe(case,1096,-3.0,0,3,3)
+ nsig_delr_cfr_nld45_tlp_s_ply_met = casedoe(case,1097,-2.3,0,3,3)
+ nsig_delr_cfr_nmos45_d_ply_m1ct = casedoe(case,1098,-2.9,0,3,3)
+ nsig_delr_cfr_nmos_ull_s_ply_ct_end = casedoe(case,1099,-3.0,0,3,3)
+ nsig_delr_cfr_pmos45_s_ply_m1ct = casedoe(case,1100,-2.9,0,3,3)
+ nsig_delr_cfr_pmos_ana_s_ply_m1ct = casedoe(case,1101,-3.0,0,3,3)
+ nsig_delr_cfr_pld30b_s_ply_met = casedoe(case,1102,-2.6,0,3,3)
+ nsig_delr_cfr_pld90b_d_ply_met = casedoe(case,1103,-3.0,0,3,3)
+ nsig_delr_cfr_pld45b_d_ply_m1ct = casedoe(case,1104,-2.7,0,3,3)
+ nsig_delr_cfr_nld45b_he_s_ply_met = casedoe(case,1105,-2.3,0,3,3)
+ nsig_delr_cfr_nld45_s_ply_met = casedoe(case,1106,-2.3,0,3,3)
+ nsig_delr_cfr_nmos_d_ply_m1ct = casedoe(case,1107,-3.0,0,3,3)
+ nsig_delr_cfr_pmos_ull_d_ply_m1ct = casedoe(case,1108,-3.0,0,3,3)
+ nsig_delr_cfr_pld45b_d_ply_met = casedoe(case,1109,-2.8,0,3,3)
+ nsig_delr_cfr_pmos90_s_ply_m1ct = casedoe(case,1110,-2.9,0,3,3)
+ nsig_delr_cfr_pld30_d_ply_m1ct = casedoe(case,1111,-2.5,0,3,3)
+ nsig_delr_cfr_nld45_he_s_ply_met = casedoe(case,1112,-2.3,0,3,3)
+ nsig_delr_cfr_nmos3_zvt_s_ply_m1ct = casedoe(case,1113,-3.0,0,3,3)
+ nsig_delr_cfr_nsrampd_d_ply_m1ct = casedoe(case,1114,-3.0,0,3,3)
+ nsig_delr_cfr_nmos90_d_ply_met = casedoe(case,1115,-3.0,0,3,3)
+ nsig_delr_cfr_nmos_ana_s_ply_met = casedoe(case,1116,-2.4,0,3,3)
+ nsig_delr_cfr_psrampu_s_ply_m1ct = casedoe(case,1117,-3.0,0,3,3)
+ nsig_delr_cfr_nmos45b_s_ply_m1ct = casedoe(case,1118,-2.9,0,3,3)
+ nsig_delr_cfr_nld45_he_d_ply_m1ct = casedoe(case,1119,-2.6,0,3,3)
+ nsig_delr_cfr_nld45b_d_ply_m1ct = casedoe(case,1120,-2.6,0,3,3)
+ nsig_delr_cfr_nld45_d_ply_m1ct = casedoe(case,1121,-2.6,0,3,3)
+ nsig_delr_cfr_nmos_ull_d_ply_ct_end = casedoe(case,1122,-3.0,0,3,3)
+ nsig_delr_acj0_junc_psd_nw = casedoe(case,1123,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_psd_nw = casedoe(case,1124,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_psd_nw = casedoe(case,1125,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_psd_nw = casedoe(case,1126,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nsd_pw = casedoe(case,1127,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nsd_pw = casedoe(case,1128,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nsd_pw = casedoe(case,1129,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nsd_pw = casedoe(case,1130,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_psd_nhv = casedoe(case,1131,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_psd_nhv = casedoe(case,1132,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_psd_nhv = casedoe(case,1133,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_psd_nhv = casedoe(case,1134,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nsd_phv = casedoe(case,1135,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nsd_phv = casedoe(case,1136,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nsd_phv = casedoe(case,1137,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nsd_phv = casedoe(case,1138,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pepi_nbl = casedoe(case,1139,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pepi_nbl = casedoe(case,1140,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pepi_nbl = casedoe(case,1141,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pepi_nbl = casedoe(case,1142,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nw_pepi = casedoe(case,1143,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nw_pepi = casedoe(case,1144,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nw_pepi = casedoe(case,1145,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nw_pepi = casedoe(case,1146,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nw_pepi_tr = casedoe(case,1147,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nw_pepi_tr = casedoe(case,1148,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nw_pepi_tr = casedoe(case,1149,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nw_pepi_tr = casedoe(case,1150,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nhv_pepi_tr = casedoe(case,1151,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nhv_pepi_tr = casedoe(case,1152,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nhv_pepi_tr = casedoe(case,1153,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nhv_pepi_tr = casedoe(case,1154,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nbl_pepi_tr = casedoe(case,1155,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nbl_pepi_tr = casedoe(case,1156,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nbl_pepi_tr = casedoe(case,1157,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nbl_pepi_tr = casedoe(case,1158,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos_sd_body = casedoe(case,1159,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos_sd_body = casedoe(case,1160,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos_sd_body = casedoe(case,1161,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos_sd_body = casedoe(case,1162,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos_sd_body = casedoe(case,1163,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos_sd_body = casedoe(case,1164,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos_ll_sd_body = casedoe(case,1165,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos_ll_sd_body = casedoe(case,1166,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos_ll_sd_body = casedoe(case,1167,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos_ll_sd_body = casedoe(case,1168,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos_ll_sd_body = casedoe(case,1169,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos_ll_sd_body = casedoe(case,1170,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos_ull_sd_body = casedoe(case,1171,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos_ull_sd_body = casedoe(case,1172,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos_ull_sd_body = casedoe(case,1173,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos_ull_sd_body = casedoe(case,1174,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos_ull_sd_body = casedoe(case,1175,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos_ull_sd_body = casedoe(case,1176,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos_ana_sd_body = casedoe(case,1177,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos_ana_sd_body = casedoe(case,1178,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos_ana_sd_body = casedoe(case,1179,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos_ana_sd_body = casedoe(case,1180,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos_ana_sd_body = casedoe(case,1181,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos_ana_sd_body = casedoe(case,1182,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nsrampg_sd_body = casedoe(case,1183,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nsrampg_sd_body = casedoe(case,1184,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nsrampg_sd_body = casedoe(case,1185,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nsrampg_sd_body = casedoe(case,1186,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nsrampg_sd_body = casedoe(case,1187,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nsrampg_sd_body = casedoe(case,1188,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nsrampd_sd_body = casedoe(case,1189,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nsrampd_sd_body = casedoe(case,1190,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nsrampd_sd_body = casedoe(case,1191,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nsrampd_sd_body = casedoe(case,1192,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nsrampd_sd_body = casedoe(case,1193,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nsrampd_sd_body = casedoe(case,1194,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos_sd_body = casedoe(case,1195,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos_sd_body = casedoe(case,1196,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos_sd_body = casedoe(case,1197,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos_sd_body = casedoe(case,1198,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos_sd_body = casedoe(case,1199,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos_sd_body = casedoe(case,1200,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos_ll_sd_body = casedoe(case,1201,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos_ll_sd_body = casedoe(case,1202,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos_ll_sd_body = casedoe(case,1203,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos_ll_sd_body = casedoe(case,1204,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos_ll_sd_body = casedoe(case,1205,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos_ll_sd_body = casedoe(case,1206,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos_ull_sd_body = casedoe(case,1207,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos_ull_sd_body = casedoe(case,1208,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos_ull_sd_body = casedoe(case,1209,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos_ull_sd_body = casedoe(case,1210,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos_ull_sd_body = casedoe(case,1211,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos_ull_sd_body = casedoe(case,1212,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos_ana_sd_body = casedoe(case,1213,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos_ana_sd_body = casedoe(case,1214,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos_ana_sd_body = casedoe(case,1215,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos_ana_sd_body = casedoe(case,1216,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos_ana_sd_body = casedoe(case,1217,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos_ana_sd_body = casedoe(case,1218,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos3_zvt_d_body = casedoe(case,1219,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos3_zvt_d_body = casedoe(case,1220,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos3_zvt_d_body = casedoe(case,1221,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos3_zvt_d_body = casedoe(case,1222,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos3_zvt_d_body = casedoe(case,1223,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos3_zvt_d_body = casedoe(case,1224,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos3_zvt_s_body = casedoe(case,1225,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos3_zvt_s_body = casedoe(case,1226,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos3_zvt_s_body = casedoe(case,1227,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos3_zvt_s_body = casedoe(case,1228,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos3_zvt_s_body = casedoe(case,1229,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos3_zvt_s_body = casedoe(case,1230,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_psrampu_sd_body = casedoe(case,1231,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_psrampu_sd_body = casedoe(case,1232,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_psrampu_sd_body = casedoe(case,1233,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_psrampu_sd_body = casedoe(case,1234,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_psrampu_sd_body = casedoe(case,1235,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_psrampu_sd_body = casedoe(case,1236,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos5_s_body = casedoe(case,1237,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos5_s_body = casedoe(case,1238,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos5_s_body = casedoe(case,1239,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos5_s_body = casedoe(case,1240,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos5_s_body = casedoe(case,1241,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos5_s_body = casedoe(case,1242,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos5_d_body = casedoe(case,1243,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos5_d_body = casedoe(case,1244,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos5_d_body = casedoe(case,1245,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos5_d_body = casedoe(case,1246,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos5_d_body = casedoe(case,1247,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos5_d_body = casedoe(case,1248,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos5_sd_body = casedoe(case,1249,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos5_sd_body = casedoe(case,1250,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos5_sd_body = casedoe(case,1251,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos5_sd_body = casedoe(case,1252,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos5_sd_body = casedoe(case,1253,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos5_sd_body = casedoe(case,1254,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos10_d_body = casedoe(case,1255,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos10_d_body = casedoe(case,1256,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos10_d_body = casedoe(case,1257,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos10_d_body = casedoe(case,1258,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos10_d_body = casedoe(case,1259,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos10_d_body = casedoe(case,1260,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos10_s_body = casedoe(case,1261,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos10_s_body = casedoe(case,1262,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos10_s_body = casedoe(case,1263,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos10_s_body = casedoe(case,1264,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos10_s_body = casedoe(case,1265,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos10_s_body = casedoe(case,1266,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos10_d_body = casedoe(case,1267,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos10_d_body = casedoe(case,1268,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos10_d_body = casedoe(case,1269,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos10_d_body = casedoe(case,1270,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos10_d_body = casedoe(case,1271,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos10_d_body = casedoe(case,1272,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos10_s_body = casedoe(case,1273,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos10_s_body = casedoe(case,1274,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos10_s_body = casedoe(case,1275,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos10_s_body = casedoe(case,1276,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos10_s_body = casedoe(case,1277,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos10_s_body = casedoe(case,1278,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos45_d_body = casedoe(case,1279,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos45_d_body = casedoe(case,1280,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos45_d_body = casedoe(case,1281,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos45_d_body = casedoe(case,1282,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos45_d_body = casedoe(case,1283,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos45_d_body = casedoe(case,1284,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos45_s_body = casedoe(case,1285,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos45_s_body = casedoe(case,1286,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos45_s_body = casedoe(case,1287,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos45_s_body = casedoe(case,1288,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos45_s_body = casedoe(case,1289,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos45_s_body = casedoe(case,1290,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos45b_d_body = casedoe(case,1291,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos45b_d_body = casedoe(case,1292,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos45b_d_body = casedoe(case,1293,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos45b_d_body = casedoe(case,1294,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos45b_d_body = casedoe(case,1295,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos45b_d_body = casedoe(case,1296,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos45b_s_body = casedoe(case,1297,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos45b_s_body = casedoe(case,1298,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos45b_s_body = casedoe(case,1299,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos45b_s_body = casedoe(case,1300,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos45b_s_body = casedoe(case,1301,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos45b_s_body = casedoe(case,1302,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos45_d_body = casedoe(case,1303,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos45_d_body = casedoe(case,1304,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos45_d_body = casedoe(case,1305,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos45_d_body = casedoe(case,1306,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos45_d_body = casedoe(case,1307,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos45_d_body = casedoe(case,1308,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos45_s_body = casedoe(case,1309,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos45_s_body = casedoe(case,1310,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos45_s_body = casedoe(case,1311,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos45_s_body = casedoe(case,1312,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos45_s_body = casedoe(case,1313,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos45_s_body = casedoe(case,1314,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos45b_d_body = casedoe(case,1315,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos45b_d_body = casedoe(case,1316,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos45b_d_body = casedoe(case,1317,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos45b_d_body = casedoe(case,1318,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos45b_d_body = casedoe(case,1319,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos45b_d_body = casedoe(case,1320,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos45b_s_body = casedoe(case,1321,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos45b_s_body = casedoe(case,1322,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos45b_s_body = casedoe(case,1323,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos45b_s_body = casedoe(case,1324,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos45b_s_body = casedoe(case,1325,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos45b_s_body = casedoe(case,1326,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmoshs45_d_body = casedoe(case,1327,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmoshs45_d_body = casedoe(case,1328,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmoshs45_d_body = casedoe(case,1329,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmoshs45_d_body = casedoe(case,1330,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmoshs45_d_body = casedoe(case,1331,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmoshs45_d_body = casedoe(case,1332,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmoshs45_s_body = casedoe(case,1333,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmoshs45_s_body = casedoe(case,1334,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmoshs45_s_body = casedoe(case,1335,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmoshs45_s_body = casedoe(case,1336,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmoshs45_s_body = casedoe(case,1337,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmoshs45_s_body = casedoe(case,1338,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmoshs45b_d_body = casedoe(case,1339,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmoshs45b_d_body = casedoe(case,1340,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmoshs45b_d_body = casedoe(case,1341,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmoshs45b_d_body = casedoe(case,1342,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmoshs45b_d_body = casedoe(case,1343,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmoshs45b_d_body = casedoe(case,1344,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmoshs45b_s_body = casedoe(case,1345,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmoshs45b_s_body = casedoe(case,1346,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmoshs45b_s_body = casedoe(case,1347,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmoshs45b_s_body = casedoe(case,1348,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmoshs45b_s_body = casedoe(case,1349,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmoshs45b_s_body = casedoe(case,1350,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos90_d_body = casedoe(case,1351,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos90_d_body = casedoe(case,1352,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos90_d_body = casedoe(case,1353,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos90_d_body = casedoe(case,1354,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos90_d_body = casedoe(case,1355,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos90_d_body = casedoe(case,1356,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos90_s_body = casedoe(case,1357,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos90_s_body = casedoe(case,1358,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos90_s_body = casedoe(case,1359,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos90_s_body = casedoe(case,1360,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos90_s_body = casedoe(case,1361,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos90_s_body = casedoe(case,1362,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos90b_d_body = casedoe(case,1363,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos90b_d_body = casedoe(case,1364,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos90b_d_body = casedoe(case,1365,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos90b_d_body = casedoe(case,1366,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos90b_d_body = casedoe(case,1367,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos90b_d_body = casedoe(case,1368,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nmos90b_s_body = casedoe(case,1369,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nmos90b_s_body = casedoe(case,1370,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nmos90b_s_body = casedoe(case,1371,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nmos90b_s_body = casedoe(case,1372,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nmos90b_s_body = casedoe(case,1373,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nmos90b_s_body = casedoe(case,1374,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos90_d_body = casedoe(case,1375,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos90_d_body = casedoe(case,1376,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos90_d_body = casedoe(case,1377,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos90_d_body = casedoe(case,1378,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos90_d_body = casedoe(case,1379,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos90_d_body = casedoe(case,1380,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos90b_d_body = casedoe(case,1381,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos90b_d_body = casedoe(case,1382,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos90b_d_body = casedoe(case,1383,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos90b_d_body = casedoe(case,1384,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos90b_d_body = casedoe(case,1385,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos90b_d_body = casedoe(case,1386,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos90_s_body = casedoe(case,1387,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos90_s_body = casedoe(case,1388,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos90_s_body = casedoe(case,1389,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos90_s_body = casedoe(case,1390,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos90_s_body = casedoe(case,1391,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos90_s_body = casedoe(case,1392,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pmos90b_s_body = casedoe(case,1393,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pmos90b_s_body = casedoe(case,1394,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pmos90b_s_body = casedoe(case,1395,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pmos90b_s_body = casedoe(case,1396,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pmos90b_s_body = casedoe(case,1397,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pmos90b_s_body = casedoe(case,1398,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld5_d_body = casedoe(case,1399,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld5_d_body = casedoe(case,1400,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld5_d_body = casedoe(case,1401,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld5_d_body = casedoe(case,1402,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld5_d_body = casedoe(case,1403,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld5_d_body = casedoe(case,1404,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld5_lvt_d_body = casedoe(case,1405,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld5_lvt_d_body = casedoe(case,1406,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld5_lvt_d_body = casedoe(case,1407,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld5_lvt_d_body = casedoe(case,1408,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld5_lvt_d_body = casedoe(case,1409,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld5_lvt_d_body = casedoe(case,1410,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld10_d_body = casedoe(case,1411,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld10_d_body = casedoe(case,1412,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld10_d_body = casedoe(case,1413,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld10_d_body = casedoe(case,1414,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld10_d_body = casedoe(case,1415,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld10_d_body = casedoe(case,1416,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld30_d_body = casedoe(case,1417,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld30_d_body = casedoe(case,1418,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld30_d_body = casedoe(case,1419,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld30_d_body = casedoe(case,1420,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld30_d_body = casedoe(case,1421,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld30_d_body = casedoe(case,1422,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld30b_d_body = casedoe(case,1423,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld30b_d_body = casedoe(case,1424,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld30b_d_body = casedoe(case,1425,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld30b_d_body = casedoe(case,1426,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld30b_d_body = casedoe(case,1427,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld30b_d_body = casedoe(case,1428,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45_d_body = casedoe(case,1429,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45_d_body = casedoe(case,1430,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45_d_body = casedoe(case,1431,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45_d_body = casedoe(case,1432,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45_d_body = casedoe(case,1433,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45_d_body = casedoe(case,1434,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45b_d_body = casedoe(case,1435,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45b_d_body = casedoe(case,1436,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45b_d_body = casedoe(case,1437,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45b_d_body = casedoe(case,1438,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45b_d_body = casedoe(case,1439,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45b_d_body = casedoe(case,1440,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45_he_d_body = casedoe(case,1441,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45_he_d_body = casedoe(case,1442,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45_he_d_body = casedoe(case,1443,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45_he_d_body = casedoe(case,1444,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45_he_d_body = casedoe(case,1445,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45_he_d_body = casedoe(case,1446,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45b_he_d_body = casedoe(case,1447,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45b_he_d_body = casedoe(case,1448,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45b_he_d_body = casedoe(case,1449,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45b_he_d_body = casedoe(case,1450,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45b_he_d_body = casedoe(case,1451,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45b_he_d_body = casedoe(case,1452,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45_tlp_d_body = casedoe(case,1453,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45_tlp_d_body = casedoe(case,1454,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45_tlp_d_body = casedoe(case,1455,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45_tlp_d_body = casedoe(case,1456,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45_tlp_d_body = casedoe(case,1457,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45_tlp_d_body = casedoe(case,1458,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld45b_tlp_d_body = casedoe(case,1459,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld45b_tlp_d_body = casedoe(case,1460,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld45b_tlp_d_body = casedoe(case,1461,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld45b_tlp_d_body = casedoe(case,1462,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld45b_tlp_d_body = casedoe(case,1463,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld45b_tlp_d_body = casedoe(case,1464,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld65_d_body = casedoe(case,1465,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld65_d_body = casedoe(case,1466,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld65_d_body = casedoe(case,1467,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld65_d_body = casedoe(case,1468,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld65_d_body = casedoe(case,1469,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld65_d_body = casedoe(case,1470,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld65b_d_body = casedoe(case,1471,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld65b_d_body = casedoe(case,1472,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld65b_d_body = casedoe(case,1473,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld65b_d_body = casedoe(case,1474,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld65b_d_body = casedoe(case,1475,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld65b_d_body = casedoe(case,1476,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld90_d_body = casedoe(case,1477,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld90_d_body = casedoe(case,1478,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld90_d_body = casedoe(case,1479,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld90_d_body = casedoe(case,1480,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld90_d_body = casedoe(case,1481,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld90_d_body = casedoe(case,1482,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_nld90b_d_body = casedoe(case,1483,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_nld90b_d_body = casedoe(case,1484,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_nld90b_d_body = casedoe(case,1485,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_nld90b_d_body = casedoe(case,1486,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_nld90b_d_body = casedoe(case,1487,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_nld90b_d_body = casedoe(case,1488,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld5_d_body = casedoe(case,1489,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld5_d_body = casedoe(case,1490,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld5_d_body = casedoe(case,1491,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld5_d_body = casedoe(case,1492,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld5_d_body = casedoe(case,1493,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld5_d_body = casedoe(case,1494,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld10_d_body = casedoe(case,1495,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld10_d_body = casedoe(case,1496,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld10_d_body = casedoe(case,1497,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld10_d_body = casedoe(case,1498,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld10_d_body = casedoe(case,1499,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld10_d_body = casedoe(case,1500,-3.0,0.0,3.0,3)
+ nsig_delr_cj0_junc_pld10b_d_body = casedoe(case,1501,-3.0,0.0,3.0,3)
+ nsig_delr_js_junc_pld10b_d_body = casedoe(case,1502,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld30_d_body = casedoe(case,1503,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld30_d_body = casedoe(case,1504,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld30_d_body = casedoe(case,1505,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld30_d_body = casedoe(case,1506,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld30_d_body = casedoe(case,1507,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld30_d_body = casedoe(case,1508,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld30b_d_body = casedoe(case,1509,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld30b_d_body = casedoe(case,1510,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld30b_d_body = casedoe(case,1511,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld30b_d_body = casedoe(case,1512,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld30b_d_body = casedoe(case,1513,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld30b_d_body = casedoe(case,1514,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld45_d_body = casedoe(case,1515,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld45_d_body = casedoe(case,1516,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld45_d_body = casedoe(case,1517,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld45_d_body = casedoe(case,1518,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld45_d_body = casedoe(case,1519,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld45_d_body = casedoe(case,1520,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld45b_d_body = casedoe(case,1521,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld45b_d_body = casedoe(case,1522,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld45b_d_body = casedoe(case,1523,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld45b_d_body = casedoe(case,1524,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld45b_d_body = casedoe(case,1525,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld45b_d_body = casedoe(case,1526,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld90_d_body = casedoe(case,1527,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld90_d_body = casedoe(case,1528,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld90_d_body = casedoe(case,1529,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld90_d_body = casedoe(case,1530,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld90_d_body = casedoe(case,1531,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld90_d_body = casedoe(case,1532,-3.0,0.0,3.0,3)
+ nsig_delr_acj0_junc_pld90b_d_body = casedoe(case,1533,-3.0,0.0,3.0,3)
+ nsig_delr_ajs_junc_pld90b_d_body = casedoe(case,1534,-3.0,0.0,3.0,3)
+ nsig_delr_pcj0_junc_pld90b_d_body = casedoe(case,1535,-3.0,0.0,3.0,3)
+ nsig_delr_pjs_junc_pld90b_d_body = casedoe(case,1536,-3.0,0.0,3.0,3)
+ nsig_delr_chcj0_junc_pld90b_d_body = casedoe(case,1537,-3.0,0.0,3.0,3)
+ nsig_delr_chjs_junc_pld90b_d_body = casedoe(case,1538,-3.0,0.0,3.0,3)
+ nsig_delr_tox_box = casedoe(case,1539,-3.0,0,3.0,3)
+ nsig_delr_is_dpldd_junc_10hv = casedoe(case,1540,-3.0,0.0,3.0,3)
+ nsig_delr_ir_dpldd_junc_10hv = casedoe(case,1541,-3.0,0.0,3.0,3)
+ nsig_dela_bv_dpldd_junc_10hv = casedoe(case,1542,-3.0,0.0,3.0,3)
+ nsig_delr_cj_dpldd_junc_10hv = casedoe(case,1543,-3.0,0.0,3.0,3)

//}

}
endsection case
//***********************************************************

//***********************************************************
section wcs_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (-4.9464)
+    nsig_dela_od_nmos_10hv_bsim4   = (2.98574)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (1.72352)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (-1.5436)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (3.14346)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (2.39546)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (1.58563)
+    nsig_delr_a0_nmos_10hv_bsim4   = (3.19108)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (5.99312)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (1.61466)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (-1.41339)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (1.30951)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (1.94804)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (1.93798)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (0.73069)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (6.13962)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (-0.235568)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (-1.96037)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-3.37567)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (1.72112)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (-2.01695)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (-1.90388)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (0.802107)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (2.23472)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (0.485392)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (-2.08703)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (1.63178)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (-1.71386)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (1.57866)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (-1.60087)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (1.94135)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (1.33274)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (1.37925)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (1.6593)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (-2.33686)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (1.407808)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (1.56829)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (2.40918)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (1.1648)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0.676859)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (1.38093)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (-1.00515)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0.683)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (-0.171126)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.376381)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (-3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (-1.73015)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (2.65672)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (-1.14055)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (1.27703)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (1.667)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (-1.939)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (-2.87)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (-3.221)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (0.5075)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (-3.395)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (5.056)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (1.856)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (-2.35902)
+    nsig_dela_od_pmos_10hv_bsim4   = (3.13242)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (1.79837)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (-3.17742)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (3.54336)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (2.11678)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (-2.267076)
+    nsig_dela_a0_pmos_10hv_bsim4   = (-3.14416)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (-3.56498)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (-3)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (-3.87318)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (-1.9671)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (-1.31442)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (2.614506)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (1.88567)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (-1.27882)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (3.46231)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (3.41338)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (-2.05347)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (-1.56503)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (2.969965)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (1.78719)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (2.05659)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (0.810168)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (1.18787)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (-0.541051)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (-0.80914)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (2.20673)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (-2.579)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (-2.605395)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (3.04066)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (0.785292)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (-2.32098)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (-2.524892)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-2.891529)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (-1.6845)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (3)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (3)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (-0.496)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (2.133)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (-1.527)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (1.665)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (1.877)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (1.801)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0.01371)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (-2.305)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (0.3462)

//***********************************************************
endsection wcs_thin_mos_process_params
//***********************************************************

//***********************************************************
section wnhp_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (-4.9464)
+    nsig_dela_od_nmos_10hv_bsim4   = (2.98574)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (1.72352)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (-1.5436)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (3.14346)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (2.39546)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (1.58563)
+    nsig_delr_a0_nmos_10hv_bsim4   = (3.19108)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (5.99312)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (1.61466)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (-1.41339)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (1.30951)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (1.94804)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (1.93798)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (0.73069)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (6.13962)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (-0.235568)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (-1.96037)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-3.37567)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (1.72112)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (-2.01695)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (-1.90388)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (0.802107)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (2.23472)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (0.485392)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (-2.08703)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (1.63178)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (-3)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (-1.71386)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (1.57866)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (-1.60087)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (1.94135)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (1.33274)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (1.37925)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (1.6593)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (-2.33686)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (1.407808)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (1.56829)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (2.40918)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (1.1648)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0.676859)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (1.38093)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (-1.00515)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0.683)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (-0.171126)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.376381)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (-3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (-1.73015)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (2.65672)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (-1.14055)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (1.27703)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (1.667)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (-1.939)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (-2.87)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (-3.221)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (0.5075)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (-3.395)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (5.056)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (1.856)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (1.129754)
+    nsig_dela_od_pmos_10hv_bsim4   = (-0.953649)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (-2.29875)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (3.13428)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (-1.2999)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (-0.919275)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (1.162857)
+    nsig_dela_a0_pmos_10hv_bsim4   = (4.72476)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (0.774728)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (2.5)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (1.041549)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (2.74313)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (1.69008)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (-5.08647)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (-0.542603)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (0.801657)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (-0.577059)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (-3.46264)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (2.5)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (2.78296)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (0.617592)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (1.751195)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (-2.43688)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (-0.765226)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (1.845399)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (-0.406122)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (2.25774)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (1.371985)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (2)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (2)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (2)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (-2.94437)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (4.71092)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (4.04729)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (-1.652944)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (2.135936)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (-0.412394)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (2.033884)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-0.616797)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (2.78627)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (-3.614)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (-3.066)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (2.007)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (0.2608)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (-1.095)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (-0.4875)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0.5615)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (3.21)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (-0.6288)

//***********************************************************
endsection wnhp_thin_mos_process_params
//***********************************************************

//***********************************************************
section wphn_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (0.2739156)
+    nsig_dela_od_nmos_10hv_bsim4   = (-1.1711)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (-2.6023)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (1.98748)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (-1.62642)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (-1.09445)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (-1.015858)
+    nsig_delr_a0_nmos_10hv_bsim4   = (-2.79389)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (-1.10775)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (-1.5)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (-1.5)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (+1.5)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (-4.47108)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (1.64992)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (-1.82078)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (-0.654704)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (-0.752494)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (2.02839)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (-2.6723)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (0.578408)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (3.51578)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (2.5)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-0.552395)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (-2.74198)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (-0.248022)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (0.807576)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (-2.28498)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (-1.07556)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (-0.374157)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (-0.352814)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (-0.444853)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (2)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (2)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (2)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (2)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (0.275472)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (-0.958144)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (2.6854)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (-2.30518)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (-0.25351)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (-0.821281)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (0.349973)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (0.411394)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (-0.597328)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (-0.536315)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (-1.5)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (-1.5)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (1.5)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (-2.10696)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (-1.83348)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0.0751072)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (1.62359)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (3.68387)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (-0.183542)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (1.00663)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.488899)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (-3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (3.21748)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (-1.68591)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (-0.059571)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (-0.484973)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (0.02223)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (-0.04054)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (1.612)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (1.365)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (-0.1336)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (2.395)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (-1.476)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (-0.3357)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (-2.35902)
+    nsig_dela_od_pmos_10hv_bsim4   = (3.13242)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (1.79837)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (-3.17742)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (3.54336)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (2.11678)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (-2.267076)
+    nsig_dela_a0_pmos_10hv_bsim4   = (-3.14416)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (-3.56498)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (-3)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (-3.87318)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (-1.9671)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (-1.31442)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (2.614506)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (1.88567)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (-1.27882)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (3.46231)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (3.41338)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (-3)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (-2.05347)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (-1.56503)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (2.969965)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (1.78719)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (2.05659)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (0.810168)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (1.18787)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (-0.541051)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (-0.80914)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (-3.5)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (2.20673)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (-2.579)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (-2.605395)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (3.04066)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (0.785292)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (-2.32098)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (-2.524892)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-2.891529)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (-1.6845)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (3)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (3)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (-0.4964)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (2.133)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (-1.527)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (1.665)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (1.877)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (1.801)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0.01371)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (-2.305)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (0.3462)

//***********************************************************
endsection wphn_thin_mos_process_params
//***********************************************************

//***********************************************************
section typ_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (0)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (0)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_10hv_bsim4   = (0)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (0)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (0)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (0)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (0)
+    nsig_delr_a0_nmos_10hv_bsim4   = (0)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (0)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_10hv_bsim4   = (0)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (0)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (0)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (0)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (0)
+    nsig_dela_a0_pmos_10hv_bsim4   = (0)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (0)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (0)

//***********************************************************
endsection typ_thin_mos_process_params
//***********************************************************

//***********************************************************
section mc_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (0)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (0)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_10hv_bsim4   = (0)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (0)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (0)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (0)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (0)
+    nsig_delr_a0_nmos_10hv_bsim4   = (0)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (0)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (0)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_10hv_bsim4   = (0)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (0)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (0)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (0)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (0)
+    nsig_dela_a0_pmos_10hv_bsim4   = (0)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (0)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (0)

statistics {
    process {
        vary nsig_delr_mosfet_thin_tox_bsim3v3     dist=gauss std=1
        vary nsig_dela_cd_cmos_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_mosfet_thin_tox_bsim4     dist=gauss std=1
        vary nsig_dela_cd_cmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_cd_cmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_a0_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_pvsat_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_lvoff_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pvoff_nmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_vsat_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wwl_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_jtss_nmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_lu0_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wwl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_vsat_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_wvsat_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_b0_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_jtss_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_agidl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wagidl_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pvoff_nmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_vsat_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_pvsat_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wwl_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_voff_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_lvoff_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pvoff_nmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwwl_nsrampg_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_b0_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwwl_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_vsat_nsrampd_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dwox_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pu0_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_agidl_pmos_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_ags_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_jtss_pmos_ll_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wwl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_la0_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pa0_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_b0_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_jtss_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_agidl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wagidl_pmos_ull_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_od_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtw_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_lwl_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_a0_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_wvoff_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pvoff_pmos_ana_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vfb_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtw_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtm_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_a0_psrampu_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_wwl_psrampu_10hv_bsim3v3     dist=gauss std=1
    }
}

//***********************************************************
endsection mc_thin_mos_process_params
//***********************************************************

//***********************************************************
section bpln_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (-0.700268)
+    nsig_dela_od_nmos_10hv_bsim4   = (1.10474)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (2.78156)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (-1.70848)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (1.90709)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (1.16936)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (0.919444)
+    nsig_delr_a0_nmos_10hv_bsim4   = (2.87473)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (1.97238)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (1.5)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (1.5)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (-1.5)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (4.35076)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (-1.52005)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (2.25593)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (0.592245)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (0.924854)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (-1.230815)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (2.92549)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (-0.29957)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (-2.90392)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (-2.5)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-0.22283)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (2.46928)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (-1.11707)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (-0.645555)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (2.64482)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (1.20349)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (0.326596)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (-0.0595902)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (0.730292)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (-0.364372)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (1.34489)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (-2.54643)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (2.29466)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (0.105417)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (0.838446)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (2.01793)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (-0.110238)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (-0.269652)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (-0.75823)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (1.5)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (1.5)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (-1.5)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (2.11532)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (2.17751)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (0.554886)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (-0.53514)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (-4.77909)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (0.231939)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (-0.504965)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (-0.23182)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (-3.01904)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (1.81895)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (0.0340178)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (0.864104)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (1.164)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (-0.5799)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (-1.781)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (-2.557)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (0.1522)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (-2.571)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (2.938)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (0.4661)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (1.585144)
+    nsig_dela_od_pmos_10hv_bsim4   = (-1.75749)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (-2.01187)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (2.21534)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (-1.93843)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (-2.26426)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (2.206395)
+    nsig_dela_a0_pmos_10hv_bsim4   = (5.54516)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (1.314842)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (3)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (2.005866)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (1.96296)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (1.11197)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (-1.098066)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (-2.11854)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (1.41581)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (-1.3821)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (-5.28858)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (3)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (2.12392)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (1.13602)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (3.86039)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (-1.6491)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (-2.23624)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (-3.7995)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (-0.887552)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (2.48551)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (3.29119)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (-2.2452)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (2.0049)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (2.682515)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (-2.2975)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (-2.971372)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (1.750732)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (3.05408)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-0.3504555)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (2.57446)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (-1.376)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (-2.301)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (1.258)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (-1.12)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (-1.451)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (-1.763)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0.3214)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (4.346)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (-0.1326)

//***********************************************************
endsection bpln_thin_mos_process_params
//***********************************************************

//***********************************************************
section bnlp_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (0.733524)
+    nsig_dela_od_nmos_10hv_bsim4   = (-2.26425)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (-2.25474)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (1.32229)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (-2.45749)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (-2.45708)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (-1.95063)
+    nsig_delr_a0_nmos_10hv_bsim4   = (-2.52559)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (-2.46183)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (-1.79712)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (1.11611)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (-0.604759)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (-2.11164)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (-1.40494)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (1.112225)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (-4.57224)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (1.61405)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (3.48912)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-1.10482)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (-1.88378)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (0.717818)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (1.82955)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (-0.73615)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (-2.21373)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (-0.342032)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (1.04295)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (-1.27317)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (1.270136)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (-1.27677)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (1.43123)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (-1.91177)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (-1.29176)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (-1.54289)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (-1.87067)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (1.919614)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (-2.35408)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (-1.89794)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (-2.4258)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (-0.58551)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (1.37833)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (2.86052)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (-4.83143)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (-0.339956)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (1.98001)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.385337)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (1.55775)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (-2.87925)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (0.997128)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (-2.06836)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (-0.6037)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (0.6181)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (2.329)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (2.309)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (-0.2479)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (2.622)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (-3.207)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (-0.9379)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (-0.962366)
+    nsig_dela_od_pmos_10hv_bsim4   = (1.15185)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (2.15252)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (-3.48462)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (1.83897)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (1.02015)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (-1.105224)
+    nsig_dela_a0_pmos_10hv_bsim4   = (-4.43603)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (-1.249226)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (-2.5)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (-1.492038)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (-2.73932)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (-1.5861)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (5.84865)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (0.613436)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (-0.745171)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (1.03584)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (3.04961)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (-2.5)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (-2.6865)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (-0.63674)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (-0.233706)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (2.83631)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (0.853103)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (-2.0061)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (0.389824)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (-1.33942)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (-0.983065)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (-2)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (2.90891)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (-4.4536)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (-2.132035)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (1.731032)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (-3.466828)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (0.202342)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (-1.719068)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-0.739935)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (-2.45659)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (3.759)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (2.968)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (-1.894)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (-0.2255)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (1.248)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (0.6735)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (-0.6529)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (-2.279)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (0.4426)

//***********************************************************
endsection bnlp_thin_mos_process_params
//***********************************************************

//***********************************************************
section bcs_thin_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thin_tox_bsim3v3 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim3v3 = (0)
+    nsig_delr_mosfet_thin_tox_bsim4 = (-3)
+    nsig_dela_cd_cmos_10hv_bsim4   = (0)
+    nsig_dela_cd_cmos_ana_10hv_bsim4 = (0)
+    nsig_dela_dwox_nmos_10hv_bsim4 = (0.733524)
+    nsig_dela_od_nmos_10hv_bsim4   = (-2.26425)
+    nsig_dela_vfb_nmos_10hv_bsim4  = (-2.25474)
+    nsig_delr_ubref_nmos_10hv_bsim4 = (1.32229)
+    nsig_dela_vtl_nmos_10hv_bsim4  = (-2.45749)
+    nsig_dela_vtw_nmos_10hv_bsim4  = (-2.45708)
+    nsig_dela_vtm_nmos_10hv_bsim4  = (-1.95063)
+    nsig_delr_a0_nmos_10hv_bsim4   = (-2.52559)
+    nsig_delr_pvsat_nmos_10hv_bsim4 = (-2.46183)
+    nsig_dela_lvoff_nmos_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ll_10hv_bsim4 = (3)
+    nsig_dela_vfb_nmos_ll_10hv_bsim4 = (-1.79712)
+    nsig_delr_ubref_nmos_ll_10hv_bsim4 = (1.11611)
+    nsig_dela_vtl_nmos_ll_10hv_bsim4 = (-0.604759)
+    nsig_dela_vtw_nmos_ll_10hv_bsim4 = (-2.11164)
+    nsig_dela_vtm_nmos_ll_10hv_bsim4 = (-1.40494)
+    nsig_delr_vsat_nmos_ll_10hv_bsim4 = (1.112225)
+    nsig_dela_od_nmos_ll_10hv_bsim4 = (-4.57224)
+    nsig_dela_wwl_nmos_ll_10hv_bsim4 = (1.61405)
+    nsig_dela_a0_nmos_ll_10hv_bsim4 = (3.48912)
+    nsig_dela_jtss_nmos_ll_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ull_10hv_bsim4 = (-1.10482)
+    nsig_dela_vfb_nmos_ull_10hv_bsim4 = (-1.88378)
+    nsig_delr_ubref_nmos_ull_10hv_bsim4 = (0.717818)
+    nsig_dela_lu0_nmos_ull_10hv_bsim4 = (1.82955)
+    nsig_dela_vtl_nmos_ull_10hv_bsim4 = (-0.73615)
+    nsig_dela_vtw_nmos_ull_10hv_bsim4 = (-2.21373)
+    nsig_dela_vtm_nmos_ull_10hv_bsim4 = (-0.342032)
+    nsig_dela_wwl_nmos_ull_10hv_bsim4 = (1.04295)
+    nsig_delr_vsat_nmos_ull_10hv_bsim4 = (-1.27317)
+    nsig_delr_wvsat_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_od_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_a0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_agidl_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_wagidl_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_ull_10hv_bsim4 = (3)
+    nsig_dela_dwox_nmos_ana_10hv_bsim4 = (1.270136)
+    nsig_dela_od_nmos_ana_10hv_bsim4 = (-1.27677)
+    nsig_delr_ubref_nmos_ana_10hv_bsim4 = (1.43123)
+    nsig_dela_vfb_nmos_ana_10hv_bsim4 = (-1.91177)
+    nsig_dela_vtl_nmos_ana_10hv_bsim4 = (-1.29176)
+    nsig_dela_vtw_nmos_ana_10hv_bsim4 = (-1.54289)
+    nsig_dela_vtm_nmos_ana_10hv_bsim4 = (-1.87067)
+    nsig_delr_vsat_nmos_ana_10hv_bsim4 = (1.919614)
+    nsig_delr_pvsat_nmos_ana_10hv_bsim4 = (-2.35408)
+    nsig_dela_wwl_nmos_ana_10hv_bsim4 = (-1.89794)
+    nsig_dela_voff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_lvoff_nmos_ana_10hv_bsim4 = (3)
+    nsig_dela_pvoff_nmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos3_zvt_10hv_bsim3v3 = (-2.4258)
+    nsig_dela_vtl_nmos3_zvt_10hv_bsim3v3 = (-0.58551)
+    nsig_dela_vtm_nmos3_zvt_10hv_bsim3v3 = (1.37833)
+    nsig_dela_vtw_nmos3_zvt_10hv_bsim3v3 = (2.86052)
+    nsig_delr_ubref_nmos3_zvt_10hv_bsim3v3 = (-4.83143)
+    nsig_dela_dl_nmos3_zvt_10hv_bsim3v3 = (-0.339956)
+    nsig_dela_dwox_nmos3_zvt_10hv_bsim3v3 = (1.98001)
+    nsig_dela_wwl_nmos3_zvt_10hv_bsim3v3 = (0.385337)
+    nsig_dela_dwox_nsrampg_10hv_bsim3v3 = (3)
+    nsig_delr_ubref_nsrampg_10hv_bsim3v3 = (1.55775)
+    nsig_dela_vtw_nsrampg_10hv_bsim3v3 = (-2.87925)
+    nsig_dela_vtm_nsrampg_10hv_bsim3v3 = (0.997128)
+    nsig_dela_dwwl_nsrampg_10hv_bsim3v3 = (-2.06836)
+    nsig_dela_dwox_nsrampd_10hv_bsim3v3 = (-0.6037)
+    nsig_dela_vfb_nsrampd_10hv_bsim3v3 = (0.6181)
+    nsig_delr_ubref_nsrampd_10hv_bsim3v3 = (2.329)
+    nsig_dela_b0_nsrampd_10hv_bsim3v3 = (2.309)
+    nsig_dela_a0_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nsrampd_10hv_bsim3v3 = (-0.2479)
+    nsig_dela_vtl_nsrampd_10hv_bsim3v3 = (2.622)
+    nsig_dela_vtw_nsrampd_10hv_bsim3v3 = (-3.207)
+    nsig_dela_vtm_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwwl_nsrampd_10hv_bsim3v3 = (-0.9379)
+    nsig_delr_vsat_nsrampd_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos_10hv_bsim4 = (1.585144)
+    nsig_dela_od_pmos_10hv_bsim4   = (-1.75749)
+    nsig_dela_vfb_pmos_10hv_bsim4  = (-2.01187)
+    nsig_delr_ubref_pmos_10hv_bsim4 = (2.21534)
+    nsig_dela_vtl_pmos_10hv_bsim4  = (-1.93843)
+    nsig_dela_vtw_pmos_10hv_bsim4  = (-2.26426)
+    nsig_dela_vtm_pmos_10hv_bsim4  = (2.206395)
+    nsig_dela_a0_pmos_10hv_bsim4   = (5.54516)
+    nsig_dela_pu0_pmos_10hv_bsim4  = (1.314842)
+    nsig_dela_agidl_pmos_10hv_bsim4 = (3)
+    nsig_dela_dwox_pmos_ll_10hv_bsim4 = (2.005866)
+    nsig_dela_vfb_pmos_ll_10hv_bsim4 = (1.96296)
+    nsig_delr_ubref_pmos_ll_10hv_bsim4 = (1.11197)
+    nsig_dela_vtl_pmos_ll_10hv_bsim4 = (-1.098066)
+    nsig_dela_vtw_pmos_ll_10hv_bsim4 = (-2.11854)
+    nsig_dela_vtm_pmos_ll_10hv_bsim4 = (1.41581)
+    nsig_dela_od_pmos_ll_10hv_bsim4 = (-1.3821)
+    nsig_dela_ags_pmos_ll_10hv_bsim4 = (-5.28858)
+    nsig_dela_jtss_pmos_ll_10hv_bsim4 = (3)
+    nsig_dela_dwox_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos_ull_10hv_bsim4 = (2.12392)
+    nsig_delr_ubref_pmos_ull_10hv_bsim4 = (1.13602)
+    nsig_dela_wwl_pmos_ull_10hv_bsim4 = (3.86039)
+    nsig_dela_vtl_pmos_ull_10hv_bsim4 = (-1.6491)
+    nsig_dela_vtw_pmos_ull_10hv_bsim4 = (-2.23624)
+    nsig_dela_vtm_pmos_ull_10hv_bsim4 = (-3.7995)
+    nsig_dela_od_pmos_ull_10hv_bsim4 = (-0.887552)
+    nsig_dela_a0_pmos_ull_10hv_bsim4 = (2.48551)
+    nsig_dela_la0_pmos_ull_10hv_bsim4 = (3.29119)
+    nsig_dela_pa0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_b0_pmos_ull_10hv_bsim4 = (0)
+    nsig_dela_jtss_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_agidl_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_wagidl_pmos_ull_10hv_bsim4 = (3)
+    nsig_dela_vfb_pmos_ana_10hv_bsim4 = (-2.2452)
+    nsig_delr_ubref_pmos_ana_10hv_bsim4 = (2.0049)
+    nsig_dela_vtl_pmos_ana_10hv_bsim4 = (2.682515)
+    nsig_dela_od_pmos_ana_10hv_bsim4 = (-2.2975)
+    nsig_dela_vtw_pmos_ana_10hv_bsim4 = (-2.971372)
+    nsig_dela_dwox_pmos_ana_10hv_bsim4 = (1.750732)
+    nsig_dela_vtm_pmos_ana_10hv_bsim4 = (3.05408)
+    nsig_dela_lwl_pmos_ana_10hv_bsim4 = (-0.3504555)
+    nsig_dela_a0_pmos_ana_10hv_bsim4 = (2.57446)
+    nsig_dela_wvoff_pmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_pvoff_pmos_ana_10hv_bsim4 = (-3)
+    nsig_dela_dwox_psrampu_10hv_bsim3v3 = (-1.376)
+    nsig_dela_vfb_psrampu_10hv_bsim3v3 = (-2.301)
+    nsig_delr_ubref_psrampu_10hv_bsim3v3 = (1.258)
+    nsig_dela_dl_psrampu_10hv_bsim3v3 = (-1.12)
+    nsig_dela_vtl_psrampu_10hv_bsim3v3 = (-1.451)
+    nsig_dela_vtw_psrampu_10hv_bsim3v3 = (-1.763)
+    nsig_dela_vtm_psrampu_10hv_bsim3v3 = (0.3214)
+    nsig_dela_a0_psrampu_10hv_bsim3v3 = (4.346)
+    nsig_dela_wwl_psrampu_10hv_bsim3v3 = (-0.1326)

//***********************************************************
endsection bcs_thin_mos_process_params
//***********************************************************

//***********************************************************
section wcs_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (2.04617)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (1.57385)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (-0.309007)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (0.573726)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (-1.57757)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (2.35735)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (-1.50407)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (2.24303)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (0.970468)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (6.77519)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (-0.544194)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-1.44713)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (2.34413)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (-1.22866)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.284196)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (2.77366)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (3.39864)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (2.46465)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (-0.151007)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (-0.823273)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (-0.596193)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (0.873838)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (-0.327584)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (2.26554)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (-1.86548)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (1.41694)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (0.845969)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (0.365386)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.550358)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0.240476)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (-1.31622)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (-0.434998)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.752381)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (5.55541)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (0.142766)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (2.26554)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (-1.86548)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (1.41694)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (0.845969)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (0.365386)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.550358)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0.240476)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (-1.31622)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (-0.434998)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.752381)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (5.55541)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (0.142766)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0.11929)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (2.15151)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (-1.76356)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (0.993659)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.961763)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (0.286005)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-4.63256)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (5.33737)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (-1.19704)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0.580746)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0.11929)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (2.15151)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (-1.76356)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (0.993659)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.961763)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (0.286005)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-4.63256)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (5.33737)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (-1.19704)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0.580746)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (1.89563)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (-1.54061)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.218193)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (1.60734)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (1.38681)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0.678351)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (-1.05085)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (-1.0178)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (6.93143)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.324473)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (0.623428)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (-3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (1.86642)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (-1.4521)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (2.49262)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (0.654892)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (-0.13819)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (-0.438097)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (-0.506404)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (-1.04117)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (1.70565)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (-1.54815)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (0.824405)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (0.695301)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (0.383955)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.349959)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (-0.765825)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (-0.384888)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (0.282616)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (1.91539)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (-0.248356)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (1.77506)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (-1.78263)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (1.15768)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (0.770893)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (0.352168)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0.182073)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (-10.5899)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (0.263859)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (1.17575)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (1.82346)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (-0.829482)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (1.69858)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (-1.55233)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (0.817031)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0.709981)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0.351858)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.427424)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (-0.782574)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (0.295057)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (1.96163)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (-0.829482)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (1.69858)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (-1.55233)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0.817031)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0.709981)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0.351858)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.427424)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (-0.782574)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0.295057)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (1.96163)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (-3.789)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (2.065)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (-0.438)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (3.294)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (1.026)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (0.3818)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (0.3988)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (-1.467)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0.812)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (-1.703)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (-3.789)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (2.065*1.1)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (-0.438*3)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (3.294*1.1)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (1.026*1.3)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (0.3818*2)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (0.3988*5)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (-1.467*1.1)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0.812)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (-1.703*1.1)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = -1.3392857
+    nsig_delr_res_pmos90b_sphv_10hv = 3.64705882
+    nsig_dela_vfb_pmos90b_sphv_10hv = 2.0079
+    nsig_dela_vtw_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = -2.1075269
+    nsig_dela_mueo_pmos90b_sphv_10hv = -2.6769231
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_res_pmoshs45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = 2.0
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = -1.82
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = 2.45
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = -4.361
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_tox_nmos10_sphv_10hv = 3.0
+    nsig_delr_uch_nmos10_sphv_10hv = -1.75
+    nsig_dela_vfb_nmos10_sphv_10hv = 2.57
+    nsig_dela_vtl_nmos10_sphv_10hv = -1.88888889
+    nsig_dela_vtw_nmos10_sphv_10hv = -0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = -6.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = 3.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = 0.33
+    nsig_dela_lvaro_nmos10_sphv_10hv = 2.95
+    nsig_delr_cj_nmos10_sphv_10hv = 3.0
+    nsig_delr_is_nmos10_sphv_10hv = -3.0
+    nsig_delr_is2_nmos10_sphv_10hv = -3.0
+    nsig_delr_ir_nmos10_sphv_10hv = -3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = -2.931
+    nsig_delr_res_pmos45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = 1.998
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = -2.47
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = 2.89
+    nsig_dela_dlw_pmos45b_sphv_10hv = -3.1
+    nsig_delr_cjs_pmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = -3.608
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = 2.6781
+    nsig_dela_vtw_nmos45b_sphv_10hv = 3.0
+    nsig_dela_vtl_nmos45b_sphv_10hv = 3.0
+    nsig_dela_vtm_nmos45b_sphv_10hv = 3.0
+    nsig_delr_mobref_nmos45b_sphv_10hv = -3.0
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = 3.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_tox_pmos10_sphv_10hv = 3.0
+    nsig_delr_uch_pmos10_sphv_10hv = -1.52
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = 2.347
+    nsig_dela_vtl_pmos10_sphv_10hv = 2.727
+    nsig_dela_vtw_pmos10_sphv_10hv = -0.462
+    nsig_dela_vtlw_pmos10_sphv_10hv = -5.035
+    nsig_dela_dl_pmos10_sphv_10hv = 2.399
+    nsig_dela_dw_pmos10_sphv_10hv = -3.563
+    nsig_dela_dlw_pmos10_sphv_10hv = -1.264
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = 2.602
+    nsig_delr_cj_pmos10_sphv_10hv = 3.0
+    nsig_delr_is_pmos10_sphv_10hv = -3.0
+    nsig_delr_is2_pmos10_sphv_10hv = -3.0
+    nsig_delr_ir_pmos10_sphv_10hv = -3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = -1.7
+    nsig_delr_res_nmos90b_sphv_10hv = 3.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = 2.8333333
+    nsig_dela_vtw_nmos90b_sphv_10hv = 4.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = -3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = 3.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = -2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = -3.0
+    nsig_delr_cj_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_nmos120_sphv_10hv = 3.0
+    nsig_delr_uch_nmos120_sphv_10hv = -2.601
+    nsig_delr_res_nmos120_sphv_10hv = 2.831
+    nsig_dela_vfb_nmos120_sphv_10hv = 1.62
+    nsig_dela_vtw_nmos120_sphv_10hv = -3.36666666667
+    nsig_dela_vtl_nmos120_sphv_10hv = -3.02857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 1.86666666667
+    nsig_dela_dw_nmos120_sphv_10hv = -3.0
+    nsig_dela_thesato_nmos120_sphv_10hv = 1.104
+    nsig_dela_lvaro_nmos120_sphv_10hv = -3.0
+    nsig_dela_vdscale_nmos120_sphv_10hv = -0.966666666667
+    nsig_dela_vdscalel_nmos120_sphv_10hv = -0.4375
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -0.75
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = 1.62
+    nsig_dela_xw_nmos120_sphv_10hv = -0.714333333333
+    nsig_dela_lvarw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = 3.0
+    nsig_delr_is_nmos120_sphv_10hv = -3.0
+    nsig_delr_is2_nmos120_sphv_10hv = -3.0
+    nsig_delr_ir_nmos120_sphv_10hv = -3.0


//***********************************************************
endsection wcs_thick_mos_process_params
//***********************************************************

//***********************************************************
section wnhp_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (2.04617)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (1.57385)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (-0.309007)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (0.573726)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (-1.57757)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (2.35735)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (-1.50407)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (2.24303)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (0.970468)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (6.77519)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (-0.544194)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-1.44713)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (-3)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (2.34413)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (-1.22866)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.284196)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (2.77366)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (3.39864)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (2.46465)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (-0.151007)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (-0.823273)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (-0.596193)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (0.873838)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (-0.327584)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (2.26554)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (-1.86548)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (1.41694)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (0.845969)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (0.365386)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.550358)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0.240476)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (-1.31622)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (-0.434998)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.752381)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (5.55541)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (0.142766)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (2.26554)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (-1.86548)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (1.41694)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (0.845969)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (0.365386)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.550358)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0.240476)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (-1.31622)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (-0.434998)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.752381)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (5.55541)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (0.142766)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0.11929)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (2.15151)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (-1.76356)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (0.993659)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.961763)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (0.286005)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-4.63256)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (5.33737)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (-1.19704)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0.580746)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0.11929)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (2.15151)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (-1.76356)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (0.993659)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.961763)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (0.286005)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-4.63256)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (5.33737)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (-1.19704)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0.580746)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (-2.9425)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (2.62788)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.388663)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (0.0271097)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (-0.543703)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0.192571)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (0.114161)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (0.469701)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (-0.187277)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.151258)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (-0.24986)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (-3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (-2.22722)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (1.82706)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (-0.475588)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (0.156308)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (0.350143)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (-0.0519071)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0.372642)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (-0.969604)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (-3.62023)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (2.81982)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (1.27541)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (-0.67301)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (-0.345835)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.212573)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (0.0432077)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (2.33166)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (-3.08499)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (-1.32822)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (-2.66807)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (-3.57984)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (2.55146)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (1.04385)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (-0.604108)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (-0.258314)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0.0719237)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (3.61736)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (1.08485)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (-0.948278)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (-1.28969)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (-1.63559)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (-3.64695)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (2.85596)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (1.2732)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (-0.661531)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (-0.145088)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.378173)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (0.161415)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (-3.08568)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (-1.32993)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (-0.63559)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (-3.64695)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (2.85596)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (-0.732)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (-0.661531)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (-0.145088)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.378173)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (0.161415)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (-0.08568)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (-1.32993)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (1.773)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (-2.172)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (1.142)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (-0.4859)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (-0.3047)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (-0.4416)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (-0.03883)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (0.442)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0.4065)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (0.8379)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (1.773)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (-2.172)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (1.142)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (-0.4859)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (-0.3047)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (-0.4416)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (-0.03883*5)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (0.442)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0.4065)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (0.8379)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = 2.75
+    nsig_delr_res_pmos90b_sphv_10hv = -2.0
+    nsig_dela_vfb_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vtw_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = 3.4021505
+    nsig_dela_mueo_pmos90b_sphv_10hv = 4.5
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = 4.5
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = 2.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = 6.001
+    nsig_delr_res_pmoshs45b_sphv_10hv = -1.5
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = -2.967
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 2.16
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = 1.08222
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = -2.34
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = -1.65
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = 2.917
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos10_sphv_10hv = 3.0
+    nsig_delr_uch_nmos10_sphv_10hv = -1.75
+    nsig_dela_vfb_nmos10_sphv_10hv = 2.57
+    nsig_dela_vtl_nmos10_sphv_10hv = -1.88888889
+    nsig_dela_vtw_nmos10_sphv_10hv = -0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = -6.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = 3.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = 0.33
+    nsig_dela_lvaro_nmos10_sphv_10hv = 2.95
+    nsig_delr_cj_nmos10_sphv_10hv = 3.0
+    nsig_delr_is_nmos10_sphv_10hv = -3.0
+    nsig_delr_is2_nmos10_sphv_10hv = -3.0
+    nsig_delr_ir_nmos10_sphv_10hv = -3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = 5.863
+    nsig_delr_res_pmos45b_sphv_10hv = -1.5
+    nsig_dela_vfb_pmos45b_sphv_10hv = -2.967
+    nsig_dela_vtw_pmos45b_sphv_10hv = 2.16
+    nsig_dela_vtl_pmos45b_sphv_10hv = 1.46
+    nsig_dela_vtm_pmos45b_sphv_10hv = -2.34
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = -1.5
+    nsig_dela_dlw_pmos45b_sphv_10hv = 1.5
+    nsig_delr_cjs_pmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = 2.6781
+    nsig_dela_vtw_nmos45b_sphv_10hv = 3.0
+    nsig_dela_vtl_nmos45b_sphv_10hv = 3.0
+    nsig_dela_vtm_nmos45b_sphv_10hv = 3.0
+    nsig_delr_mobref_nmos45b_sphv_10hv = -3.0
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = 3.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_nmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = -3.0
+    nsig_delr_tox_pmos10_sphv_10hv = 3.0
+    nsig_delr_uch_pmos10_sphv_10hv = 2.09
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = -2.839
+    nsig_dela_vtl_pmos10_sphv_10hv = -1.529
+    nsig_dela_vtw_pmos10_sphv_10hv = 1.628
+    nsig_dela_vtlw_pmos10_sphv_10hv = -1.561
+    nsig_dela_dl_pmos10_sphv_10hv = -0.855
+    nsig_dela_dw_pmos10_sphv_10hv = -0.95
+    nsig_dela_dlw_pmos10_sphv_10hv = 0.475
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = 2.28
+    nsig_delr_cj_pmos10_sphv_10hv = -3.0
+    nsig_delr_is_pmos10_sphv_10hv = 3.0
+    nsig_delr_is2_pmos10_sphv_10hv = 3.0
+    nsig_delr_ir_pmos10_sphv_10hv = 3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = -1.7
+    nsig_delr_res_nmos90b_sphv_10hv = 3.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = 2.8333333
+    nsig_dela_vtw_nmos90b_sphv_10hv = 4.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = -3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = 3.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = -2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = -3.0
+    nsig_delr_cj_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_nmos120_sphv_10hv = 3.0
+    nsig_delr_uch_nmos120_sphv_10hv = -2.601
+    nsig_delr_res_nmos120_sphv_10hv = 2.831
+    nsig_dela_vfb_nmos120_sphv_10hv = 1.62
+    nsig_dela_vtw_nmos120_sphv_10hv = -3.36666666667
+    nsig_dela_vtl_nmos120_sphv_10hv = -3.02857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 1.86666666667
+    nsig_dela_dw_nmos120_sphv_10hv = -3.0
+    nsig_dela_thesato_nmos120_sphv_10hv = 1.104
+    nsig_dela_lvaro_nmos120_sphv_10hv = -3.0
+    nsig_dela_vdscale_nmos120_sphv_10hv = -0.966666666667
+    nsig_dela_vdscalel_nmos120_sphv_10hv = -0.4375
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -0.75
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = 1.62
+    nsig_dela_xw_nmos120_sphv_10hv = -0.714333333333
+    nsig_dela_lvarw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = 3.0
+    nsig_delr_is_nmos120_sphv_10hv = -3.0
+    nsig_delr_is2_nmos120_sphv_10hv = -3.0
+    nsig_delr_ir_nmos120_sphv_10hv = -3.0


//***********************************************************
endsection wnhp_thick_mos_process_params
//***********************************************************

//***********************************************************
section wphn_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (3)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (-2.67807)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (-0.705203)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (-0.496592)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (-0.0551628)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (3.23043)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (-0.885322)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (0.58967)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (-1.06952)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (-0.896877)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (-0.499083)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (0.0924198)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (-0.463788)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (2.5)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (-2.28034)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (2.82336)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (-0.0834117)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (2.00396)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (-1.15188)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (0.696259)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (-0.22299)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (0.228136)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (0.173208)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (-0.247376)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (0.148853)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (-2.3495)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (2.48042)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (-1.14949)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (-0.645769)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (-0.173338)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0.492765)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (-0.0954673)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (1.39412)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (0.0723618)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0.013093)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (-0.317604)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (0.0142159)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (-2.3495)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (2.48042)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (-1.14949)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (-0.645769)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (-0.173338)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0.492765)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (-0.0954673)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (1.39412)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (0.0723618)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0.013093)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (-0.317604)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (0.0142159)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (-2.45863)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (2.42886)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (-0.614618)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0.671419)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (-0.347811)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (-5.01903)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (-2.14918)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (3.20123)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (-0.0607679)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (-2.45863)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (2.42886)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (-0.614618)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0.671419)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (-0.347811)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (-5.01903)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (-2.14918)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (3.20123)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (-0.0607679)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (1.89563)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (-1.54061)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0.218193)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (1.60734)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (1.38681)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0.678351)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (-1.05085)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (-1.0178)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (6.93143)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0.324473)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (0.623428)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (-3)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (1.86642)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (-1.4521)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (2.49262)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (0.654892)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (-0.13819)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (-0.438097)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (-0.506404)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (-1.04117)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (1.70565)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (-1.54815)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (0.824405)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (0.695301)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (0.383955)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0.349959)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (-0.765825)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (-0.384888)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (0.282616)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (1.91539)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (-0.248356)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (1.77506)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (-1.78263)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (1.15768)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (0.770893)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (0.352168)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0.182073)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (-10.5899)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (0.263859)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (1.17575)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (1.82346)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (-0.829482)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (1.69858)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (-1.55233)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (0.817031)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0.709981)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0.351858)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0.427424)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (-0.782574)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (0.295057)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (1.96163)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (-0.829482)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (1.69858)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (-1.55233)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0.817031)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0.709981)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0.351858)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0.427424)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (-0.782574)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0.295057)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (1.96163)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (-3.789)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (2.065)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (-0.438)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (3.294)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (1.026)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (0.3818)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (0.3988)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (-1.467)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0.812)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (-1.703)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (3)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (-3.789)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (2.065*1.1)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (-0.438*3)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (3.294*1.1)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (1.026*1.3)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (0.3818*2)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (0.3988*5)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (-1.467*1.1)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0.812)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (-1.703*1.1)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos90b_sphv_10hv = -1.3392857
+    nsig_delr_res_pmos90b_sphv_10hv = 3.64705882
+    nsig_dela_vfb_pmos90b_sphv_10hv = 2.0079
+    nsig_dela_vtw_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = -2.1075269
+    nsig_dela_mueo_pmos90b_sphv_10hv = -2.6769231
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = -3.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = 3.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = 3.0
+    nsig_delr_is_pmos90b_sphv_10hv = -3.0
+    nsig_delr_is2_pmos90b_sphv_10hv = -3.0
+    nsig_delr_ir_pmos90b_sphv_10hv = -3.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_res_pmoshs45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = 2.0
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = -1.82
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = 2.45
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = -4.3615
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = -3.608
+    nsig_delr_tox_nmos10_sphv_10hv = 3.0
+    nsig_delr_uch_nmos10_sphv_10hv = 1.8
+    nsig_dela_vfb_nmos10_sphv_10hv = -2.45
+    nsig_dela_vtl_nmos10_sphv_10hv = 0.111111111
+    nsig_dela_vtw_nmos10_sphv_10hv = 0.17
+    nsig_delr_thesatl_nmos10_sphv_10hv = 1.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = -1.5
+    nsig_dela_vdscale_nmos10_sphv_10hv = -0.5
+    nsig_dela_lvaro_nmos10_sphv_10hv = -0.5
+    nsig_delr_cj_nmos10_sphv_10hv = -3.0
+    nsig_delr_is_nmos10_sphv_10hv = 3.0
+    nsig_delr_is2_nmos10_sphv_10hv = 3.0
+    nsig_delr_ir_nmos10_sphv_10hv = 3.0
+    nsig_delr_tox_pmos45b_sphv_10hv = 3.0
+    nsig_delr_uch_pmos45b_sphv_10hv = -2.931
+    nsig_delr_res_pmos45b_sphv_10hv = 3.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = 1.998
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = -2.47
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = 2.89
+    nsig_dela_dlw_pmos45b_sphv_10hv = -3.1
+    nsig_delr_cjs_pmos45b_sphv_10hv = 3.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = 3.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jdideal_pmos45b_sphv_10hv = -3.608
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = -3.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = -3.608
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 1.058824
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = -2.336
+    nsig_dela_vtw_nmos45b_sphv_10hv = -0.84403
+    nsig_dela_vtl_nmos45b_sphv_10hv = -1.08124
+    nsig_dela_vtm_nmos45b_sphv_10hv = -1.10329
+    nsig_delr_mobref_nmos45b_sphv_10hv = 0.8
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = -1.5
+    nsig_delr_cjs_nmos45b_sphv_10hv = -3.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = -3.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = 3.0
+    nsig_delr_tox_pmos10_sphv_10hv = 3.0
+    nsig_delr_uch_pmos10_sphv_10hv = -1.52
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = 2.347
+    nsig_dela_vtl_pmos10_sphv_10hv = 2.727
+    nsig_dela_vtw_pmos10_sphv_10hv = -0.462
+    nsig_dela_vtlw_pmos10_sphv_10hv = -5.035
+    nsig_dela_dl_pmos10_sphv_10hv = 2.399
+    nsig_dela_dw_pmos10_sphv_10hv = -3.563
+    nsig_dela_dlw_pmos10_sphv_10hv = -1.264
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = 2.602
+    nsig_delr_cj_pmos10_sphv_10hv = 3.0
+    nsig_delr_is_pmos10_sphv_10hv = -3.0
+    nsig_delr_is2_pmos10_sphv_10hv = -3.0
+    nsig_delr_ir_pmos10_sphv_10hv = -3.0
+    nsig_delr_tox_nmos90b_sphv_10hv = 3.0
+    nsig_delr_uch_nmos90b_sphv_10hv = 1.6
+    nsig_delr_res_nmos90b_sphv_10hv = -1.5
+    nsig_dela_vfb_nmos90b_sphv_10hv = -2.4583333
+    nsig_dela_vtw_nmos90b_sphv_10hv = -3.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = 3.0
+    nsig_dela_dw_nmos90b_sphv_10hv = -4.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = 2.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = -2.1
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = 2.6
+    nsig_delr_cj_nmos90b_sphv_10hv = -3.0
+    nsig_delr_is_nmos90b_sphv_10hv = 3.0
+    nsig_delr_is2_nmos90b_sphv_10hv = 3.0
+    nsig_delr_ir_nmos90b_sphv_10hv = 3.0
+    nsig_delr_tox_nmos120_sphv_10hv = 3.0
+    nsig_delr_uch_nmos120_sphv_10hv = 2.89
+    nsig_delr_res_nmos120_sphv_10hv = -1.52
+    nsig_dela_vfb_nmos120_sphv_10hv = -3.33333333333
+    nsig_dela_vtw_nmos120_sphv_10hv = 0.8
+    nsig_dela_vtl_nmos120_sphv_10hv = 1.74857142857
+    nsig_dela_vtlw_nmos120_sphv_10hv = 2.93333333333
+    nsig_dela_dw_nmos120_sphv_10hv = 2.30769230769
+    nsig_dela_thesato_nmos120_sphv_10hv = 0.88
+    nsig_dela_lvaro_nmos120_sphv_10hv = 1.515
+    nsig_dela_vdscale_nmos120_sphv_10hv = 0.9
+    nsig_dela_vdscalel_nmos120_sphv_10hv = 1.08125
+    nsig_dela_vdscalew_nmos120_sphv_10hv = -1.05
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = -3.0
+    nsig_dela_xw_nmos120_sphv_10hv = 1.03
+    nsig_dela_lvarw_nmos120_sphv_10hv = 3.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = -1.5
+    nsig_delr_is_nmos120_sphv_10hv = 1.5
+    nsig_delr_is2_nmos120_sphv_10hv = 1.5
+    nsig_delr_ir_nmos120_sphv_10hv = 1.5


//***********************************************************
endsection wphn_thick_mos_process_params
//***********************************************************

//***********************************************************
section typ_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (0)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (0)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (0)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (0)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (0)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (0)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (0)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (0)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (0)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (0)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (0)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (0)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (0)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (0)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (0)


parameters
+    nsig_delr_tox_pmos90b_sphv_10hv = 0.0
+    nsig_delr_uch_pmos90b_sphv_10hv = 0.0
+    nsig_delr_res_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos90b_sphv_10hv = 0.0
+    nsig_dela_mueo_pmos90b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscale_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalew_pmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_pmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_pmos90b_sphv_10hv = 0.0
+    nsig_delr_is_pmos90b_sphv_10hv = 0.0
+    nsig_delr_is2_pmos90b_sphv_10hv = 0.0
+    nsig_delr_ir_pmos90b_sphv_10hv = 0.0
+    nsig_delr_tox_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_uch_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_res_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_vtm_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmoshs45b_sphv_10hv = 0.0
+    nsig_dela_dlw_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_cjs_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_cjd_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_jsdideal_pmoshs45b_sphv_10hv = 0.0
+    nsig_delr_tox_nmos10_sphv_10hv = 0.0
+    nsig_delr_uch_nmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos10_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos10_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos10_sphv_10hv = 0.0
+    nsig_delr_thesatl_nmos10_sphv_10hv = 0.0
+    nsig_delr_thesatlw_nmos10_sphv_10hv = 0.0
+    nsig_dela_vdscale_nmos10_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos10_sphv_10hv = 0.0
+    nsig_delr_cj_nmos10_sphv_10hv = 0.0
+    nsig_delr_is_nmos10_sphv_10hv = 0.0
+    nsig_delr_is2_nmos10_sphv_10hv = 0.0
+    nsig_delr_ir_nmos10_sphv_10hv = 0.0
+    nsig_delr_tox_pmos45b_sphv_10hv = 0.0
+    nsig_delr_uch_pmos45b_sphv_10hv = 0.0
+    nsig_delr_res_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos45b_sphv_10hv = 0.0
+    nsig_dela_vtm_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_pmos45b_sphv_10hv = 0.0
+    nsig_delr_cjs_pmos45b_sphv_10hv = 0.0
+    nsig_delr_cjd_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_pmos45b_sphv_10hv = 0.0
+    nsig_delr_jsdideal_pmos45b_sphv_10hv = 0.0
+    nsig_dela_dw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_dlw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos45b_sphv_10hv = 0.0
+    nsig_dela_vtm_nmos45b_sphv_10hv = 0.0
+    nsig_delr_mobref_nmos45b_sphv_10hv = 0.0
+    nsig_delr_satl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_rshl_nmos45b_sphv_10hv = 0.0
+    nsig_delr_cjs_nmos45b_sphv_10hv = 0.0
+    nsig_delr_cjd_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jsideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jdideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jsnonideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_jdnonideal_nmos45b_sphv_10hv = 0.0
+    nsig_delr_tox_pmos10_sphv_10hv = 0.0
+    nsig_delr_uch_pmos10_sphv_10hv = 0.0
+    nsig_delr_res_pmos10_sphv_10hv = 0.0
+    nsig_dela_vfb_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtl_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vtlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_dl_pmos10_sphv_10hv = 0.0
+    nsig_dela_dw_pmos10_sphv_10hv = 0.0
+    nsig_dela_dlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesato_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatl_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatw_pmos10_sphv_10hv = 0.0
+    nsig_dela_thesatlw_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscalel_pmos10_sphv_10hv = 0.0
+    nsig_dela_vdscaleo_pmos10_sphv_10hv = 0.0
+    nsig_delr_cj_pmos10_sphv_10hv = 0.0
+    nsig_delr_is_pmos10_sphv_10hv = 0.0
+    nsig_delr_is2_pmos10_sphv_10hv = 0.0
+    nsig_delr_ir_pmos10_sphv_10hv = 0.0
+    nsig_delr_tox_nmos90b_sphv_10hv = 0.0
+    nsig_delr_uch_nmos90b_sphv_10hv = 0.0
+    nsig_delr_res_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos90b_sphv_10hv = 0.0
+    nsig_dela_dw_nmos90b_sphv_10hv = 0.0
+    nsig_dela_thesato_nmos90b_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos90b_sphv_10hv = 0.0
+    nsig_dela_vdscalel_nmos90b_sphv_10hv = 0.0
+    nsig_delr_cj_nmos90b_sphv_10hv = 0.0
+    nsig_delr_is_nmos90b_sphv_10hv = 0.0
+    nsig_delr_is2_nmos90b_sphv_10hv = 0.0
+    nsig_delr_ir_nmos90b_sphv_10hv = 0.0
+    nsig_delr_tox_nmos120_sphv_10hv = 0.0
+    nsig_delr_uch_nmos120_sphv_10hv = 0.0
+    nsig_delr_res_nmos120_sphv_10hv = 0.0
+    nsig_dela_vfb_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtw_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtl_nmos120_sphv_10hv = 0.0
+    nsig_dela_vtlw_nmos120_sphv_10hv = 0.0
+    nsig_dela_dw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesato_nmos120_sphv_10hv = 0.0
+    nsig_dela_lvaro_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscale_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalel_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalew_nmos120_sphv_10hv = 0.0
+    nsig_dela_vdscalelw_nmos120_sphv_10hv = 0.0
+    nsig_dela_xw_nmos120_sphv_10hv = 0.0
+    nsig_dela_lvarw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatw_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatl_nmos120_sphv_10hv = 0.0
+    nsig_dela_thesatlw_nmos120_sphv_10hv = 0.0
+    nsig_delr_cj_nmos120_sphv_10hv = 0.0
+    nsig_delr_is_nmos120_sphv_10hv = 0.0
+    nsig_delr_is2_nmos120_sphv_10hv = 0.0
+    nsig_delr_ir_nmos120_sphv_10hv = 0.0


//***********************************************************
endsection typ_thick_mos_process_params
//***********************************************************

//***********************************************************
section mc_thick_mos_process_params
//***********************************************************

parameters
+    nsig_delr_mosfet_thick_tox     = (0)
+    nsig_dela_vfb_nmos5_10hv_bsim4 = (0)
+    nsig_dela_vtl_nmos5_10hv_bsim4 = (0)
+    nsig_dela_k3_nmos5_10hv_bsim4  = (0)
+    nsig_dela_vtm_nmos5_10hv_bsim4 = (0)
+    nsig_delr_ubref_nmos5_10hv_bsim4 = (0)
+    nsig_dela_dl_nmos5_10hv_bsim4  = (0)
+    nsig_dela_dwox_nmos5_10hv_bsim4 = (0)
+    nsig_dela_pu0_nmos5_10hv_bsim4 = (0)
+    nsig_dela_ags_nmos5_10hv_bsim4 = (0)
+    nsig_delr_vsat_nmos5_10hv_bsim4 = (0)
+    nsig_dela_b0_nmos5_10hv_bsim4  = (0)
+    nsig_delr_pvsat_nmos5_10hv_bsim4 = (0)
+    nsig_dela_jts_nmos5_10hv_bsim4 = (0)
+    nsig_dela_vfb_nmos10_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_ags_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos10_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_k3_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_pu0_nmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_la0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos45_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_pa0_nmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_la0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_vsat_nmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_pa0_nmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_tox_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_rdsw_nmos90_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos90_10hv_bsim3v3 = (0)
+    nsig_delr_tox_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_nmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_nmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_rdsw_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_nmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos5_10hv_bsim4 = (0)
+    nsig_delr_ubref_pmos5_10hv_bsim4 = (0)
+    nsig_dela_a0_pmos5_10hv_bsim4  = (0)
+    nsig_dela_vtl_pmos5_10hv_bsim4 = (0)
+    nsig_dela_dl_pmos5_10hv_bsim4  = (0)
+    nsig_dela_vsat_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vtw_pmos5_10hv_bsim4 = (0)
+    nsig_dela_dwox_pmos5_10hv_bsim4 = (0)
+    nsig_dela_wags_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vtm_pmos5_10hv_bsim4 = (0)
+    nsig_dela_wwl_pmos5_10hv_bsim4 = (0)
+    nsig_delr_agidl_pmos5_10hv_bsim4 = (0)
+    nsig_dela_vfb_pmos10_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_lw_pmos10_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos45_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmos45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos45b_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmos45b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmoshs45_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_prsh_pmoshs45b_10hv_bsim3v3 = (0)
+    nsig_delr_tox_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos90_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos90_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos90_10hv_bsim3v3 = (0)
+    nsig_delr_tox_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dwox_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vfb_pmos90b_10hv_bsim3v3 = (0)
+    nsig_delr_ubref_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_dl_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtl_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtw_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_vtm_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_a0_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_b0_pmos90b_10hv_bsim3v3 = (0)
+    nsig_dela_wwl_pmos90b_10hv_bsim3v3 = (0)

statistics {
    process {
        vary nsig_delr_mosfet_thick_tox     dist=gauss std=1
        vary nsig_dela_vfb_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtl_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_k3_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vtm_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_ubref_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dl_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_dwox_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_pu0_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_ags_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_vsat_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_b0_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_delr_pvsat_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_jts_nmos5_10hv_bsim4     dist=gauss std=1
        vary nsig_dela_vfb_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_ubref_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_ags_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_vtl_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_dela_dl_nmos10_10hv_bsim3v3     dist=gauss std=1
        vary nsig_delr_vsat_nmos10_10hv_bsim3v3     dist=gauss std=1
