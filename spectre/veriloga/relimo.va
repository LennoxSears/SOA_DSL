real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
        			//$display("Parameter MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2);
				
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule


module relimo_aging_hci_nmos45b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.617e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 19300 ;
parameter real a0_b0_b0_a1_em = -6.46 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -2760 ;
parameter real a0_b0_a1_a1_em = -2.91 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -903 ;
parameter real a0_b0_a2_a1_em = -6.21 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 3210 ;
parameter real a0_b0_a3_a1_em = -2.66 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -0.671 ;
parameter real a0_b0_p1_a1_em = 0.00438 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 0.996 ;
parameter real a0_b0_p2_a1_em = -0.0113 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.66 ;
parameter real a0_b0_p3_a1_em = -0.00286 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 8000 ;
parameter real a0_b0_b0_a2_em = 0 ;
parameter real b0_a0_b0_a2_em = 8 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -1000 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 4000 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -1000 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.5 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 1.3 ;
parameter real a0_b0_p2_a2_em = 0 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 2.2 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 5180 ;
parameter real a0_b0_b0_a3_em = 0.868 ;
parameter real b0_a0_b0_a3_em = 23 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 2120 ;
parameter real a0_b0_a1_a3_em = -3 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -12000 ;
parameter real a0_b0_a2_a3_em = 14.5 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -4980 ;
parameter real a0_b0_a3_a3_em = 6.86 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0.52 ;
parameter real a0_b0_p1_a3_em = -0.00333 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 2.27 ;
parameter real a0_b0_p2_a3_em = -0.00177 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 2.4 ;
parameter real a0_b0_p3_a3_em = -0.000878 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 3 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 11100 ;
parameter real a0_b0_b0_a4_em = -45.2 ;
parameter real b0_a0_b0_a4_em = 19.2 ;
parameter real a0_a0_b0_a4_em = 0.261 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 266 ;
parameter real a0_b0_a1_a4_em = 0.0606 ;
parameter real b0_a0_a1_a4_em = 1.64 ;
parameter real a0_a0_a1_a4_em = -0.000585 ;
parameter real b0_b0_a2_a4_em = -487 ;
parameter real a0_b0_a2_a4_em = -0.656 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.0279 ;
parameter real b0_b0_a3_a4_em = 4640 ;
parameter real a0_b0_a3_a4_em = -14.8 ;
parameter real b0_a0_a3_a4_em = -1.58 ;
parameter real a0_a0_a3_a4_em = -0.192 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 25.2 ;
parameter real a0_b0_p1_a4_em = -0.158 ;
parameter real b0_a0_p1_a4_em = -0.0634 ;
parameter real a0_a0_p1_a4_em = 1.21E-03 ;
parameter real b0_b0_p2_a4_em = 1.52 ;
parameter real a0_b0_p2_a4_em = -0.00143 ;
parameter real b0_a0_p2_a4_em = 0.00124 ;
parameter real a0_a0_p2_a4_em = 8.71E-06 ;
parameter real b0_b0_p3_a4_em = 3.45 ;
parameter real a0_b0_p3_a4_em = -0.00301 ;
parameter real b0_a0_p3_a4_em = -0.058 ;
parameter real a0_a0_p3_a4_em = 2.02E-04 ;
parameter real b0_b0_p4_a4_em = 5.51 ;
parameter real a0_b0_p4_a4_em = -0.00666 ;
parameter real b0_a0_p4_a4_em = -0.0565 ;
parameter real a0_a0_p4_a4_em = 1.71E-04 ;
parameter real b0_b0_b0_p1_em = 7.64 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 4.46 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 0.416 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -4.63 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 1.29 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 3.87 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 4.5 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4.95 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 14.1 ;
parameter real a0_b0_b0_p2_em = 0.00339 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = -0.968 ;
parameter real a0_b0_a1_p2_em = -0.000562 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 5.35 ;
parameter real a0_b0_a2_p2_em = -0.00493 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = -2.32 ;
parameter real a0_b0_a3_p2_em = 0.000692 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 2.44 ;
parameter real a0_b0_p2_p2_em = -0.00178 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 3.94 ;
parameter real a0_b0_p3_p2_em = 0.000322 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 5 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 25 ;
parameter real a0_b0_b0_p3_em = 0.00403 ;
parameter real b0_a0_b0_p3_em = 0.025 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = -2.38 ;
parameter real a0_b0_a1_p3_em = 0.00211 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = -0.0466 ;
parameter real a0_b0_a2_p3_em = 0.00887 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -0.549 ;
parameter real a0_b0_a3_p3_em = 0.00339 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 1.29 ;
parameter real a0_b0_p1_p3_em = -0.00555 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 1.19 ;
parameter real a0_b0_p2_p3_em = 0.00219 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 2.47 ;
parameter real a0_b0_p3_p3_em = 0.000299 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 10.6 ;
parameter real a0_b0_p4_p3_em = -0.0106 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 44.4 ;
parameter real a0_b0_b0_p4_em = 0.193 ;
parameter real b0_a0_b0_p4_em = -0.42 ;
parameter real a0_a0_b0_p4_em = -2.25E-03 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = -6.52 ;
parameter real a0_b0_a1_p4_em = 0.0035 ;
parameter real b0_a0_a1_p4_em = 0.0294 ;
parameter real a0_a0_a1_p4_em = -3.32E-05 ;
parameter real b0_b0_a2_p4_em = -21.7 ;
parameter real a0_b0_a2_p4_em = 0.0831 ;
parameter real b0_a0_a2_p4_em = 0.228 ;
parameter real a0_a0_a2_p4_em = -0.00112 ;
parameter real b0_b0_a3_p4_em = 12 ;
parameter real a0_b0_a3_p4_em = -0.0383 ;
parameter real b0_a0_a3_p4_em = -0.846 ;
parameter real a0_a0_a3_p4_em = 0.00382 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 1.83 ;
parameter real a0_b0_p1_p4_em = -0.0461 ;
parameter real b0_a0_p1_p4_em = 0.0572 ;
parameter real a0_a0_p1_p4_em = 4.77E-04 ;
parameter real b0_b0_p2_p4_em = 0.334 ;
parameter real a0_b0_p2_p4_em = 0.00275 ;
parameter real b0_a0_p2_p4_em = 0.0217 ;
parameter real a0_a0_p2_p4_em = -5.76E-05 ;
parameter real b0_b0_p3_p4_em = 2.22 ;
parameter real a0_b0_p3_p4_em = -0.00112 ;
parameter real b0_a0_p3_p4_em = -0.0193 ;
parameter real a0_a0_p3_p4_em = 1.10E-04 ;
parameter real b0_b0_p4_p4_em = 13 ;
parameter real a0_b0_p4_p4_em = -0.0286 ;
parameter real b0_a0_p4_p4_em = -0.177 ;
parameter real a0_a0_p4_p4_em = 5.21E-04 ;
     
   


parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.325;
parameter real        relimo_a2 = 1.64;
parameter real        relimo_c1 = 495;
parameter real        relimo_alpha1 = 3.94e-11;
parameter real        relimo_m1 = 1.59;
parameter real        relimo_lamda0 = 4.71e-7;
parameter real        relimo_fstat1 = 0.00382;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 1000;
parameter real        relimo_n_hci3 = 0.362;
parameter real        relimo_alpha2 = 4.59e29;
parameter real        relimo_beta2 = 4.39;
parameter real        relimo_gama2 = 10.7;
parameter real        relimo_eps2 = 8.2;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.733;
parameter real        relimo_rth = 0.00624;
parameter real        relimo_fstat2 = 0.0198;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1.0/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
        			//$display("Parameter MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2*relimo_fstat1);
				
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", pow(vgs,-1*relimo_gama2), pow(vds,-1*relimo_eps2), exp(-1*relimo_eta2*abs(V(sub)-V(s))), exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule




module relimo_aging_bti_pld30b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_nbti_aging_open_flag  = 0;
parameter real        relimo_pbti_aging_open_flag  = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pld30b";
parameter string      relimo_probe_name            = "mpowermos";

parameter real        relimo_n_nbti                = 0.201;
parameter real        relimo_alpha_nbti            = 9.05e-4;
parameter real        relimo_m_nbti                = 14.8;
parameter real        relimo_e_nbti                = 0.844;
parameter real        relimo_fstat_nbti            = 0.0256;

parameter real        relimo_n_pbti                = 0.45;
parameter real        relimo_alpha_pbti            = 1.55e-7;
parameter real        relimo_m_pbti                = 10.1;
parameter real        relimo_e_pbti                = 1.44;
parameter real        relimo_fstat_pbti            = 0.0337;

parameter real        relimo_kb                    = 8.62e-5;


// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgsub, vgs, vds, vdsmax, vgsmax; 
real dt, last_abstime; 
real damage_nbti, delta_damage_nbti, last_delta_damage_nbti; 
real damage_pbti, delta_damage_pbti, last_delta_damage_pbti; 
   
// Start simulatoin
analog begin
	if($abstime>=relimo_aging_tstart) begin
		dt                = ($abstime - last_abstime);	
		last_abstime      = $abstime;			
	end else begin
		last_abstime   = $abstime;
	end
	if(relimo_nbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vgs = -max(-vgs, -(vgs-vds));
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			if(vgs < 0) begin 
				delta_damage_nbti = 1.0/(relimo_fstat_nbti*relimo_alpha_nbti)*pow(abs(vgs), relimo_m_nbti)*exp(-1*relimo_e_nbti/(relimo_kb*$temperature));
			end else begin
				delta_damage_nbti = 0;
			end
			//$display ("nbti %M, %e, %e, %e, %e, %e", V(g), V(s), vgs, V(d), delta_damage_nbti);
			if($abstime>=relimo_aging_tstart) begin
				damage_nbti       = damage_nbti+dt/2*(delta_damage_nbti+last_delta_damage_nbti);
				last_delta_damage_nbti = delta_damage_nbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	if(relimo_pbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgsub = V(g)-V(sub);
			if(vgsub < 0) begin 
				delta_damage_pbti = 0;
			end else begin
				delta_damage_pbti = 1.0/(relimo_fstat_pbti*relimo_alpha_pbti)*pow(abs(vgsub), relimo_m_pbti)*exp(-1*relimo_e_pbti/(relimo_kb*$temperature));
			end
			//$display ("pbti %M, %e, %e, %e, %e, %e", V(g), V(sub), vgsub, V(d), delta_damage_pbti);
			if($abstime>=relimo_aging_tstart) begin
				damage_pbti       = damage_pbti+dt/2*(delta_damage_pbti+last_delta_damage_pbti);
				last_delta_damage_pbti = delta_damage_pbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
			//$display ("DDDDD %M, %e, %e, %e, %e, %e", V(g), V(sub), vgsub, V(d), damage_pbti);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
				if ($abstime > relimo_aging_tstart) begin
					damage_nbti = (damage_nbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
					damage_pbti = (damage_pbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
				end else begin
					damage_nbti = 0;
					damage_pbti = 0;
				end
			end else begin
				damage_nbti = delta_damage_nbti*relimo_aging_time*3600;      
				damage_pbti = delta_damage_pbti*relimo_aging_time*3600;      
      			end
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s probe_name %s\n", relimo_device_name, relimo_probe_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", damage_nbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", damage_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_pbti %e\n", 0.0);
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
			if ($abstime > relimo_aging_tstart) begin
				damage_nbti = (damage_nbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
				damage_pbti = (damage_pbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
			end else begin
				damage_nbti = 0;
				damage_pbti = 0;
      			end
			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", damage_nbti);
			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", damage_pbti);
			$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_u0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_u0_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_pbti %e\n", 0.0);
		end
	end	
end
endmodule


module relimo_aging_bti_pld45b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_nbti_aging_open_flag  = 0;
parameter real        relimo_pbti_aging_open_flag  = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pld45b";
parameter string      relimo_probe_name            = "mpowermos";

parameter real        relimo_n_nbti                = 0.201;
parameter real        relimo_alpha_nbti            = 1.18e-6;
parameter real        relimo_m_nbti                = 13.3;
parameter real        relimo_e_nbti                = 0.977;
parameter real        relimo_fstat_nbti            = 0.0165;

parameter real        relimo_n_pbti                = 0.355;
parameter real        relimo_alpha_pbti            = 1.14e-5;
parameter real        relimo_m_pbti                = 11.9;
parameter real        relimo_e_pbti                = 1.39;
parameter real        relimo_fstat_pbti            = 0.0143;

parameter real        relimo_kb                    = 8.62e-5;


// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgsub, vgs, vds, vdsmax, vgsmax; 
real dt, last_abstime; 
real damage_nbti, delta_damage_nbti, last_delta_damage_nbti; 
real damage_pbti, delta_damage_pbti, last_delta_damage_pbti; 
   
// Start simulatoin
analog begin
	if($abstime>=relimo_aging_tstart) begin
		dt                = ($abstime - last_abstime);	
		last_abstime      = $abstime;			
	end else begin
		last_abstime   = $abstime;
	end
	if(relimo_nbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vgs = -max(-vgs, -(vgs-vds));
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			if(vgs < 0) begin 
				delta_damage_nbti = 1.0/(relimo_fstat_nbti*relimo_alpha_nbti)*pow(abs(vgs), relimo_m_nbti)*exp(-1*relimo_e_nbti/(relimo_kb*$temperature));
			end else begin
				delta_damage_nbti = 0;
			end
			//$display ("%M, %e, %e, %e, %e, %e", V(g), V(s), vgs, V(d), relimo_e_nbti);
			if($abstime>=relimo_aging_tstart) begin
				damage_nbti       = damage_nbti+dt/2*(delta_damage_nbti+last_delta_damage_nbti);
				last_delta_damage_nbti = delta_damage_nbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	if(relimo_pbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgsub = V(g)-V(sub);
			if(vgsub < 0) begin 
				delta_damage_pbti = 0;
			end else begin
				delta_damage_pbti = 1.0/(relimo_fstat_pbti*relimo_alpha_pbti)*pow(abs(vgsub), relimo_m_pbti)*exp(-1*relimo_e_pbti/(relimo_kb*$temperature));
			end
			//$display ("sdfse %M, %e, %e, %e, %e, %e", V(g), V(sub), vgsub, V(d), delta_damage_pbti);
			if($abstime>=relimo_aging_tstart) begin
				damage_pbti       = damage_pbti+dt/2*(delta_damage_pbti+last_delta_damage_pbti);
				last_delta_damage_pbti = delta_damage_pbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
			//$display ("DDDDD %M, %e, %e, %e, %e, %e", V(g), V(sub), vgsub, V(d), damage_pbti);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
				if ($abstime > relimo_aging_tstart) begin
					damage_nbti = (damage_nbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
					damage_pbti = (damage_pbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
				end else begin
					damage_nbti = 0;
					damage_pbti = 0;
				end
			end else begin
				damage_nbti = delta_damage_nbti*relimo_aging_time*3600;      
				damage_pbti = delta_damage_pbti*relimo_aging_time*3600;      
      			end
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s probe_name %s\n", relimo_device_name, relimo_probe_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", damage_nbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", damage_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_pbti %e\n", 0.0);
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
			if ($abstime > relimo_aging_tstart) begin
				damage_nbti = (damage_nbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
				damage_pbti = (damage_pbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
			end else begin
				damage_nbti = 0;
				damage_pbti = 0;
      			end
			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", damage_nbti);
			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", damage_pbti);
			$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_u0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_u0_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_pbti %e\n", 0.0);
		end
	end	
end
endmodule

module relimo_aging_bti(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_nbti_aging_open_flag  = 0;
parameter real        relimo_pbti_aging_open_flag  = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";

parameter real        relimo_n_nbti                = 0.201;
parameter real        relimo_alpha_nbti            = 2.43e-5;
parameter real        relimo_m_nbti                = 13.9;
parameter real        relimo_e_nbti                = 0.916;
parameter real        relimo_fstat_nbti            = 0.0159;

parameter real        relimo_n_pbti                = 0.442;
parameter real        relimo_alpha_pbti            = 1.62e-4;
parameter real        relimo_m_pbti                = 11.9;
parameter real        relimo_e_pbti                = 1.33;
parameter real        relimo_fstat_pbti            = 0.0084;

parameter real        relimo_kb                    = 8.62e-5;


// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgsub, vgs, vds, vdsmax, vgsmax; 
real dt, last_abstime; 
real damage_nbti, delta_damage_nbti, last_delta_damage_nbti; 
real damage_pbti, delta_damage_pbti, last_delta_damage_pbti; 
   
// Start simulatoin
analog begin
	if($abstime>=relimo_aging_tstart) begin
		dt                = ($abstime - last_abstime);	
		last_abstime      = $abstime;			
	end else begin
		last_abstime   = $abstime;
	end
	if(relimo_nbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vgs = -max(-vgs, -(vgs-vds));
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			if(vgs < 0) begin 
				delta_damage_nbti = 1.0/(relimo_fstat_nbti*relimo_alpha_nbti)*pow(abs(vgs), relimo_m_nbti)*exp(-1*relimo_e_nbti/(relimo_kb*$temperature));
			end else begin
				delta_damage_nbti = 0;
			end
			//$display ("%M, %e, %e, %e, %e, %e, %e, %e, %e", relimo_fstat_nbti, relimo_alpha_nbti, vgs, relimo_m_nbti, delta_damage_nbti,relimo_e_nbti,relimo_kb,$temperature);
			if($abstime>=relimo_aging_tstart) begin
				damage_nbti       = damage_nbti+dt/2*(delta_damage_nbti+last_delta_damage_nbti);
				last_delta_damage_nbti = delta_damage_nbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	if(relimo_pbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgsub = V(g)-V(sub);
			if(vgsub < 0) begin 
				delta_damage_pbti = 0;
			end else begin
				delta_damage_pbti = 1.0/(relimo_fstat_pbti*relimo_alpha_pbti)*pow(abs(vgsub), relimo_m_pbti)*exp(-1*relimo_e_pbti/(relimo_kb*$temperature));
			end
			//$display ("%M, %e, %e, %e, %e, %e, %e, %e, %e", V(g), V(sub), vgsub, relimo_m_pbti, delta_damage_pbti,relimo_e_pbti,relimo_kb,$temperature);
			if($abstime>=relimo_aging_tstart) begin
				damage_pbti       = damage_pbti+dt/2*(delta_damage_pbti+last_delta_damage_pbti);
				last_delta_damage_pbti = delta_damage_pbti;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
			//$display ("DDDDD %M, %e, %e, %e, %e, %e", V(g), (V(sub)-V(s)), vgsub, V(d), damage_pbti);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
				if ($abstime > relimo_aging_tstart) begin
					damage_nbti = (damage_nbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
					damage_pbti = (damage_pbti)*relimo_aging_time*3600/($abstime-relimo_aging_tstart);    
				end else begin
					damage_nbti = 0;
					damage_pbti = 0;
				end
			end else begin
				damage_nbti = delta_damage_nbti*relimo_aging_time*3600;      
				damage_pbti = delta_damage_pbti*relimo_aging_time*3600;      
      			end
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s probe_name %s\n", relimo_device_name, relimo_probe_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", damage_nbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", damage_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_pbti %e\n", 0.0);
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
			if ($abstime > relimo_aging_tstart) begin
				damage_nbti = (damage_nbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
				damage_pbti = (damage_pbti)*(relimo_aging_time)*(3600*24*365.24)/($abstime-relimo_aging_tstart);     
			end else begin
				damage_nbti = 0;
				damage_pbti = 0;
      			end
			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", damage_nbti);
			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", 1.0/relimo_n_nbti);
			$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", damage_pbti);
			$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", 1.0/relimo_n_pbti);
			$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_u0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_u0_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_pbti %e\n", 0.0);
		end
	end	
end
endmodule



module relimo_aging_hv_hci_nld10(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "nld10";
parameter string      relimo_probe_name            = "mpowermos";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

  
parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 9280 ;
parameter real a0_b0_b0_a1_em = -0.997 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -764 ;
parameter real a0_b0_a1_a1_em = -4.63 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 114 ;
parameter real a0_b0_a2_a1_em = 0.297 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -7.38 ;
parameter real a0_b0_a3_a1_em = 5.62 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.312 ;
parameter real a0_b0_p1_a1_em = 0.000259 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 2.13 ;
parameter real a0_b0_p2_a1_em = -0.00128 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.7 ;
parameter real a0_b0_p3_a1_em = 0.00154 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 5 ;
parameter real a0_b0_p4_a1_em = 0 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 23000 ;
parameter real a0_b0_b0_a2_em = 10 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = -0.0002 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 9000 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = -12000 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = 0 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.2 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 1.5 ;
parameter real a0_b0_p2_a2_em = -0.0002 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 2.5 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3.5 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 25000 ;
parameter real a0_b0_b0_a3_em = 4 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 20000 ;
parameter real a0_b0_a1_a3_em = 0 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -20000 ;
parameter real a0_b0_a2_a3_em = 0 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = 0 ;
parameter real a0_b0_a3_a3_em = 0 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 1 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 2 ;
parameter real a0_b0_p2_a3_em = 0 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 3 ;
parameter real a0_b0_p3_a3_em = 0 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 4 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 25200 ;
parameter real a0_b0_b0_a4_em = 1.2 ;
parameter real b0_a0_b0_a4_em = -0.518 ;
parameter real a0_a0_b0_a4_em = 0.00131 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 5640 ;
parameter real a0_b0_a1_a4_em = 3.84 ;
parameter real b0_a0_a1_a4_em = 0.55 ;
parameter real a0_a0_a1_a4_em = 0.00386 ;
parameter real b0_b0_a2_a4_em = -3610 ;
parameter real a0_b0_a2_a4_em = -0.156 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0.0005 ;
parameter real b0_b0_a3_a4_em = -6290 ;
parameter real a0_b0_a3_a4_em = -0.173 ;
parameter real b0_a0_a3_a4_em = 0.443 ;
parameter real a0_a0_a3_a4_em = 0.00313 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 1.6 ;
parameter real a0_b0_p1_a4_em = -0.000709 ;
parameter real b0_a0_p1_a4_em = -0.0000472 ;
parameter real a0_a0_p1_a4_em = 0.000000327 ;
parameter real b0_b0_p2_a4_em = 2.61 ;
parameter real a0_b0_p2_a4_em = -0.00147 ;
parameter real b0_a0_p2_a4_em = -0.000182 ;
parameter real a0_a0_p2_a4_em = 0.000000197 ;
parameter real b0_b0_p3_a4_em = 2.89 ;
parameter real a0_b0_p3_a4_em = 0.00348 ;
parameter real b0_a0_p3_a4_em = 0.00261 ;
parameter real a0_a0_p3_a4_em = -0.00000617 ;
parameter real b0_b0_p4_a4_em = 5.37 ;
parameter real a0_b0_p4_a4_em = -0.000432 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -7.4 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 2 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 0.01 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -1.1 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 1.34 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 2.1 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 3.57 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4.4 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 3.52 ;
parameter real a0_b0_b0_p2_em = 0.00158 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 1.7 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 1.44 ;
parameter real a0_b0_a1_p2_em = -0.00128 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0.521 ;
parameter real a0_b0_a2_p2_em = -0.00173 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = -0.2 ;
parameter real a0_b0_a3_p2_em = 0.0000282 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.22 ;
parameter real a0_b0_p2_p2_em = 0.000915 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 3.86 ;
parameter real a0_b0_p3_p2_em = -0.00302 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 8.78 ;
parameter real a0_b0_p4_p2_em = -0.00821 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 72.6 ;
parameter real a0_b0_b0_p3_em = -0.287 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0.3 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 1.08 ;
parameter real a0_b0_a1_p3_em = -0.00000609 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0.782 ;
parameter real a0_b0_a2_p3_em = -0.00348 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -4.05 ;
parameter real a0_b0_a3_p3_em = 0.007 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 86.8 ;
parameter real a0_b0_p1_p3_em = -0.369 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.31 ;
parameter real a0_b0_p2_p3_em = 0.0000997 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 3.52 ;
parameter real a0_b0_p3_p3_em = 0.000709 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 3.65 ;
parameter real a0_b0_p4_p3_em = 0.00278 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 6.89 ;
parameter real a0_b0_b0_p4_em = 0.000237 ;
parameter real b0_a0_b0_p4_em = -0.000637 ;
parameter real a0_a0_b0_p4_em = 0.00000132 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 0 ;
parameter real a0_b0_a1_p4_em = 0 ;
parameter real b0_a0_a1_p4_em = 0 ;
parameter real a0_a0_a1_p4_em = 0 ;
parameter real b0_b0_a2_p4_em = 0 ;
parameter real a0_b0_a2_p4_em = 0 ;
parameter real b0_a0_a2_p4_em = 0 ;
parameter real a0_a0_a2_p4_em = 0 ;
parameter real b0_b0_a3_p4_em = 0 ;
parameter real a0_b0_a3_p4_em = 0 ;
parameter real b0_a0_a3_p4_em = 0 ;
parameter real a0_a0_a3_p4_em = 0 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0 ;
parameter real a0_b0_p1_p4_em = 0 ;
parameter real b0_a0_p1_p4_em = 0 ;
parameter real a0_a0_p1_p4_em = 0 ;
parameter real b0_b0_p2_p4_em = 0 ;
parameter real a0_b0_p2_p4_em = 0 ;
parameter real b0_a0_p2_p4_em = 0 ;
parameter real a0_a0_p2_p4_em = 0 ;
parameter real b0_b0_p3_p4_em = 0 ;
parameter real a0_b0_p3_p4_em = 0 ;
parameter real b0_a0_p3_p4_em = 0 ;
parameter real a0_a0_p3_p4_em = 0 ;
parameter real b0_b0_p4_p4_em = 0 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;
  

parameter real        relimo_k_hci1 = 8.14807e-2;
parameter real        relimo_n1_1_hci1 = 0.59;
parameter real        relimo_n2_1_hci1 = 0.5;

parameter real        relimo_a1 = 0.369;
parameter real        relimo_a2 = 1.15;
parameter real        relimo_c1 = 1.02e2;
parameter real        relimo_alpha1 = 1.42e-6;
parameter real        relimo_m1 = 1.59;
parameter real        relimo_lamda0 = 9.02e-7;
parameter real        relimo_fstat1 = 0.01;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 497;
parameter real        relimo_n_hci3 = 0.49;
parameter real        relimo_alpha2 = 3.36495059253878e11;
parameter real        relimo_beta2 = 5.27e-5;
parameter real        relimo_gama2 = 10.80;
parameter real        relimo_eps2 = 5.61;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.71;
parameter real        relimo_rth = 0.00912;
parameter real        relimo_fstat2 = 0.02;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage1_1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					if (((relimo_intercept-relimo_c*vddtransistor) > 490) || (-1*relimo_e/(relimo_kb*$temperature) > 490)) begin
						delta_damage1 = 0;
					end else begin
						delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
        					//$display("Zhichen Debug 111 %e, %e, %e, %e,  %e, %e, %e, %e", relimo_intercept, relimo_c, vddtransistor, delta_damage1,relimo_a_idsat,relimo_m,relimo_e,vddtransistor);
				        	//$display("Parameter MULT in device %e, %e, %e, %e, %e, %e, %e, %e, %e, %e", relimo_intercept, relimo_c, vddtransistor, relimo_a_idsat, relimo_m, relimo_e, relimo_kb, $temperature, delta_damage1, 1.0/delta_damage1);
					end
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s))) // High V HCI.
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					if (relimo_Feb/(em*lamda) > 490) begin
						delta_damage2 = 0;
					end else begin
						delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
					end
				end
        			//$display("Paramerer MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2);
				//$display("Parameter MULT in device %e, %e, %e, %e", delta_damage2, 1.0/delta_damage2, em, id);
				if(vds > 0 && vgs > 0) begin	// High Vgs HCI.
					if ((-1*relimo_eta2*V(sub) > 490) || (relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6)) > 490)) begin
						delta_damage3 = 0;
					end else begin
						delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*V(sub))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
					end
				end
				//$display("Parameter MULT in device %e, %e, %e", relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2), pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*V(sub)), exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				//$display("Parameter MULT in device %e, %e, %e", delta_damage3, 1.0/delta_damage3, id);
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e, %e", em, relimo_ratio21_a, w, id, -1e-7*pow(($temperature-273.15),2)+7e-5*($temperature-273.15)-0.0556);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, V(sub));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, V(sub), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, V(sub), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
	
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			
			
			if (delta_damage1==0 || damage1==0) begin
				damage1_1 = 1e12;
			end else begin
				damage1_1 = 1/(pow(damage1,relimo_n2_1_hci1)*pow(1.0/delta_damage1,(relimo_n2_1_hci1-relimo_n1_1_hci1)));
			end
				

			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, V(sub), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
			//$display("Parameter %M in device %e, %e, %e, %e, %e, %e, %e, %e", relimo_k_hci1, relimo_n1_1_hci1, relimo_n2_1_hci1, damage1, pow(damage1,relimo_n1_1_hci1), pow(damage1,relimo_n2_1_hci1), 1/delta_damage1, pow(1/delta_damage1,relimo_n2_1_hci1-relimo_n1_1_hci1));
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			//$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth %e\n", relimo_ratio_vth2a0, -1e-7*pow(($temperature-273.15),2)+7e-5*($temperature-273.15)-0.0556);
			
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0*0.0031, -0.0472*0, -0.0017*0);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			
			
			
			//$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1/(pow(damage1,relimo_n2_1_hci1)*pow(1.0/delta_damage1,(relimo_n2_1_hci1-relimo_n1_1_hci1))));
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_k_hci1*pow(damage1,relimo_n1_1_hci1));
			
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			
			if (delta_damage1==0 || damage1==0) begin
				damage1_1 = 1e12;
			end else begin
				damage1_1 = 1/(pow(damage1,relimo_n2_1_hci1)*pow(1.0/delta_damage1,(relimo_n2_1_hci1-relimo_n1_1_hci1)));
			end
			
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			//$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth %e\n", relimo_ratio_vth2a0, -1e-7*pow(($temperature-273.15),2)+7e-5*($temperature-273.15)-0.0556);
			
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0*0.0031, -0.0472*0, -0.0017*0);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			//$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1/(pow(damage1,relimo_n2_1_hci1)*pow(1.0/delta_damage1,(relimo_n2_1_hci1-relimo_n1_1_hci1))));
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1_1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_k_hci1*pow(damage1,relimo_n1_1_hci1));
			
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
		end	
	end
end
endmodule



module relimo_aging_hv_hci_nld90b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "nld90b";
parameter string      relimo_probe_name            = "mpowermos";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 0;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

  
parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 12400 ;
parameter real a0_b0_b0_a1_em = -0.155 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -378 ;
parameter real a0_b0_a1_a1_em = -0.618 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 5390 ;
parameter real a0_b0_a2_a1_em = -7.39 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -1760 ;
parameter real a0_b0_a3_a1_em = 3.16 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -0.823 ;
parameter real a0_b0_p1_a1_em = 0.000291 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.97 ;
parameter real a0_b0_p2_a1_em = 0.000044 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 4.49 ;
parameter real a0_b0_p3_a1_em = -0.00267 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.5 ;
parameter real a0_b0_p4_a1_em = 0 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 8000 ;
parameter real a0_b0_b0_a2_em = 0 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 1200 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 0 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = -4000 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = 0 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.5 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 1.7 ;
parameter real a0_b0_p2_a2_em = 0 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 3.5 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 4 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 500 ;
parameter real a0_b0_b0_a3_em = 0 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 0 ;
parameter real a0_b0_a1_a3_em = 0 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 0 ;
parameter real a0_b0_a2_a3_em = 0 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = 0 ;
parameter real a0_b0_a3_a3_em = 0 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 0 ;
parameter real a0_b0_p2_a3_em = 0 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 0 ;
parameter real a0_b0_p3_a3_em = 0 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 0 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 238 ;
parameter real a0_b0_b0_a4_em = 2.17 ;
parameter real b0_a0_b0_a4_em = 30.3 ;
parameter real a0_a0_b0_a4_em = -0.0447 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 0 ;
parameter real a0_b0_a1_a4_em = 0 ;
parameter real b0_a0_a1_a4_em = 0 ;
parameter real a0_a0_a1_a4_em = 0 ;
parameter real b0_b0_a2_a4_em = 0 ;
parameter real a0_b0_a2_a4_em = 0 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0 ;
parameter real b0_b0_a3_a4_em = 0 ;
parameter real a0_b0_a3_a4_em = 0 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0 ;
parameter real a0_b0_p1_a4_em = 0 ;
parameter real b0_a0_p1_a4_em = 0 ;
parameter real a0_a0_p1_a4_em = 0 ;
parameter real b0_b0_p2_a4_em = 0 ;
parameter real a0_b0_p2_a4_em = 0 ;
parameter real b0_a0_p2_a4_em = 0 ;
parameter real a0_a0_p2_a4_em = 0 ;
parameter real b0_b0_p3_a4_em = 0 ;
parameter real a0_b0_p3_a4_em = 0 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 0 ;
parameter real a0_b0_p4_a4_em = 0 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = 2.75 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.1 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 4.5 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 6 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 0.5 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.74 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 3.5 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4.04 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 24.7 ;
parameter real a0_b0_b0_p2_em = -0.000697 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0.518 ;
parameter real a0_b0_a1_p2_em = 0.00176 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = -10.4 ;
parameter real a0_b0_a2_p2_em = 0.0123 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 1.97 ;
parameter real a0_b0_a3_p2_em = -0.00556 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 2.12 ;
parameter real a0_b0_p2_p2_em = -0.000524 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 2.5 ;
parameter real a0_b0_p3_p2_em = 0.000633 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 1.24 ;
parameter real a0_b0_p4_p2_em = 0.0027 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 33 ;
parameter real a0_b0_b0_p3_em = 0 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0 ;
parameter real a0_b0_a1_p3_em = 0 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0 ;
parameter real a0_b0_a2_p3_em = 0 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0 ;
parameter real a0_b0_a3_p3_em = 0 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0 ;
parameter real a0_b0_p1_p3_em = 0 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 0 ;
parameter real a0_b0_p2_p3_em = 0 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 0 ;
parameter real a0_b0_p3_p3_em = 0 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 0 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = -20.6 ;
parameter real a0_b0_b0_p4_em = 0.123 ;
parameter real b0_a0_b0_p4_em = 0.807 ;
parameter real a0_a0_b0_p4_em = -0.00258 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 0 ;
parameter real a0_b0_a1_p4_em = 0 ;
parameter real b0_a0_a1_p4_em = 0 ;
parameter real a0_a0_a1_p4_em = 0 ;
parameter real b0_b0_a2_p4_em = 0 ;
parameter real a0_b0_a2_p4_em = 0 ;
parameter real b0_a0_a2_p4_em = 0 ;
parameter real a0_a0_a2_p4_em = 0 ;
parameter real b0_b0_a3_p4_em = 0 ;
parameter real a0_b0_a3_p4_em = 0 ;
parameter real b0_a0_a3_p4_em = 0 ;
parameter real a0_a0_a3_p4_em = 0 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0 ;
parameter real a0_b0_p1_p4_em = 0 ;
parameter real b0_a0_p1_p4_em = 0 ;
parameter real a0_a0_p1_p4_em = 0 ;
parameter real b0_b0_p2_p4_em = 0 ;
parameter real a0_b0_p2_p4_em = 0 ;
parameter real b0_a0_p2_p4_em = 0 ;
parameter real a0_a0_p2_p4_em = 0 ;
parameter real b0_b0_p3_p4_em = 0 ;
parameter real a0_b0_p3_p4_em = 0 ;
parameter real b0_a0_p3_p4_em = 0 ;
parameter real a0_a0_p3_p4_em = 0 ;
parameter real b0_b0_p4_p4_em = 0 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;

  

parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.456;
parameter real        relimo_a2 = 0.298;
parameter real        relimo_c1 = 9.04e2;
parameter real        relimo_alpha1 = 3.31e-14;
parameter real        relimo_m1 = 1.24;
parameter real        relimo_lamda0 = 3.96e-7;
parameter real        relimo_fstat1 = 0.0029;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 328.897234744751;
parameter real        relimo_n_hci3 = 0.398964672265143;
parameter real        relimo_alpha2 = 9.95939441800961e23;
parameter real        relimo_beta2 = 8e-8;
parameter real        relimo_gama2 = 18.830740743597;
parameter real        relimo_eps2 = 8.36674142708708;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.810028787024253;
parameter real        relimo_rth = 0.00268380090939087;
parameter real        relimo_fstat2 = 0.0176092698723206;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					if (((relimo_intercept-relimo_c*vddtransistor) > 490) || (-1*relimo_e/(relimo_kb*$temperature) > 490)) begin
						delta_damage1 = 0;
					end else begin
						delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
        					//$display("Zhichen Debug 111 %e, %e, %e, %e,  %e, %e, %e, %e", relimo_intercept, relimo_c, relimo_a_idsat, relimo_m, relimo_e, delta_damage1,relimo_c,relimo_c);
				        	//$display("Parameter MULT in device %e, %e, %e, %e, %e, %e, %e, %e, %e, %e", relimo_intercept, relimo_c, vddtransistor, relimo_a_idsat, relimo_m, relimo_e, relimo_kb, $temperature, delta_damage1, 1.0/delta_damage1);
					end
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					   if (relimo_Feb/(em*lamda) > 490) begin
					   	delta_damage2 = 0;
					   end else begin
						delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
					   end
				end
        			//$display("Paramerer MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2);
				//$display("Parameter MULT in device %e, %e, %e, %e", em, id, delta_damage2, 1.0/delta_damage2);
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					if ((-1*relimo_eta2*abs(V(sub)-V(s)) > 490) || (relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6)) > 490)) begin
						delta_damage3 = 0;
					end else begin
						delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
					end
				end
				//$display("Parameter MULT in device %e, %e, %e", delta_damage3, 1.0/delta_damage3, id);
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e, %e, %e", em, 1.0/delta_damage1, 1.0/delta_damage2, 1.0/delta_damage3, w, id);
		//$display("Paramerer %M in device %e, %e, %e, %e, %e, %e, %e, %e, %", $temperature, id,relimo_fstat1,relimo_alpha1, relimo_m1,em,relimo_Feb,lamda, delta_damage2, 1.0/delta_damage2);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule


module relimo_aging_hv_hci_nmos90b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "nmos90b";
parameter string      relimo_probe_name            = "mamost";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 0;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;

// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

  
parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 20900 ;
parameter real a0_b0_b0_a1_em = -1.51 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = -2500 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = 3920 ;
parameter real a0_b0_a1_a1_em = -4.01 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -3420 ;
parameter real a0_b0_a2_a1_em = -23.1 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -38100 ;
parameter real a0_b0_a3_a1_em = 186 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.966 ;
parameter real a0_b0_p1_a1_em = 0.000674 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.59 ;
parameter real a0_b0_p2_a1_em = 0.00166 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.18 ;
parameter real a0_b0_p3_a1_em = 0.00033 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 3.5 ;
parameter real a0_b0_p4_a1_em = 0 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 5900 ;
parameter real a0_b0_b0_a2_em = 0.8 ;
parameter real b0_a0_b0_a2_em = 3.55 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0.5 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -2000 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 15300 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -10000 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.7 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 1.9 ;
parameter real a0_b0_p2_a2_em = 0.0005 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 2.7 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3.9 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 3000 ;
parameter real a0_b0_b0_a3_em = 0.5 ;
parameter real b0_a0_b0_a3_em = 10 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 3000 ;
parameter real a0_b0_a1_a3_em = -0.002 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -4500 ;
parameter real a0_b0_a2_a3_em = -0.000003 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = 0 ;
parameter real a0_b0_a3_a3_em = 0 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0.9 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 2.5 ;
parameter real a0_b0_p2_a3_em = -0.0003 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 4 ;
parameter real a0_b0_p3_a3_em = -0.000004 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 4.5 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 889 ;
parameter real a0_b0_b0_a4_em = -1.05 ;
parameter real b0_a0_b0_a4_em = 17.5 ;
parameter real a0_a0_b0_a4_em = 0.0102 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 0 ;
parameter real a0_b0_a1_a4_em = 0 ;
parameter real b0_a0_a1_a4_em = 0 ;
parameter real a0_a0_a1_a4_em = 0 ;
parameter real b0_b0_a2_a4_em = 0 ;
parameter real a0_b0_a2_a4_em = 0 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0 ;
parameter real b0_b0_a3_a4_em = 0 ;
parameter real a0_b0_a3_a4_em = 0 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0 ;
parameter real a0_b0_p1_a4_em = 0 ;
parameter real b0_a0_p1_a4_em = 0 ;
parameter real a0_a0_p1_a4_em = 0 ;
parameter real b0_b0_p2_a4_em = 0 ;
parameter real a0_b0_p2_a4_em = 0 ;
parameter real b0_a0_p2_a4_em = 0 ;
parameter real a0_a0_p2_a4_em = 0 ;
parameter real b0_b0_p3_a4_em = 0 ;
parameter real a0_b0_p3_a4_em = 0 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 0 ;
parameter real a0_b0_p4_a4_em = 0 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -8 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = -0.1 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 9 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 0.1 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -0.9 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.4 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 3.08 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4.3 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 8.42 ;
parameter real a0_b0_b0_p2_em = 0.000999 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 1.66 ;
parameter real a0_b0_a0_p2_em = -0.0005 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = -4.56 ;
parameter real a0_b0_a1_p2_em = 0.0118 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 13.7 ;
parameter real a0_b0_a2_p2_em = -0.0153 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = -10.2 ;
parameter real a0_b0_a3_p2_em = -0.00276 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0.7 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.36 ;
parameter real a0_b0_p2_p2_em = 0.00115 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 2.26 ;
parameter real a0_b0_p3_p2_em = 0.000641 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 3.1 ;
parameter real a0_b0_p4_p2_em = 0.000275 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 17.6 ;
parameter real a0_b0_b0_p3_em = 0.00292 ;
parameter real b0_a0_b0_p3_em = 0.1 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = -9.45 ;
parameter real a0_b0_a1_p3_em = -0.0435 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 17 ;
parameter real a0_b0_a2_p3_em = -0.0256 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0.457 ;
parameter real a0_b0_a3_p3_em = -0.0183 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0.35 ;
parameter real a0_b0_p1_p3_em = 0.00179 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 1.24 ;
parameter real a0_b0_p2_p3_em = 0.000298 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 2.21 ;
parameter real a0_b0_p3_p3_em = 0.00128 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 4 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 43.4 ;
parameter real a0_b0_b0_p4_em = -0.0144 ;
parameter real b0_a0_b0_p4_em = 0.313 ;
parameter real a0_a0_b0_p4_em = -0.000301 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = -18 ;
parameter real a0_b0_a1_p4_em = 0.0146 ;
parameter real b0_a0_a1_p4_em = -0.0649 ;
parameter real a0_a0_a1_p4_em = 0.0000371 ;
parameter real b0_b0_a2_p4_em = -18.1 ;
parameter real a0_b0_a2_p4_em = 0.137 ;
parameter real b0_a0_a2_p4_em = 0.945 ;
parameter real a0_a0_a2_p4_em = -0.00142 ;
parameter real b0_b0_a3_p4_em = 0.0315 ;
parameter real a0_b0_a3_p4_em = -0.183 ;
parameter real b0_a0_a3_p4_em = 1.55 ;
parameter real a0_a0_a3_p4_em = 0.00225 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 1.42 ;
parameter real a0_b0_p1_p4_em = -0.00115 ;
parameter real b0_a0_p1_p4_em = -0.00603 ;
parameter real a0_a0_p1_p4_em = 0.0000146 ;
parameter real b0_b0_p2_p4_em = 2.09 ;
parameter real a0_b0_p2_p4_em = 0.000857 ;
parameter real b0_a0_p2_p4_em = 0.00871 ;
parameter real a0_a0_p2_p4_em = -0.0000117 ;
parameter real b0_b0_p3_p4_em = 3.31 ;
parameter real a0_b0_p3_p4_em = 0.00286 ;
parameter real b0_a0_p3_p4_em = 0.0118 ;
parameter real a0_a0_p3_p4_em = -0.0001 ;
parameter real b0_b0_p4_p4_em = 4 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;
  

parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.078;
parameter real        relimo_a2 = 0.48;
parameter real        relimo_c1 = 9.64e2;
parameter real        relimo_alpha1 = 1.96e-12;
parameter real        relimo_m1 = 1.1;
parameter real        relimo_lamda0 = 3.09e-7;
parameter real        relimo_fstat1 = 0.00392;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 283.763535360547;
parameter real        relimo_n_hci3 = 0.46671749214653;
parameter real        relimo_alpha2 = 1.10163299713746e17;
parameter real        relimo_beta2 = 0.0000437895530284509;
parameter real        relimo_gama2 = 11.9861294324972;
parameter real        relimo_eps2 = 4.86661881343166;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.61992188566913;
parameter real        relimo_rth = 0.00249866524239777;
parameter real        relimo_fstat2 = 0.0160772520570436;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					if (((relimo_intercept-relimo_c*vddtransistor) > 490) || (-1*relimo_e/(relimo_kb*$temperature) > 490)) begin
						delta_damage1 = 0;
					end else begin
						delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
        					//$display("Parameter MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", exp(relimo_intercept-relimo_c*vddtransistor), relimo_a_idsat*relimo_m, exp(-1*relimo_e/(relimo_kb*$temperature)), delta_damage1,relimo_c,relimo_intercept-relimo_c*vddtransistor,relimo_intercept,vddtransistor);
				        	//$display("Parameter MULT in device %e, %e, %e, %e, %e, %e, %e, %e, %e, %e", relimo_intercept, relimo_c, vddtransistor, relimo_a_idsat, relimo_m, relimo_e, relimo_kb, $temperature, delta_damage1, 1.0/delta_damage1);
					end
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					   if (relimo_Feb/(em*lamda) > 490) begin
					   	delta_damage2 = 0;
					   end else begin
						delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
					   end
				end
        			//$display("Paramerer MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2);
				//$display("Parameter MULT in device %e, %e, %e, %e", em, id, delta_damage2, 1.0/delta_damage2);
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					if ((-1*relimo_eta2*abs(V(sub)-V(s)) > 490) || (relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6)) > 490)) begin
						delta_damage3 = 0;
					end else begin
						delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
					end
				end
				//$display("Parameter MULT in device %e, %e, %e", delta_damage3, 1.0/delta_damage3, id);
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e, %e, %e, %e", em, delta_damage2, 1.0/delta_damage2, 1.0/delta_damage1, 1.0/delta_damage3, w, id);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_pld45b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pld45b";
parameter string      relimo_probe_name            = "mpowermos";
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_n                     = 1.0;
parameter real        relimo_a_idlin               = 0.0;
parameter real        relimo_a_gm                  = 0.0;
parameter real        relimo_a_vth                 = 0.0;
parameter integer     relimo_function              = 1;


parameter real        relimo_vth                   = -1;			

// parameter for HighVgs HCI
parameter real        relimo_a_hci3 = 1000;
parameter real        relimo_n_hci3 = 0.241;
parameter real        relimo_fstat3 = 0.0142;
parameter real        relimo_alpha3 = 5.12E+11;
parameter real        relimo_beta3 = 2.90E-08;
parameter real        relimo_gama3 = 15.7;
parameter real        relimo_eps3 = 4.56;
parameter real        relimo_eta3 = 0;
parameter real        relimo_ea3 = 1.31;
parameter real        relimo_rth = 0.0279;

// parameter for off stat
parameter real        relimo_a1_off = 14.5;
parameter real        relimo_a2_off = 0.288;
parameter real        relimo_n1_off = 0.301;
parameter real        relimo_n2_off = 1.46;
parameter real        relimo_alpha1_off = 7330;
parameter real        relimo_beta1 = 0.112;
parameter real        relimo_ea1 = 0.368;
parameter real        relimo_alpha2_off = 0.0011;
parameter real        relimo_beta2 = 0.139;
parameter real        relimo_ea2 = 0.48;
parameter real        fstat_tau1_off = 0.0129;
parameter real        fstat_tau2_off = 0.0189;
parameter real        fstat_tau1tau2_off = 18.2;
parameter real        fstat_tau2tau1_off = 18.2;
parameter real        m_sigma_b_off = 1;
parameter real        delta_m_sigma_b_off = 0.5;
parameter real        m_sigma_a_off = 1;
parameter real        delta_m_sigma_a_off = 0.5;

// parameter for HCIHV
parameter real        relimo_Ep = 0.063;
parameter real        relimo_lamda_h0 = 2.66E-06;
parameter real        relimo_alpha1 = 0.342;
parameter real        relimo_m1 = 0.49;
parameter real        relimo_Feb_h = 4.8;
parameter real        relimo_lamda_el0 = 3.16E-07;
parameter real        relimo_alpha2 = 7.38E-40;
parameter real        relimo_m2 = 0.851;
parameter real        relimo_Feb_el = 3.2;
parameter real        relimo_a1 = 1.0483;
parameter real        relimo_a2 = 34.922;
parameter real        relimo_c1 = 1.48E+05;
parameter real        relimo_b = 7.44E-05;
parameter real        relimo_n_hci = 3;
parameter real        m_sigma_b = 1;
parameter real        delta_m_sigma_b = 0.4;
parameter real        m_sigma_a = 1;
parameter real        delta_m_sigma_a = 6;
parameter real        fstat_tau1 = 0.0387;
parameter real        fstat_tau2 = 0.00333;
parameter real        fstat_tau1tau2 = 96.8;
parameter real        fstat_tau2tau1 = 96.8;
parameter real        vgs_cutoff_HCI = -0.9;
parameter real        m_cutoff_HCI = 1;
parameter real        delta_cutoff_HCI = 0.01;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 13700 ;
parameter real a0_b0_b0_a1_em = -2.61 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = 466 ;
parameter real a0_b0_a1_a1_em = -0.885 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -2500 ;
parameter real a0_b0_a2_a1_em = -3.64 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 2120 ;
parameter real a0_b0_a3_a1_em = -1.8 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 2.15 ;
parameter real a0_b0_p1_a1_em = -0.00452 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.84 ;
parameter real a0_b0_p2_a1_em = 0.000795 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.65 ;
parameter real a0_b0_p3_a1_em = -0.000646 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 7250 ;
parameter real a0_b0_b0_a2_em = -0.926 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -344 ;
parameter real a0_b0_a1_a2_em = 3.25 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 1520 ;
parameter real a0_b0_a2_a2_em = -9.25 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -2780 ;
parameter real a0_b0_a3_a2_em = 3.52 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -0.214 ;
parameter real a0_b0_p1_a2_em = 0.00118 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 1.51 ;
parameter real a0_b0_p2_a2_em = 0.000344 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 2.37 ;
parameter real a0_b0_p3_a2_em = -0.000328 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 4 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 4340 ;
parameter real a0_b0_b0_a3_em = -0.16 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 623 ;
parameter real a0_b0_a1_a3_em = -1.83 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -7100 ;
parameter real a0_b0_a2_a3_em = 16.7 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -1760 ;
parameter real a0_b0_a3_a3_em = 1.81 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = -1.82 ;
parameter real a0_b0_p1_a3_em = 0.00979 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.69 ;
parameter real a0_b0_p2_a3_em = 0.00141 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.91 ;
parameter real a0_b0_p3_a3_em = 0.00058 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 3 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 2990 ;
parameter real a0_b0_b0_a4_em = 0.323 ;
parameter real b0_a0_b0_a4_em = -0.204 ;
parameter real a0_a0_b0_a4_em = 0.000505 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = -470 ;
parameter real a0_b0_a1_a4_em = 1.79 ;
parameter real b0_a0_a1_a4_em = 0.0293 ;
parameter real a0_a0_a1_a4_em = 0.00881 ;
parameter real b0_b0_a2_a4_em = -413 ;
parameter real a0_b0_a2_a4_em = 0.531 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.00135 ;
parameter real b0_b0_a3_a4_em = 442 ;
parameter real a0_b0_a3_a4_em = -1.14 ;
parameter real b0_a0_a3_a4_em = -0.423 ;
parameter real a0_a0_a3_a4_em = -0.00545 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0.0428 ;
parameter real a0_b0_p1_a4_em = 0.00318 ;
parameter real b0_a0_p1_a4_em = -0.0223 ;
parameter real a0_a0_p1_a4_em = 6.39E-05 ;
parameter real b0_b0_p2_a4_em = 1.43 ;
parameter real a0_b0_p2_a4_em = -0.000456 ;
parameter real b0_a0_p2_a4_em = -0.00644 ;
parameter real a0_a0_p2_a4_em = 3.43E-05 ;
parameter real b0_b0_p3_a4_em = 2 ;
parameter real a0_b0_p3_a4_em = 0.00508 ;
parameter real b0_a0_p3_a4_em = -0.00732 ;
parameter real a0_a0_p3_a4_em = 1.42E-05 ;
parameter real b0_b0_p4_a4_em = 3.61 ;
parameter real a0_b0_p4_a4_em = 0.00576 ;
parameter real b0_a0_p4_a4_em = -0.0734 ;
parameter real a0_a0_p4_a4_em = 0.000243 ;
parameter real b0_b0_b0_p1_em = 4.05 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.827 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -0.877 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -4.88 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 0.116 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.7 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.5 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 3.46 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 14.2 ;
parameter real a0_b0_b0_p2_em = 0.0037 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0.327 ;
parameter real a0_b0_a1_p2_em = -0.0014 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = -1.5 ;
parameter real a0_b0_a2_p2_em = 0.00513 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = -0.11 ;
parameter real a0_b0_a3_p2_em = -0.0172 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.09 ;
parameter real a0_b0_p2_p2_em = 0.0031 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 3.77 ;
parameter real a0_b0_p3_p2_em = -0.000521 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 4.78 ;
parameter real a0_b0_p4_p2_em = -0.00196 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 21.7 ;
parameter real a0_b0_b0_p3_em = 0.00308 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 1.82 ;
parameter real a0_b0_a1_p3_em = -0.000988 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 1.31 ;
parameter real a0_b0_a2_p3_em = -0.00202 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0.0916 ;
parameter real a0_b0_a3_p3_em = 0.00239 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 4.52 ;
parameter real a0_b0_p1_p3_em = -0.00217 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.32 ;
parameter real a0_b0_p2_p3_em = -0.00512 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 0.938 ;
parameter real a0_b0_p3_p3_em = 0.00601 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 4.02 ;
parameter real a0_b0_p4_p3_em = 0.0872 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 33.5 ;
parameter real a0_b0_b0_p4_em = 0.00418 ;
parameter real b0_a0_b0_p4_em = 0.0126 ;
parameter real a0_a0_b0_p4_em = -3.91E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 12.4 ;
parameter real a0_b0_a1_p4_em = 0.0683 ;
parameter real b0_a0_a1_p4_em = -0.0213 ;
parameter real a0_a0_a1_p4_em = 0.000322 ;
parameter real b0_b0_a2_p4_em = -14.9 ;
parameter real a0_b0_a2_p4_em = 0.0255 ;
parameter real b0_a0_a2_p4_em = -0.344 ;
parameter real a0_a0_a2_p4_em = 0.000792 ;
parameter real b0_b0_a3_p4_em = -15.9 ;
parameter real a0_b0_a3_p4_em = -0.0024 ;
parameter real b0_a0_a3_p4_em = 0.158 ;
parameter real a0_a0_a3_p4_em = -0.000578 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 1.89 ;
parameter real a0_b0_p1_p4_em = 0.00101 ;
parameter real b0_a0_p1_p4_em = 0.000923 ;
parameter real a0_a0_p1_p4_em = -1.13E-06 ;
parameter real b0_b0_p2_p4_em = 2.7 ;
parameter real a0_b0_p2_p4_em = -0.000443 ;
parameter real b0_a0_p2_p4_em = 0.00365 ;
parameter real a0_a0_p2_p4_em = -9.26E-06 ;
parameter real b0_b0_p3_p4_em = 3.19 ;
parameter real a0_b0_p3_p4_em = 0.00164 ;
parameter real b0_a0_p3_p4_em = 0.00461 ;
parameter real a0_a0_p3_p4_em = -8.57E-08 ;
parameter real b0_b0_p4_p4_em = 5.18 ;
parameter real a0_b0_p4_p4_em = -0.00168 ;
parameter real b0_a0_p4_p4_em = -0.00462 ;
parameter real a0_a0_p4_p4_em = 5.38E-06 ;

parameter real b0_b0_b0_b0_em2 = 0 ;
parameter real a0_b0_b0_b0_em2 = 0 ;
parameter real b0_a0_b0_b0_em2 = 0 ;
parameter real a0_a0_b0_b0_em2 = 0 ;
parameter real b0_b0_a0_b0_em2 = 0 ;
parameter real a0_b0_a0_b0_em2 = 0 ;
parameter real b0_a0_a0_b0_em2 = 0 ;
parameter real a0_a0_a0_b0_em2 = 0 ;
parameter real b0_b0_a1_b0_em2 = 0 ;
parameter real a0_b0_a1_b0_em2 = 0 ;
parameter real b0_a0_a1_b0_em2 = 0 ;
parameter real a0_a0_a1_b0_em2 = 0 ;
parameter real b0_b0_a2_b0_em2 = 0 ;
parameter real a0_b0_a2_b0_em2 = 0 ;
parameter real b0_a0_a2_b0_em2 = 0 ;
parameter real a0_a0_a2_b0_em2 = 0 ;
parameter real b0_b0_a3_b0_em2 = 0 ;
parameter real a0_b0_a3_b0_em2 = 0 ;
parameter real b0_a0_a3_b0_em2 = 0 ;
parameter real a0_a0_a3_b0_em2 = 0 ;
parameter real b0_b0_a4_b0_em2 = 0 ;
parameter real a0_b0_a4_b0_em2 = 0 ;
parameter real b0_a0_a4_b0_em2 = 0 ;
parameter real a0_a0_a4_b0_em2 = 0 ;
parameter real b0_b0_p1_b0_em2 = 0 ;
parameter real a0_b0_p1_b0_em2 = 0 ;
parameter real b0_a0_p1_b0_em2 = 0 ;
parameter real a0_a0_p1_b0_em2 = 0 ;
parameter real b0_b0_p2_b0_em2 = 0 ;
parameter real a0_b0_p2_b0_em2 = 0 ;
parameter real b0_a0_p2_b0_em2 = 0 ;
parameter real a0_a0_p2_b0_em2 = 0 ;
parameter real b0_b0_p3_b0_em2 = 0 ;
parameter real a0_b0_p3_b0_em2 = 0 ;
parameter real b0_a0_p3_b0_em2 = 0 ;
parameter real a0_a0_p3_b0_em2 = 0 ;
parameter real b0_b0_p4_b0_em2 = 0 ;
parameter real a0_b0_p4_b0_em2 = 0 ;
parameter real b0_a0_p4_b0_em2 = 0 ;
parameter real a0_a0_p4_b0_em2 = 0 ;
parameter real b0_b0_b0_a0_em2 = 0 ;
parameter real a0_b0_b0_a0_em2 = 0 ;
parameter real b0_a0_b0_a0_em2 = 0 ;
parameter real a0_a0_b0_a0_em2 = 0 ;
parameter real b0_b0_a0_a0_em2 = 0 ;
parameter real a0_b0_a0_a0_em2 = 0 ;
parameter real b0_a0_a0_a0_em2 = 0 ;
parameter real a0_a0_a0_a0_em2 = 0 ;
parameter real b0_b0_a1_a0_em2 = 0 ;
parameter real a0_b0_a1_a0_em2 = 0 ;
parameter real b0_a0_a1_a0_em2 = 0 ;
parameter real a0_a0_a1_a0_em2 = 0 ;
parameter real b0_b0_a2_a0_em2 = 0 ;
parameter real a0_b0_a2_a0_em2 = 0 ;
parameter real b0_a0_a2_a0_em2 = 0 ;
parameter real a0_a0_a2_a0_em2 = 0 ;
parameter real b0_b0_a3_a0_em2 = 0 ;
parameter real a0_b0_a3_a0_em2 = 0 ;
parameter real b0_a0_a3_a0_em2 = 0 ;
parameter real a0_a0_a3_a0_em2 = 0 ;
parameter real b0_b0_a4_a0_em2 = 0 ;
parameter real a0_b0_a4_a0_em2 = 0 ;
parameter real b0_a0_a4_a0_em2 = 0 ;
parameter real a0_a0_a4_a0_em2 = 0 ;
parameter real b0_b0_p1_a0_em2 = 0 ;
parameter real a0_b0_p1_a0_em2 = 0 ;
parameter real b0_a0_p1_a0_em2 = 0 ;
parameter real a0_a0_p1_a0_em2 = 0 ;
parameter real b0_b0_p2_a0_em2 = 0 ;
parameter real a0_b0_p2_a0_em2 = 0 ;
parameter real b0_a0_p2_a0_em2 = 0 ;
parameter real a0_a0_p2_a0_em2 = 0 ;
parameter real b0_b0_p3_a0_em2 = 0 ;
parameter real a0_b0_p3_a0_em2 = 0 ;
parameter real b0_a0_p3_a0_em2 = 0 ;
parameter real a0_a0_p3_a0_em2 = 0 ;
parameter real b0_b0_p4_a0_em2 = 0 ;
parameter real a0_b0_p4_a0_em2 = 0 ;
parameter real b0_a0_p4_a0_em2 = 0 ;
parameter real a0_a0_p4_a0_em2 = 0 ;
parameter real b0_b0_b0_a1_em2 = 11800 ;
parameter real a0_b0_b0_a1_em2 = -2.09 ;
parameter real b0_a0_b0_a1_em2 = 0 ;
parameter real a0_a0_b0_a1_em2 = 0 ;
parameter real b0_b0_a0_a1_em2 = 0 ;
parameter real a0_b0_a0_a1_em2 = 0 ;
parameter real b0_a0_a0_a1_em2 = 0 ;
parameter real a0_a0_a0_a1_em2 = 0 ;
parameter real b0_b0_a1_a1_em2 = -502 ;
parameter real a0_b0_a1_a1_em2 = 0.398 ;
parameter real b0_a0_a1_a1_em2 = 0 ;
parameter real a0_a0_a1_a1_em2 = 0 ;
parameter real b0_b0_a2_a1_em2 = -1520 ;
parameter real a0_b0_a2_a1_em2 = -0.915 ;
parameter real b0_a0_a2_a1_em2 = 0 ;
parameter real a0_a0_a2_a1_em2 = 0 ;
parameter real b0_b0_a3_a1_em2 = -1070 ;
parameter real a0_b0_a3_a1_em2 = 2.14 ;
parameter real b0_a0_a3_a1_em2 = 0 ;
parameter real a0_a0_a3_a1_em2 = 0 ;
parameter real b0_b0_a4_a1_em2 = 0 ;
parameter real a0_b0_a4_a1_em2 = 0 ;
parameter real b0_a0_a4_a1_em2 = 0 ;
parameter real a0_a0_a4_a1_em2 = 0 ;
parameter real b0_b0_p1_a1_em2 = -2.79 ;
parameter real a0_b0_p1_a1_em2 = 0.000263 ;
parameter real b0_a0_p1_a1_em2 = 0 ;
parameter real a0_a0_p1_a1_em2 = 0 ;
parameter real b0_b0_p2_a1_em2 = 2.54 ;
parameter real a0_b0_p2_a1_em2 = -0.00164 ;
parameter real b0_a0_p2_a1_em2 = 0 ;
parameter real a0_a0_p2_a1_em2 = 0 ;
parameter real b0_b0_p3_a1_em2 = 3.27 ;
parameter real a0_b0_p3_a1_em2 = -0.000853 ;
parameter real b0_a0_p3_a1_em2 = 0 ;
parameter real a0_a0_p3_a1_em2 = 0 ;
parameter real b0_b0_p4_a1_em2 = 4.9 ;
parameter real a0_b0_p4_a1_em2 = -0.0017 ;
parameter real b0_a0_p4_a1_em2 = 0 ;
parameter real a0_a0_p4_a1_em2 = 0 ;
parameter real b0_b0_b0_a2_em2 = 5700 ;
parameter real a0_b0_b0_a2_em2 = -1.7 ;
parameter real b0_a0_b0_a2_em2 = 0 ;
parameter real a0_a0_b0_a2_em2 = 0 ;
parameter real b0_b0_a0_a2_em2 = 0 ;
parameter real a0_b0_a0_a2_em2 = 0 ;
parameter real b0_a0_a0_a2_em2 = 0 ;
parameter real a0_a0_a0_a2_em2 = 0 ;
parameter real b0_b0_a1_a2_em2 = -1230 ;
parameter real a0_b0_a1_a2_em2 = 0.923 ;
parameter real b0_a0_a1_a2_em2 = 0 ;
parameter real a0_a0_a1_a2_em2 = 0 ;
parameter real b0_b0_a2_a2_em2 = 123 ;
parameter real a0_b0_a2_a2_em2 = 0.528 ;
parameter real b0_a0_a2_a2_em2 = 0 ;
parameter real a0_a0_a2_a2_em2 = 0 ;
parameter real b0_b0_a3_a2_em2 = -1720 ;
parameter real a0_b0_a3_a2_em2 = 1.83 ;
parameter real b0_a0_a3_a2_em2 = 0 ;
parameter real a0_a0_a3_a2_em2 = 0 ;
parameter real b0_b0_a4_a2_em2 = 0 ;
parameter real a0_b0_a4_a2_em2 = 0 ;
parameter real b0_a0_a4_a2_em2 = 0 ;
parameter real a0_a0_a4_a2_em2 = 0 ;
parameter real b0_b0_p1_a2_em2 = -1.45 ;
parameter real a0_b0_p1_a2_em2 = 0.00118 ;
parameter real b0_a0_p1_a2_em2 = 0 ;
parameter real a0_a0_p1_a2_em2 = 0 ;
parameter real b0_b0_p2_a2_em2 = -0.285 ;
parameter real a0_b0_p2_a2_em2 = 0.000212 ;
parameter real b0_a0_p2_a2_em2 = 0 ;
parameter real a0_a0_p2_a2_em2 = 0 ;
parameter real b0_b0_p3_a2_em2 = 2.72 ;
parameter real a0_b0_p3_a2_em2 = -0.0023 ;
parameter real b0_a0_p3_a2_em2 = 0 ;
parameter real a0_a0_p3_a2_em2 = 0 ;
parameter real b0_b0_p4_a2_em2 = 4 ;
parameter real a0_b0_p4_a2_em2 = 0 ;
parameter real b0_a0_p4_a2_em2 = 0 ;
parameter real a0_a0_p4_a2_em2 = 0 ;
parameter real b0_b0_b0_a3_em2 = 3160 ;
parameter real a0_b0_b0_a3_em2 = 0.264 ;
parameter real b0_a0_b0_a3_em2 = 0 ;
parameter real a0_a0_b0_a3_em2 = 0 ;
parameter real b0_b0_a0_a3_em2 = 0 ;
parameter real a0_b0_a0_a3_em2 = 0 ;
parameter real b0_a0_a0_a3_em2 = 0 ;
parameter real a0_a0_a0_a3_em2 = 0 ;
parameter real b0_b0_a1_a3_em2 = 311 ;
parameter real a0_b0_a1_a3_em2 = -1.12 ;
parameter real b0_a0_a1_a3_em2 = 0 ;
parameter real a0_a0_a1_a3_em2 = 0 ;
parameter real b0_b0_a2_a3_em2 = -2270 ;
parameter real a0_b0_a2_a3_em2 = 6.19 ;
parameter real b0_a0_a2_a3_em2 = 0 ;
parameter real a0_a0_a2_a3_em2 = 0 ;
parameter real b0_b0_a3_a3_em2 = -413 ;
parameter real a0_b0_a3_a3_em2 = -0.749 ;
parameter real b0_a0_a3_a3_em2 = 0 ;
parameter real a0_a0_a3_a3_em2 = 0 ;
parameter real b0_b0_a4_a3_em2 = 0 ;
parameter real a0_b0_a4_a3_em2 = 0 ;
parameter real b0_a0_a4_a3_em2 = 0 ;
parameter real a0_a0_a4_a3_em2 = 0 ;
parameter real b0_b0_p1_a3_em2 = -3.3 ;
parameter real a0_b0_p1_a3_em2 = 0.0102 ;
parameter real b0_a0_p1_a3_em2 = 0 ;
parameter real a0_a0_p1_a3_em2 = 0 ;
parameter real b0_b0_p2_a3_em2 = -1.15 ;
parameter real a0_b0_p2_a3_em2 = 0.0132 ;
parameter real b0_a0_p2_a3_em2 = 0 ;
parameter real a0_a0_p2_a3_em2 = 0 ;
parameter real b0_b0_p3_a3_em2 = -1.27 ;
parameter real a0_b0_p3_a3_em2 = 0.0126 ;
parameter real b0_a0_p3_a3_em2 = 0 ;
parameter real a0_a0_p3_a3_em2 = 0 ;
parameter real b0_b0_p4_a3_em2 = 4.5 ;
parameter real a0_b0_p4_a3_em2 = 0 ;
parameter real b0_a0_p4_a3_em2 = 0 ;
parameter real a0_a0_p4_a3_em2 = 0 ;
parameter real b0_b0_b0_a4_em2 = 2230 ;
parameter real a0_b0_b0_a4_em2 = 0.075 ;
parameter real b0_a0_b0_a4_em2 = -0.0157 ;
parameter real a0_a0_b0_a4_em2 = 0.00113 ;
parameter real b0_b0_a0_a4_em2 = 0 ;
parameter real a0_b0_a0_a4_em2 = 0 ;
parameter real b0_a0_a0_a4_em2 = 0 ;
parameter real a0_a0_a0_a4_em2 = 0 ;
parameter real b0_b0_a1_a4_em2 = 242 ;
parameter real a0_b0_a1_a4_em2 = -0.625 ;
parameter real b0_a0_a1_a4_em2 = 1.14 ;
parameter real a0_a0_a1_a4_em2 = -0.00266 ;
parameter real b0_b0_a2_a4_em2 = 11.8 ;
parameter real a0_b0_a2_a4_em2 = -0.239 ;
parameter real b0_a0_a2_a4_em2 = 0 ;
parameter real a0_a0_a2_a4_em2 = 9.01E-05 ;
parameter real b0_b0_a3_a4_em2 = 1540 ;
parameter real a0_b0_a3_a4_em2 = 16.4 ;
parameter real b0_a0_a3_a4_em2 = -0.000875 ;
parameter real a0_a0_a3_a4_em2 = -0.19 ;
parameter real b0_b0_a4_a4_em2 = 0 ;
parameter real a0_b0_a4_a4_em2 = 0 ;
parameter real b0_a0_a4_a4_em2 = 0 ;
parameter real a0_a0_a4_a4_em2 = 0 ;
parameter real b0_b0_p1_a4_em2 = -0.58 ;
parameter real a0_b0_p1_a4_em2 = 0.000326 ;
parameter real b0_a0_p1_a4_em2 = 0.109 ;
parameter real a0_a0_p1_a4_em2 = -0.000229 ;
parameter real b0_b0_p2_a4_em2 = -2.55 ;
parameter real a0_b0_p2_a4_em2 = 0.0103 ;
parameter real b0_a0_p2_a4_em2 = 0.0581 ;
parameter real a0_a0_p2_a4_em2 = -0.00014 ;
parameter real b0_b0_p3_a4_em2 = -4.34 ;
parameter real a0_b0_p3_a4_em2 = 0.037 ;
parameter real b0_a0_p3_a4_em2 = -8.81E-05 ;
parameter real a0_a0_p3_a4_em2 = -1.12E-05 ;
parameter real b0_b0_p4_a4_em2 = -4.38 ;
parameter real a0_b0_p4_a4_em2 = 0.0463 ;
parameter real b0_a0_p4_a4_em2 = 0 ;
parameter real a0_a0_p4_a4_em2 = 0 ;
parameter real b0_b0_b0_p1_em2 = 0.07 ;
parameter real a0_b0_b0_p1_em2 = 0 ;
parameter real b0_a0_b0_p1_em2 = 0 ;
parameter real a0_a0_b0_p1_em2 = 0 ;
parameter real b0_b0_a0_p1_em2 = 0 ;
parameter real a0_b0_a0_p1_em2 = 0 ;
parameter real b0_a0_a0_p1_em2 = 0 ;
parameter real a0_a0_a0_p1_em2 = 0 ;
parameter real b0_b0_a1_p1_em2 = 0.753 ;
parameter real a0_b0_a1_p1_em2 = 0 ;
parameter real b0_a0_a1_p1_em2 = 0 ;
parameter real a0_a0_a1_p1_em2 = 0 ;
parameter real b0_b0_a2_p1_em2 = 1.20E-08 ;
parameter real a0_b0_a2_p1_em2 = 0 ;
parameter real b0_a0_a2_p1_em2 = 0 ;
parameter real a0_a0_a2_p1_em2 = 0 ;
parameter real b0_b0_a3_p1_em2 = 7.53E-12 ;
parameter real a0_b0_a3_p1_em2 = 0 ;
parameter real b0_a0_a3_p1_em2 = 0 ;
parameter real a0_a0_a3_p1_em2 = 0 ;
parameter real b0_b0_a4_p1_em2 = 0 ;
parameter real a0_b0_a4_p1_em2 = 0 ;
parameter real b0_a0_a4_p1_em2 = 0 ;
parameter real a0_a0_a4_p1_em2 = 0 ;
parameter real b0_b0_p1_p1_em2 = -0.172 ;
parameter real a0_b0_p1_p1_em2 = 0 ;
parameter real b0_a0_p1_p1_em2 = 0 ;
parameter real a0_a0_p1_p1_em2 = 0 ;
parameter real b0_b0_p2_p1_em2 = 1.9 ;
parameter real a0_b0_p2_p1_em2 = 0 ;
parameter real b0_a0_p2_p1_em2 = 0 ;
parameter real a0_a0_p2_p1_em2 = 0 ;
parameter real b0_b0_p3_p1_em2 = 2 ;
parameter real a0_b0_p3_p1_em2 = 0 ;
parameter real b0_a0_p3_p1_em2 = 0 ;
parameter real a0_a0_p3_p1_em2 = 0 ;
parameter real b0_b0_p4_p1_em2 = 3 ;
parameter real a0_b0_p4_p1_em2 = 0 ;
parameter real b0_a0_p4_p1_em2 = 0 ;
parameter real a0_a0_p4_p1_em2 = 0 ;
parameter real b0_b0_b0_p2_em2 = 14.1 ;
parameter real a0_b0_b0_p2_em2 = 0.00409 ;
parameter real b0_a0_b0_p2_em2 = 0 ;
parameter real a0_a0_b0_p2_em2 = 0 ;
parameter real b0_b0_a0_p2_em2 = 0 ;
parameter real a0_b0_a0_p2_em2 = 0 ;
parameter real b0_a0_a0_p2_em2 = 0 ;
parameter real a0_a0_a0_p2_em2 = 0 ;
parameter real b0_b0_a1_p2_em2 = 1.03 ;
parameter real a0_b0_a1_p2_em2 = -0.00161 ;
parameter real b0_a0_a1_p2_em2 = 0 ;
parameter real a0_a0_a1_p2_em2 = 0 ;
parameter real b0_b0_a2_p2_em2 = -2.27 ;
parameter real a0_b0_a2_p2_em2 = 0.00625 ;
parameter real b0_a0_a2_p2_em2 = 0 ;
parameter real a0_a0_a2_p2_em2 = 0 ;
parameter real b0_b0_a3_p2_em2 = 1.64 ;
parameter real a0_b0_a3_p2_em2 = -0.0103 ;
parameter real b0_a0_a3_p2_em2 = 0 ;
parameter real a0_a0_a3_p2_em2 = 0 ;
parameter real b0_b0_a4_p2_em2 = 0 ;
parameter real a0_b0_a4_p2_em2 = 0 ;
parameter real b0_a0_a4_p2_em2 = 0 ;
parameter real a0_a0_a4_p2_em2 = 0 ;
parameter real b0_b0_p1_p2_em2 = -1 ;
parameter real a0_b0_p1_p2_em2 = 0 ;
parameter real b0_a0_p1_p2_em2 = 0 ;
parameter real a0_a0_p1_p2_em2 = 0 ;
parameter real b0_b0_p2_p2_em2 = 2.02 ;
parameter real a0_b0_p2_p2_em2 = -0.000541 ;
parameter real b0_a0_p2_p2_em2 = 0 ;
parameter real a0_a0_p2_p2_em2 = 0 ;
parameter real b0_b0_p3_p2_em2 = 3.04 ;
parameter real a0_b0_p3_p2_em2 = -0.000317 ;
parameter real b0_a0_p3_p2_em2 = 0 ;
parameter real a0_a0_p3_p2_em2 = 0 ;
parameter real b0_b0_p4_p2_em2 = 3.96 ;
parameter real a0_b0_p4_p2_em2 = -0.000614 ;
parameter real b0_a0_p4_p2_em2 = 0 ;
parameter real a0_a0_p4_p2_em2 = 0 ;
parameter real b0_b0_b0_p3_em2 = 6.79 ;
parameter real a0_b0_b0_p3_em2 = 0.0318 ;
parameter real b0_a0_b0_p3_em2 = 0 ;
parameter real a0_a0_b0_p3_em2 = 0 ;
parameter real b0_b0_a0_p3_em2 = 0 ;
parameter real a0_b0_a0_p3_em2 = 0 ;
parameter real b0_a0_a0_p3_em2 = 0 ;
parameter real a0_a0_a0_p3_em2 = 0 ;
parameter real b0_b0_a1_p3_em2 = 2.59 ;
parameter real a0_b0_a1_p3_em2 = 0.00113 ;
parameter real b0_a0_a1_p3_em2 = 0 ;
parameter real a0_a0_a1_p3_em2 = 0 ;
parameter real b0_b0_a2_p3_em2 = -0.142 ;
parameter real a0_b0_a2_p3_em2 = 0.00058 ;
parameter real b0_a0_a2_p3_em2 = 0 ;
parameter real a0_a0_a2_p3_em2 = 0 ;
parameter real b0_b0_a3_p3_em2 = -5.83 ;
parameter real a0_b0_a3_p3_em2 = 0.00774 ;
parameter real b0_a0_a3_p3_em2 = 0 ;
parameter real a0_a0_a3_p3_em2 = 0 ;
parameter real b0_b0_a4_p3_em2 = 0 ;
parameter real a0_b0_a4_p3_em2 = 0 ;
parameter real b0_a0_a4_p3_em2 = 0 ;
parameter real a0_a0_a4_p3_em2 = 0 ;
parameter real b0_b0_p1_p3_em2 = -6.44 ;
parameter real a0_b0_p1_p3_em2 = 0.0106 ;
parameter real b0_a0_p1_p3_em2 = 0 ;
parameter real a0_a0_p1_p3_em2 = 0 ;
parameter real b0_b0_p2_p3_em2 = -0.0982 ;
parameter real a0_b0_p2_p3_em2 = -0.000827 ;
parameter real b0_a0_p2_p3_em2 = 0 ;
parameter real a0_a0_p2_p3_em2 = 0 ;
parameter real b0_b0_p3_p3_em2 = 5.54 ;
parameter real a0_b0_p3_p3_em2 = -0.00496 ;
parameter real b0_a0_p3_p3_em2 = 0 ;
parameter real a0_a0_p3_p3_em2 = 0 ;
parameter real b0_b0_p4_p3_em2 = 4.15 ;
parameter real a0_b0_p4_p3_em2 = 0.00794 ;
parameter real b0_a0_p4_p3_em2 = 0 ;
parameter real a0_a0_p4_p3_em2 = 0 ;
parameter real b0_b0_b0_p4_em2 = 37.3 ;
parameter real a0_b0_b0_p4_em2 = 0.000597 ;
parameter real b0_a0_b0_p4_em2 = 0.0329 ;
parameter real a0_a0_b0_p4_em2 = -8.93E-05 ;
parameter real b0_b0_a0_p4_em2 = 0 ;
parameter real a0_b0_a0_p4_em2 = 0 ;
parameter real b0_a0_a0_p4_em2 = 0 ;
parameter real a0_a0_a0_p4_em2 = 0 ;
parameter real b0_b0_a1_p4_em2 = -72.8 ;
parameter real a0_b0_a1_p4_em2 = 0.305 ;
parameter real b0_a0_a1_p4_em2 = -0.455 ;
parameter real a0_a0_a1_p4_em2 = -5.93E-05 ;
parameter real b0_b0_a2_p4_em2 = -2.04 ;
parameter real a0_b0_a2_p4_em2 = 0.00132 ;
parameter real b0_a0_a2_p4_em2 = -0.0189 ;
parameter real a0_a0_a2_p4_em2 = 4.39E-05 ;
parameter real b0_b0_a3_p4_em2 = 23.5 ;
parameter real a0_b0_a3_p4_em2 = -0.0792 ;
parameter real b0_a0_a3_p4_em2 = -0.157 ;
parameter real a0_a0_a3_p4_em2 = 0.000532 ;
parameter real b0_b0_a4_p4_em2 = 0 ;
parameter real a0_b0_a4_p4_em2 = 0 ;
parameter real b0_a0_a4_p4_em2 = 0 ;
parameter real a0_a0_a4_p4_em2 = 0 ;
parameter real b0_b0_p1_p4_em2 = 2.28 ;
parameter real a0_b0_p1_p4_em2 = -0.00342 ;
parameter real b0_a0_p1_p4_em2 = 0.0392 ;
parameter real a0_a0_p1_p4_em2 = -9.06E-05 ;
parameter real b0_b0_p2_p4_em2 = 2.33 ;
parameter real a0_b0_p2_p4_em2 = -0.00345 ;
parameter real b0_a0_p2_p4_em2 = 0.0389 ;
parameter real a0_a0_p2_p4_em2 = -8.94E-05 ;
parameter real b0_b0_p3_p4_em2 = 1.22 ;
parameter real a0_b0_p3_p4_em2 = 0.00555 ;
parameter real b0_a0_p3_p4_em2 = -0.014 ;
parameter real a0_a0_p3_p4_em2 = 2.67E-05 ;
parameter real b0_b0_p4_p4_em2 = 5.44 ;
parameter real a0_b0_p4_p4_em2 = -0.00233 ;
parameter real b0_a0_p4_p4_em2 = -0.00146 ;
parameter real a0_a0_p4_p4_em2 = 6.28E-06 ;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vsub, id, vdsmax, vgsmax;
real delta_damage3, last_delta_damage3, damage3;
real dt, last_abstime;  
real delta_idsat;
real delta_damage2_1_1,delta_damage2_1_2,damage2_1_1,damage2_1_2;
real delta_damage2_2_1,delta_damage2_2_2,damage2_2_1,damage2_2_2;
real delta_damage2_3_1,delta_damage2_3_2,damage2_3_1,damage2_3_2,last_delta_damage2_3_1,last_delta_damage2_3_2;
real delta_damage1_1_1,delta_damage1_1_2,damage1_1_1,damage1_1_2;
real delta_damage1_2_1,delta_damage1_2_2,damage1_2_1,damage1_2_2;
real delta_damage1_3_1,delta_damage1_3_2,damage1_3_1,damage1_3_2,last_delta_damage1_3_1,last_delta_damage1_3_2;
real lamda_h,lamda_el,ron_50p,s_50p,fa,ron_fa,s_fa,fstat1,fstat2;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;

real b0_b0_b0_em2, a0_b0_b0_em2, b0_a0_b0_em2, a0_a0_b0_em2, b0_a1_b0_em2;
real a0_a1_b0_em2, b0_a2_b0_em2, a0_a2_b0_em2, b0_a3_b0_em2, a0_a3_b0_em2;
real b0_a4_b0_em2, a0_a4_b0_em2, b0_p1_b0_em2, a0_p1_b0_em2, b0_p2_b0_em2;
real a0_p2_b0_em2, b0_p3_b0_em2, a0_p3_b0_em2, b0_p4_b0_em2, a0_p4_b0_em2;
real b0_b0_a0_em2, a0_b0_a0_em2, b0_a0_a0_em2, a0_a0_a0_em2, b0_a1_a0_em2;
real a0_a1_a0_em2, b0_a2_a0_em2, a0_a2_a0_em2, b0_a3_a0_em2, a0_a3_a0_em2;
real b0_a4_a0_em2, a0_a4_a0_em2, b0_p1_a0_em2, a0_p1_a0_em2, b0_p2_a0_em2;
real a0_p2_a0_em2, b0_p3_a0_em2, a0_p3_a0_em2, b0_p4_a0_em2, a0_p4_a0_em2;
real b0_b0_a1_em2, a0_b0_a1_em2, b0_a0_a1_em2, a0_a0_a1_em2, b0_a1_a1_em2;
real a0_a1_a1_em2, b0_a2_a1_em2, a0_a2_a1_em2, b0_a3_a1_em2, a0_a3_a1_em2;
real b0_a4_a1_em2, a0_a4_a1_em2, b0_p1_a1_em2, a0_p1_a1_em2, b0_p2_a1_em2;
real a0_p2_a1_em2, b0_p3_a1_em2, a0_p3_a1_em2, b0_p4_a1_em2, a0_p4_a1_em2;
real b0_b0_a2_em2, a0_b0_a2_em2, b0_a0_a2_em2, a0_a0_a2_em2, b0_a1_a2_em2;
real a0_a1_a2_em2, b0_a2_a2_em2, a0_a2_a2_em2, b0_a3_a2_em2, a0_a3_a2_em2;
real b0_a4_a2_em2, a0_a4_a2_em2, b0_p1_a2_em2, a0_p1_a2_em2, b0_p2_a2_em2;
real a0_p2_a2_em2, b0_p3_a2_em2, a0_p3_a2_em2, b0_p4_a2_em2, a0_p4_a2_em2;
real b0_b0_a3_em2, a0_b0_a3_em2, b0_a0_a3_em2, a0_a0_a3_em2, b0_a1_a3_em2;
real a0_a1_a3_em2, b0_a2_a3_em2, a0_a2_a3_em2, b0_a3_a3_em2, a0_a3_a3_em2;
real b0_a4_a3_em2, a0_a4_a3_em2, b0_p1_a3_em2, a0_p1_a3_em2, b0_p2_a3_em2;
real a0_p2_a3_em2, b0_p3_a3_em2, a0_p3_a3_em2, b0_p4_a3_em2, a0_p4_a3_em2;
real b0_b0_a4_em2, a0_b0_a4_em2, b0_a0_a4_em2, a0_a0_a4_em2, b0_a1_a4_em2;
real a0_a1_a4_em2, b0_a2_a4_em2, a0_a2_a4_em2, b0_a3_a4_em2, a0_a3_a4_em2;
real b0_a4_a4_em2, a0_a4_a4_em2, b0_p1_a4_em2, a0_p1_a4_em2, b0_p2_a4_em2;
real a0_p2_a4_em2, b0_p3_a4_em2, a0_p3_a4_em2, b0_p4_a4_em2, a0_p4_a4_em2;
real b0_b0_p1_em2, a0_b0_p1_em2, b0_a0_p1_em2, a0_a0_p1_em2, b0_a1_p1_em2;
real a0_a1_p1_em2, b0_a2_p1_em2, a0_a2_p1_em2, b0_a3_p1_em2, a0_a3_p1_em2;
real b0_a4_p1_em2, a0_a4_p1_em2, b0_p1_p1_em2, a0_p1_p1_em2, b0_p2_p1_em2;
real a0_p2_p1_em2, b0_p3_p1_em2, a0_p3_p1_em2, b0_p4_p1_em2, a0_p4_p1_em2;
real b0_b0_p2_em2, a0_b0_p2_em2, b0_a0_p2_em2, a0_a0_p2_em2, b0_a1_p2_em2;
real a0_a1_p2_em2, b0_a2_p2_em2, a0_a2_p2_em2, b0_a3_p2_em2, a0_a3_p2_em2;
real b0_a4_p2_em2, a0_a4_p2_em2, b0_p1_p2_em2, a0_p1_p2_em2, b0_p2_p2_em2;
real a0_p2_p2_em2, b0_p3_p2_em2, a0_p3_p2_em2, b0_p4_p2_em2, a0_p4_p2_em2;
real b0_b0_p3_em2, a0_b0_p3_em2, b0_a0_p3_em2, a0_a0_p3_em2, b0_a1_p3_em2;
real a0_a1_p3_em2, b0_a2_p3_em2, a0_a2_p3_em2, b0_a3_p3_em2, a0_a3_p3_em2;
real b0_a4_p3_em2, a0_a4_p3_em2, b0_p1_p3_em2, a0_p1_p3_em2, b0_p2_p3_em2;
real a0_p2_p3_em2, b0_p3_p3_em2, a0_p3_p3_em2, b0_p4_p3_em2, a0_p4_p3_em2;
real b0_b0_p4_em2, a0_b0_p4_em2, b0_a0_p4_em2, a0_a0_p4_em2, b0_a1_p4_em2;
real a0_a1_p4_em2, b0_a2_p4_em2, a0_a2_p4_em2, b0_a3_p4_em2, a0_a3_p4_em2;
real b0_a4_p4_em2, a0_a4_p4_em2, b0_p1_p4_em2, a0_p1_p4_em2, b0_p2_p4_em2;
real a0_p2_p4_em2, b0_p3_p4_em2, a0_p3_p4_em2, b0_p4_p4_em2, a0_p4_p4_em2;
real b0_b0_em2, a0_b0_em2, a1_b0_em2, a2_b0_em2, a3_b0_em2, a4_b0_em2, p1_b0_em2;
real p2_b0_em2, p3_b0_em2, p4_b0_em2, b0_a0_em2, a0_a0_em2, a1_a0_em2, a2_a0_em2;
real a3_a0_em2, a4_a0_em2, p1_a0_em2, p2_a0_em2, p3_a0_em2, p4_a0_em2, b0_a1_em2;
real a0_a1_em2, a1_a1_em2, a2_a1_em2, a3_a1_em2, a4_a1_em2, p1_a1_em2, p2_a1_em2;
real p3_a1_em2, p4_a1_em2, b0_a2_em2, a0_a2_em2, a1_a2_em2, a2_a2_em2, a3_a2_em2;
real a4_a2_em2, p1_a2_em2, p2_a2_em2, p3_a2_em2, p4_a2_em2, b0_a3_em2, a0_a3_em2;
real a1_a3_em2, a2_a3_em2, a3_a3_em2, a4_a3_em2, p1_a3_em2, p2_a3_em2, p3_a3_em2;
real p4_a3_em2, b0_a4_em2, a0_a4_em2, a1_a4_em2, a2_a4_em2, a3_a4_em2, a4_a4_em2;
real p1_a4_em2, p2_a4_em2, p3_a4_em2, p4_a4_em2, b0_p1_em2, a0_p1_em2, a1_p1_em2;
real a2_p1_em2, a3_p1_em2, a4_p1_em2, p1_p1_em2, p2_p1_em2, p3_p1_em2, p4_p1_em2;
real b0_p2_em2, a0_p2_em2, a1_p2_em2, a2_p2_em2, a3_p2_em2, a4_p2_em2, p1_p2_em2;
real p2_p2_em2, p3_p2_em2, p4_p2_em2, b0_p3_em2, a0_p3_em2, a1_p3_em2, a2_p3_em2;
real a3_p3_em2, a4_p3_em2, p1_p3_em2, p2_p3_em2, p3_p3_em2, p4_p3_em2, b0_p4_em2;
real a0_p4_em2, a1_p4_em2, a2_p4_em2, a3_p4_em2, a4_p4_em2, p1_p4_em2, p2_p4_em2;
real p3_p4_em2, p4_p4_em2;
real b0_em2, a0_em2, a1_em2, a2_em2, a3_em2, a4_em2, p1_em2, p2_em2, p3_em2, p4_em2, em2;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vsub = V(sub)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			
			delta_damage1_3_1 = 0;
			delta_damage1_3_2 = 0;
			delta_damage1_2_1 = 0;
			delta_damage1_2_2 = 0;
			delta_damage1_1_1 = 0;
			delta_damage1_1_2 = 0;
			delta_damage2_3_1 = 0;
			delta_damage2_3_2 = 0;
			delta_damage2_2_1 = 0;
			delta_damage2_2_2 = 0;
			delta_damage2_1_1 = 0;
			delta_damage2_1_2 = 0;
			delta_damage3 = 0;
			
			// off state HCI.
			if(vds < 0) begin	
				if(relimo_beta1*abs(vds) > 490) begin
					delta_damage1_3_1 = 0.0;
				end else begin				
					delta_damage1_3_1 = 1.0/relimo_alpha1_off*(exp(relimo_beta1*abs(vds))-1.0)*exp(-1.0*relimo_ea1/(relimo_kb*$temperature));
				end
				if(relimo_beta2*abs(vds) > 490) begin
					delta_damage1_3_2 = 0.0;
				end else begin				
					delta_damage1_3_2 = 1.0/relimo_alpha2_off*(exp(relimo_beta2*abs(vds))-1.0)*exp(-1.0*relimo_ea2/(relimo_kb*$temperature));
				end				
			end
			
			// HCIHV
			`EM($temperature, -1.0*vgs, -1.0*vds, vsub)
			`EM2($temperature, -1.0*vgs, -1.0*vds, vsub)
			if (em != 0) begin
				lamda_h = relimo_lamda_h0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if(relimo_Feb_h/(em*lamda_h) > 490) begin
					delta_damage2_3_1 = 0.0;
				end else begin
					delta_damage2_3_1 = 1.0/(relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb_h/(em*lamda_h)*exp(relimo_Feb_h/(em*lamda_h)));
				end
			end
			if (em2 != 0) begin
				lamda_el = relimo_lamda_el0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if (relimo_Feb_el/(em2*lamda_el) > 490) begin
					delta_damage2_3_2 = 0.0;
				end else begin
					delta_damage2_3_2 = 1.0/(relimo_alpha2*pow(w*1e-6/id,relimo_m2)*relimo_Feb_el/(em2*lamda_el)*exp(relimo_Feb_el/(em2*lamda_el)));
				end
			end
			 
			// High Vgs HCI.
			if(vds < 0 && vgs < 0) begin
				if((relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))) > 490) begin
					delta_damage3 = 0.0;
				end else begin	
					delta_damage3 = 1.0/(relimo_fstat3*relimo_alpha3*pow(w*1e-6/id,relimo_beta3)*pow(abs(vgs),-1.0*relimo_gama3)*pow(abs(vds),-1.0*relimo_eps3)*exp(-1.0*relimo_eta3*abs(vsub))*exp(relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))));
				end
			end
			
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				
				// off stat damages
				damage1_3_1 = damage1_3_1 + dt/2.0*(delta_damage1_3_1 + last_delta_damage1_3_1);
				damage1_3_2 = damage1_3_2 + dt/2.0*(delta_damage1_3_2 + last_delta_damage1_3_2);


				// HCIHV damages

				damage2_3_1 = damage2_3_1 + dt/2.0*(delta_damage2_3_1 + last_delta_damage2_3_1);
				damage2_3_2 = damage2_3_2 + dt/2.0*(delta_damage2_3_2 + last_delta_damage2_3_2);
	
				
				// High Vgs HCI.
				damage3 = damage3 + dt/2.0*(delta_damage3 + last_delta_damage3);
				
				last_delta_damage1_3_1 = delta_damage1_3_1;
				last_delta_damage1_3_2 = delta_damage1_3_2;
				last_delta_damage2_3_1 = delta_damage2_3_1;
				last_delta_damage2_3_2 = delta_damage2_3_2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, em2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, relimo_rth, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*V(sub)), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1_3_1 = damage1_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage1_3_2 = damage1_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_1 = damage2_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_2 = damage2_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1_3_1 = 0;
					damage1_3_2 = 0;
					damage2_3_1 = 0;
					damage2_3_2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1_3_1 = delta_damage1_3_1*relimo_aging_time*3600;
				damage1_3_2 = delta_damage1_3_2*relimo_aging_time*3600;
				damage2_3_1 = delta_damage2_3_1*relimo_aging_time*3600;
				damage2_3_2 = delta_damage2_3_2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
			end				

			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_b_off)+pow(delta_m_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_a_off)+pow(delta_m_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_m_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_m_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

      			
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
        		
			//$display("Parameter %M in device %e, %e, %e, %e", lamda_h, lamda_el, delta_damage2_3_1, delta_damage2_3_2);
			//$display("Parameter %M in device %e, %e, %e, %e", ron_50p, s_50p, fa, ron_fa);
			//$display("Parameter %M in device %e, %e, %e, %e, %e", s_fa, fstat1, fstat2, damage2_1_1, damage2_1_2);
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, V(sub), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.130*0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 0);
			
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1_3_1 = damage1_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage1_3_2 = damage1_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_1 = damage2_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_2 = damage2_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1_3_1 = 0;
				damage1_3_2 = 0;
				damage2_3_1 = 0;
				damage2_3_2 = 0;
				damage3 = 0;
      			end


			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_b_off)+pow(delta_m_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_a_off)+pow(delta_m_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_m_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_m_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.130*0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);			
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 0);			
			
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_pld30b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pld30b";
parameter string      relimo_probe_name            = "mpowermos";
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_n                     = 1.0;
parameter real        relimo_a_idlin               = 0.0;
parameter real        relimo_a_gm                  = 0.0;
parameter real        relimo_a_vth                 = 0.0;
parameter integer     relimo_function              = 1;


parameter real        relimo_vth                   = -1;			

// parameter for HighVgs HCI
parameter real        relimo_a_hci3 = 1000;
parameter real        relimo_n_hci3 = 0.234;
parameter real        relimo_alpha3 = 2.16E+28;
parameter real        relimo_beta3 = 2.76;
parameter real        relimo_gama3 = 14.8;
parameter real        relimo_eps3 = 8.91;
parameter real        relimo_eta3 = 0;
parameter real        relimo_ea3 = 0.751;
parameter real        relimo_rth = 0.00743;
parameter real        relimo_fstat3 = 0.0409;

// parameter for off stat
parameter real        relimo_a1_off = 12.7;
parameter real        relimo_n1_off = 0.15;
parameter real        relimo_a2_off = 2.02;
parameter real        relimo_n2_off = 0.463;
parameter real        relimo_alpha1_off = 93900;
parameter real        relimo_beta1 = 0.229;
parameter real        relimo_ea1 = 0.666;
parameter real        relimo_alpha2_off = 5.61;
parameter real        relimo_beta2 = 0.325;
parameter real        relimo_ea2 = 0.469;
parameter real        fstat_tau1_off = 0.0134;
parameter real        fstat_tau2_off = 0.0707;
parameter real        fstat_tau1tau2_off = 56.3;
parameter real        fstat_tau2tau1_off = 56.3;
parameter real        m_sigma_b_off = 1;
parameter real        delta_m_sigma_b_off = 0.5;
parameter real        m_sigma_a_off = 1;
parameter real        delta_m_sigma_a_off = 0.5;

// parameter for HCIHV
parameter real        relimo_Feb_el = 3.2;
parameter real        relimo_Feb_h = 4.8;
parameter real        relimo_Ep = 0.063;

parameter real        relimo_a1 = 1.5199;
parameter real        relimo_a2 = 3.4802;
parameter real        relimo_c1 = 288.96;
parameter real        relimo_b = 0.032351;
parameter real        relimo_n_hci = 1.8297;
parameter real        relimo_alpha1 = 0.000404;
parameter real        relimo_m1 = 1.35;
parameter real        relimo_lamda_h0 = 9.56E-07;
parameter real        relimo_alpha2 = 7.86E-31;
parameter real        relimo_m2 = 0.874;
parameter real        relimo_lamda_el0 = 3.25E-07;
parameter real        fstat_tau1 = 0.0299;
parameter real        fstat_tau2 = 0.00269;
parameter real        fstat_tau1tau2 = 152;
parameter real        fstat_tau2tau1 = 152;
parameter real        m_sigma_a = 1;
parameter real        delta_m_sigma_a = 6;
parameter real        m_sigma_b = 1;
parameter real        delta_m_sigma_b = 0.4;
parameter real        vgs_cutoff_HCI = -0.3;
parameter real        m_cutoff_HCI = 1;
parameter real        delta_cutoff_HCI = 0.01;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 48300 ;
parameter real a0_b0_b0_a1_em = -40.7 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -580 ;
parameter real a0_b0_a1_a1_em = 0.71 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -1370 ;
parameter real a0_b0_a2_a1_em = -3.46 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 1990 ;
parameter real a0_b0_a3_a1_em = -1.79 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -54.2 ;
parameter real a0_b0_p1_a1_em = 0.00138 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.28 ;
parameter real a0_b0_p2_a1_em = 0.000574 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 2.46 ;
parameter real a0_b0_p3_a1_em = -4.67E-05 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 12500 ;
parameter real a0_b0_b0_a2_em = -1.63 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 966 ;
parameter real a0_b0_a1_a2_em = -1.55 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = -2660 ;
parameter real a0_b0_a2_a2_em = 3.18 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -515 ;
parameter real a0_b0_a3_a2_em = -0.108 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 4.38 ;
parameter real a0_b0_p1_a2_em = -0.0111 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 2.02 ;
parameter real a0_b0_p2_a2_em = -0.002 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 1.98 ;
parameter real a0_b0_p3_a2_em = 0.00105 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 4 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 9040 ;
parameter real a0_b0_b0_a3_em = -0.397 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 613 ;
parameter real a0_b0_a1_a3_em = -2.07 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -7430 ;
parameter real a0_b0_a2_a3_em = 1.92 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -3220 ;
parameter real a0_b0_a3_a3_em = 1.16 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = -0.855 ;
parameter real a0_b0_p1_a3_em = 0.00486 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.5 ;
parameter real a0_b0_p2_a3_em = 0.00113 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.31 ;
parameter real a0_b0_p3_a3_em = 0.00125 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 3 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 4580 ;
parameter real a0_b0_b0_a4_em = 2.06 ;
parameter real b0_a0_b0_a4_em = -11.6 ;
parameter real a0_a0_b0_a4_em = 0.0349 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 1490 ;
parameter real a0_b0_a1_a4_em = -2.59 ;
parameter real b0_a0_a1_a4_em = 0.349 ;
parameter real a0_a0_a1_a4_em = 0.222 ;
parameter real b0_b0_a2_a4_em = -766 ;
parameter real a0_b0_a2_a4_em = 1.62 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.00571 ;
parameter real b0_b0_a3_a4_em = 1280 ;
parameter real a0_b0_a3_a4_em = -2.19 ;
parameter real b0_a0_a3_a4_em = -1.68 ;
parameter real a0_a0_a3_a4_em = 0.00401 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 1.69 ;
parameter real a0_b0_p1_a4_em = -0.000112 ;
parameter real b0_a0_p1_a4_em = 0.00464 ;
parameter real a0_a0_p1_a4_em = -1.99E-05 ;
parameter real b0_b0_p2_a4_em = 1.61 ;
parameter real a0_b0_p2_a4_em = 0.000945 ;
parameter real b0_a0_p2_a4_em = 0.00287 ;
parameter real a0_a0_p2_a4_em = -5.40E-06 ;
parameter real b0_b0_p3_a4_em = 2.43 ;
parameter real a0_b0_p3_a4_em = 0.00368 ;
parameter real b0_a0_p3_a4_em = -0.000645 ;
parameter real a0_a0_p3_a4_em = 4.65E-06 ;
parameter real b0_b0_p4_a4_em = 2.41 ;
parameter real a0_b0_p4_a4_em = 0.00876 ;
parameter real b0_a0_p4_a4_em = -0.0085 ;
parameter real a0_a0_p4_a4_em = 2.18E-05 ;
parameter real b0_b0_b0_p1_em = 1.62 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.216 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -2.41 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 2.69E-05 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -1.09 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.55 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.45 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 2.13 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 11.1 ;
parameter real a0_b0_b0_p2_em = 0.00576 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 1.2 ;
parameter real a0_b0_a1_p2_em = -0.00324 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = -10.7 ;
parameter real a0_b0_a2_p2_em = 0.0153 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = -1.46 ;
parameter real a0_b0_a3_p2_em = -0.000321 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.97 ;
parameter real a0_b0_p2_p2_em = 0.000922 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 2.37 ;
parameter real a0_b0_p3_p2_em = 0.00127 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 4.94 ;
parameter real a0_b0_p4_p2_em = -0.00247 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 16.8 ;
parameter real a0_b0_b0_p3_em = 0.00252 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = -1.61 ;
parameter real a0_b0_a1_p3_em = 0.00304 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = -2.34 ;
parameter real a0_b0_a2_p3_em = -4.87E-05 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0.769 ;
parameter real a0_b0_a3_p3_em = -0.000416 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 2.09 ;
parameter real a0_b0_p1_p3_em = -0.00402 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.58 ;
parameter real a0_b0_p2_p3_em = -0.00036 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 4.83 ;
parameter real a0_b0_p3_p3_em = -0.00136 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 6 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 25.5 ;
parameter real a0_b0_b0_p4_em = -0.0011 ;
parameter real b0_a0_b0_p4_em = 0.02 ;
parameter real a0_a0_b0_p4_em = -6.04E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = -5.22 ;
parameter real a0_b0_a1_p4_em = 0.00888 ;
parameter real b0_a0_a1_p4_em = -0.0275 ;
parameter real a0_a0_a1_p4_em = 7.37E-05 ;
parameter real b0_b0_a2_p4_em = 12.5 ;
parameter real a0_b0_a2_p4_em = -0.0205 ;
parameter real b0_a0_a2_p4_em = 0.00131 ;
parameter real a0_a0_a2_p4_em = 3.13E-06 ;
parameter real b0_b0_a3_p4_em = -5.61 ;
parameter real a0_b0_a3_p4_em = 0.00578 ;
parameter real b0_a0_a3_p4_em = 0.0235 ;
parameter real a0_a0_a3_p4_em = -4.63E-05 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 1.24 ;
parameter real a0_b0_p1_p4_em = -0.000731 ;
parameter real b0_a0_p1_p4_em = 0.00394 ;
parameter real a0_a0_p1_p4_em = -9.11E-06 ;
parameter real b0_b0_p2_p4_em = 2.19 ;
parameter real a0_b0_p2_p4_em = -6.92E-05 ;
parameter real b0_a0_p2_p4_em = -0.00175 ;
parameter real a0_a0_p2_p4_em = 6.09E-06 ;
parameter real b0_b0_p3_p4_em = 2.6 ;
parameter real a0_b0_p3_p4_em = 0.000913 ;
parameter real b0_a0_p3_p4_em = -0.00121 ;
parameter real a0_a0_p3_p4_em = 2.12E-06 ;
parameter real b0_b0_p4_p4_em = 5.04 ;
parameter real a0_b0_p4_p4_em = 0.00206 ;
parameter real b0_a0_p4_p4_em = -0.0222 ;
parameter real a0_a0_p4_p4_em = 6.49E-05 ;

parameter real b0_b0_b0_b0_em2 = 0 ;
parameter real a0_b0_b0_b0_em2 = 0 ;
parameter real b0_a0_b0_b0_em2 = 0 ;
parameter real a0_a0_b0_b0_em2 = 0 ;
parameter real b0_b0_a0_b0_em2 = 0 ;
parameter real a0_b0_a0_b0_em2 = 0 ;
parameter real b0_a0_a0_b0_em2 = 0 ;
parameter real a0_a0_a0_b0_em2 = 0 ;
parameter real b0_b0_a1_b0_em2 = 0 ;
parameter real a0_b0_a1_b0_em2 = 0 ;
parameter real b0_a0_a1_b0_em2 = 0 ;
parameter real a0_a0_a1_b0_em2 = 0 ;
parameter real b0_b0_a2_b0_em2 = 0 ;
parameter real a0_b0_a2_b0_em2 = 0 ;
parameter real b0_a0_a2_b0_em2 = 0 ;
parameter real a0_a0_a2_b0_em2 = 0 ;
parameter real b0_b0_a3_b0_em2 = 0 ;
parameter real a0_b0_a3_b0_em2 = 0 ;
parameter real b0_a0_a3_b0_em2 = 0 ;
parameter real a0_a0_a3_b0_em2 = 0 ;
parameter real b0_b0_a4_b0_em2 = 0 ;
parameter real a0_b0_a4_b0_em2 = 0 ;
parameter real b0_a0_a4_b0_em2 = 0 ;
parameter real a0_a0_a4_b0_em2 = 0 ;
parameter real b0_b0_p1_b0_em2 = 0 ;
parameter real a0_b0_p1_b0_em2 = 0 ;
parameter real b0_a0_p1_b0_em2 = 0 ;
parameter real a0_a0_p1_b0_em2 = 0 ;
parameter real b0_b0_p2_b0_em2 = 0 ;
parameter real a0_b0_p2_b0_em2 = 0 ;
parameter real b0_a0_p2_b0_em2 = 0 ;
parameter real a0_a0_p2_b0_em2 = 0 ;
parameter real b0_b0_p3_b0_em2 = 0 ;
parameter real a0_b0_p3_b0_em2 = 0 ;
parameter real b0_a0_p3_b0_em2 = 0 ;
parameter real a0_a0_p3_b0_em2 = 0 ;
parameter real b0_b0_p4_b0_em2 = 0 ;
parameter real a0_b0_p4_b0_em2 = 0 ;
parameter real b0_a0_p4_b0_em2 = 0 ;
parameter real a0_a0_p4_b0_em2 = 0 ;
parameter real b0_b0_b0_a0_em2 = 0 ;
parameter real a0_b0_b0_a0_em2 = 0 ;
parameter real b0_a0_b0_a0_em2 = 0 ;
parameter real a0_a0_b0_a0_em2 = 0 ;
parameter real b0_b0_a0_a0_em2 = 0 ;
parameter real a0_b0_a0_a0_em2 = 0 ;
parameter real b0_a0_a0_a0_em2 = 0 ;
parameter real a0_a0_a0_a0_em2 = 0 ;
parameter real b0_b0_a1_a0_em2 = 0 ;
parameter real a0_b0_a1_a0_em2 = 0 ;
parameter real b0_a0_a1_a0_em2 = 0 ;
parameter real a0_a0_a1_a0_em2 = 0 ;
parameter real b0_b0_a2_a0_em2 = 0 ;
parameter real a0_b0_a2_a0_em2 = 0 ;
parameter real b0_a0_a2_a0_em2 = 0 ;
parameter real a0_a0_a2_a0_em2 = 0 ;
parameter real b0_b0_a3_a0_em2 = 0 ;
parameter real a0_b0_a3_a0_em2 = 0 ;
parameter real b0_a0_a3_a0_em2 = 0 ;
parameter real a0_a0_a3_a0_em2 = 0 ;
parameter real b0_b0_a4_a0_em2 = 0 ;
parameter real a0_b0_a4_a0_em2 = 0 ;
parameter real b0_a0_a4_a0_em2 = 0 ;
parameter real a0_a0_a4_a0_em2 = 0 ;
parameter real b0_b0_p1_a0_em2 = 0 ;
parameter real a0_b0_p1_a0_em2 = 0 ;
parameter real b0_a0_p1_a0_em2 = 0 ;
parameter real a0_a0_p1_a0_em2 = 0 ;
parameter real b0_b0_p2_a0_em2 = 0 ;
parameter real a0_b0_p2_a0_em2 = 0 ;
parameter real b0_a0_p2_a0_em2 = 0 ;
parameter real a0_a0_p2_a0_em2 = 0 ;
parameter real b0_b0_p3_a0_em2 = 0 ;
parameter real a0_b0_p3_a0_em2 = 0 ;
parameter real b0_a0_p3_a0_em2 = 0 ;
parameter real a0_a0_p3_a0_em2 = 0 ;
parameter real b0_b0_p4_a0_em2 = 0 ;
parameter real a0_b0_p4_a0_em2 = 0 ;
parameter real b0_a0_p4_a0_em2 = 0 ;
parameter real a0_a0_p4_a0_em2 = 0 ;
parameter real b0_b0_b0_a1_em2 = 11900 ;
parameter real a0_b0_b0_a1_em2 = -9.82 ;
parameter real b0_a0_b0_a1_em2 = 0 ;
parameter real a0_a0_b0_a1_em2 = 0 ;
parameter real b0_b0_a0_a1_em2 = 0 ;
parameter real a0_b0_a0_a1_em2 = 0 ;
parameter real b0_a0_a0_a1_em2 = 0 ;
parameter real a0_a0_a0_a1_em2 = 0 ;
parameter real b0_b0_a1_a1_em2 = 3350 ;
parameter real a0_b0_a1_a1_em2 = -0.864 ;
parameter real b0_a0_a1_a1_em2 = 0 ;
parameter real a0_a0_a1_a1_em2 = 0 ;
parameter real b0_b0_a2_a1_em2 = -2220 ;
parameter real a0_b0_a2_a1_em2 = 4.52 ;
parameter real b0_a0_a2_a1_em2 = 0 ;
parameter real a0_a0_a2_a1_em2 = 0 ;
parameter real b0_b0_a3_a1_em2 = -4050 ;
parameter real a0_b0_a3_a1_em2 = 2.43 ;
parameter real b0_a0_a3_a1_em2 = 0 ;
parameter real a0_a0_a3_a1_em2 = 0 ;
parameter real b0_b0_a4_a1_em2 = 0 ;
parameter real a0_b0_a4_a1_em2 = 0 ;
parameter real b0_a0_a4_a1_em2 = 0 ;
parameter real a0_a0_a4_a1_em2 = 0 ;
parameter real b0_b0_p1_a1_em2 = -0.0246 ;
parameter real a0_b0_p1_a1_em2 = -0.00041 ;
parameter real b0_a0_p1_a1_em2 = 0 ;
parameter real a0_a0_p1_a1_em2 = 0 ;
parameter real b0_b0_p2_a1_em2 = 0.975 ;
parameter real a0_b0_p2_a1_em2 = 0.000376 ;
parameter real b0_a0_p2_a1_em2 = 0 ;
parameter real a0_a0_p2_a1_em2 = 0 ;
parameter real b0_b0_p3_a1_em2 = 2.89 ;
parameter real a0_b0_p3_a1_em2 = -0.00123 ;
parameter real b0_a0_p3_a1_em2 = 0 ;
parameter real a0_a0_p3_a1_em2 = 0 ;
parameter real b0_b0_p4_a1_em2 = 3.9 ;
parameter real a0_b0_p4_a1_em2 = -0.0001 ;
parameter real b0_a0_p4_a1_em2 = 0 ;
parameter real a0_a0_p4_a1_em2 = 0 ;
parameter real b0_b0_b0_a2_em2 = 8160 ;
parameter real a0_b0_b0_a2_em2 = 3.34 ;
parameter real b0_a0_b0_a2_em2 = 0 ;
parameter real a0_a0_b0_a2_em2 = 0 ;
parameter real b0_b0_a0_a2_em2 = 0 ;
parameter real a0_b0_a0_a2_em2 = 0 ;
parameter real b0_a0_a0_a2_em2 = 0 ;
parameter real a0_a0_a0_a2_em2 = 0 ;
parameter real b0_b0_a1_a2_em2 = 714 ;
parameter real a0_b0_a1_a2_em2 = 9.39 ;
parameter real b0_a0_a1_a2_em2 = 0 ;
parameter real a0_a0_a1_a2_em2 = 0 ;
parameter real b0_b0_a2_a2_em2 = -3740 ;
parameter real a0_b0_a2_a2_em2 = 4.27 ;
parameter real b0_a0_a2_a2_em2 = 0 ;
parameter real a0_a0_a2_a2_em2 = 0 ;
parameter real b0_b0_a3_a2_em2 = 3050 ;
parameter real a0_b0_a3_a2_em2 = -10.9 ;
parameter real b0_a0_a3_a2_em2 = 0 ;
parameter real a0_a0_a3_a2_em2 = 0 ;
parameter real b0_b0_a4_a2_em2 = 0 ;
parameter real a0_b0_a4_a2_em2 = 0 ;
parameter real b0_a0_a4_a2_em2 = 0 ;
parameter real a0_a0_a4_a2_em2 = 0 ;
parameter real b0_b0_p1_a2_em2 = -0.887 ;
parameter real a0_b0_p1_a2_em2 = 0.00271 ;
parameter real b0_a0_p1_a2_em2 = 0 ;
parameter real a0_a0_p1_a2_em2 = 0 ;
parameter real b0_b0_p2_a2_em2 = 1.31 ;
parameter real a0_b0_p2_a2_em2 = -0.000751 ;
parameter real b0_a0_p2_a2_em2 = 0 ;
parameter real a0_a0_p2_a2_em2 = 0 ;
parameter real b0_b0_p3_a2_em2 = 2.83 ;
parameter real a0_b0_p3_a2_em2 = 0.00258 ;
parameter real b0_a0_p3_a2_em2 = 0 ;
parameter real a0_a0_p3_a2_em2 = 0 ;
parameter real b0_b0_p4_a2_em2 = 4 ;
parameter real a0_b0_p4_a2_em2 = 0 ;
parameter real b0_a0_p4_a2_em2 = 0 ;
parameter real a0_a0_p4_a2_em2 = 0 ;
parameter real b0_b0_b0_a3_em2 = 4270 ;
parameter real a0_b0_b0_a3_em2 = 13.4 ;
parameter real b0_a0_b0_a3_em2 = 0 ;
parameter real a0_a0_b0_a3_em2 = 0 ;
parameter real b0_b0_a0_a3_em2 = 0 ;
parameter real a0_b0_a0_a3_em2 = 0 ;
parameter real b0_a0_a0_a3_em2 = 0 ;
parameter real a0_a0_a0_a3_em2 = 0 ;
parameter real b0_b0_a1_a3_em2 = 514 ;
parameter real a0_b0_a1_a3_em2 = -4.08 ;
parameter real b0_a0_a1_a3_em2 = 0 ;
parameter real a0_a0_a1_a3_em2 = 0 ;
parameter real b0_b0_a2_a3_em2 = 3690 ;
parameter real a0_b0_a2_a3_em2 = -2.09 ;
parameter real b0_a0_a2_a3_em2 = 0 ;
parameter real a0_a0_a2_a3_em2 = 0 ;
parameter real b0_b0_a3_a3_em2 = -993 ;
parameter real a0_b0_a3_a3_em2 = -0.568 ;
parameter real b0_a0_a3_a3_em2 = 0 ;
parameter real a0_a0_a3_a3_em2 = 0 ;
parameter real b0_b0_a4_a3_em2 = 0 ;
parameter real a0_b0_a4_a3_em2 = 0 ;
parameter real b0_a0_a4_a3_em2 = 0 ;
parameter real a0_a0_a4_a3_em2 = 0 ;
parameter real b0_b0_p1_a3_em2 = 0.818 ;
parameter real a0_b0_p1_a3_em2 = -0.00394 ;
parameter real b0_a0_p1_a3_em2 = 0 ;
parameter real a0_a0_p1_a3_em2 = 0 ;
parameter real b0_b0_p2_a3_em2 = 0.281 ;
parameter real a0_b0_p2_a3_em2 = -0.000546 ;
parameter real b0_a0_p2_a3_em2 = 0 ;
parameter real a0_a0_p2_a3_em2 = 0 ;
parameter real b0_b0_p3_a3_em2 = 0.929 ;
parameter real a0_b0_p3_a3_em2 = -0.00049 ;
parameter real b0_a0_p3_a3_em2 = 0 ;
parameter real a0_a0_p3_a3_em2 = 0 ;
parameter real b0_b0_p4_a3_em2 = 4.5 ;
parameter real a0_b0_p4_a3_em2 = 0 ;
parameter real b0_a0_p4_a3_em2 = 0 ;
parameter real a0_a0_p4_a3_em2 = 0 ;
parameter real b0_b0_b0_a4_em2 = 6810 ;
parameter real a0_b0_b0_a4_em2 = -1.6 ;
parameter real b0_a0_b0_a4_em2 = -1.04 ;
parameter real a0_a0_b0_a4_em2 = 0.00305 ;
parameter real b0_b0_a0_a4_em2 = 0 ;
parameter real a0_b0_a0_a4_em2 = 0 ;
parameter real b0_a0_a0_a4_em2 = 0 ;
parameter real a0_a0_a0_a4_em2 = 0 ;
parameter real b0_b0_a1_a4_em2 = -1350 ;
parameter real a0_b0_a1_a4_em2 = 4.74 ;
parameter real b0_a0_a1_a4_em2 = -0.718 ;
parameter real a0_a0_a1_a4_em2 = 0.00231 ;
parameter real b0_b0_a2_a4_em2 = -73.4 ;
parameter real a0_b0_a2_a4_em2 = -2.2 ;
parameter real b0_a0_a2_a4_em2 = 0 ;
parameter real a0_a0_a2_a4_em2 = 0.00588 ;
parameter real b0_b0_a3_a4_em2 = -445 ;
parameter real a0_b0_a3_a4_em2 = 4.15 ;
parameter real b0_a0_a3_a4_em2 = 0.708 ;
parameter real a0_a0_a3_a4_em2 = -0.00966 ;
parameter real b0_b0_a4_a4_em2 = 0 ;
parameter real a0_b0_a4_a4_em2 = 0 ;
parameter real b0_a0_a4_a4_em2 = 0 ;
parameter real a0_a0_a4_a4_em2 = 0 ;
parameter real b0_b0_p1_a4_em2 = -0.011 ;
parameter real a0_b0_p1_a4_em2 = -0.00282 ;
parameter real b0_a0_p1_a4_em2 = 0.00387 ;
parameter real a0_a0_p1_a4_em2 = -8.04E-06 ;
parameter real b0_b0_p2_a4_em2 = -0.19 ;
parameter real a0_b0_p2_a4_em2 = 0.000581 ;
parameter real b0_a0_p2_a4_em2 = 0.00111 ;
parameter real a0_a0_p2_a4_em2 = -3.28E-06 ;
parameter real b0_b0_p3_a4_em2 = 2.19 ;
parameter real a0_b0_p3_a4_em2 = 0.00188 ;
parameter real b0_a0_p3_a4_em2 = -0.00511 ;
parameter real a0_a0_p3_a4_em2 = 1.02E-05 ;
parameter real b0_b0_p4_a4_em2 = 4.39 ;
parameter real a0_b0_p4_a4_em2 = -0.000239 ;
parameter real b0_a0_p4_a4_em2 = 0.00753 ;
parameter real a0_a0_p4_a4_em2 = -1.54E-05 ;
parameter real b0_b0_b0_p1_em2 = 4.7 ;
parameter real a0_b0_b0_p1_em2 = 0 ;
parameter real b0_a0_b0_p1_em2 = 0 ;
parameter real a0_a0_b0_p1_em2 = 0 ;
parameter real b0_b0_a0_p1_em2 = 0 ;
parameter real a0_b0_a0_p1_em2 = 0 ;
parameter real b0_a0_a0_p1_em2 = 0 ;
parameter real a0_a0_a0_p1_em2 = 0 ;
parameter real b0_b0_a1_p1_em2 = 4.15 ;
parameter real a0_b0_a1_p1_em2 = 0 ;
parameter real b0_a0_a1_p1_em2 = 0 ;
parameter real a0_a0_a1_p1_em2 = 0 ;
parameter real b0_b0_a2_p1_em2 = -1.88 ;
parameter real a0_b0_a2_p1_em2 = 0 ;
parameter real b0_a0_a2_p1_em2 = 0 ;
parameter real a0_a0_a2_p1_em2 = 0 ;
parameter real b0_b0_a3_p1_em2 = -5.05 ;
parameter real a0_b0_a3_p1_em2 = 0 ;
parameter real b0_a0_a3_p1_em2 = 0 ;
parameter real a0_a0_a3_p1_em2 = 0 ;
parameter real b0_b0_a4_p1_em2 = 0 ;
parameter real a0_b0_a4_p1_em2 = 0 ;
parameter real b0_a0_a4_p1_em2 = 0 ;
parameter real a0_a0_a4_p1_em2 = 0 ;
parameter real b0_b0_p1_p1_em2 = -0.233 ;
parameter real a0_b0_p1_p1_em2 = 0 ;
parameter real b0_a0_p1_p1_em2 = 0 ;
parameter real a0_a0_p1_p1_em2 = 0 ;
parameter real b0_b0_p2_p1_em2 = 1 ;
parameter real a0_b0_p2_p1_em2 = 0 ;
parameter real b0_a0_p2_p1_em2 = 0 ;
parameter real a0_a0_p2_p1_em2 = 0 ;
parameter real b0_b0_p3_p1_em2 = 2.56 ;
parameter real a0_b0_p3_p1_em2 = 0 ;
parameter real b0_a0_p3_p1_em2 = 0 ;
parameter real a0_a0_p3_p1_em2 = 0 ;
parameter real b0_b0_p4_p1_em2 = 3.9 ;
parameter real a0_b0_p4_p1_em2 = 0 ;
parameter real b0_a0_p4_p1_em2 = 0 ;
parameter real a0_a0_p4_p1_em2 = 0 ;
parameter real b0_b0_b0_p2_em2 = 15 ;
parameter real a0_b0_b0_p2_em2 = 0 ;
parameter real b0_a0_b0_p2_em2 = 0 ;
parameter real a0_a0_b0_p2_em2 = 0 ;
parameter real b0_b0_a0_p2_em2 = 0 ;
parameter real a0_b0_a0_p2_em2 = 0 ;
parameter real b0_a0_a0_p2_em2 = 0 ;
parameter real a0_a0_a0_p2_em2 = 0 ;
parameter real b0_b0_a1_p2_em2 = 0 ;
parameter real a0_b0_a1_p2_em2 = 0 ;
parameter real b0_a0_a1_p2_em2 = 0 ;
parameter real a0_a0_a1_p2_em2 = 0 ;
parameter real b0_b0_a2_p2_em2 = 0 ;
parameter real a0_b0_a2_p2_em2 = 0 ;
parameter real b0_a0_a2_p2_em2 = 0 ;
parameter real a0_a0_a2_p2_em2 = 0 ;
parameter real b0_b0_a3_p2_em2 = 0 ;
parameter real a0_b0_a3_p2_em2 = 0 ;
parameter real b0_a0_a3_p2_em2 = 0 ;
parameter real a0_a0_a3_p2_em2 = 0 ;
parameter real b0_b0_a4_p2_em2 = 0 ;
parameter real a0_b0_a4_p2_em2 = 0 ;
parameter real b0_a0_a4_p2_em2 = 0 ;
parameter real a0_a0_a4_p2_em2 = 0 ;
parameter real b0_b0_p1_p2_em2 = 0 ;
parameter real a0_b0_p1_p2_em2 = 0 ;
parameter real b0_a0_p1_p2_em2 = 0 ;
parameter real a0_a0_p1_p2_em2 = 0 ;
parameter real b0_b0_p2_p2_em2 = 1 ;
parameter real a0_b0_p2_p2_em2 = 0 ;
parameter real b0_a0_p2_p2_em2 = 0 ;
parameter real a0_a0_p2_p2_em2 = 0 ;
parameter real b0_b0_p3_p2_em2 = 2 ;
parameter real a0_b0_p3_p2_em2 = 0 ;
parameter real b0_a0_p3_p2_em2 = 0 ;
parameter real a0_a0_p3_p2_em2 = 0 ;
parameter real b0_b0_p4_p2_em2 = 3 ;
parameter real a0_b0_p4_p2_em2 = 0 ;
parameter real b0_a0_p4_p2_em2 = 0 ;
parameter real a0_a0_p4_p2_em2 = 0 ;
parameter real b0_b0_b0_p3_em2 = 20 ;
parameter real a0_b0_b0_p3_em2 = 0 ;
parameter real b0_a0_b0_p3_em2 = 0 ;
parameter real a0_a0_b0_p3_em2 = 0 ;
parameter real b0_b0_a0_p3_em2 = 0 ;
parameter real a0_b0_a0_p3_em2 = 0 ;
parameter real b0_a0_a0_p3_em2 = 0 ;
parameter real a0_a0_a0_p3_em2 = 0 ;
parameter real b0_b0_a1_p3_em2 = 0 ;
parameter real a0_b0_a1_p3_em2 = 0 ;
parameter real b0_a0_a1_p3_em2 = 0 ;
parameter real a0_a0_a1_p3_em2 = 0 ;
parameter real b0_b0_a2_p3_em2 = 0 ;
parameter real a0_b0_a2_p3_em2 = 0 ;
parameter real b0_a0_a2_p3_em2 = 0 ;
parameter real a0_a0_a2_p3_em2 = 0 ;
parameter real b0_b0_a3_p3_em2 = 0 ;
parameter real a0_b0_a3_p3_em2 = 0 ;
parameter real b0_a0_a3_p3_em2 = 0 ;
parameter real a0_a0_a3_p3_em2 = 0 ;
parameter real b0_b0_a4_p3_em2 = 0 ;
parameter real a0_b0_a4_p3_em2 = 0 ;
parameter real b0_a0_a4_p3_em2 = 0 ;
parameter real a0_a0_a4_p3_em2 = 0 ;
parameter real b0_b0_p1_p3_em2 = 0 ;
parameter real a0_b0_p1_p3_em2 = 0 ;
parameter real b0_a0_p1_p3_em2 = 0 ;
parameter real a0_a0_p1_p3_em2 = 0 ;
parameter real b0_b0_p2_p3_em2 = 1 ;
parameter real a0_b0_p2_p3_em2 = 0 ;
parameter real b0_a0_p2_p3_em2 = 0 ;
parameter real a0_a0_p2_p3_em2 = 0 ;
parameter real b0_b0_p3_p3_em2 = 2 ;
parameter real a0_b0_p3_p3_em2 = 0 ;
parameter real b0_a0_p3_p3_em2 = 0 ;
parameter real a0_a0_p3_p3_em2 = 0 ;
parameter real b0_b0_p4_p3_em2 = 3 ;
parameter real a0_b0_p4_p3_em2 = 0 ;
parameter real b0_a0_p4_p3_em2 = 0 ;
parameter real a0_a0_p4_p3_em2 = 0 ;
parameter real b0_b0_b0_p4_em2 = 24 ;
parameter real a0_b0_b0_p4_em2 = 0.00305 ;
parameter real b0_a0_b0_p4_em2 = 0.00419 ;
parameter real a0_a0_b0_p4_em2 = -1.06E-05 ;
parameter real b0_b0_a0_p4_em2 = 0 ;
parameter real a0_b0_a0_p4_em2 = 0 ;
parameter real b0_a0_a0_p4_em2 = 0 ;
parameter real a0_a0_a0_p4_em2 = 0 ;
parameter real b0_b0_a1_p4_em2 = 3.38 ;
parameter real a0_b0_a1_p4_em2 = -0.00505 ;
parameter real b0_a0_a1_p4_em2 = 0 ;
parameter real a0_a0_a1_p4_em2 = 0 ;
parameter real b0_b0_a2_p4_em2 = 2.74 ;
parameter real a0_b0_a2_p4_em2 = -0.00761 ;
parameter real b0_a0_a2_p4_em2 = 0 ;
parameter real a0_a0_a2_p4_em2 = 0 ;
parameter real b0_b0_a3_p4_em2 = -9.92 ;
parameter real a0_b0_a3_p4_em2 = 0.0464 ;
parameter real b0_a0_a3_p4_em2 = 0 ;
parameter real a0_a0_a3_p4_em2 = 0 ;
parameter real b0_b0_a4_p4_em2 = 0 ;
parameter real a0_b0_a4_p4_em2 = 0 ;
parameter real b0_a0_a4_p4_em2 = 0 ;
parameter real a0_a0_a4_p4_em2 = 0 ;
parameter real b0_b0_p1_p4_em2 = 1.92 ;
parameter real a0_b0_p1_p4_em2 = 0.0224 ;
parameter real b0_a0_p1_p4_em2 = 0 ;
parameter real a0_a0_p1_p4_em2 = 0 ;
parameter real b0_b0_p2_p4_em2 = 2.45 ;
parameter real a0_b0_p2_p4_em2 = 0.0139 ;
parameter real b0_a0_p2_p4_em2 = 0 ;
parameter real a0_a0_p2_p4_em2 = 0 ;
parameter real b0_b0_p3_p4_em2 = 4.6 ;
parameter real a0_b0_p3_p4_em2 = -0.000542 ;
parameter real b0_a0_p3_p4_em2 = 0 ;
parameter real a0_a0_p3_p4_em2 = 0 ;
parameter real b0_b0_p4_p4_em2 = 9.74 ;
parameter real a0_b0_p4_p4_em2 = -0.0153 ;
parameter real b0_a0_p4_p4_em2 = 0 ;
parameter real a0_a0_p4_p4_em2 = 0 ;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vsub, id, vdsmax, vgsmax;
real delta_damage3, last_delta_damage3, damage3;
real dt, last_abstime;  
real delta_idsat;
real delta_damage2_1_1,delta_damage2_1_2,damage2_1_1,damage2_1_2;
real delta_damage2_2_1,delta_damage2_2_2,damage2_2_1,damage2_2_2;
real delta_damage2_3_1,delta_damage2_3_2,damage2_3_1,damage2_3_2,last_delta_damage2_3_1,last_delta_damage2_3_2;
real delta_damage1_1_1,delta_damage1_1_2,damage1_1_1,damage1_1_2;
real delta_damage1_2_1,delta_damage1_2_2,damage1_2_1,damage1_2_2;
real delta_damage1_3_1,delta_damage1_3_2,damage1_3_1,damage1_3_2,last_delta_damage1_3_1,last_delta_damage1_3_2;
real lamda_h,lamda_el,ron_50p,s_50p,fa,ron_fa,s_fa,fstat1,fstat2;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;

real b0_b0_b0_em2, a0_b0_b0_em2, b0_a0_b0_em2, a0_a0_b0_em2, b0_a1_b0_em2;
real a0_a1_b0_em2, b0_a2_b0_em2, a0_a2_b0_em2, b0_a3_b0_em2, a0_a3_b0_em2;
real b0_a4_b0_em2, a0_a4_b0_em2, b0_p1_b0_em2, a0_p1_b0_em2, b0_p2_b0_em2;
real a0_p2_b0_em2, b0_p3_b0_em2, a0_p3_b0_em2, b0_p4_b0_em2, a0_p4_b0_em2;
real b0_b0_a0_em2, a0_b0_a0_em2, b0_a0_a0_em2, a0_a0_a0_em2, b0_a1_a0_em2;
real a0_a1_a0_em2, b0_a2_a0_em2, a0_a2_a0_em2, b0_a3_a0_em2, a0_a3_a0_em2;
real b0_a4_a0_em2, a0_a4_a0_em2, b0_p1_a0_em2, a0_p1_a0_em2, b0_p2_a0_em2;
real a0_p2_a0_em2, b0_p3_a0_em2, a0_p3_a0_em2, b0_p4_a0_em2, a0_p4_a0_em2;
real b0_b0_a1_em2, a0_b0_a1_em2, b0_a0_a1_em2, a0_a0_a1_em2, b0_a1_a1_em2;
real a0_a1_a1_em2, b0_a2_a1_em2, a0_a2_a1_em2, b0_a3_a1_em2, a0_a3_a1_em2;
real b0_a4_a1_em2, a0_a4_a1_em2, b0_p1_a1_em2, a0_p1_a1_em2, b0_p2_a1_em2;
real a0_p2_a1_em2, b0_p3_a1_em2, a0_p3_a1_em2, b0_p4_a1_em2, a0_p4_a1_em2;
real b0_b0_a2_em2, a0_b0_a2_em2, b0_a0_a2_em2, a0_a0_a2_em2, b0_a1_a2_em2;
real a0_a1_a2_em2, b0_a2_a2_em2, a0_a2_a2_em2, b0_a3_a2_em2, a0_a3_a2_em2;
real b0_a4_a2_em2, a0_a4_a2_em2, b0_p1_a2_em2, a0_p1_a2_em2, b0_p2_a2_em2;
real a0_p2_a2_em2, b0_p3_a2_em2, a0_p3_a2_em2, b0_p4_a2_em2, a0_p4_a2_em2;
real b0_b0_a3_em2, a0_b0_a3_em2, b0_a0_a3_em2, a0_a0_a3_em2, b0_a1_a3_em2;
real a0_a1_a3_em2, b0_a2_a3_em2, a0_a2_a3_em2, b0_a3_a3_em2, a0_a3_a3_em2;
real b0_a4_a3_em2, a0_a4_a3_em2, b0_p1_a3_em2, a0_p1_a3_em2, b0_p2_a3_em2;
real a0_p2_a3_em2, b0_p3_a3_em2, a0_p3_a3_em2, b0_p4_a3_em2, a0_p4_a3_em2;
real b0_b0_a4_em2, a0_b0_a4_em2, b0_a0_a4_em2, a0_a0_a4_em2, b0_a1_a4_em2;
real a0_a1_a4_em2, b0_a2_a4_em2, a0_a2_a4_em2, b0_a3_a4_em2, a0_a3_a4_em2;
real b0_a4_a4_em2, a0_a4_a4_em2, b0_p1_a4_em2, a0_p1_a4_em2, b0_p2_a4_em2;
real a0_p2_a4_em2, b0_p3_a4_em2, a0_p3_a4_em2, b0_p4_a4_em2, a0_p4_a4_em2;
real b0_b0_p1_em2, a0_b0_p1_em2, b0_a0_p1_em2, a0_a0_p1_em2, b0_a1_p1_em2;
real a0_a1_p1_em2, b0_a2_p1_em2, a0_a2_p1_em2, b0_a3_p1_em2, a0_a3_p1_em2;
real b0_a4_p1_em2, a0_a4_p1_em2, b0_p1_p1_em2, a0_p1_p1_em2, b0_p2_p1_em2;
real a0_p2_p1_em2, b0_p3_p1_em2, a0_p3_p1_em2, b0_p4_p1_em2, a0_p4_p1_em2;
real b0_b0_p2_em2, a0_b0_p2_em2, b0_a0_p2_em2, a0_a0_p2_em2, b0_a1_p2_em2;
real a0_a1_p2_em2, b0_a2_p2_em2, a0_a2_p2_em2, b0_a3_p2_em2, a0_a3_p2_em2;
real b0_a4_p2_em2, a0_a4_p2_em2, b0_p1_p2_em2, a0_p1_p2_em2, b0_p2_p2_em2;
real a0_p2_p2_em2, b0_p3_p2_em2, a0_p3_p2_em2, b0_p4_p2_em2, a0_p4_p2_em2;
real b0_b0_p3_em2, a0_b0_p3_em2, b0_a0_p3_em2, a0_a0_p3_em2, b0_a1_p3_em2;
real a0_a1_p3_em2, b0_a2_p3_em2, a0_a2_p3_em2, b0_a3_p3_em2, a0_a3_p3_em2;
real b0_a4_p3_em2, a0_a4_p3_em2, b0_p1_p3_em2, a0_p1_p3_em2, b0_p2_p3_em2;
real a0_p2_p3_em2, b0_p3_p3_em2, a0_p3_p3_em2, b0_p4_p3_em2, a0_p4_p3_em2;
real b0_b0_p4_em2, a0_b0_p4_em2, b0_a0_p4_em2, a0_a0_p4_em2, b0_a1_p4_em2;
real a0_a1_p4_em2, b0_a2_p4_em2, a0_a2_p4_em2, b0_a3_p4_em2, a0_a3_p4_em2;
real b0_a4_p4_em2, a0_a4_p4_em2, b0_p1_p4_em2, a0_p1_p4_em2, b0_p2_p4_em2;
real a0_p2_p4_em2, b0_p3_p4_em2, a0_p3_p4_em2, b0_p4_p4_em2, a0_p4_p4_em2;
real b0_b0_em2, a0_b0_em2, a1_b0_em2, a2_b0_em2, a3_b0_em2, a4_b0_em2, p1_b0_em2;
real p2_b0_em2, p3_b0_em2, p4_b0_em2, b0_a0_em2, a0_a0_em2, a1_a0_em2, a2_a0_em2;
real a3_a0_em2, a4_a0_em2, p1_a0_em2, p2_a0_em2, p3_a0_em2, p4_a0_em2, b0_a1_em2;
real a0_a1_em2, a1_a1_em2, a2_a1_em2, a3_a1_em2, a4_a1_em2, p1_a1_em2, p2_a1_em2;
real p3_a1_em2, p4_a1_em2, b0_a2_em2, a0_a2_em2, a1_a2_em2, a2_a2_em2, a3_a2_em2;
real a4_a2_em2, p1_a2_em2, p2_a2_em2, p3_a2_em2, p4_a2_em2, b0_a3_em2, a0_a3_em2;
real a1_a3_em2, a2_a3_em2, a3_a3_em2, a4_a3_em2, p1_a3_em2, p2_a3_em2, p3_a3_em2;
real p4_a3_em2, b0_a4_em2, a0_a4_em2, a1_a4_em2, a2_a4_em2, a3_a4_em2, a4_a4_em2;
real p1_a4_em2, p2_a4_em2, p3_a4_em2, p4_a4_em2, b0_p1_em2, a0_p1_em2, a1_p1_em2;
real a2_p1_em2, a3_p1_em2, a4_p1_em2, p1_p1_em2, p2_p1_em2, p3_p1_em2, p4_p1_em2;
real b0_p2_em2, a0_p2_em2, a1_p2_em2, a2_p2_em2, a3_p2_em2, a4_p2_em2, p1_p2_em2;
real p2_p2_em2, p3_p2_em2, p4_p2_em2, b0_p3_em2, a0_p3_em2, a1_p3_em2, a2_p3_em2;
real a3_p3_em2, a4_p3_em2, p1_p3_em2, p2_p3_em2, p3_p3_em2, p4_p3_em2, b0_p4_em2;
real a0_p4_em2, a1_p4_em2, a2_p4_em2, a3_p4_em2, a4_p4_em2, p1_p4_em2, p2_p4_em2;
real p3_p4_em2, p4_p4_em2;
real b0_em2, a0_em2, a1_em2, a2_em2, a3_em2, a4_em2, p1_em2, p2_em2, p3_em2, p4_em2, em2;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vsub = V(sub)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			if(vsub > 0 && vsub < 1e-6) begin
				vsub = 1e-6;
			end
			if(vsub < 0 && vsub > -1e-6) begin
				vsub = -1e-6;
			end
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			
			delta_damage1_3_1 = 0;
			delta_damage1_3_2 = 0;
			delta_damage1_2_1 = 0;
			delta_damage1_2_2 = 0;
			delta_damage1_1_1 = 0;
			delta_damage1_1_2 = 0;
			delta_damage2_3_1 = 0;
			delta_damage2_3_2 = 0;
			delta_damage2_2_1 = 0;
			delta_damage2_2_2 = 0;
			delta_damage2_1_1 = 0;
			delta_damage2_1_2 = 0;
			delta_damage3 = 0;
			
			// off state HCI.
			if(vds < 0) begin	
				if(relimo_beta1*abs(vds) > 490) begin
					delta_damage1_3_1 = 0.0;
				end else begin				
					delta_damage1_3_1 = 1.0/relimo_alpha1_off*(exp(relimo_beta1*abs(vds))-1.0)*exp(-1.0*relimo_ea1/(relimo_kb*$temperature));
				end
				if(relimo_beta2*abs(vds) > 490) begin
					delta_damage1_3_2 = 0.0;
				end else begin				
					delta_damage1_3_2 = 1.0/relimo_alpha2_off*(exp(relimo_beta2*abs(vds))-1.0)*exp(-1.0*relimo_ea2/(relimo_kb*$temperature));
				end				
			end
			
			// HCIHV
			`EM($temperature, -1.0*vgs, -1.0*vds, vsub)
			`EM2($temperature, -1.0*vgs, -1.0*vds, vsub)
			if (em != 0) begin
				lamda_h = relimo_lamda_h0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if(relimo_Feb_h/(em*lamda_h) > 490) begin
					delta_damage2_3_1 = 0.0;
				end else begin
					delta_damage2_3_1 = 1.0/(relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb_h/(em*lamda_h)*exp(relimo_Feb_h/(em*lamda_h)));
				end
			end
			if (em2 != 0) begin
				lamda_el = relimo_lamda_el0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if (relimo_Feb_el/(em2*lamda_el) > 490) begin
					delta_damage2_3_2 = 0.0;
				end else begin
					delta_damage2_3_2 = 1.0/(relimo_alpha2*pow(w*1e-6/id,relimo_m2)*relimo_Feb_el/(em2*lamda_el)*exp(relimo_Feb_el/(em2*lamda_el)));
				end
			end
			 
			// High Vgs HCI.
			if(vds < 0 && vgs < 0) begin
				if((relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))) > 490) begin
					delta_damage3 = 0.0;
				end else begin	
					delta_damage3 = 1.0/(relimo_fstat3*relimo_alpha3*pow(w*1e-6/id,relimo_beta3)*pow(abs(vgs),-1.0*relimo_gama3)*pow(abs(vds),-1.0*relimo_eps3)*exp(-1.0*relimo_eta3*abs(vsub))*exp(relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))));
				end
			end
			
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				
				// off stat damages
				damage1_3_1 = damage1_3_1 + dt/2.0*(delta_damage1_3_1 + last_delta_damage1_3_1);
				damage1_3_2 = damage1_3_2 + dt/2.0*(delta_damage1_3_2 + last_delta_damage1_3_2);


				// HCIHV damages

				damage2_3_1 = damage2_3_1 + dt/2.0*(delta_damage2_3_1 + last_delta_damage2_3_1);
				damage2_3_2 = damage2_3_2 + dt/2.0*(delta_damage2_3_2 + last_delta_damage2_3_2);
	
				
				// High Vgs HCI.
				damage3 = damage3 + dt/2.0*(delta_damage3 + last_delta_damage3);
				
				last_delta_damage1_3_1 = delta_damage1_3_1;
				last_delta_damage1_3_2 = delta_damage1_3_2;
				last_delta_damage2_3_1 = delta_damage2_3_1;
				last_delta_damage2_3_2 = delta_damage2_3_2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, em2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, vgs, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*V(sub)), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1_3_1 = damage1_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage1_3_2 = damage1_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_1 = damage2_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_2 = damage2_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1_3_1 = 0;
					damage1_3_2 = 0;
					damage2_3_1 = 0;
					damage2_3_2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1_3_1 = delta_damage1_3_1*relimo_aging_time*3600;
				damage1_3_2 = delta_damage1_3_2*relimo_aging_time*3600;
				damage2_3_1 = delta_damage2_3_1*relimo_aging_time*3600;
				damage2_3_2 = delta_damage2_3_2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
			end				

			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_b_off)+pow(delta_m_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_a_off)+pow(delta_m_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_m_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_m_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

      			
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
        		
			//$display("Parameter %M in device %e, %e, %e, %e", lamda_h, lamda_el, delta_damage2_3_1, delta_damage2_3_2);
			//$display("Parameter %M in device %e, %e, %e, %e", ron_50p, s_50p, fa, ron_fa);
			//$display("Parameter %M in device %e, %e, %e, %e, %e", s_fa, fstat1, fstat2, damage2_1_1, damage2_1_2);
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, V(sub), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.106*0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 0);
			
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1_3_1 = damage1_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage1_3_2 = damage1_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_1 = damage2_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_2 = damage2_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1_3_1 = 0;
				damage1_3_2 = 0;
				damage2_3_1 = 0;
				damage2_3_2 = 0;
				damage3 = 0;
      			end


			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_b_off)+pow(delta_m_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_a_off)+pow(delta_m_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_m_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_m_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.106*0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);			
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 0);			
			
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_pld10b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pld10b";
parameter string      relimo_probe_name            = "mamost";
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_n                     = 1.0;
parameter real        relimo_a_idlin               = 0.0;
parameter real        relimo_a_gm                  = 0.0;
parameter real        relimo_a_vth                 = 0.0;
parameter integer     relimo_function              = 1;


parameter real        relimo_vth                   = -1;			

// parameter for HighVgs HCI
parameter real        relimo_a_hci3 = 1000;
parameter real        relimo_n_hci3 = 0.24;
parameter real        relimo_alpha3 = 1.28E+7;
parameter real        relimo_beta3 = 5.9e-9;
parameter real        relimo_gama3 = 11.7;
parameter real        relimo_eps3 = 3.7;
parameter real        relimo_eta3 = 0;
parameter real        relimo_ea3 = 1.28;
parameter real        relimo_rth = 0.0601;
parameter real        relimo_fstat3 = 0.0171;

// parameter for off stat
parameter real        relimo_a1_off = 12.7;
parameter real        relimo_n1_off = 0.15;
parameter real        relimo_a2_off = 2.02;
parameter real        relimo_n2_off = 0.463;
parameter real        relimo_alpha1_off = 93900;
parameter real        relimo_beta1 = 0.229;
parameter real        relimo_ea1 = 0.666;
parameter real        relimo_alpha2_off = 5.61;
parameter real        relimo_beta2 = 0.325;
parameter real        relimo_ea2 = 0.469;
parameter real        fstat_tau1_off = 0.0134;
parameter real        fstat_tau2_off = 0.0707;
parameter real        fstat_tau1tau2_off = 56.3;
parameter real        fstat_tau2tau1_off = 56.3;
parameter real        m_sigma_b_off = 1;
parameter real        delta_m_sigma_b_off = 0.5;
parameter real        m_sigma_a_off = 1;
parameter real        delta_m_sigma_a_off = 0.5;

// parameter for HCIHV
parameter real        relimo_Feb_el = 3.2;
parameter real        relimo_Feb_h = 4.8;
parameter real        relimo_Ep = 0.063;

parameter real        relimo_a1 = 0.769;
parameter real        relimo_a2 = 1.83e-8;
parameter real        relimo_c1 = 7.89e12;
parameter real        relimo_b = 4.77;
parameter real        relimo_n_hci = 0.236;
parameter real        relimo_alpha1 = 0.00211;
parameter real        relimo_m1 = 1.18;
parameter real        relimo_lamda_h0 = 4.09E-6;
parameter real        relimo_alpha2 = 0.14;
parameter real        relimo_m2 = 1.18;
parameter real        relimo_lamda_el0 = 2.73E-06;
parameter real        fstat_tau1 = 0.018;
parameter real        fstat_tau2 = 0.018;
parameter real        fstat_tau1tau2 = 1;
parameter real        fstat_tau2tau1 = 1;
parameter real        m_sigma_a = 1;
parameter real        delta_m_sigma_a = 6;
parameter real        m_sigma_b = 1;
parameter real        delta_m_sigma_b = 0.4;
parameter real        vgs_cutoff_HCI = -0.6;
parameter real        m_cutoff_HCI = 1;
parameter real        delta_cutoff_HCI = 0.01;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 0.6336;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 1010 ;
parameter real a0_b0_b0_a1_em = 0.00908 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = 5.34 ;
parameter real a0_b0_a1_a1_em = 0.00395 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -7.39 ;
parameter real a0_b0_a2_a1_em = -0.00369 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 5000 ;
parameter real a0_b0_a3_a1_em = -0.00713 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.842 ;
parameter real a0_b0_p1_a1_em = -0.000441 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.5 ;
parameter real a0_b0_p2_a1_em = 0.000898 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3 ;
parameter real a0_b0_p3_a1_em = -0.00176 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 6 ;
parameter real a0_b0_p4_a1_em = 0 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 24200 ;
parameter real a0_b0_b0_a2_em = 13.9 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -2940 ;
parameter real a0_b0_a1_a2_em = -6.55 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 3460 ;
parameter real a0_b0_a2_a2_em = -17.7 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = 2300 ;
parameter real a0_b0_a3_a2_em = -0.318 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -1.18 ;
parameter real a0_b0_p1_a2_em = 0.00238 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 4 ;
parameter real a0_b0_p2_a2_em = -0.0112 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 6.53 ;
parameter real a0_b0_p3_a2_em = -0.00537 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 6 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 28500 ;
parameter real a0_b0_b0_a3_em = -7.78 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 5110 ;
parameter real a0_b0_a1_a3_em = -12.7 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -1820 ;
parameter real a0_b0_a2_a3_em = 2.79 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -4090 ;
parameter real a0_b0_a3_a3_em = 0.117 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = -1.07 ;
parameter real a0_b0_p1_a3_em = 0.00538 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 0.0341 ;
parameter real a0_b0_p2_a3_em = 0.00216 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.58 ;
parameter real a0_b0_p3_a3_em = 0.00378 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 6 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 12300 ;
parameter real a0_b0_b0_a4_em = 16.8 ;
parameter real b0_a0_b0_a4_em = -0.0175 ;
parameter real a0_a0_b0_a4_em = -0.171 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = -1360 ;
parameter real a0_b0_a1_a4_em = 13.6 ;
parameter real b0_a0_a1_a4_em = -0.000497 ;
parameter real a0_a0_a1_a4_em = 0.203 ;
parameter real b0_b0_a2_a4_em = -3260 ;
parameter real a0_b0_a2_a4_em = 15.5 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0.0318 ;
parameter real b0_b0_a3_a4_em = -6010 ;
parameter real a0_b0_a3_a4_em = 8.15 ;
parameter real b0_a0_a3_a4_em = 0.00471 ;
parameter real a0_a0_a3_a4_em = 0.0382 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = -1.42 ;
parameter real a0_b0_p1_a4_em = 0.000549 ;
parameter real b0_a0_p1_a4_em = 0.55 ;
parameter real a0_a0_p1_a4_em = -0.00166 ;
parameter real b0_b0_p2_a4_em = 5.89 ;
parameter real a0_b0_p2_a4_em = -0.0234 ;
parameter real b0_a0_p2_a4_em = -0.33 ;
parameter real a0_a0_p2_a4_em = 0.0013 ;
parameter real b0_b0_p3_a4_em = 5.73 ;
parameter real a0_b0_p3_a4_em = -0.0103 ;
parameter real b0_a0_p3_a4_em = 0.0191 ;
parameter real a0_a0_p3_a4_em = -5.95E-05 ;
parameter real b0_b0_p4_a4_em = 3.71 ;
parameter real a0_b0_p4_a4_em = 0.00308 ;
parameter real b0_a0_p4_a4_em = 0.00956 ;
parameter real a0_a0_p4_a4_em = 2.32E-06 ;
parameter real b0_b0_b0_p1_em = 2.05 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 22.3 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -1.07 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -2.11 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 1.2 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.3 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.18 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 3.4 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 4.72 ;
parameter real a0_b0_b0_p2_em = 0.00247 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = -0.549 ;
parameter real a0_b0_a1_p2_em = 0.00244 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0.596 ;
parameter real a0_b0_a2_p2_em = -0.00241 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 2.79 ;
parameter real a0_b0_a3_p2_em = -0.0264 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 4.38 ;
parameter real a0_b0_p2_p2_em = -0.00737 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 3.69 ;
parameter real a0_b0_p3_p2_em = -3.90E-05 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 5.19 ;
parameter real a0_b0_p4_p2_em = -0.00243 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 10 ;
parameter real a0_b0_b0_p3_em = 0 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0 ;
parameter real a0_b0_a1_p3_em = 0 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0 ;
parameter real a0_b0_a2_p3_em = 0 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0 ;
parameter real a0_b0_a3_p3_em = 0 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = -1 ;
parameter real a0_b0_p1_p3_em = 0 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.5 ;
parameter real a0_b0_p2_p3_em = 0 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 4 ;
parameter real a0_b0_p3_p3_em = 0 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 6 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 13.4 ;
parameter real a0_b0_b0_p4_em = 0.0028 ;
parameter real b0_a0_b0_p4_em = 0.0163 ;
parameter real a0_a0_b0_p4_em = 3.54E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 1.32 ;
parameter real a0_b0_a1_p4_em = -0.00399 ;
parameter real b0_a0_a1_p4_em = -0.0222 ;
parameter real a0_a0_a1_p4_em = 5.70E-05 ;
parameter real b0_b0_a2_p4_em = 4.36 ;
parameter real a0_b0_a2_p4_em = -0.00947 ;
parameter real b0_a0_a2_p4_em = 0.00211 ;
parameter real a0_a0_a2_p4_em = -2.04E-05 ;
parameter real b0_b0_a3_p4_em = -3.68 ;
parameter real a0_b0_a3_p4_em = 0.00288 ;
parameter real b0_a0_a3_p4_em = -0.0495 ;
parameter real a0_a0_a3_p4_em = 0.000178 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = -0.453 ;
parameter real a0_b0_p1_p4_em = 0.00529 ;
parameter real b0_a0_p1_p4_em = 0.0436 ;
parameter real a0_a0_p1_p4_em = -0.000176 ;
parameter real b0_b0_p2_p4_em = 3.47 ;
parameter real a0_b0_p2_p4_em = -0.0054 ;
parameter real b0_a0_p2_p4_em = -0.0938 ;
parameter real a0_a0_p2_p4_em = 0.00039 ;
parameter real b0_b0_p3_p4_em = 3.64 ;
parameter real a0_b0_p3_p4_em = -0.00292 ;
parameter real b0_a0_p3_p4_em = -0.0362 ;
parameter real a0_a0_p3_p4_em = 0.000122 ;
parameter real b0_b0_p4_p4_em = 4.16 ;
parameter real a0_b0_p4_p4_em = -0.000635 ;
parameter real b0_a0_p4_p4_em = -0.063 ;
parameter real a0_a0_p4_p4_em = 0.000171 ;

parameter real b0_b0_b0_b0_em2 = 0 ;
parameter real a0_b0_b0_b0_em2 = 0 ;
parameter real b0_a0_b0_b0_em2 = 0 ;
parameter real a0_a0_b0_b0_em2 = 0 ;
parameter real b0_b0_a0_b0_em2 = 0 ;
parameter real a0_b0_a0_b0_em2 = 0 ;
parameter real b0_a0_a0_b0_em2 = 0 ;
parameter real a0_a0_a0_b0_em2 = 0 ;
parameter real b0_b0_a1_b0_em2 = 0 ;
parameter real a0_b0_a1_b0_em2 = 0 ;
parameter real b0_a0_a1_b0_em2 = 0 ;
parameter real a0_a0_a1_b0_em2 = 0 ;
parameter real b0_b0_a2_b0_em2 = 0 ;
parameter real a0_b0_a2_b0_em2 = 0 ;
parameter real b0_a0_a2_b0_em2 = 0 ;
parameter real a0_a0_a2_b0_em2 = 0 ;
parameter real b0_b0_a3_b0_em2 = 0 ;
parameter real a0_b0_a3_b0_em2 = 0 ;
parameter real b0_a0_a3_b0_em2 = 0 ;
parameter real a0_a0_a3_b0_em2 = 0 ;
parameter real b0_b0_a4_b0_em2 = 0 ;
parameter real a0_b0_a4_b0_em2 = 0 ;
parameter real b0_a0_a4_b0_em2 = 0 ;
parameter real a0_a0_a4_b0_em2 = 0 ;
parameter real b0_b0_p1_b0_em2 = 0 ;
parameter real a0_b0_p1_b0_em2 = 0 ;
parameter real b0_a0_p1_b0_em2 = 0 ;
parameter real a0_a0_p1_b0_em2 = 0 ;
parameter real b0_b0_p2_b0_em2 = 0 ;
parameter real a0_b0_p2_b0_em2 = 0 ;
parameter real b0_a0_p2_b0_em2 = 0 ;
parameter real a0_a0_p2_b0_em2 = 0 ;
parameter real b0_b0_p3_b0_em2 = 0 ;
parameter real a0_b0_p3_b0_em2 = 0 ;
parameter real b0_a0_p3_b0_em2 = 0 ;
parameter real a0_a0_p3_b0_em2 = 0 ;
parameter real b0_b0_p4_b0_em2 = 0 ;
parameter real a0_b0_p4_b0_em2 = 0 ;
parameter real b0_a0_p4_b0_em2 = 0 ;
parameter real a0_a0_p4_b0_em2 = 0 ;
parameter real b0_b0_b0_a0_em2 = 0 ;
parameter real a0_b0_b0_a0_em2 = 0 ;
parameter real b0_a0_b0_a0_em2 = 0 ;
parameter real a0_a0_b0_a0_em2 = 0 ;
parameter real b0_b0_a0_a0_em2 = 0 ;
parameter real a0_b0_a0_a0_em2 = 0 ;
parameter real b0_a0_a0_a0_em2 = 0 ;
parameter real a0_a0_a0_a0_em2 = 0 ;
parameter real b0_b0_a1_a0_em2 = 0 ;
parameter real a0_b0_a1_a0_em2 = 0 ;
parameter real b0_a0_a1_a0_em2 = 0 ;
parameter real a0_a0_a1_a0_em2 = 0 ;
parameter real b0_b0_a2_a0_em2 = 0 ;
parameter real a0_b0_a2_a0_em2 = 0 ;
parameter real b0_a0_a2_a0_em2 = 0 ;
parameter real a0_a0_a2_a0_em2 = 0 ;
parameter real b0_b0_a3_a0_em2 = 0 ;
parameter real a0_b0_a3_a0_em2 = 0 ;
parameter real b0_a0_a3_a0_em2 = 0 ;
parameter real a0_a0_a3_a0_em2 = 0 ;
parameter real b0_b0_a4_a0_em2 = 0 ;
parameter real a0_b0_a4_a0_em2 = 0 ;
parameter real b0_a0_a4_a0_em2 = 0 ;
parameter real a0_a0_a4_a0_em2 = 0 ;
parameter real b0_b0_p1_a0_em2 = 0 ;
parameter real a0_b0_p1_a0_em2 = 0 ;
parameter real b0_a0_p1_a0_em2 = 0 ;
parameter real a0_a0_p1_a0_em2 = 0 ;
parameter real b0_b0_p2_a0_em2 = 0 ;
parameter real a0_b0_p2_a0_em2 = 0 ;
parameter real b0_a0_p2_a0_em2 = 0 ;
parameter real a0_a0_p2_a0_em2 = 0 ;
parameter real b0_b0_p3_a0_em2 = 0 ;
parameter real a0_b0_p3_a0_em2 = 0 ;
parameter real b0_a0_p3_a0_em2 = 0 ;
parameter real a0_a0_p3_a0_em2 = 0 ;
parameter real b0_b0_p4_a0_em2 = 0 ;
parameter real a0_b0_p4_a0_em2 = 0 ;
parameter real b0_a0_p4_a0_em2 = 0 ;
parameter real a0_a0_p4_a0_em2 = 0 ;
parameter real b0_b0_b0_a1_em2 = 1010 ;
parameter real a0_b0_b0_a1_em2 = 0.00908 ;
parameter real b0_a0_b0_a1_em2 = 0 ;
parameter real a0_a0_b0_a1_em2 = 0 ;
parameter real b0_b0_a0_a1_em2 = 0 ;
parameter real a0_b0_a0_a1_em2 = 0 ;
parameter real b0_a0_a0_a1_em2 = 0 ;
parameter real a0_a0_a0_a1_em2 = 0 ;
parameter real b0_b0_a1_a1_em2 = 5.34 ;
parameter real a0_b0_a1_a1_em2 = 0.00395 ;
parameter real b0_a0_a1_a1_em2 = 0 ;
parameter real a0_a0_a1_a1_em2 = 0 ;
parameter real b0_b0_a2_a1_em2 = -7.39 ;
parameter real a0_b0_a2_a1_em2 = -0.00369 ;
parameter real b0_a0_a2_a1_em2 = 0 ;
parameter real a0_a0_a2_a1_em2 = 0 ;
parameter real b0_b0_a3_a1_em2 = 5000 ;
parameter real a0_b0_a3_a1_em2 = -0.00713 ;
parameter real b0_a0_a3_a1_em2 = 0 ;
parameter real a0_a0_a3_a1_em2 = 0 ;
parameter real b0_b0_a4_a1_em2 = 0 ;
parameter real a0_b0_a4_a1_em2 = 0 ;
parameter real b0_a0_a4_a1_em2 = 0 ;
parameter real a0_a0_a4_a1_em2 = 0 ;
parameter real b0_b0_p1_a1_em2 = 0.842 ;
parameter real a0_b0_p1_a1_em2 = -0.000441 ;
parameter real b0_a0_p1_a1_em2 = 0 ;
parameter real a0_a0_p1_a1_em2 = 0 ;
parameter real b0_b0_p2_a1_em2 = 1.5 ;
parameter real a0_b0_p2_a1_em2 = 0.000898 ;
parameter real b0_a0_p2_a1_em2 = 0 ;
parameter real a0_a0_p2_a1_em2 = 0 ;
parameter real b0_b0_p3_a1_em2 = 3 ;
parameter real a0_b0_p3_a1_em2 = -0.00176 ;
parameter real b0_a0_p3_a1_em2 = 0 ;
parameter real a0_a0_p3_a1_em2 = 0 ;
parameter real b0_b0_p4_a1_em2 = 6 ;
parameter real a0_b0_p4_a1_em2 = 0 ;
parameter real b0_a0_p4_a1_em2 = 0 ;
parameter real a0_a0_p4_a1_em2 = 0 ;
parameter real b0_b0_b0_a2_em2 = 24200 ;
parameter real a0_b0_b0_a2_em2 = 13.9 ;
parameter real b0_a0_b0_a2_em2 = 0 ;
parameter real a0_a0_b0_a2_em2 = 0 ;
parameter real b0_b0_a0_a2_em2 = 0 ;
parameter real a0_b0_a0_a2_em2 = 0 ;
parameter real b0_a0_a0_a2_em2 = 0 ;
parameter real a0_a0_a0_a2_em2 = 0 ;
parameter real b0_b0_a1_a2_em2 = -2940 ;
parameter real a0_b0_a1_a2_em2 = -6.55 ;
parameter real b0_a0_a1_a2_em2 = 0 ;
parameter real a0_a0_a1_a2_em2 = 0 ;
parameter real b0_b0_a2_a2_em2 = 3460 ;
parameter real a0_b0_a2_a2_em2 = -17.7 ;
parameter real b0_a0_a2_a2_em2 = 0 ;
parameter real a0_a0_a2_a2_em2 = 0 ;
parameter real b0_b0_a3_a2_em2 = 2300 ;
parameter real a0_b0_a3_a2_em2 = -0.318 ;
parameter real b0_a0_a3_a2_em2 = 0 ;
parameter real a0_a0_a3_a2_em2 = 0 ;
parameter real b0_b0_a4_a2_em2 = 0 ;
parameter real a0_b0_a4_a2_em2 = 0 ;
parameter real b0_a0_a4_a2_em2 = 0 ;
parameter real a0_a0_a4_a2_em2 = 0 ;
parameter real b0_b0_p1_a2_em2 = -1.18 ;
parameter real a0_b0_p1_a2_em2 = 0.00238 ;
parameter real b0_a0_p1_a2_em2 = 0 ;
parameter real a0_a0_p1_a2_em2 = 0 ;
parameter real b0_b0_p2_a2_em2 = 4 ;
parameter real a0_b0_p2_a2_em2 = -0.0112 ;
parameter real b0_a0_p2_a2_em2 = 0 ;
parameter real a0_a0_p2_a2_em2 = 0 ;
parameter real b0_b0_p3_a2_em2 = 6.53 ;
parameter real a0_b0_p3_a2_em2 = -0.00537 ;
parameter real b0_a0_p3_a2_em2 = 0 ;
parameter real a0_a0_p3_a2_em2 = 0 ;
parameter real b0_b0_p4_a2_em2 = 6 ;
parameter real a0_b0_p4_a2_em2 = 0 ;
parameter real b0_a0_p4_a2_em2 = 0 ;
parameter real a0_a0_p4_a2_em2 = 0 ;
parameter real b0_b0_b0_a3_em2 = 28500 ;
parameter real a0_b0_b0_a3_em2 = -7.78 ;
parameter real b0_a0_b0_a3_em2 = 0 ;
parameter real a0_a0_b0_a3_em2 = 0 ;
parameter real b0_b0_a0_a3_em2 = 0 ;
parameter real a0_b0_a0_a3_em2 = 0 ;
parameter real b0_a0_a0_a3_em2 = 0 ;
parameter real a0_a0_a0_a3_em2 = 0 ;
parameter real b0_b0_a1_a3_em2 = 5110 ;
parameter real a0_b0_a1_a3_em2 = -12.7 ;
parameter real b0_a0_a1_a3_em2 = 0 ;
parameter real a0_a0_a1_a3_em2 = 0 ;
parameter real b0_b0_a2_a3_em2 = -1820 ;
parameter real a0_b0_a2_a3_em2 = 2.79 ;
parameter real b0_a0_a2_a3_em2 = 0 ;
parameter real a0_a0_a2_a3_em2 = 0 ;
parameter real b0_b0_a3_a3_em2 = -4090 ;
parameter real a0_b0_a3_a3_em2 = 0.117 ;
parameter real b0_a0_a3_a3_em2 = 0 ;
parameter real a0_a0_a3_a3_em2 = 0 ;
parameter real b0_b0_a4_a3_em2 = 0 ;
parameter real a0_b0_a4_a3_em2 = 0 ;
parameter real b0_a0_a4_a3_em2 = 0 ;
parameter real a0_a0_a4_a3_em2 = 0 ;
parameter real b0_b0_p1_a3_em2 = -1.07 ;
parameter real a0_b0_p1_a3_em2 = 0.00538 ;
parameter real b0_a0_p1_a3_em2 = 0 ;
parameter real a0_a0_p1_a3_em2 = 0 ;
parameter real b0_b0_p2_a3_em2 = 0.0341 ;
parameter real a0_b0_p2_a3_em2 = 0.00216 ;
parameter real b0_a0_p2_a3_em2 = 0 ;
parameter real a0_a0_p2_a3_em2 = 0 ;
parameter real b0_b0_p3_a3_em2 = 1.58 ;
parameter real a0_b0_p3_a3_em2 = 0.00378 ;
parameter real b0_a0_p3_a3_em2 = 0 ;
parameter real a0_a0_p3_a3_em2 = 0 ;
parameter real b0_b0_p4_a3_em2 = 6 ;
parameter real a0_b0_p4_a3_em2 = 0 ;
parameter real b0_a0_p4_a3_em2 = 0 ;
parameter real a0_a0_p4_a3_em2 = 0 ;
parameter real b0_b0_b0_a4_em2 = 12300 ;
parameter real a0_b0_b0_a4_em2 = 16.8 ;
parameter real b0_a0_b0_a4_em2 = -0.0175 ;
parameter real a0_a0_b0_a4_em2 = -0.171 ;
parameter real b0_b0_a0_a4_em2 = 0 ;
parameter real a0_b0_a0_a4_em2 = 0 ;
parameter real b0_a0_a0_a4_em2 = 0 ;
parameter real a0_a0_a0_a4_em2 = 0 ;
parameter real b0_b0_a1_a4_em2 = -1360 ;
parameter real a0_b0_a1_a4_em2 = 13.6 ;
parameter real b0_a0_a1_a4_em2 = -0.000497 ;
parameter real a0_a0_a1_a4_em2 = 0.203 ;
parameter real b0_b0_a2_a4_em2 = -3260 ;
parameter real a0_b0_a2_a4_em2 = 15.5 ;
parameter real b0_a0_a2_a4_em2 = 0 ;
parameter real a0_a0_a2_a4_em2 = 0.0318 ;
parameter real b0_b0_a3_a4_em2 = -6010 ;
parameter real a0_b0_a3_a4_em2 = 8.15 ;
parameter real b0_a0_a3_a4_em2 = 0.00471 ;
parameter real a0_a0_a3_a4_em2 = 0.0382 ;
parameter real b0_b0_a4_a4_em2 = 0 ;
parameter real a0_b0_a4_a4_em2 = 0 ;
parameter real b0_a0_a4_a4_em2 = 0 ;
parameter real a0_a0_a4_a4_em2 = 0 ;
parameter real b0_b0_p1_a4_em2 = -1.42 ;
parameter real a0_b0_p1_a4_em2 = 0.000549 ;
parameter real b0_a0_p1_a4_em2 = 0.55 ;
parameter real a0_a0_p1_a4_em2 = -0.00166 ;
parameter real b0_b0_p2_a4_em2 = 5.89 ;
parameter real a0_b0_p2_a4_em2 = -0.0234 ;
parameter real b0_a0_p2_a4_em2 = -0.33 ;
parameter real a0_a0_p2_a4_em2 = 0.0013 ;
parameter real b0_b0_p3_a4_em2 = 5.73 ;
parameter real a0_b0_p3_a4_em2 = -0.0103 ;
parameter real b0_a0_p3_a4_em2 = 0.0191 ;
parameter real a0_a0_p3_a4_em2 = -5.95E-05 ;
parameter real b0_b0_p4_a4_em2 = 3.71 ;
parameter real a0_b0_p4_a4_em2 = 0.00308 ;
parameter real b0_a0_p4_a4_em2 = 0.00956 ;
parameter real a0_a0_p4_a4_em2 = 2.32E-06 ;
parameter real b0_b0_b0_p1_em2 = 2.05 ;
parameter real a0_b0_b0_p1_em2 = 0 ;
parameter real b0_a0_b0_p1_em2 = 0 ;
parameter real a0_a0_b0_p1_em2 = 0 ;
parameter real b0_b0_a0_p1_em2 = 0 ;
parameter real a0_b0_a0_p1_em2 = 0 ;
parameter real b0_a0_a0_p1_em2 = 0 ;
parameter real a0_a0_a0_p1_em2 = 0 ;
parameter real b0_b0_a1_p1_em2 = 22.3 ;
parameter real a0_b0_a1_p1_em2 = 0 ;
parameter real b0_a0_a1_p1_em2 = 0 ;
parameter real a0_a0_a1_p1_em2 = 0 ;
parameter real b0_b0_a2_p1_em2 = -1.07 ;
parameter real a0_b0_a2_p1_em2 = 0 ;
parameter real b0_a0_a2_p1_em2 = 0 ;
parameter real a0_a0_a2_p1_em2 = 0 ;
parameter real b0_b0_a3_p1_em2 = -2.11 ;
parameter real a0_b0_a3_p1_em2 = 0 ;
parameter real b0_a0_a3_p1_em2 = 0 ;
parameter real a0_a0_a3_p1_em2 = 0 ;
parameter real b0_b0_a4_p1_em2 = 0 ;
parameter real a0_b0_a4_p1_em2 = 0 ;
parameter real b0_a0_a4_p1_em2 = 0 ;
parameter real a0_a0_a4_p1_em2 = 0 ;
parameter real b0_b0_p1_p1_em2 = 1.2 ;
parameter real a0_b0_p1_p1_em2 = 0 ;
parameter real b0_a0_p1_p1_em2 = 0 ;
parameter real a0_a0_p1_p1_em2 = 0 ;
parameter real b0_b0_p2_p1_em2 = 1.3 ;
parameter real a0_b0_p2_p1_em2 = 0 ;
parameter real b0_a0_p2_p1_em2 = 0 ;
parameter real a0_a0_p2_p1_em2 = 0 ;
parameter real b0_b0_p3_p1_em2 = 2.18 ;
parameter real a0_b0_p3_p1_em2 = 0 ;
parameter real b0_a0_p3_p1_em2 = 0 ;
parameter real a0_a0_p3_p1_em2 = 0 ;
parameter real b0_b0_p4_p1_em2 = 3.4 ;
parameter real a0_b0_p4_p1_em2 = 0 ;
parameter real b0_a0_p4_p1_em2 = 0 ;
parameter real a0_a0_p4_p1_em2 = 0 ;
parameter real b0_b0_b0_p2_em2 = 4.72 ;
parameter real a0_b0_b0_p2_em2 = 0.00247 ;
parameter real b0_a0_b0_p2_em2 = 0 ;
parameter real a0_a0_b0_p2_em2 = 0 ;
parameter real b0_b0_a0_p2_em2 = 0 ;
parameter real a0_b0_a0_p2_em2 = 0 ;
parameter real b0_a0_a0_p2_em2 = 0 ;
parameter real a0_a0_a0_p2_em2 = 0 ;
parameter real b0_b0_a1_p2_em2 = -0.549 ;
parameter real a0_b0_a1_p2_em2 = 0.00244 ;
parameter real b0_a0_a1_p2_em2 = 0 ;
parameter real a0_a0_a1_p2_em2 = 0 ;
parameter real b0_b0_a2_p2_em2 = 0.596 ;
parameter real a0_b0_a2_p2_em2 = -0.00241 ;
parameter real b0_a0_a2_p2_em2 = 0 ;
parameter real a0_a0_a2_p2_em2 = 0 ;
parameter real b0_b0_a3_p2_em2 = 2.79 ;
parameter real a0_b0_a3_p2_em2 = -0.0264 ;
parameter real b0_a0_a3_p2_em2 = 0 ;
parameter real a0_a0_a3_p2_em2 = 0 ;
parameter real b0_b0_a4_p2_em2 = 0 ;
parameter real a0_b0_a4_p2_em2 = 0 ;
parameter real b0_a0_a4_p2_em2 = 0 ;
parameter real a0_a0_a4_p2_em2 = 0 ;
parameter real b0_b0_p1_p2_em2 = -1 ;
parameter real a0_b0_p1_p2_em2 = 0 ;
parameter real b0_a0_p1_p2_em2 = 0 ;
parameter real a0_a0_p1_p2_em2 = 0 ;
parameter real b0_b0_p2_p2_em2 = 4.38 ;
parameter real a0_b0_p2_p2_em2 = -0.00737 ;
parameter real b0_a0_p2_p2_em2 = 0 ;
parameter real a0_a0_p2_p2_em2 = 0 ;
parameter real b0_b0_p3_p2_em2 = 3.69 ;
parameter real a0_b0_p3_p2_em2 = -3.90E-05 ;
parameter real b0_a0_p3_p2_em2 = 0 ;
parameter real a0_a0_p3_p2_em2 = 0 ;
parameter real b0_b0_p4_p2_em2 = 5.19 ;
parameter real a0_b0_p4_p2_em2 = -0.00243 ;
parameter real b0_a0_p4_p2_em2 = 0 ;
parameter real a0_a0_p4_p2_em2 = 0 ;
parameter real b0_b0_b0_p3_em2 = 10 ;
parameter real a0_b0_b0_p3_em2 = 0 ;
parameter real b0_a0_b0_p3_em2 = 0 ;
parameter real a0_a0_b0_p3_em2 = 0 ;
parameter real b0_b0_a0_p3_em2 = 0 ;
parameter real a0_b0_a0_p3_em2 = 0 ;
parameter real b0_a0_a0_p3_em2 = 0 ;
parameter real a0_a0_a0_p3_em2 = 0 ;
parameter real b0_b0_a1_p3_em2 = 0 ;
parameter real a0_b0_a1_p3_em2 = 0 ;
parameter real b0_a0_a1_p3_em2 = 0 ;
parameter real a0_a0_a1_p3_em2 = 0 ;
parameter real b0_b0_a2_p3_em2 = 0 ;
parameter real a0_b0_a2_p3_em2 = 0 ;
parameter real b0_a0_a2_p3_em2 = 0 ;
parameter real a0_a0_a2_p3_em2 = 0 ;
parameter real b0_b0_a3_p3_em2 = 0 ;
parameter real a0_b0_a3_p3_em2 = 0 ;
parameter real b0_a0_a3_p3_em2 = 0 ;
parameter real a0_a0_a3_p3_em2 = 0 ;
parameter real b0_b0_a4_p3_em2 = 0 ;
parameter real a0_b0_a4_p3_em2 = 0 ;
parameter real b0_a0_a4_p3_em2 = 0 ;
parameter real a0_a0_a4_p3_em2 = 0 ;
parameter real b0_b0_p1_p3_em2 = -1 ;
parameter real a0_b0_p1_p3_em2 = 0 ;
parameter real b0_a0_p1_p3_em2 = 0 ;
parameter real a0_a0_p1_p3_em2 = 0 ;
parameter real b0_b0_p2_p3_em2 = 2.5 ;
parameter real a0_b0_p2_p3_em2 = 0 ;
parameter real b0_a0_p2_p3_em2 = 0 ;
parameter real a0_a0_p2_p3_em2 = 0 ;
parameter real b0_b0_p3_p3_em2 = 4 ;
parameter real a0_b0_p3_p3_em2 = 0 ;
parameter real b0_a0_p3_p3_em2 = 0 ;
parameter real a0_a0_p3_p3_em2 = 0 ;
parameter real b0_b0_p4_p3_em2 = 6 ;
parameter real a0_b0_p4_p3_em2 = 0 ;
parameter real b0_a0_p4_p3_em2 = 0 ;
parameter real a0_a0_p4_p3_em2 = 0 ;
parameter real b0_b0_b0_p4_em2 = 13.4 ;
parameter real a0_b0_b0_p4_em2 = 0.0028 ;
parameter real b0_a0_b0_p4_em2 = 0.0163 ;
parameter real a0_a0_b0_p4_em2 = 3.54E-05 ;
parameter real b0_b0_a0_p4_em2 = 0 ;
parameter real a0_b0_a0_p4_em2 = 0 ;
parameter real b0_a0_a0_p4_em2 = 0 ;
parameter real a0_a0_a0_p4_em2 = 0 ;
parameter real b0_b0_a1_p4_em2 = 1.32 ;
parameter real a0_b0_a1_p4_em2 = -0.00399 ;
parameter real b0_a0_a1_p4_em2 = -0.0222 ;
parameter real a0_a0_a1_p4_em2 = 5.70E-05 ;
parameter real b0_b0_a2_p4_em2 = 4.36 ;
parameter real a0_b0_a2_p4_em2 = -0.00947 ;
parameter real b0_a0_a2_p4_em2 = 0.00211 ;
parameter real a0_a0_a2_p4_em2 = -2.04E-05 ;
parameter real b0_b0_a3_p4_em2 = -3.68 ;
parameter real a0_b0_a3_p4_em2 = 0.00288 ;
parameter real b0_a0_a3_p4_em2 = -0.0495 ;
parameter real a0_a0_a3_p4_em2 = 0.000178 ;
parameter real b0_b0_a4_p4_em2 = 0 ;
parameter real a0_b0_a4_p4_em2 = 0 ;
parameter real b0_a0_a4_p4_em2 = 0 ;
parameter real a0_a0_a4_p4_em2 = 0 ;
parameter real b0_b0_p1_p4_em2 = -0.453 ;
parameter real a0_b0_p1_p4_em2 = 0.00529 ;
parameter real b0_a0_p1_p4_em2 = 0.0436 ;
parameter real a0_a0_p1_p4_em2 = -0.000176 ;
parameter real b0_b0_p2_p4_em2 = 3.47 ;
parameter real a0_b0_p2_p4_em2 = -0.0054 ;
parameter real b0_a0_p2_p4_em2 = -0.0938 ;
parameter real a0_a0_p2_p4_em2 = 0.00039 ;
parameter real b0_b0_p3_p4_em2 = 3.64 ;
parameter real a0_b0_p3_p4_em2 = -0.00292 ;
parameter real b0_a0_p3_p4_em2 = -0.0362 ;
parameter real a0_a0_p3_p4_em2 = 0.000122 ;
parameter real b0_b0_p4_p4_em2 = 4.16 ;
parameter real a0_b0_p4_p4_em2 = -0.000635 ;
parameter real b0_a0_p4_p4_em2 = -0.063 ;
parameter real a0_a0_p4_p4_em2 = 0.000171 ;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vsub, id, vdsmax, vgsmax;
real delta_damage3, last_delta_damage3, damage3;
real dt, last_abstime;  
real delta_idsat;
real delta_damage2_1_1,delta_damage2_1_2,damage2_1_1,damage2_1_2;
real delta_damage2_2_1,delta_damage2_2_2,damage2_2_1,damage2_2_2;
real delta_damage2_3_1,delta_damage2_3_2,damage2_3_1,damage2_3_2,last_delta_damage2_3_1,last_delta_damage2_3_2;
real delta_damage1_1_1,delta_damage1_1_2,damage1_1_1,damage1_1_2;
real delta_damage1_2_1,delta_damage1_2_2,damage1_2_1,damage1_2_2;
real delta_damage1_3_1,delta_damage1_3_2,damage1_3_1,damage1_3_2,last_delta_damage1_3_1,last_delta_damage1_3_2;
real lamda_h,lamda_el,ron_50p,s_50p,fa,ron_fa,s_fa,fstat1,fstat2;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;

real b0_b0_b0_em2, a0_b0_b0_em2, b0_a0_b0_em2, a0_a0_b0_em2, b0_a1_b0_em2;
real a0_a1_b0_em2, b0_a2_b0_em2, a0_a2_b0_em2, b0_a3_b0_em2, a0_a3_b0_em2;
real b0_a4_b0_em2, a0_a4_b0_em2, b0_p1_b0_em2, a0_p1_b0_em2, b0_p2_b0_em2;
real a0_p2_b0_em2, b0_p3_b0_em2, a0_p3_b0_em2, b0_p4_b0_em2, a0_p4_b0_em2;
real b0_b0_a0_em2, a0_b0_a0_em2, b0_a0_a0_em2, a0_a0_a0_em2, b0_a1_a0_em2;
real a0_a1_a0_em2, b0_a2_a0_em2, a0_a2_a0_em2, b0_a3_a0_em2, a0_a3_a0_em2;
real b0_a4_a0_em2, a0_a4_a0_em2, b0_p1_a0_em2, a0_p1_a0_em2, b0_p2_a0_em2;
real a0_p2_a0_em2, b0_p3_a0_em2, a0_p3_a0_em2, b0_p4_a0_em2, a0_p4_a0_em2;
real b0_b0_a1_em2, a0_b0_a1_em2, b0_a0_a1_em2, a0_a0_a1_em2, b0_a1_a1_em2;
real a0_a1_a1_em2, b0_a2_a1_em2, a0_a2_a1_em2, b0_a3_a1_em2, a0_a3_a1_em2;
real b0_a4_a1_em2, a0_a4_a1_em2, b0_p1_a1_em2, a0_p1_a1_em2, b0_p2_a1_em2;
real a0_p2_a1_em2, b0_p3_a1_em2, a0_p3_a1_em2, b0_p4_a1_em2, a0_p4_a1_em2;
real b0_b0_a2_em2, a0_b0_a2_em2, b0_a0_a2_em2, a0_a0_a2_em2, b0_a1_a2_em2;
real a0_a1_a2_em2, b0_a2_a2_em2, a0_a2_a2_em2, b0_a3_a2_em2, a0_a3_a2_em2;
real b0_a4_a2_em2, a0_a4_a2_em2, b0_p1_a2_em2, a0_p1_a2_em2, b0_p2_a2_em2;
real a0_p2_a2_em2, b0_p3_a2_em2, a0_p3_a2_em2, b0_p4_a2_em2, a0_p4_a2_em2;
real b0_b0_a3_em2, a0_b0_a3_em2, b0_a0_a3_em2, a0_a0_a3_em2, b0_a1_a3_em2;
real a0_a1_a3_em2, b0_a2_a3_em2, a0_a2_a3_em2, b0_a3_a3_em2, a0_a3_a3_em2;
real b0_a4_a3_em2, a0_a4_a3_em2, b0_p1_a3_em2, a0_p1_a3_em2, b0_p2_a3_em2;
real a0_p2_a3_em2, b0_p3_a3_em2, a0_p3_a3_em2, b0_p4_a3_em2, a0_p4_a3_em2;
real b0_b0_a4_em2, a0_b0_a4_em2, b0_a0_a4_em2, a0_a0_a4_em2, b0_a1_a4_em2;
real a0_a1_a4_em2, b0_a2_a4_em2, a0_a2_a4_em2, b0_a3_a4_em2, a0_a3_a4_em2;
real b0_a4_a4_em2, a0_a4_a4_em2, b0_p1_a4_em2, a0_p1_a4_em2, b0_p2_a4_em2;
real a0_p2_a4_em2, b0_p3_a4_em2, a0_p3_a4_em2, b0_p4_a4_em2, a0_p4_a4_em2;
real b0_b0_p1_em2, a0_b0_p1_em2, b0_a0_p1_em2, a0_a0_p1_em2, b0_a1_p1_em2;
real a0_a1_p1_em2, b0_a2_p1_em2, a0_a2_p1_em2, b0_a3_p1_em2, a0_a3_p1_em2;
real b0_a4_p1_em2, a0_a4_p1_em2, b0_p1_p1_em2, a0_p1_p1_em2, b0_p2_p1_em2;
real a0_p2_p1_em2, b0_p3_p1_em2, a0_p3_p1_em2, b0_p4_p1_em2, a0_p4_p1_em2;
real b0_b0_p2_em2, a0_b0_p2_em2, b0_a0_p2_em2, a0_a0_p2_em2, b0_a1_p2_em2;
real a0_a1_p2_em2, b0_a2_p2_em2, a0_a2_p2_em2, b0_a3_p2_em2, a0_a3_p2_em2;
real b0_a4_p2_em2, a0_a4_p2_em2, b0_p1_p2_em2, a0_p1_p2_em2, b0_p2_p2_em2;
real a0_p2_p2_em2, b0_p3_p2_em2, a0_p3_p2_em2, b0_p4_p2_em2, a0_p4_p2_em2;
real b0_b0_p3_em2, a0_b0_p3_em2, b0_a0_p3_em2, a0_a0_p3_em2, b0_a1_p3_em2;
real a0_a1_p3_em2, b0_a2_p3_em2, a0_a2_p3_em2, b0_a3_p3_em2, a0_a3_p3_em2;
real b0_a4_p3_em2, a0_a4_p3_em2, b0_p1_p3_em2, a0_p1_p3_em2, b0_p2_p3_em2;
real a0_p2_p3_em2, b0_p3_p3_em2, a0_p3_p3_em2, b0_p4_p3_em2, a0_p4_p3_em2;
real b0_b0_p4_em2, a0_b0_p4_em2, b0_a0_p4_em2, a0_a0_p4_em2, b0_a1_p4_em2;
real a0_a1_p4_em2, b0_a2_p4_em2, a0_a2_p4_em2, b0_a3_p4_em2, a0_a3_p4_em2;
real b0_a4_p4_em2, a0_a4_p4_em2, b0_p1_p4_em2, a0_p1_p4_em2, b0_p2_p4_em2;
real a0_p2_p4_em2, b0_p3_p4_em2, a0_p3_p4_em2, b0_p4_p4_em2, a0_p4_p4_em2;
real b0_b0_em2, a0_b0_em2, a1_b0_em2, a2_b0_em2, a3_b0_em2, a4_b0_em2, p1_b0_em2;
real p2_b0_em2, p3_b0_em2, p4_b0_em2, b0_a0_em2, a0_a0_em2, a1_a0_em2, a2_a0_em2;
real a3_a0_em2, a4_a0_em2, p1_a0_em2, p2_a0_em2, p3_a0_em2, p4_a0_em2, b0_a1_em2;
real a0_a1_em2, a1_a1_em2, a2_a1_em2, a3_a1_em2, a4_a1_em2, p1_a1_em2, p2_a1_em2;
real p3_a1_em2, p4_a1_em2, b0_a2_em2, a0_a2_em2, a1_a2_em2, a2_a2_em2, a3_a2_em2;
real a4_a2_em2, p1_a2_em2, p2_a2_em2, p3_a2_em2, p4_a2_em2, b0_a3_em2, a0_a3_em2;
real a1_a3_em2, a2_a3_em2, a3_a3_em2, a4_a3_em2, p1_a3_em2, p2_a3_em2, p3_a3_em2;
real p4_a3_em2, b0_a4_em2, a0_a4_em2, a1_a4_em2, a2_a4_em2, a3_a4_em2, a4_a4_em2;
real p1_a4_em2, p2_a4_em2, p3_a4_em2, p4_a4_em2, b0_p1_em2, a0_p1_em2, a1_p1_em2;
real a2_p1_em2, a3_p1_em2, a4_p1_em2, p1_p1_em2, p2_p1_em2, p3_p1_em2, p4_p1_em2;
real b0_p2_em2, a0_p2_em2, a1_p2_em2, a2_p2_em2, a3_p2_em2, a4_p2_em2, p1_p2_em2;
real p2_p2_em2, p3_p2_em2, p4_p2_em2, b0_p3_em2, a0_p3_em2, a1_p3_em2, a2_p3_em2;
real a3_p3_em2, a4_p3_em2, p1_p3_em2, p2_p3_em2, p3_p3_em2, p4_p3_em2, b0_p4_em2;
real a0_p4_em2, a1_p4_em2, a2_p4_em2, a3_p4_em2, a4_p4_em2, p1_p4_em2, p2_p4_em2;
real p3_p4_em2, p4_p4_em2;
real b0_em2, a0_em2, a1_em2, a2_em2, a3_em2, a4_em2, p1_em2, p2_em2, p3_em2, p4_em2, em2;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vsub = V(sub)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			if(vsub > 0 && vsub < 1e-6) begin
				vsub = 1e-6;
			end
			if(vsub < 0 && vsub > -1e-6) begin
				vsub = -1e-6;
			end
			
			id = abs($simprobe(relimo_probe_name, "ide"));
			
			id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));
			
			if (id == 0) begin
				id = id+1e-15;
			end
			
			
			
			delta_damage1_3_1 = 0;
			delta_damage1_3_2 = 0;
			delta_damage1_2_1 = 0;
			delta_damage1_2_2 = 0;
			delta_damage1_1_1 = 0;
			delta_damage1_1_2 = 0;
			delta_damage2_3_1 = 0;
			delta_damage2_3_2 = 0;
			delta_damage2_2_1 = 0;
			delta_damage2_2_2 = 0;
			delta_damage2_1_1 = 0;
			delta_damage2_1_2 = 0;
			delta_damage3 = 0;
			
			// off state HCI.
			if(vds < 0) begin	
				if(relimo_beta1*abs(vds) > 490) begin
					delta_damage1_3_1 = 0.0;
				end else begin				
					delta_damage1_3_1 = 1.0/relimo_alpha1_off*(exp(relimo_beta1*abs(vds))-1.0)*exp(-1.0*relimo_ea1/(relimo_kb*$temperature));
				end
				if(relimo_beta2*abs(vds) > 490) begin
					delta_damage1_3_2 = 0.0;
				end else begin				
					delta_damage1_3_2 = 1.0/relimo_alpha2_off*(exp(relimo_beta2*abs(vds))-1.0)*exp(-1.0*relimo_ea2/(relimo_kb*$temperature));
				end				
				
				// There is no off-state value for this device. To keep above lines for not reporting warning. 
				delta_damage1_3_1 = 0.0;	
				delta_damage1_3_2 = 0.0;
			end
			
			// HCIHV
			`EM($temperature, -1.0*vgs, -1.0*vds, vsub)
			`EM2($temperature, -1.0*vgs, -1.0*vds, vsub)
			if (em != 0) begin
				lamda_h = relimo_lamda_h0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if(relimo_Feb_h/(em*lamda_h) > 490) begin
					delta_damage2_3_1 = 0.0;
				end else begin
					delta_damage2_3_1 = 1.0/(relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb_h/(em*lamda_h)*exp(relimo_Feb_h/(em*lamda_h)));
				end
			end
			if (em2 != 0) begin
				lamda_el = relimo_lamda_el0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if (relimo_Feb_el/(em2*lamda_el) > 490) begin
					delta_damage2_3_2 = 0.0;
				end else begin
					delta_damage2_3_2 = 1.0/(relimo_alpha2*pow(w*1e-6/id,relimo_m2)*relimo_Feb_el/(em2*lamda_el)*exp(relimo_Feb_el/(em2*lamda_el)));
				end
			end
			 
			// High Vgs HCI.
			if(vds < 0 && vgs < 0) begin
				if((relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))) > 490) begin
					delta_damage3 = 0.0;
				end else begin	
					delta_damage3 = 1.0/(relimo_fstat3*relimo_alpha3*pow(w*1e-6/id,relimo_beta3)*pow(abs(vgs),-1.0*relimo_gama3)*pow(abs(vds),-1.0*relimo_eps3)*exp(-1.0*relimo_eta3*abs(vsub))*exp(relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))));
				end
			end
			
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				
				// off stat damages
				damage1_3_1 = damage1_3_1 + dt/2.0*(delta_damage1_3_1 + last_delta_damage1_3_1);
				damage1_3_2 = damage1_3_2 + dt/2.0*(delta_damage1_3_2 + last_delta_damage1_3_2);


				// HCIHV damages

				damage2_3_1 = damage2_3_1 + dt/2.0*(delta_damage2_3_1 + last_delta_damage2_3_1);
				damage2_3_2 = damage2_3_2 + dt/2.0*(delta_damage2_3_2 + last_delta_damage2_3_2);
	
				
				// High Vgs HCI.
				damage3 = damage3 + dt/2.0*(delta_damage3 + last_delta_damage3);
				
				last_delta_damage1_3_1 = delta_damage1_3_1;
				last_delta_damage1_3_2 = delta_damage1_3_2;
				last_delta_damage2_3_1 = delta_damage2_3_1;
				last_delta_damage2_3_2 = delta_damage2_3_2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	$display("Parameter %M in device %e, %e, %e, %e", em, em2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, vgs, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*V(sub)), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1_3_1 = damage1_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage1_3_2 = damage1_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_1 = damage2_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_2 = damage2_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1_3_1 = 0;
					damage1_3_2 = 0;
					damage2_3_1 = 0;
					damage2_3_2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1_3_1 = delta_damage1_3_1*relimo_aging_time*3600;
				damage1_3_2 = delta_damage1_3_2*relimo_aging_time*3600;
				damage2_3_1 = delta_damage2_3_1*relimo_aging_time*3600;
				damage2_3_2 = delta_damage2_3_2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
			end				

			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_b_off)+pow(delta_m_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_a_off)+pow(delta_m_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

