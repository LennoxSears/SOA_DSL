real a0_a1_a0_em2, b0_a2_a0_em2, a0_a2_a0_em2, b0_a3_a0_em2, a0_a3_a0_em2;
real b0_a4_a0_em2, a0_a4_a0_em2, b0_p1_a0_em2, a0_p1_a0_em2, b0_p2_a0_em2;
real a0_p2_a0_em2, b0_p3_a0_em2, a0_p3_a0_em2, b0_p4_a0_em2, a0_p4_a0_em2;
real b0_b0_a1_em2, a0_b0_a1_em2, b0_a0_a1_em2, a0_a0_a1_em2, b0_a1_a1_em2;
real a0_a1_a1_em2, b0_a2_a1_em2, a0_a2_a1_em2, b0_a3_a1_em2, a0_a3_a1_em2;
real b0_a4_a1_em2, a0_a4_a1_em2, b0_p1_a1_em2, a0_p1_a1_em2, b0_p2_a1_em2;
real a0_p2_a1_em2, b0_p3_a1_em2, a0_p3_a1_em2, b0_p4_a1_em2, a0_p4_a1_em2;
real b0_b0_a2_em2, a0_b0_a2_em2, b0_a0_a2_em2, a0_a0_a2_em2, b0_a1_a2_em2;
real a0_a1_a2_em2, b0_a2_a2_em2, a0_a2_a2_em2, b0_a3_a2_em2, a0_a3_a2_em2;
real b0_a4_a2_em2, a0_a4_a2_em2, b0_p1_a2_em2, a0_p1_a2_em2, b0_p2_a2_em2;
real a0_p2_a2_em2, b0_p3_a2_em2, a0_p3_a2_em2, b0_p4_a2_em2, a0_p4_a2_em2;
real b0_b0_a3_em2, a0_b0_a3_em2, b0_a0_a3_em2, a0_a0_a3_em2, b0_a1_a3_em2;
real a0_a1_a3_em2, b0_a2_a3_em2, a0_a2_a3_em2, b0_a3_a3_em2, a0_a3_a3_em2;
real b0_a4_a3_em2, a0_a4_a3_em2, b0_p1_a3_em2, a0_p1_a3_em2, b0_p2_a3_em2;
real a0_p2_a3_em2, b0_p3_a3_em2, a0_p3_a3_em2, b0_p4_a3_em2, a0_p4_a3_em2;
real b0_b0_a4_em2, a0_b0_a4_em2, b0_a0_a4_em2, a0_a0_a4_em2, b0_a1_a4_em2;
real a0_a1_a4_em2, b0_a2_a4_em2, a0_a2_a4_em2, b0_a3_a4_em2, a0_a3_a4_em2;
real b0_a4_a4_em2, a0_a4_a4_em2, b0_p1_a4_em2, a0_p1_a4_em2, b0_p2_a4_em2;
real a0_p2_a4_em2, b0_p3_a4_em2, a0_p3_a4_em2, b0_p4_a4_em2, a0_p4_a4_em2;
real b0_b0_p1_em2, a0_b0_p1_em2, b0_a0_p1_em2, a0_a0_p1_em2, b0_a1_p1_em2;
real a0_a1_p1_em2, b0_a2_p1_em2, a0_a2_p1_em2, b0_a3_p1_em2, a0_a3_p1_em2;
real b0_a4_p1_em2, a0_a4_p1_em2, b0_p1_p1_em2, a0_p1_p1_em2, b0_p2_p1_em2;
real a0_p2_p1_em2, b0_p3_p1_em2, a0_p3_p1_em2, b0_p4_p1_em2, a0_p4_p1_em2;
real b0_b0_p2_em2, a0_b0_p2_em2, b0_a0_p2_em2, a0_a0_p2_em2, b0_a1_p2_em2;
real a0_a1_p2_em2, b0_a2_p2_em2, a0_a2_p2_em2, b0_a3_p2_em2, a0_a3_p2_em2;
real b0_a4_p2_em2, a0_a4_p2_em2, b0_p1_p2_em2, a0_p1_p2_em2, b0_p2_p2_em2;
real a0_p2_p2_em2, b0_p3_p2_em2, a0_p3_p2_em2, b0_p4_p2_em2, a0_p4_p2_em2;
real b0_b0_p3_em2, a0_b0_p3_em2, b0_a0_p3_em2, a0_a0_p3_em2, b0_a1_p3_em2;
real a0_a1_p3_em2, b0_a2_p3_em2, a0_a2_p3_em2, b0_a3_p3_em2, a0_a3_p3_em2;
real b0_a4_p3_em2, a0_a4_p3_em2, b0_p1_p3_em2, a0_p1_p3_em2, b0_p2_p3_em2;
real a0_p2_p3_em2, b0_p3_p3_em2, a0_p3_p3_em2, b0_p4_p3_em2, a0_p4_p3_em2;
real b0_b0_p4_em2, a0_b0_p4_em2, b0_a0_p4_em2, a0_a0_p4_em2, b0_a1_p4_em2;
real a0_a1_p4_em2, b0_a2_p4_em2, a0_a2_p4_em2, b0_a3_p4_em2, a0_a3_p4_em2;
real b0_a4_p4_em2, a0_a4_p4_em2, b0_p1_p4_em2, a0_p1_p4_em2, b0_p2_p4_em2;
real a0_p2_p4_em2, b0_p3_p4_em2, a0_p3_p4_em2, b0_p4_p4_em2, a0_p4_p4_em2;
real b0_b0_em2, a0_b0_em2, a1_b0_em2, a2_b0_em2, a3_b0_em2, a4_b0_em2, p1_b0_em2;
real p2_b0_em2, p3_b0_em2, p4_b0_em2, b0_a0_em2, a0_a0_em2, a1_a0_em2, a2_a0_em2;
real a3_a0_em2, a4_a0_em2, p1_a0_em2, p2_a0_em2, p3_a0_em2, p4_a0_em2, b0_a1_em2;
real a0_a1_em2, a1_a1_em2, a2_a1_em2, a3_a1_em2, a4_a1_em2, p1_a1_em2, p2_a1_em2;
real p3_a1_em2, p4_a1_em2, b0_a2_em2, a0_a2_em2, a1_a2_em2, a2_a2_em2, a3_a2_em2;
real a4_a2_em2, p1_a2_em2, p2_a2_em2, p3_a2_em2, p4_a2_em2, b0_a3_em2, a0_a3_em2;
real a1_a3_em2, a2_a3_em2, a3_a3_em2, a4_a3_em2, p1_a3_em2, p2_a3_em2, p3_a3_em2;
real p4_a3_em2, b0_a4_em2, a0_a4_em2, a1_a4_em2, a2_a4_em2, a3_a4_em2, a4_a4_em2;
real p1_a4_em2, p2_a4_em2, p3_a4_em2, p4_a4_em2, b0_p1_em2, a0_p1_em2, a1_p1_em2;
real a2_p1_em2, a3_p1_em2, a4_p1_em2, p1_p1_em2, p2_p1_em2, p3_p1_em2, p4_p1_em2;
real b0_p2_em2, a0_p2_em2, a1_p2_em2, a2_p2_em2, a3_p2_em2, a4_p2_em2, p1_p2_em2;
real p2_p2_em2, p3_p2_em2, p4_p2_em2, b0_p3_em2, a0_p3_em2, a1_p3_em2, a2_p3_em2;
real a3_p3_em2, a4_p3_em2, p1_p3_em2, p2_p3_em2, p3_p3_em2, p4_p3_em2, b0_p4_em2;
real a0_p4_em2, a1_p4_em2, a2_p4_em2, a3_p4_em2, a4_p4_em2, p1_p4_em2, p2_p4_em2;
real p3_p4_em2, p4_p4_em2;
real b0_em2, a0_em2, a1_em2, a2_em2, a3_em2, a4_em2, p1_em2, p2_em2, p3_em2, p4_em2, em2;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vsub = V(sub)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));
			
			//$display("Parameter %M in device %e, %e", id, vgs, vgs_cutoff_HCI, m_cutoff_HCI, delta_cutoff_HCI, (-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			
			delta_damage1_3_1 = 0;
			delta_damage1_3_2 = 0;
			delta_damage1_2_1 = 0;
			delta_damage1_2_2 = 0;
			delta_damage1_1_1 = 0;
			delta_damage1_1_2 = 0;
			delta_damage2_3_1 = 0;
			delta_damage2_3_2 = 0;
			delta_damage2_2_1 = 0;
			delta_damage2_2_2 = 0;
			delta_damage2_1_1 = 0;
			delta_damage2_1_2 = 0;
			delta_damage3 = 0;
			
			// off state HCI.
			if(vds < 0) begin	
				if(relimo_beta1*abs(vds) > 490) begin
					delta_damage1_3_1 = 0.0;
				end else begin				
					delta_damage1_3_1 = 1.0/relimo_alpha1_off*(exp(relimo_beta1*abs(vds))-1.0)*exp(-1.0*relimo_ea1/(relimo_kb*$temperature));
					$display("Parameter %M in device %e, %e", delta_damage1_3_1, 1.0/delta_damage1_3_1);
				end
				if(relimo_beta2*abs(vds) > 490) begin
					delta_damage1_3_2 = 0.0;
				end else begin				
					delta_damage1_3_2 = 1.0/relimo_alpha2_off*(exp(relimo_beta2*abs(vds))-1.0)*exp(-1.0*relimo_ea2/(relimo_kb*$temperature));
					$display("Parameter %M in device %e, %e", delta_damage1_3_2, 1.0/delta_damage1_3_2);
				end				
			end
			
			// HCIHV
			`EM($temperature, -1.0*vgs, -1.0*vds, vsub)
			
			`EM2($temperature, -1.0*vgs, -1.0*vds, vsub)
			
			//$display("Parameter %M in device %e, %e, %e, %e, ", b0_p1_a1_em, p1_a1_em, a1_em, em);
			//$display("Parameter %M in device %e, %e, %e, %e, ", b0_p1_a1_em2, p1_a1_em2, a1_em2, em2);
			
			if (em != 0) begin
				lamda_h = relimo_lamda_h0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if(relimo_Feb_h/(em*lamda_h) > 490) begin
					delta_damage2_3_1 = 0.0;
				end else begin
					delta_damage2_3_1 = 1.0/(relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb_h/(em*lamda_h)*exp(relimo_Feb_h/(em*lamda_h)));
					$display("Parameter %M in device %e, %e, %e, %e, %e, %e, %e, %e, %e", id, em, w, lamda_h,relimo_alpha1,relimo_m1, relimo_Feb_h/(em*lamda_h),exp(relimo_Feb_h/(em*lamda_h)), relimo_alpha1*pow(w*1e-6/id,relimo_m1), delta_damage2_3_1, 1.0/delta_damage2_3_1);	
				end
			end
			if (em2 != 0) begin
				lamda_el = relimo_lamda_el0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
				if (relimo_Feb_el/(em2*lamda_el) > 490) begin
					delta_damage2_3_2 = 0.0;
				end else begin
					delta_damage2_3_2 = 1.0/(relimo_alpha2*pow(w*1e-6/id,relimo_m2)*relimo_Feb_el/(em2*lamda_el)*exp(relimo_Feb_el/(em2*lamda_el)));
					$display("Parameter %M in device %e, %e, %e, %e, %e, %e, %e, %e, %e, %e, %e", id, em2, w, lamda_el, relimo_alpha2, relimo_m2, relimo_Feb_el/(em2*lamda_el),relimo_alpha2*pow(w*1e-6/id,relimo_m2), exp(relimo_Feb_el/(em2*lamda_el)),delta_damage2_3_2, 1.0/delta_damage2_3_2);
				end
			end
			 
			// High Vgs HCI.
			if(vds < 0 && vgs < 0) begin
				if((relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))) > 490) begin
					delta_damage3 = 0.0;
				end else begin	
					delta_damage3 = 1.0/(relimo_fstat3*relimo_alpha3*pow(w*1e-6/id,relimo_beta3)*pow(abs(vgs),-1.0*relimo_gama3)*pow(abs(vds),-1.0*relimo_eps3)*exp(-1.0*relimo_eta3*abs(vsub))*exp(relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))));
				        $display("Parameter %M in device %e, %e, %e, %e, %e, %e, %e, %e, %e, %e",relimo_fstat3, relimo_alpha3, pow(w*1e-6/id,relimo_beta3), vgs, pow(abs(vgs),-1.0*relimo_gama3), pow(abs(vds),-1.0*relimo_eps3), exp(-1.0*relimo_eta3*abs(vsub)), exp(relimo_ea3/relimo_kb/($temperature+relimo_rth*id*abs(vds)/(w*1e-6))), delta_damage3, 1.0/delta_damage3);
				end
			end
			
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				
				// off stat damages
				damage1_3_1 = damage1_3_1 + dt/2.0*(delta_damage1_3_1 + last_delta_damage1_3_1);
				damage1_3_2 = damage1_3_2 + dt/2.0*(delta_damage1_3_2 + last_delta_damage1_3_2);


				// HCIHV damages

				damage2_3_1 = damage2_3_1 + dt/2.0*(delta_damage2_3_1 + last_delta_damage2_3_1);
				damage2_3_2 = damage2_3_2 + dt/2.0*(delta_damage2_3_2 + last_delta_damage2_3_2);
	
				
				// High Vgs HCI.
				damage3 = damage3 + dt/2.0*(delta_damage3 + last_delta_damage3);
				
				last_delta_damage1_3_1 = delta_damage1_3_1;
				last_delta_damage1_3_2 = delta_damage1_3_2;
				last_delta_damage2_3_1 = delta_damage2_3_1;
				last_delta_damage2_3_2 = delta_damage2_3_2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, em2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, relimo_rth, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*V(sub)), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1_3_1 = damage1_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage1_3_2 = damage1_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_1 = damage2_3_1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2_3_2 = damage2_3_2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1_3_1 = 0;
					damage1_3_2 = 0;
					damage2_3_1 = 0;
					damage2_3_2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1_3_1 = delta_damage1_3_1*relimo_aging_time*3600;
				damage1_3_2 = delta_damage1_3_2*relimo_aging_time*3600;
				damage2_3_1 = delta_damage2_3_1*relimo_aging_time*3600;
				damage2_3_2 = delta_damage2_3_2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
			end				

			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a_off)+pow(delta_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b_off)+pow(delta_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

      			
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-31;
			end
        		
			//$display("Parameter %M in device %e, %e, %e, %e", lamda_h, lamda_el, delta_damage2_3_1, delta_damage2_3_2);
			//$display("Parameter %M in device %e, %e, %e, %e", ron_50p, s_50p, fa, ron_fa);
			//$display("Parameter %M in device %e, %e, %e, %e, %e", s_fa, fstat1, fstat2, damage2_1_1, damage2_1_2);
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, V(sub), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.130*0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 0);
			
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", relimo_ratio_vth);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1_3_1 = damage1_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage1_3_2 = damage1_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_1 = damage2_3_1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2_3_2 = damage2_3_2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1_3_1 = 0;
				damage1_3_2 = 0;
				damage2_3_1 = 0;
				damage2_3_2 = 0;
				damage3 = 0;
      			end


			// off stat damages 
			ron_50p = relimo_a1_off*pow(ln(1.0+damage1_3_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_3_2),relimo_n2_off);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a_off)+pow(delta_sigma_a_off,2.0*m_sigma_a_off)),1.0/(2.0*m_sigma_a_off));
			fa = 1.0/2.0*(s_50p*(fstat_tau1_off-fstat_tau2_off)+fstat_tau1_off+fstat_tau2_off);
			
			if (fa == 0) begin
				damage1_2_1 = 0;
				damage1_2_2 = 0;
			end else begin
				damage1_2_1 = damage1_3_1/fa;
				damage1_2_2 = damage1_3_2/fa;
			end
			ron_fa = relimo_a1_off*pow(ln(1.0+damage1_2_1),relimo_n1_off)-relimo_a2_off*pow(ln(1.0+damage1_2_2),relimo_n2_off);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b_off)+pow(delta_sigma_b_off,2.0*m_sigma_b_off)),1.0/(2.0*m_sigma_b_off));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2_off)+fa*(1+fstat_tau1tau2_off));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1_off-fa)+fa*(1+fstat_tau2tau1_off));
			if (fstat1 == 0) begin
				damage1_1_1 = 0;
			end else begin				
				damage1_1_1 = damage1_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage1_1_2 = 0;
			end else begin
				damage1_1_2 = damage1_3_2/fstat2;
			end
       			

			// HCIHV damages 

			ron_50p = relimo_a1*ln(1.0+damage2_3_1)+relimo_a2*ln(1.0+damage2_3_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_3_2),relimo_n_hci);
			s_50p = ron_50p/pow((pow(ron_50p,2.0*m_sigma_a)+pow(delta_sigma_a,2.0*m_sigma_a)),1.0/(2.0*m_sigma_a));
			fa = 1.0/2.0*(s_50p*(fstat_tau1-fstat_tau2)+fstat_tau1+fstat_tau2);
			
			if (fa == 0) begin
				damage2_2_1 = 0;
				damage2_2_2 = 0;
			end else begin
				damage2_2_1 = damage2_3_1/fa;
				damage2_2_2 = damage2_3_2/fa;
			end
			ron_fa = relimo_a1*ln(1.0+damage2_2_1)+relimo_a2*ln(1.0+damage2_2_1/relimo_c1)-relimo_b*pow(ln(1.0+damage2_2_2),relimo_n_hci);
			s_fa = ron_fa/pow((pow(ron_fa,2.0*m_sigma_b)+pow(delta_sigma_b,2.0*m_sigma_b)),1.0/(2.0*m_sigma_b));
			
			fstat1 = 1.0/2.0*(s_fa*(fa-fa*fstat_tau1tau2)+fa*(1+fstat_tau1tau2));
			fstat2 = 1.0/2.0*(s_fa*(fa*fstat_tau2tau1-fa)+fa*(1+fstat_tau2tau1));
			if (fstat1 == 0) begin
				damage2_1_1 = 0;
			end else begin				
				damage2_1_1 = damage2_3_1/fstat1;
			end
			if (fstat2 == 0) begin
				damage2_1_2 = 0;
			end else begin
				damage2_1_2 = damage2_3_2/fstat2;
			end

			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage3 == 0) begin
				damage3 = 1e-31;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, -0.130*0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);			
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 0);			
			
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", damage1_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", damage1_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", relimo_a1_off);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", relimo_a2_off);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", relimo_n1_off);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", relimo_n2_off);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0/relimo_c1*damage2_1_1);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", damage2_1_2);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", relimo_b);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", relimo_n_hci);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", relimo_ratio_vth);
		end	
	end
end
endmodule


module relimo_aging_pnp(b,e);
input b,e;
electrical b,e;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_pnp_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "pnp";
parameter real        w               		   = 0;			
parameter real        l               		   = 0;			
parameter real        dl               		   = 0;			
parameter real        relimo_n                     = 0.2;
parameter real        relimo_c                     = 0;			
parameter real        relimo_kb                    = 8.617e-5;
parameter real        relimo_Ea                    = 0;
parameter real        relimo_gamma                 = 0.0000166;
parameter real        relimo_a                     = 4.01e-38;
parameter real        relimo_b                     = 33.2;
parameter real        relimo_fstat                 = 0.00966;
		
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real veb, delta_damage1, last_delta_damage1, damage1, dt, last_abstime;  
   
// Start simulatoin
analog begin
	if(relimo_pnp_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			veb = V(e)-V(b);
			
			if(veb >= 0) begin
				delta_damage1 = 0;
			end else begin
				delta_damage1 = relimo_a/relimo_fstat*exp(-1*relimo_b/abs(veb))*pow((1-relimo_c)+relimo_c*exp(-1*relimo_Ea/(relimo_kb*$temperature)),1.0/relimo_n);
				//$display("Parameter MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", exp(relimo_intercept-relimo_c*vddtransistor), relimo_a_idsat*relimo_m, exp(-1*relimo_e/(relimo_kb*$temperature)), delta_damage1,relimo_c,relimo_intercept-relimo_c*vddtransistor,relimo_intercept,vddtransistor);
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				last_delta_damage1 = delta_damage1;
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
	
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e\n", dela_vth_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
      			end

			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);			
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", 0.0, 0.0, 0.0, 0.0);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", 1, damage1, 1, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e\n", 0.0);
			// use relimo_ratio1_b as P_eff*Gamma
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e\n", -100*2.0*(w+dl+l+dl)*relimo_gamma*1e-6);			
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
      			end
		
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);			
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", 0.0, 0.0, 0.0, 0.0);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", 1, damage1, 1, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e\n", 0.0);
			// use relimo_ratio1_b as P_eff*Gamma
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e\n", -100*2.0*(w+dl+l+dl)*relimo_gamma*1e-6);		
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
		end	
	end
end
endmodule
