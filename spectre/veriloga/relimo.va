////////////////////////////////////////
// veriloga aging model for smos10hv
// Developed by : circuit CAE
// Created on   : 02/10/2021 
// by           : nxa23194 
// Freescale Internal Use Only  
//
// Version update:
// version	time		comment
// v12.1:	02/10/2021	vdscutoff is changed to be vgscutoff.
//                              relimo_aging_hci1 model is updated, delta_damage is freshed in each loop.
// ams3.12:	04/20/2020	relimo_aging_nbti model is updated. When relimo_pbti_aging_open_flag=1, pbti dummy outputs will not be outputted.
//                              Then relimo_aging_pbti model can be added together in one device to output real pbti damage.
// ams3.8:	06/22/2018	Full HCI model added for nld45(b) and nld45(b)_he.
// ams3.7:	11/30/2017	HCI model updated. HCI3 model added for Ron model.
// ams2.0:	03/31/2014	First version.

`include "discipline.h"
`include "constants.h"

`define EM(T, VGS, VDS, VSubS) \
    b0_b0_b0_em = linear(b0_b0_b0_b0_em, a0_b0_b0_b0_em, (T)); \
    a0_b0_b0_em = linear(b0_a0_b0_b0_em, a0_a0_b0_b0_em, (T)); \
    b0_a0_b0_em = linear(b0_b0_a0_b0_em, a0_b0_a0_b0_em, (T)); \
    a0_a0_b0_em = linear(b0_a0_a0_b0_em, a0_a0_a0_b0_em, (T)); \
    b0_a1_b0_em = linear(b0_b0_a1_b0_em, a0_b0_a1_b0_em, (T)); \
    a0_a1_b0_em = linear(b0_a0_a1_b0_em, a0_a0_a1_b0_em, (T)); \
    b0_a2_b0_em = linear(b0_b0_a2_b0_em, a0_b0_a2_b0_em, (T)); \
    a0_a2_b0_em = linear(b0_a0_a2_b0_em, a0_a0_a2_b0_em, (T)); \
    b0_a3_b0_em = linear(b0_b0_a3_b0_em, a0_b0_a3_b0_em, (T)); \
    a0_a3_b0_em = linear(b0_a0_a3_b0_em, a0_a0_a3_b0_em, (T)); \
    b0_a4_b0_em = linear(b0_b0_a4_b0_em, a0_b0_a4_b0_em, (T)); \
    a0_a4_b0_em = linear(b0_a0_a4_b0_em, a0_a0_a4_b0_em, (T)); \
    b0_p1_b0_em = linear(b0_b0_p1_b0_em, a0_b0_p1_b0_em, (T)); \
    a0_p1_b0_em = linear(b0_a0_p1_b0_em, a0_a0_p1_b0_em, (T)); \
    b0_p2_b0_em = linear(b0_b0_p2_b0_em, a0_b0_p2_b0_em, (T)); \
    a0_p2_b0_em = linear(b0_a0_p2_b0_em, a0_a0_p2_b0_em, (T)); \
    b0_p3_b0_em = linear(b0_b0_p3_b0_em, a0_b0_p3_b0_em, (T)); \
    a0_p3_b0_em = linear(b0_a0_p3_b0_em, a0_a0_p3_b0_em, (T)); \
    b0_p4_b0_em = linear(b0_b0_p4_b0_em, a0_b0_p4_b0_em, (T)); \
    a0_p4_b0_em = linear(b0_a0_p4_b0_em, a0_a0_p4_b0_em, (T)); \
    b0_b0_a0_em = linear(b0_b0_b0_a0_em, a0_b0_b0_a0_em, (T)); \
    a0_b0_a0_em = linear(b0_a0_b0_a0_em, a0_a0_b0_a0_em, (T)); \
    b0_a0_a0_em = linear(b0_b0_a0_a0_em, a0_b0_a0_a0_em, (T)); \
    a0_a0_a0_em = linear(b0_a0_a0_a0_em, a0_a0_a0_a0_em, (T)); \
    b0_a1_a0_em = linear(b0_b0_a1_a0_em, a0_b0_a1_a0_em, (T)); \
    a0_a1_a0_em = linear(b0_a0_a1_a0_em, a0_a0_a1_a0_em, (T)); \
    b0_a2_a0_em = linear(b0_b0_a2_a0_em, a0_b0_a2_a0_em, (T)); \
    a0_a2_a0_em = linear(b0_a0_a2_a0_em, a0_a0_a2_a0_em, (T)); \
    b0_a3_a0_em = linear(b0_b0_a3_a0_em, a0_b0_a3_a0_em, (T)); \
    a0_a3_a0_em = linear(b0_a0_a3_a0_em, a0_a0_a3_a0_em, (T)); \
    b0_a4_a0_em = linear(b0_b0_a4_a0_em, a0_b0_a4_a0_em, (T)); \
    a0_a4_a0_em = linear(b0_a0_a4_a0_em, a0_a0_a4_a0_em, (T)); \
    b0_p1_a0_em = linear(b0_b0_p1_a0_em, a0_b0_p1_a0_em, (T)); \
    a0_p1_a0_em = linear(b0_a0_p1_a0_em, a0_a0_p1_a0_em, (T)); \
    b0_p2_a0_em = linear(b0_b0_p2_a0_em, a0_b0_p2_a0_em, (T)); \
    a0_p2_a0_em = linear(b0_a0_p2_a0_em, a0_a0_p2_a0_em, (T)); \
    b0_p3_a0_em = linear(b0_b0_p3_a0_em, a0_b0_p3_a0_em, (T)); \
    a0_p3_a0_em = linear(b0_a0_p3_a0_em, a0_a0_p3_a0_em, (T)); \
    b0_p4_a0_em = linear(b0_b0_p4_a0_em, a0_b0_p4_a0_em, (T)); \
    a0_p4_a0_em = linear(b0_a0_p4_a0_em, a0_a0_p4_a0_em, (T)); \
    b0_b0_a1_em = linear(b0_b0_b0_a1_em, a0_b0_b0_a1_em, (T)); \
    a0_b0_a1_em = linear(b0_a0_b0_a1_em, a0_a0_b0_a1_em, (T)); \
    b0_a0_a1_em = linear(b0_b0_a0_a1_em, a0_b0_a0_a1_em, (T)); \
    a0_a0_a1_em = linear(b0_a0_a0_a1_em, a0_a0_a0_a1_em, (T)); \
    b0_a1_a1_em = linear(b0_b0_a1_a1_em, a0_b0_a1_a1_em, (T)); \
    a0_a1_a1_em = linear(b0_a0_a1_a1_em, a0_a0_a1_a1_em, (T)); \
    b0_a2_a1_em = linear(b0_b0_a2_a1_em, a0_b0_a2_a1_em, (T)); \
    a0_a2_a1_em = linear(b0_a0_a2_a1_em, a0_a0_a2_a1_em, (T)); \
    b0_a3_a1_em = linear(b0_b0_a3_a1_em, a0_b0_a3_a1_em, (T)); \
    a0_a3_a1_em = linear(b0_a0_a3_a1_em, a0_a0_a3_a1_em, (T)); \
    b0_a4_a1_em = linear(b0_b0_a4_a1_em, a0_b0_a4_a1_em, (T)); \
    a0_a4_a1_em = linear(b0_a0_a4_a1_em, a0_a0_a4_a1_em, (T)); \
    b0_p1_a1_em = linear(b0_b0_p1_a1_em, a0_b0_p1_a1_em, (T)); \
    a0_p1_a1_em = linear(b0_a0_p1_a1_em, a0_a0_p1_a1_em, (T)); \
    b0_p2_a1_em = linear(b0_b0_p2_a1_em, a0_b0_p2_a1_em, (T)); \
    a0_p2_a1_em = linear(b0_a0_p2_a1_em, a0_a0_p2_a1_em, (T)); \
    b0_p3_a1_em = linear(b0_b0_p3_a1_em, a0_b0_p3_a1_em, (T)); \
    a0_p3_a1_em = linear(b0_a0_p3_a1_em, a0_a0_p3_a1_em, (T)); \
    b0_p4_a1_em = linear(b0_b0_p4_a1_em, a0_b0_p4_a1_em, (T)); \
    a0_p4_a1_em = linear(b0_a0_p4_a1_em, a0_a0_p4_a1_em, (T)); \
    b0_b0_a2_em = linear(b0_b0_b0_a2_em, a0_b0_b0_a2_em, (T)); \
    a0_b0_a2_em = linear(b0_a0_b0_a2_em, a0_a0_b0_a2_em, (T)); \
    b0_a0_a2_em = linear(b0_b0_a0_a2_em, a0_b0_a0_a2_em, (T)); \
    a0_a0_a2_em = linear(b0_a0_a0_a2_em, a0_a0_a0_a2_em, (T)); \
    b0_a1_a2_em = linear(b0_b0_a1_a2_em, a0_b0_a1_a2_em, (T)); \
    a0_a1_a2_em = linear(b0_a0_a1_a2_em, a0_a0_a1_a2_em, (T)); \
    b0_a2_a2_em = linear(b0_b0_a2_a2_em, a0_b0_a2_a2_em, (T)); \
    a0_a2_a2_em = linear(b0_a0_a2_a2_em, a0_a0_a2_a2_em, (T)); \
    b0_a3_a2_em = linear(b0_b0_a3_a2_em, a0_b0_a3_a2_em, (T)); \
    a0_a3_a2_em = linear(b0_a0_a3_a2_em, a0_a0_a3_a2_em, (T)); \
    b0_a4_a2_em = linear(b0_b0_a4_a2_em, a0_b0_a4_a2_em, (T)); \
    a0_a4_a2_em = linear(b0_a0_a4_a2_em, a0_a0_a4_a2_em, (T)); \
    b0_p1_a2_em = linear(b0_b0_p1_a2_em, a0_b0_p1_a2_em, (T)); \
    a0_p1_a2_em = linear(b0_a0_p1_a2_em, a0_a0_p1_a2_em, (T)); \
    b0_p2_a2_em = linear(b0_b0_p2_a2_em, a0_b0_p2_a2_em, (T)); \
    a0_p2_a2_em = linear(b0_a0_p2_a2_em, a0_a0_p2_a2_em, (T)); \
    b0_p3_a2_em = linear(b0_b0_p3_a2_em, a0_b0_p3_a2_em, (T)); \
    a0_p3_a2_em = linear(b0_a0_p3_a2_em, a0_a0_p3_a2_em, (T)); \
    b0_p4_a2_em = linear(b0_b0_p4_a2_em, a0_b0_p4_a2_em, (T)); \
    a0_p4_a2_em = linear(b0_a0_p4_a2_em, a0_a0_p4_a2_em, (T)); \
    b0_b0_a3_em = linear(b0_b0_b0_a3_em, a0_b0_b0_a3_em, (T)); \
    a0_b0_a3_em = linear(b0_a0_b0_a3_em, a0_a0_b0_a3_em, (T)); \
    b0_a0_a3_em = linear(b0_b0_a0_a3_em, a0_b0_a0_a3_em, (T)); \
    a0_a0_a3_em = linear(b0_a0_a0_a3_em, a0_a0_a0_a3_em, (T)); \
    b0_a1_a3_em = linear(b0_b0_a1_a3_em, a0_b0_a1_a3_em, (T)); \
    a0_a1_a3_em = linear(b0_a0_a1_a3_em, a0_a0_a1_a3_em, (T)); \
    b0_a2_a3_em = linear(b0_b0_a2_a3_em, a0_b0_a2_a3_em, (T)); \
    a0_a2_a3_em = linear(b0_a0_a2_a3_em, a0_a0_a2_a3_em, (T)); \
    b0_a3_a3_em = linear(b0_b0_a3_a3_em, a0_b0_a3_a3_em, (T)); \
    a0_a3_a3_em = linear(b0_a0_a3_a3_em, a0_a0_a3_a3_em, (T)); \
    b0_a4_a3_em = linear(b0_b0_a4_a3_em, a0_b0_a4_a3_em, (T)); \
    a0_a4_a3_em = linear(b0_a0_a4_a3_em, a0_a0_a4_a3_em, (T)); \
    b0_p1_a3_em = linear(b0_b0_p1_a3_em, a0_b0_p1_a3_em, (T)); \
    a0_p1_a3_em = linear(b0_a0_p1_a3_em, a0_a0_p1_a3_em, (T)); \
    b0_p2_a3_em = linear(b0_b0_p2_a3_em, a0_b0_p2_a3_em, (T)); \
    a0_p2_a3_em = linear(b0_a0_p2_a3_em, a0_a0_p2_a3_em, (T)); \
    b0_p3_a3_em = linear(b0_b0_p3_a3_em, a0_b0_p3_a3_em, (T)); \
    a0_p3_a3_em = linear(b0_a0_p3_a3_em, a0_a0_p3_a3_em, (T)); \
    b0_p4_a3_em = linear(b0_b0_p4_a3_em, a0_b0_p4_a3_em, (T)); \
    a0_p4_a3_em = linear(b0_a0_p4_a3_em, a0_a0_p4_a3_em, (T)); \
    b0_b0_a4_em = linear(b0_b0_b0_a4_em, a0_b0_b0_a4_em, (T)); \
    a0_b0_a4_em = linear(b0_a0_b0_a4_em, a0_a0_b0_a4_em, (T)); \
    b0_a0_a4_em = linear(b0_b0_a0_a4_em, a0_b0_a0_a4_em, (T)); \
    a0_a0_a4_em = linear(b0_a0_a0_a4_em, a0_a0_a0_a4_em, (T)); \
    b0_a1_a4_em = linear(b0_b0_a1_a4_em, a0_b0_a1_a4_em, (T)); \
    a0_a1_a4_em = linear(b0_a0_a1_a4_em, a0_a0_a1_a4_em, (T)); \
    b0_a2_a4_em = linear(b0_b0_a2_a4_em, a0_b0_a2_a4_em, (T)); \
    a0_a2_a4_em = linear(b0_a0_a2_a4_em, a0_a0_a2_a4_em, (T)); \
    b0_a3_a4_em = linear(b0_b0_a3_a4_em, a0_b0_a3_a4_em, (T)); \
    a0_a3_a4_em = linear(b0_a0_a3_a4_em, a0_a0_a3_a4_em, (T)); \
    b0_a4_a4_em = linear(b0_b0_a4_a4_em, a0_b0_a4_a4_em, (T)); \
    a0_a4_a4_em = linear(b0_a0_a4_a4_em, a0_a0_a4_a4_em, (T)); \
    b0_p1_a4_em = linear(b0_b0_p1_a4_em, a0_b0_p1_a4_em, (T)); \
    a0_p1_a4_em = linear(b0_a0_p1_a4_em, a0_a0_p1_a4_em, (T)); \
    b0_p2_a4_em = linear(b0_b0_p2_a4_em, a0_b0_p2_a4_em, (T)); \
    a0_p2_a4_em = linear(b0_a0_p2_a4_em, a0_a0_p2_a4_em, (T)); \
    b0_p3_a4_em = linear(b0_b0_p3_a4_em, a0_b0_p3_a4_em, (T)); \
    a0_p3_a4_em = linear(b0_a0_p3_a4_em, a0_a0_p3_a4_em, (T)); \
    b0_p4_a4_em = linear(b0_b0_p4_a4_em, a0_b0_p4_a4_em, (T)); \
    a0_p4_a4_em = linear(b0_a0_p4_a4_em, a0_a0_p4_a4_em, (T)); \
    b0_b0_p1_em = linear(b0_b0_b0_p1_em, a0_b0_b0_p1_em, (T)); \
    a0_b0_p1_em = linear(b0_a0_b0_p1_em, a0_a0_b0_p1_em, (T)); \
    b0_a0_p1_em = linear(b0_b0_a0_p1_em, a0_b0_a0_p1_em, (T)); \
    a0_a0_p1_em = linear(b0_a0_a0_p1_em, a0_a0_a0_p1_em, (T)); \
    b0_a1_p1_em = linear(b0_b0_a1_p1_em, a0_b0_a1_p1_em, (T)); \
    a0_a1_p1_em = linear(b0_a0_a1_p1_em, a0_a0_a1_p1_em, (T)); \
    b0_a2_p1_em = linear(b0_b0_a2_p1_em, a0_b0_a2_p1_em, (T)); \
    a0_a2_p1_em = linear(b0_a0_a2_p1_em, a0_a0_a2_p1_em, (T)); \
    b0_a3_p1_em = linear(b0_b0_a3_p1_em, a0_b0_a3_p1_em, (T)); \
    a0_a3_p1_em = linear(b0_a0_a3_p1_em, a0_a0_a3_p1_em, (T)); \
    b0_a4_p1_em = linear(b0_b0_a4_p1_em, a0_b0_a4_p1_em, (T)); \
    a0_a4_p1_em = linear(b0_a0_a4_p1_em, a0_a0_a4_p1_em, (T)); \
    b0_p1_p1_em = linear(b0_b0_p1_p1_em, a0_b0_p1_p1_em, (T)); \
    a0_p1_p1_em = linear(b0_a0_p1_p1_em, a0_a0_p1_p1_em, (T)); \
    b0_p2_p1_em = linear(b0_b0_p2_p1_em, a0_b0_p2_p1_em, (T)); \
    a0_p2_p1_em = linear(b0_a0_p2_p1_em, a0_a0_p2_p1_em, (T)); \
    b0_p3_p1_em = linear(b0_b0_p3_p1_em, a0_b0_p3_p1_em, (T)); \
    a0_p3_p1_em = linear(b0_a0_p3_p1_em, a0_a0_p3_p1_em, (T)); \
    b0_p4_p1_em = linear(b0_b0_p4_p1_em, a0_b0_p4_p1_em, (T)); \
    a0_p4_p1_em = linear(b0_a0_p4_p1_em, a0_a0_p4_p1_em, (T)); \
    b0_b0_p2_em = linear(b0_b0_b0_p2_em, a0_b0_b0_p2_em, (T)); \
    a0_b0_p2_em = linear(b0_a0_b0_p2_em, a0_a0_b0_p2_em, (T)); \
    b0_a0_p2_em = linear(b0_b0_a0_p2_em, a0_b0_a0_p2_em, (T)); \
    a0_a0_p2_em = linear(b0_a0_a0_p2_em, a0_a0_a0_p2_em, (T)); \
    b0_a1_p2_em = linear(b0_b0_a1_p2_em, a0_b0_a1_p2_em, (T)); \
    a0_a1_p2_em = linear(b0_a0_a1_p2_em, a0_a0_a1_p2_em, (T)); \
    b0_a2_p2_em = linear(b0_b0_a2_p2_em, a0_b0_a2_p2_em, (T)); \
    a0_a2_p2_em = linear(b0_a0_a2_p2_em, a0_a0_a2_p2_em, (T)); \
    b0_a3_p2_em = linear(b0_b0_a3_p2_em, a0_b0_a3_p2_em, (T)); \
    a0_a3_p2_em = linear(b0_a0_a3_p2_em, a0_a0_a3_p2_em, (T)); \
    b0_a4_p2_em = linear(b0_b0_a4_p2_em, a0_b0_a4_p2_em, (T)); \
    a0_a4_p2_em = linear(b0_a0_a4_p2_em, a0_a0_a4_p2_em, (T)); \
    b0_p1_p2_em = linear(b0_b0_p1_p2_em, a0_b0_p1_p2_em, (T)); \
    a0_p1_p2_em = linear(b0_a0_p1_p2_em, a0_a0_p1_p2_em, (T)); \
    b0_p2_p2_em = linear(b0_b0_p2_p2_em, a0_b0_p2_p2_em, (T)); \
    a0_p2_p2_em = linear(b0_a0_p2_p2_em, a0_a0_p2_p2_em, (T)); \
    b0_p3_p2_em = linear(b0_b0_p3_p2_em, a0_b0_p3_p2_em, (T)); \
    a0_p3_p2_em = linear(b0_a0_p3_p2_em, a0_a0_p3_p2_em, (T)); \
    b0_p4_p2_em = linear(b0_b0_p4_p2_em, a0_b0_p4_p2_em, (T)); \
    a0_p4_p2_em = linear(b0_a0_p4_p2_em, a0_a0_p4_p2_em, (T)); \
    b0_b0_p3_em = linear(b0_b0_b0_p3_em, a0_b0_b0_p3_em, (T)); \
    a0_b0_p3_em = linear(b0_a0_b0_p3_em, a0_a0_b0_p3_em, (T)); \
    b0_a0_p3_em = linear(b0_b0_a0_p3_em, a0_b0_a0_p3_em, (T)); \
    a0_a0_p3_em = linear(b0_a0_a0_p3_em, a0_a0_a0_p3_em, (T)); \
    b0_a1_p3_em = linear(b0_b0_a1_p3_em, a0_b0_a1_p3_em, (T)); \
    a0_a1_p3_em = linear(b0_a0_a1_p3_em, a0_a0_a1_p3_em, (T)); \
    b0_a2_p3_em = linear(b0_b0_a2_p3_em, a0_b0_a2_p3_em, (T)); \
    a0_a2_p3_em = linear(b0_a0_a2_p3_em, a0_a0_a2_p3_em, (T)); \
    b0_a3_p3_em = linear(b0_b0_a3_p3_em, a0_b0_a3_p3_em, (T)); \
    a0_a3_p3_em = linear(b0_a0_a3_p3_em, a0_a0_a3_p3_em, (T)); \
    b0_a4_p3_em = linear(b0_b0_a4_p3_em, a0_b0_a4_p3_em, (T)); \
    a0_a4_p3_em = linear(b0_a0_a4_p3_em, a0_a0_a4_p3_em, (T)); \
    b0_p1_p3_em = linear(b0_b0_p1_p3_em, a0_b0_p1_p3_em, (T)); \
    a0_p1_p3_em = linear(b0_a0_p1_p3_em, a0_a0_p1_p3_em, (T)); \
    b0_p2_p3_em = linear(b0_b0_p2_p3_em, a0_b0_p2_p3_em, (T)); \
    a0_p2_p3_em = linear(b0_a0_p2_p3_em, a0_a0_p2_p3_em, (T)); \
    b0_p3_p3_em = linear(b0_b0_p3_p3_em, a0_b0_p3_p3_em, (T)); \
    a0_p3_p3_em = linear(b0_a0_p3_p3_em, a0_a0_p3_p3_em, (T)); \
    b0_p4_p3_em = linear(b0_b0_p4_p3_em, a0_b0_p4_p3_em, (T)); \
    a0_p4_p3_em = linear(b0_a0_p4_p3_em, a0_a0_p4_p3_em, (T)); \
    b0_b0_p4_em = linear(b0_b0_b0_p4_em, a0_b0_b0_p4_em, (T)); \
    a0_b0_p4_em = linear(b0_a0_b0_p4_em, a0_a0_b0_p4_em, (T)); \
    b0_a0_p4_em = linear(b0_b0_a0_p4_em, a0_b0_a0_p4_em, (T)); \
    a0_a0_p4_em = linear(b0_a0_a0_p4_em, a0_a0_a0_p4_em, (T)); \
    b0_a1_p4_em = linear(b0_b0_a1_p4_em, a0_b0_a1_p4_em, (T)); \
    a0_a1_p4_em = linear(b0_a0_a1_p4_em, a0_a0_a1_p4_em, (T)); \
    b0_a2_p4_em = linear(b0_b0_a2_p4_em, a0_b0_a2_p4_em, (T)); \
    a0_a2_p4_em = linear(b0_a0_a2_p4_em, a0_a0_a2_p4_em, (T)); \
    b0_a3_p4_em = linear(b0_b0_a3_p4_em, a0_b0_a3_p4_em, (T)); \
    a0_a3_p4_em = linear(b0_a0_a3_p4_em, a0_a0_a3_p4_em, (T)); \
    b0_a4_p4_em = linear(b0_b0_a4_p4_em, a0_b0_a4_p4_em, (T)); \
    a0_a4_p4_em = linear(b0_a0_a4_p4_em, a0_a0_a4_p4_em, (T)); \
    b0_p1_p4_em = linear(b0_b0_p1_p4_em, a0_b0_p1_p4_em, (T)); \
    a0_p1_p4_em = linear(b0_a0_p1_p4_em, a0_a0_p1_p4_em, (T)); \
    b0_p2_p4_em = linear(b0_b0_p2_p4_em, a0_b0_p2_p4_em, (T)); \
    a0_p2_p4_em = linear(b0_a0_p2_p4_em, a0_a0_p2_p4_em, (T)); \
    b0_p3_p4_em = linear(b0_b0_p3_p4_em, a0_b0_p3_p4_em, (T)); \
    a0_p3_p4_em = linear(b0_a0_p3_p4_em, a0_a0_p3_p4_em, (T)); \
    b0_p4_p4_em = linear(b0_b0_p4_p4_em, a0_b0_p4_p4_em, (T)); \
    a0_p4_p4_em = linear(b0_a0_p4_p4_em, a0_a0_p4_p4_em, (T)); \
    b0_b0_em    = linear(b0_b0_b0_em,    a0_b0_b0_em,    (VSubS)); \
    a0_b0_em    = linear(b0_a0_b0_em,    a0_a0_b0_em,    (VSubS)); \
    a1_b0_em    = linear(b0_a1_b0_em,    a0_a1_b0_em,    (VSubS)); \
    a2_b0_em    = linear(b0_a2_b0_em,    a0_a2_b0_em,    (VSubS)); \
    a3_b0_em    = linear(b0_a3_b0_em,    a0_a3_b0_em,    (VSubS)); \
    a4_b0_em    = linear(b0_a4_b0_em,    a0_a4_b0_em,    (VSubS)); \
    p1_b0_em    = linear(b0_p1_b0_em,    a0_p1_b0_em,    (VSubS)); \
    p2_b0_em    = linear(b0_p2_b0_em,    a0_p2_b0_em,    (VSubS)); \
    p3_b0_em    = linear(b0_p3_b0_em,    a0_p3_b0_em,    (VSubS)); \
    p4_b0_em    = linear(b0_p4_b0_em,    a0_p4_b0_em,    (VSubS)); \
    b0_a0_em    = linear(b0_b0_a0_em,    a0_b0_a0_em,    (VSubS)); \
    a0_a0_em    = linear(b0_a0_a0_em,    a0_a0_a0_em,    (VSubS)); \
    a1_a0_em    = linear(b0_a1_a0_em,    a0_a1_a0_em,    (VSubS)); \
    a2_a0_em    = linear(b0_a2_a0_em,    a0_a2_a0_em,    (VSubS)); \
    a3_a0_em    = linear(b0_a3_a0_em,    a0_a3_a0_em,    (VSubS)); \
    a4_a0_em    = linear(b0_a4_a0_em,    a0_a4_a0_em,    (VSubS)); \
    p1_a0_em    = linear(b0_p1_a0_em,    a0_p1_a0_em,    (VSubS)); \
    p2_a0_em    = linear(b0_p2_a0_em,    a0_p2_a0_em,    (VSubS)); \
    p3_a0_em    = linear(b0_p3_a0_em,    a0_p3_a0_em,    (VSubS)); \
    p4_a0_em    = linear(b0_p4_a0_em,    a0_p4_a0_em,    (VSubS)); \
    b0_a1_em    = linear(b0_b0_a1_em,    a0_b0_a1_em,    (VSubS)); \
    a0_a1_em    = linear(b0_a0_a1_em,    a0_a0_a1_em,    (VSubS)); \
    a1_a1_em    = linear(b0_a1_a1_em,    a0_a1_a1_em,    (VSubS)); \
    a2_a1_em    = linear(b0_a2_a1_em,    a0_a2_a1_em,    (VSubS)); \
    a3_a1_em    = linear(b0_a3_a1_em,    a0_a3_a1_em,    (VSubS)); \
    a4_a1_em    = linear(b0_a4_a1_em,    a0_a4_a1_em,    (VSubS)); \
    p1_a1_em    = linear(b0_p1_a1_em,    a0_p1_a1_em,    (VSubS)); \
    p2_a1_em    = linear(b0_p2_a1_em,    a0_p2_a1_em,    (VSubS)); \
    p3_a1_em    = linear(b0_p3_a1_em,    a0_p3_a1_em,    (VSubS)); \
    p4_a1_em    = linear(b0_p4_a1_em,    a0_p4_a1_em,    (VSubS)); \
    b0_a2_em    = linear(b0_b0_a2_em,    a0_b0_a2_em,    (VSubS)); \
    a0_a2_em    = linear(b0_a0_a2_em,    a0_a0_a2_em,    (VSubS)); \
    a1_a2_em    = linear(b0_a1_a2_em,    a0_a1_a2_em,    (VSubS)); \
    a2_a2_em    = linear(b0_a2_a2_em,    a0_a2_a2_em,    (VSubS)); \
    a3_a2_em    = linear(b0_a3_a2_em,    a0_a3_a2_em,    (VSubS)); \
    a4_a2_em    = linear(b0_a4_a2_em,    a0_a4_a2_em,    (VSubS)); \
    p1_a2_em    = linear(b0_p1_a2_em,    a0_p1_a2_em,    (VSubS)); \
    p2_a2_em    = linear(b0_p2_a2_em,    a0_p2_a2_em,    (VSubS)); \
    p3_a2_em    = linear(b0_p3_a2_em,    a0_p3_a2_em,    (VSubS)); \
    p4_a2_em    = linear(b0_p4_a2_em,    a0_p4_a2_em,    (VSubS)); \
    b0_a3_em    = linear(b0_b0_a3_em,    a0_b0_a3_em,    (VSubS)); \
    a0_a3_em    = linear(b0_a0_a3_em,    a0_a0_a3_em,    (VSubS)); \
    a1_a3_em    = linear(b0_a1_a3_em,    a0_a1_a3_em,    (VSubS)); \
    a2_a3_em    = linear(b0_a2_a3_em,    a0_a2_a3_em,    (VSubS)); \
    a3_a3_em    = linear(b0_a3_a3_em,    a0_a3_a3_em,    (VSubS)); \
    a4_a3_em    = linear(b0_a4_a3_em,    a0_a4_a3_em,    (VSubS)); \
    p1_a3_em    = linear(b0_p1_a3_em,    a0_p1_a3_em,    (VSubS)); \
    p2_a3_em    = linear(b0_p2_a3_em,    a0_p2_a3_em,    (VSubS)); \
    p3_a3_em    = linear(b0_p3_a3_em,    a0_p3_a3_em,    (VSubS)); \
    p4_a3_em    = linear(b0_p4_a3_em,    a0_p4_a3_em,    (VSubS)); \
    b0_a4_em    = linear(b0_b0_a4_em,    a0_b0_a4_em,    (VSubS)); \
    a0_a4_em    = linear(b0_a0_a4_em,    a0_a0_a4_em,    (VSubS)); \
    a1_a4_em    = linear(b0_a1_a4_em,    a0_a1_a4_em,    (VSubS)); \
    a2_a4_em    = linear(b0_a2_a4_em,    a0_a2_a4_em,    (VSubS)); \
    a3_a4_em    = linear(b0_a3_a4_em,    a0_a3_a4_em,    (VSubS)); \
    a4_a4_em    = linear(b0_a4_a4_em,    a0_a4_a4_em,    (VSubS)); \
    p1_a4_em    = linear(b0_p1_a4_em,    a0_p1_a4_em,    (VSubS)); \
    p2_a4_em    = linear(b0_p2_a4_em,    a0_p2_a4_em,    (VSubS)); \
    p3_a4_em    = linear(b0_p3_a4_em,    a0_p3_a4_em,    (VSubS)); \
    p4_a4_em    = linear(b0_p4_a4_em,    a0_p4_a4_em,    (VSubS)); \
    b0_p1_em    = linear(b0_b0_p1_em,    a0_b0_p1_em,    (VSubS)); \
    a0_p1_em    = linear(b0_a0_p1_em,    a0_a0_p1_em,    (VSubS)); \
    a1_p1_em    = linear(b0_a1_p1_em,    a0_a1_p1_em,    (VSubS)); \
    a2_p1_em    = linear(b0_a2_p1_em,    a0_a2_p1_em,    (VSubS)); \
    a3_p1_em    = linear(b0_a3_p1_em,    a0_a3_p1_em,    (VSubS)); \
    a4_p1_em    = linear(b0_a4_p1_em,    a0_a4_p1_em,    (VSubS)); \
    p1_p1_em    = linear(b0_p1_p1_em,    a0_p1_p1_em,    (VSubS)); \
    p2_p1_em    = linear(b0_p2_p1_em,    a0_p2_p1_em,    (VSubS)); \
    p3_p1_em    = linear(b0_p3_p1_em,    a0_p3_p1_em,    (VSubS)); \
    p4_p1_em    = linear(b0_p4_p1_em,    a0_p4_p1_em,    (VSubS)); \
    b0_p2_em    = linear(b0_b0_p2_em,    a0_b0_p2_em,    (VSubS)); \
    a0_p2_em    = linear(b0_a0_p2_em,    a0_a0_p2_em,    (VSubS)); \
    a1_p2_em    = linear(b0_a1_p2_em,    a0_a1_p2_em,    (VSubS)); \
    a2_p2_em    = linear(b0_a2_p2_em,    a0_a2_p2_em,    (VSubS)); \
    a3_p2_em    = linear(b0_a3_p2_em,    a0_a3_p2_em,    (VSubS)); \
    a4_p2_em    = linear(b0_a4_p2_em,    a0_a4_p2_em,    (VSubS)); \
    p1_p2_em    = linear(b0_p1_p2_em,    a0_p1_p2_em,    (VSubS)); \
    p2_p2_em    = linear(b0_p2_p2_em,    a0_p2_p2_em,    (VSubS)); \
    p3_p2_em    = linear(b0_p3_p2_em,    a0_p3_p2_em,    (VSubS)); \
    p4_p2_em    = linear(b0_p4_p2_em,    a0_p4_p2_em,    (VSubS)); \
    b0_p3_em    = linear(b0_b0_p3_em,    a0_b0_p3_em,    (VSubS)); \
    a0_p3_em    = linear(b0_a0_p3_em,    a0_a0_p3_em,    (VSubS)); \
    a1_p3_em    = linear(b0_a1_p3_em,    a0_a1_p3_em,    (VSubS)); \
    a2_p3_em    = linear(b0_a2_p3_em,    a0_a2_p3_em,    (VSubS)); \
    a3_p3_em    = linear(b0_a3_p3_em,    a0_a3_p3_em,    (VSubS)); \
    a4_p3_em    = linear(b0_a4_p3_em,    a0_a4_p3_em,    (VSubS)); \
    p1_p3_em    = linear(b0_p1_p3_em,    a0_p1_p3_em,    (VSubS)); \
    p2_p3_em    = linear(b0_p2_p3_em,    a0_p2_p3_em,    (VSubS)); \
    p3_p3_em    = linear(b0_p3_p3_em,    a0_p3_p3_em,    (VSubS)); \
    p4_p3_em    = linear(b0_p4_p3_em,    a0_p4_p3_em,    (VSubS)); \
    b0_p4_em    = linear(b0_b0_p4_em,    a0_b0_p4_em,    (VSubS)); \
    a0_p4_em    = linear(b0_a0_p4_em,    a0_a0_p4_em,    (VSubS)); \
    a1_p4_em    = linear(b0_a1_p4_em,    a0_a1_p4_em,    (VSubS)); \
    a2_p4_em    = linear(b0_a2_p4_em,    a0_a2_p4_em,    (VSubS)); \
    a3_p4_em    = linear(b0_a3_p4_em,    a0_a3_p4_em,    (VSubS)); \
    a4_p4_em    = linear(b0_a4_p4_em,    a0_a4_p4_em,    (VSubS)); \
    p1_p4_em    = linear(b0_p1_p4_em,    a0_p1_p4_em,    (VSubS)); \
    p2_p4_em    = linear(b0_p2_p4_em,    a0_p2_p4_em,    (VSubS)); \
    p3_p4_em    = linear(b0_p3_p4_em,    a0_p3_p4_em,    (VSubS)); \
    p4_p4_em    = linear(b0_p4_p4_em,    a0_p4_p4_em,    (VSubS)); \
    b0_em = linear_5reg(b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em, p2_b0_em, p3_b0_em, p4_b0_em, (VGS)); \
    a0_em = linear_5reg(b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em, a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, (VGS)); \
    a1_em = linear_5reg(b0_a1_em, a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em, p3_a1_em, p4_a1_em, (VGS)); \
    a2_em = linear_5reg(b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em, a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, (VGS)); \
    a3_em = linear_5reg(b0_a3_em, a0_a3_em, a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em, p4_a3_em, (VGS)); \
    a4_em = linear_5reg(b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em, p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, (VGS)); \
    p1_em = linear_5reg(b0_p1_em, a0_p1_em, a1_p1_em, a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em, (VGS)); \
    p2_em = linear_5reg(b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em, p2_p2_em, p3_p2_em, p4_p2_em, (VGS)); \
    p3_em = linear_5reg(b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em, a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, (VGS)); \
    p4_em = linear_5reg(b0_p4_em, a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em, p3_p4_em, p4_p4_em, (VGS)); \
    em    = linear_5reg(b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, (VDS));

`define EM2(T, VGS, VDS, VSubS) \
    b0_b0_b0_em2 = linear(b0_b0_b0_b0_em2, a0_b0_b0_b0_em2, (T)); \
    a0_b0_b0_em2 = linear(b0_a0_b0_b0_em2, a0_a0_b0_b0_em2, (T)); \
    b0_a0_b0_em2 = linear(b0_b0_a0_b0_em2, a0_b0_a0_b0_em2, (T)); \
    a0_a0_b0_em2 = linear(b0_a0_a0_b0_em2, a0_a0_a0_b0_em2, (T)); \
    b0_a1_b0_em2 = linear(b0_b0_a1_b0_em2, a0_b0_a1_b0_em2, (T)); \
    a0_a1_b0_em2 = linear(b0_a0_a1_b0_em2, a0_a0_a1_b0_em2, (T)); \
    b0_a2_b0_em2 = linear(b0_b0_a2_b0_em2, a0_b0_a2_b0_em2, (T)); \
    a0_a2_b0_em2 = linear(b0_a0_a2_b0_em2, a0_a0_a2_b0_em2, (T)); \
    b0_a3_b0_em2 = linear(b0_b0_a3_b0_em2, a0_b0_a3_b0_em2, (T)); \
    a0_a3_b0_em2 = linear(b0_a0_a3_b0_em2, a0_a0_a3_b0_em2, (T)); \
    b0_a4_b0_em2 = linear(b0_b0_a4_b0_em2, a0_b0_a4_b0_em2, (T)); \
    a0_a4_b0_em2 = linear(b0_a0_a4_b0_em2, a0_a0_a4_b0_em2, (T)); \
    b0_p1_b0_em2 = linear(b0_b0_p1_b0_em2, a0_b0_p1_b0_em2, (T)); \
    a0_p1_b0_em2 = linear(b0_a0_p1_b0_em2, a0_a0_p1_b0_em2, (T)); \
    b0_p2_b0_em2 = linear(b0_b0_p2_b0_em2, a0_b0_p2_b0_em2, (T)); \
    a0_p2_b0_em2 = linear(b0_a0_p2_b0_em2, a0_a0_p2_b0_em2, (T)); \
    b0_p3_b0_em2 = linear(b0_b0_p3_b0_em2, a0_b0_p3_b0_em2, (T)); \
    a0_p3_b0_em2 = linear(b0_a0_p3_b0_em2, a0_a0_p3_b0_em2, (T)); \
    b0_p4_b0_em2 = linear(b0_b0_p4_b0_em2, a0_b0_p4_b0_em2, (T)); \
    a0_p4_b0_em2 = linear(b0_a0_p4_b0_em2, a0_a0_p4_b0_em2, (T)); \
    b0_b0_a0_em2 = linear(b0_b0_b0_a0_em2, a0_b0_b0_a0_em2, (T)); \
    a0_b0_a0_em2 = linear(b0_a0_b0_a0_em2, a0_a0_b0_a0_em2, (T)); \
    b0_a0_a0_em2 = linear(b0_b0_a0_a0_em2, a0_b0_a0_a0_em2, (T)); \
    a0_a0_a0_em2 = linear(b0_a0_a0_a0_em2, a0_a0_a0_a0_em2, (T)); \
    b0_a1_a0_em2 = linear(b0_b0_a1_a0_em2, a0_b0_a1_a0_em2, (T)); \
    a0_a1_a0_em2 = linear(b0_a0_a1_a0_em2, a0_a0_a1_a0_em2, (T)); \
    b0_a2_a0_em2 = linear(b0_b0_a2_a0_em2, a0_b0_a2_a0_em2, (T)); \
    a0_a2_a0_em2 = linear(b0_a0_a2_a0_em2, a0_a0_a2_a0_em2, (T)); \
    b0_a3_a0_em2 = linear(b0_b0_a3_a0_em2, a0_b0_a3_a0_em2, (T)); \
    a0_a3_a0_em2 = linear(b0_a0_a3_a0_em2, a0_a0_a3_a0_em2, (T)); \
    b0_a4_a0_em2 = linear(b0_b0_a4_a0_em2, a0_b0_a4_a0_em2, (T)); \
    a0_a4_a0_em2 = linear(b0_a0_a4_a0_em2, a0_a0_a4_a0_em2, (T)); \
    b0_p1_a0_em2 = linear(b0_b0_p1_a0_em2, a0_b0_p1_a0_em2, (T)); \
    a0_p1_a0_em2 = linear(b0_a0_p1_a0_em2, a0_a0_p1_a0_em2, (T)); \
    b0_p2_a0_em2 = linear(b0_b0_p2_a0_em2, a0_b0_p2_a0_em2, (T)); \
    a0_p2_a0_em2 = linear(b0_a0_p2_a0_em2, a0_a0_p2_a0_em2, (T)); \
    b0_p3_a0_em2 = linear(b0_b0_p3_a0_em2, a0_b0_p3_a0_em2, (T)); \
    a0_p3_a0_em2 = linear(b0_a0_p3_a0_em2, a0_a0_p3_a0_em2, (T)); \
    b0_p4_a0_em2 = linear(b0_b0_p4_a0_em2, a0_b0_p4_a0_em2, (T)); \
    a0_p4_a0_em2 = linear(b0_a0_p4_a0_em2, a0_a0_p4_a0_em2, (T)); \
    b0_b0_a1_em2 = linear(b0_b0_b0_a1_em2, a0_b0_b0_a1_em2, (T)); \
    a0_b0_a1_em2 = linear(b0_a0_b0_a1_em2, a0_a0_b0_a1_em2, (T)); \
    b0_a0_a1_em2 = linear(b0_b0_a0_a1_em2, a0_b0_a0_a1_em2, (T)); \
    a0_a0_a1_em2 = linear(b0_a0_a0_a1_em2, a0_a0_a0_a1_em2, (T)); \
    b0_a1_a1_em2 = linear(b0_b0_a1_a1_em2, a0_b0_a1_a1_em2, (T)); \
    a0_a1_a1_em2 = linear(b0_a0_a1_a1_em2, a0_a0_a1_a1_em2, (T)); \
    b0_a2_a1_em2 = linear(b0_b0_a2_a1_em2, a0_b0_a2_a1_em2, (T)); \
    a0_a2_a1_em2 = linear(b0_a0_a2_a1_em2, a0_a0_a2_a1_em2, (T)); \
    b0_a3_a1_em2 = linear(b0_b0_a3_a1_em2, a0_b0_a3_a1_em2, (T)); \
    a0_a3_a1_em2 = linear(b0_a0_a3_a1_em2, a0_a0_a3_a1_em2, (T)); \
    b0_a4_a1_em2 = linear(b0_b0_a4_a1_em2, a0_b0_a4_a1_em2, (T)); \
    a0_a4_a1_em2 = linear(b0_a0_a4_a1_em2, a0_a0_a4_a1_em2, (T)); \
    b0_p1_a1_em2 = linear(b0_b0_p1_a1_em2, a0_b0_p1_a1_em2, (T)); \
    a0_p1_a1_em2 = linear(b0_a0_p1_a1_em2, a0_a0_p1_a1_em2, (T)); \
    b0_p2_a1_em2 = linear(b0_b0_p2_a1_em2, a0_b0_p2_a1_em2, (T)); \
    a0_p2_a1_em2 = linear(b0_a0_p2_a1_em2, a0_a0_p2_a1_em2, (T)); \
    b0_p3_a1_em2 = linear(b0_b0_p3_a1_em2, a0_b0_p3_a1_em2, (T)); \
    a0_p3_a1_em2 = linear(b0_a0_p3_a1_em2, a0_a0_p3_a1_em2, (T)); \
    b0_p4_a1_em2 = linear(b0_b0_p4_a1_em2, a0_b0_p4_a1_em2, (T)); \
    a0_p4_a1_em2 = linear(b0_a0_p4_a1_em2, a0_a0_p4_a1_em2, (T)); \
    b0_b0_a2_em2 = linear(b0_b0_b0_a2_em2, a0_b0_b0_a2_em2, (T)); \
    a0_b0_a2_em2 = linear(b0_a0_b0_a2_em2, a0_a0_b0_a2_em2, (T)); \
    b0_a0_a2_em2 = linear(b0_b0_a0_a2_em2, a0_b0_a0_a2_em2, (T)); \
    a0_a0_a2_em2 = linear(b0_a0_a0_a2_em2, a0_a0_a0_a2_em2, (T)); \
    b0_a1_a2_em2 = linear(b0_b0_a1_a2_em2, a0_b0_a1_a2_em2, (T)); \
    a0_a1_a2_em2 = linear(b0_a0_a1_a2_em2, a0_a0_a1_a2_em2, (T)); \
    b0_a2_a2_em2 = linear(b0_b0_a2_a2_em2, a0_b0_a2_a2_em2, (T)); \
    a0_a2_a2_em2 = linear(b0_a0_a2_a2_em2, a0_a0_a2_a2_em2, (T)); \
    b0_a3_a2_em2 = linear(b0_b0_a3_a2_em2, a0_b0_a3_a2_em2, (T)); \
    a0_a3_a2_em2 = linear(b0_a0_a3_a2_em2, a0_a0_a3_a2_em2, (T)); \
    b0_a4_a2_em2 = linear(b0_b0_a4_a2_em2, a0_b0_a4_a2_em2, (T)); \
    a0_a4_a2_em2 = linear(b0_a0_a4_a2_em2, a0_a0_a4_a2_em2, (T)); \
    b0_p1_a2_em2 = linear(b0_b0_p1_a2_em2, a0_b0_p1_a2_em2, (T)); \
    a0_p1_a2_em2 = linear(b0_a0_p1_a2_em2, a0_a0_p1_a2_em2, (T)); \
    b0_p2_a2_em2 = linear(b0_b0_p2_a2_em2, a0_b0_p2_a2_em2, (T)); \
    a0_p2_a2_em2 = linear(b0_a0_p2_a2_em2, a0_a0_p2_a2_em2, (T)); \
    b0_p3_a2_em2 = linear(b0_b0_p3_a2_em2, a0_b0_p3_a2_em2, (T)); \
    a0_p3_a2_em2 = linear(b0_a0_p3_a2_em2, a0_a0_p3_a2_em2, (T)); \
    b0_p4_a2_em2 = linear(b0_b0_p4_a2_em2, a0_b0_p4_a2_em2, (T)); \
    a0_p4_a2_em2 = linear(b0_a0_p4_a2_em2, a0_a0_p4_a2_em2, (T)); \
    b0_b0_a3_em2 = linear(b0_b0_b0_a3_em2, a0_b0_b0_a3_em2, (T)); \
    a0_b0_a3_em2 = linear(b0_a0_b0_a3_em2, a0_a0_b0_a3_em2, (T)); \
    b0_a0_a3_em2 = linear(b0_b0_a0_a3_em2, a0_b0_a0_a3_em2, (T)); \
    a0_a0_a3_em2 = linear(b0_a0_a0_a3_em2, a0_a0_a0_a3_em2, (T)); \
    b0_a1_a3_em2 = linear(b0_b0_a1_a3_em2, a0_b0_a1_a3_em2, (T)); \
    a0_a1_a3_em2 = linear(b0_a0_a1_a3_em2, a0_a0_a1_a3_em2, (T)); \
    b0_a2_a3_em2 = linear(b0_b0_a2_a3_em2, a0_b0_a2_a3_em2, (T)); \
    a0_a2_a3_em2 = linear(b0_a0_a2_a3_em2, a0_a0_a2_a3_em2, (T)); \
    b0_a3_a3_em2 = linear(b0_b0_a3_a3_em2, a0_b0_a3_a3_em2, (T)); \
    a0_a3_a3_em2 = linear(b0_a0_a3_a3_em2, a0_a0_a3_a3_em2, (T)); \
    b0_a4_a3_em2 = linear(b0_b0_a4_a3_em2, a0_b0_a4_a3_em2, (T)); \
    a0_a4_a3_em2 = linear(b0_a0_a4_a3_em2, a0_a0_a4_a3_em2, (T)); \
    b0_p1_a3_em2 = linear(b0_b0_p1_a3_em2, a0_b0_p1_a3_em2, (T)); \
    a0_p1_a3_em2 = linear(b0_a0_p1_a3_em2, a0_a0_p1_a3_em2, (T)); \
    b0_p2_a3_em2 = linear(b0_b0_p2_a3_em2, a0_b0_p2_a3_em2, (T)); \
    a0_p2_a3_em2 = linear(b0_a0_p2_a3_em2, a0_a0_p2_a3_em2, (T)); \
    b0_p3_a3_em2 = linear(b0_b0_p3_a3_em2, a0_b0_p3_a3_em2, (T)); \
    a0_p3_a3_em2 = linear(b0_a0_p3_a3_em2, a0_a0_p3_a3_em2, (T)); \
    b0_p4_a3_em2 = linear(b0_b0_p4_a3_em2, a0_b0_p4_a3_em2, (T)); \
    a0_p4_a3_em2 = linear(b0_a0_p4_a3_em2, a0_a0_p4_a3_em2, (T)); \
    b0_b0_a4_em2 = linear(b0_b0_b0_a4_em2, a0_b0_b0_a4_em2, (T)); \
    a0_b0_a4_em2 = linear(b0_a0_b0_a4_em2, a0_a0_b0_a4_em2, (T)); \
    b0_a0_a4_em2 = linear(b0_b0_a0_a4_em2, a0_b0_a0_a4_em2, (T)); \
    a0_a0_a4_em2 = linear(b0_a0_a0_a4_em2, a0_a0_a0_a4_em2, (T)); \
    b0_a1_a4_em2 = linear(b0_b0_a1_a4_em2, a0_b0_a1_a4_em2, (T)); \
    a0_a1_a4_em2 = linear(b0_a0_a1_a4_em2, a0_a0_a1_a4_em2, (T)); \
    b0_a2_a4_em2 = linear(b0_b0_a2_a4_em2, a0_b0_a2_a4_em2, (T)); \
    a0_a2_a4_em2 = linear(b0_a0_a2_a4_em2, a0_a0_a2_a4_em2, (T)); \
    b0_a3_a4_em2 = linear(b0_b0_a3_a4_em2, a0_b0_a3_a4_em2, (T)); \
    a0_a3_a4_em2 = linear(b0_a0_a3_a4_em2, a0_a0_a3_a4_em2, (T)); \
    b0_a4_a4_em2 = linear(b0_b0_a4_a4_em2, a0_b0_a4_a4_em2, (T)); \
    a0_a4_a4_em2 = linear(b0_a0_a4_a4_em2, a0_a0_a4_a4_em2, (T)); \
    b0_p1_a4_em2 = linear(b0_b0_p1_a4_em2, a0_b0_p1_a4_em2, (T)); \
    a0_p1_a4_em2 = linear(b0_a0_p1_a4_em2, a0_a0_p1_a4_em2, (T)); \
    b0_p2_a4_em2 = linear(b0_b0_p2_a4_em2, a0_b0_p2_a4_em2, (T)); \
    a0_p2_a4_em2 = linear(b0_a0_p2_a4_em2, a0_a0_p2_a4_em2, (T)); \
    b0_p3_a4_em2 = linear(b0_b0_p3_a4_em2, a0_b0_p3_a4_em2, (T)); \
    a0_p3_a4_em2 = linear(b0_a0_p3_a4_em2, a0_a0_p3_a4_em2, (T)); \
    b0_p4_a4_em2 = linear(b0_b0_p4_a4_em2, a0_b0_p4_a4_em2, (T)); \
    a0_p4_a4_em2 = linear(b0_a0_p4_a4_em2, a0_a0_p4_a4_em2, (T)); \
    b0_b0_p1_em2 = linear(b0_b0_b0_p1_em2, a0_b0_b0_p1_em2, (T)); \
    a0_b0_p1_em2 = linear(b0_a0_b0_p1_em2, a0_a0_b0_p1_em2, (T)); \
    b0_a0_p1_em2 = linear(b0_b0_a0_p1_em2, a0_b0_a0_p1_em2, (T)); \
    a0_a0_p1_em2 = linear(b0_a0_a0_p1_em2, a0_a0_a0_p1_em2, (T)); \
    b0_a1_p1_em2 = linear(b0_b0_a1_p1_em2, a0_b0_a1_p1_em2, (T)); \
    a0_a1_p1_em2 = linear(b0_a0_a1_p1_em2, a0_a0_a1_p1_em2, (T)); \
    b0_a2_p1_em2 = linear(b0_b0_a2_p1_em2, a0_b0_a2_p1_em2, (T)); \
    a0_a2_p1_em2 = linear(b0_a0_a2_p1_em2, a0_a0_a2_p1_em2, (T)); \
    b0_a3_p1_em2 = linear(b0_b0_a3_p1_em2, a0_b0_a3_p1_em2, (T)); \
    a0_a3_p1_em2 = linear(b0_a0_a3_p1_em2, a0_a0_a3_p1_em2, (T)); \
    b0_a4_p1_em2 = linear(b0_b0_a4_p1_em2, a0_b0_a4_p1_em2, (T)); \
    a0_a4_p1_em2 = linear(b0_a0_a4_p1_em2, a0_a0_a4_p1_em2, (T)); \
    b0_p1_p1_em2 = linear(b0_b0_p1_p1_em2, a0_b0_p1_p1_em2, (T)); \
    a0_p1_p1_em2 = linear(b0_a0_p1_p1_em2, a0_a0_p1_p1_em2, (T)); \
    b0_p2_p1_em2 = linear(b0_b0_p2_p1_em2, a0_b0_p2_p1_em2, (T)); \
    a0_p2_p1_em2 = linear(b0_a0_p2_p1_em2, a0_a0_p2_p1_em2, (T)); \
    b0_p3_p1_em2 = linear(b0_b0_p3_p1_em2, a0_b0_p3_p1_em2, (T)); \
    a0_p3_p1_em2 = linear(b0_a0_p3_p1_em2, a0_a0_p3_p1_em2, (T)); \
    b0_p4_p1_em2 = linear(b0_b0_p4_p1_em2, a0_b0_p4_p1_em2, (T)); \
    a0_p4_p1_em2 = linear(b0_a0_p4_p1_em2, a0_a0_p4_p1_em2, (T)); \
    b0_b0_p2_em2 = linear(b0_b0_b0_p2_em2, a0_b0_b0_p2_em2, (T)); \
    a0_b0_p2_em2 = linear(b0_a0_b0_p2_em2, a0_a0_b0_p2_em2, (T)); \
    b0_a0_p2_em2 = linear(b0_b0_a0_p2_em2, a0_b0_a0_p2_em2, (T)); \
    a0_a0_p2_em2 = linear(b0_a0_a0_p2_em2, a0_a0_a0_p2_em2, (T)); \
    b0_a1_p2_em2 = linear(b0_b0_a1_p2_em2, a0_b0_a1_p2_em2, (T)); \
    a0_a1_p2_em2 = linear(b0_a0_a1_p2_em2, a0_a0_a1_p2_em2, (T)); \
    b0_a2_p2_em2 = linear(b0_b0_a2_p2_em2, a0_b0_a2_p2_em2, (T)); \
    a0_a2_p2_em2 = linear(b0_a0_a2_p2_em2, a0_a0_a2_p2_em2, (T)); \
    b0_a3_p2_em2 = linear(b0_b0_a3_p2_em2, a0_b0_a3_p2_em2, (T)); \
    a0_a3_p2_em2 = linear(b0_a0_a3_p2_em2, a0_a0_a3_p2_em2, (T)); \
    b0_a4_p2_em2 = linear(b0_b0_a4_p2_em2, a0_b0_a4_p2_em2, (T)); \
    a0_a4_p2_em2 = linear(b0_a0_a4_p2_em2, a0_a0_a4_p2_em2, (T)); \
    b0_p1_p2_em2 = linear(b0_b0_p1_p2_em2, a0_b0_p1_p2_em2, (T)); \
    a0_p1_p2_em2 = linear(b0_a0_p1_p2_em2, a0_a0_p1_p2_em2, (T)); \
    b0_p2_p2_em2 = linear(b0_b0_p2_p2_em2, a0_b0_p2_p2_em2, (T)); \
    a0_p2_p2_em2 = linear(b0_a0_p2_p2_em2, a0_a0_p2_p2_em2, (T)); \
    b0_p3_p2_em2 = linear(b0_b0_p3_p2_em2, a0_b0_p3_p2_em2, (T)); \
    a0_p3_p2_em2 = linear(b0_a0_p3_p2_em2, a0_a0_p3_p2_em2, (T)); \
    b0_p4_p2_em2 = linear(b0_b0_p4_p2_em2, a0_b0_p4_p2_em2, (T)); \
    a0_p4_p2_em2 = linear(b0_a0_p4_p2_em2, a0_a0_p4_p2_em2, (T)); \
    b0_b0_p3_em2 = linear(b0_b0_b0_p3_em2, a0_b0_b0_p3_em2, (T)); \
    a0_b0_p3_em2 = linear(b0_a0_b0_p3_em2, a0_a0_b0_p3_em2, (T)); \
    b0_a0_p3_em2 = linear(b0_b0_a0_p3_em2, a0_b0_a0_p3_em2, (T)); \
    a0_a0_p3_em2 = linear(b0_a0_a0_p3_em2, a0_a0_a0_p3_em2, (T)); \
    b0_a1_p3_em2 = linear(b0_b0_a1_p3_em2, a0_b0_a1_p3_em2, (T)); \
    a0_a1_p3_em2 = linear(b0_a0_a1_p3_em2, a0_a0_a1_p3_em2, (T)); \
    b0_a2_p3_em2 = linear(b0_b0_a2_p3_em2, a0_b0_a2_p3_em2, (T)); \
    a0_a2_p3_em2 = linear(b0_a0_a2_p3_em2, a0_a0_a2_p3_em2, (T)); \
    b0_a3_p3_em2 = linear(b0_b0_a3_p3_em2, a0_b0_a3_p3_em2, (T)); \
    a0_a3_p3_em2 = linear(b0_a0_a3_p3_em2, a0_a0_a3_p3_em2, (T)); \
    b0_a4_p3_em2 = linear(b0_b0_a4_p3_em2, a0_b0_a4_p3_em2, (T)); \
    a0_a4_p3_em2 = linear(b0_a0_a4_p3_em2, a0_a0_a4_p3_em2, (T)); \
    b0_p1_p3_em2 = linear(b0_b0_p1_p3_em2, a0_b0_p1_p3_em2, (T)); \
    a0_p1_p3_em2 = linear(b0_a0_p1_p3_em2, a0_a0_p1_p3_em2, (T)); \
    b0_p2_p3_em2 = linear(b0_b0_p2_p3_em2, a0_b0_p2_p3_em2, (T)); \
    a0_p2_p3_em2 = linear(b0_a0_p2_p3_em2, a0_a0_p2_p3_em2, (T)); \
    b0_p3_p3_em2 = linear(b0_b0_p3_p3_em2, a0_b0_p3_p3_em2, (T)); \
    a0_p3_p3_em2 = linear(b0_a0_p3_p3_em2, a0_a0_p3_p3_em2, (T)); \
    b0_p4_p3_em2 = linear(b0_b0_p4_p3_em2, a0_b0_p4_p3_em2, (T)); \
    a0_p4_p3_em2 = linear(b0_a0_p4_p3_em2, a0_a0_p4_p3_em2, (T)); \
    b0_b0_p4_em2 = linear(b0_b0_b0_p4_em2, a0_b0_b0_p4_em2, (T)); \
    a0_b0_p4_em2 = linear(b0_a0_b0_p4_em2, a0_a0_b0_p4_em2, (T)); \
    b0_a0_p4_em2 = linear(b0_b0_a0_p4_em2, a0_b0_a0_p4_em2, (T)); \
    a0_a0_p4_em2 = linear(b0_a0_a0_p4_em2, a0_a0_a0_p4_em2, (T)); \
    b0_a1_p4_em2 = linear(b0_b0_a1_p4_em2, a0_b0_a1_p4_em2, (T)); \
    a0_a1_p4_em2 = linear(b0_a0_a1_p4_em2, a0_a0_a1_p4_em2, (T)); \
    b0_a2_p4_em2 = linear(b0_b0_a2_p4_em2, a0_b0_a2_p4_em2, (T)); \
    a0_a2_p4_em2 = linear(b0_a0_a2_p4_em2, a0_a0_a2_p4_em2, (T)); \
    b0_a3_p4_em2 = linear(b0_b0_a3_p4_em2, a0_b0_a3_p4_em2, (T)); \
    a0_a3_p4_em2 = linear(b0_a0_a3_p4_em2, a0_a0_a3_p4_em2, (T)); \
    b0_a4_p4_em2 = linear(b0_b0_a4_p4_em2, a0_b0_a4_p4_em2, (T)); \
    a0_a4_p4_em2 = linear(b0_a0_a4_p4_em2, a0_a0_a4_p4_em2, (T)); \
    b0_p1_p4_em2 = linear(b0_b0_p1_p4_em2, a0_b0_p1_p4_em2, (T)); \
    a0_p1_p4_em2 = linear(b0_a0_p1_p4_em2, a0_a0_p1_p4_em2, (T)); \
    b0_p2_p4_em2 = linear(b0_b0_p2_p4_em2, a0_b0_p2_p4_em2, (T)); \
    a0_p2_p4_em2 = linear(b0_a0_p2_p4_em2, a0_a0_p2_p4_em2, (T)); \
    b0_p3_p4_em2 = linear(b0_b0_p3_p4_em2, a0_b0_p3_p4_em2, (T)); \
    a0_p3_p4_em2 = linear(b0_a0_p3_p4_em2, a0_a0_p3_p4_em2, (T)); \
    b0_p4_p4_em2 = linear(b0_b0_p4_p4_em2, a0_b0_p4_p4_em2, (T)); \
    a0_p4_p4_em2 = linear(b0_a0_p4_p4_em2, a0_a0_p4_p4_em2, (T)); \
    b0_b0_em2    = linear(b0_b0_b0_em2,    a0_b0_b0_em2,    (VSubS)); \
    a0_b0_em2    = linear(b0_a0_b0_em2,    a0_a0_b0_em2,    (VSubS)); \
    a1_b0_em2    = linear(b0_a1_b0_em2,    a0_a1_b0_em2,    (VSubS)); \
    a2_b0_em2    = linear(b0_a2_b0_em2,    a0_a2_b0_em2,    (VSubS)); \
    a3_b0_em2    = linear(b0_a3_b0_em2,    a0_a3_b0_em2,    (VSubS)); \
    a4_b0_em2    = linear(b0_a4_b0_em2,    a0_a4_b0_em2,    (VSubS)); \
    p1_b0_em2    = linear(b0_p1_b0_em2,    a0_p1_b0_em2,    (VSubS)); \
    p2_b0_em2    = linear(b0_p2_b0_em2,    a0_p2_b0_em2,    (VSubS)); \
    p3_b0_em2    = linear(b0_p3_b0_em2,    a0_p3_b0_em2,    (VSubS)); \
    p4_b0_em2    = linear(b0_p4_b0_em2,    a0_p4_b0_em2,    (VSubS)); \
    b0_a0_em2    = linear(b0_b0_a0_em2,    a0_b0_a0_em2,    (VSubS)); \
    a0_a0_em2    = linear(b0_a0_a0_em2,    a0_a0_a0_em2,    (VSubS)); \
    a1_a0_em2    = linear(b0_a1_a0_em2,    a0_a1_a0_em2,    (VSubS)); \
    a2_a0_em2    = linear(b0_a2_a0_em2,    a0_a2_a0_em2,    (VSubS)); \
    a3_a0_em2    = linear(b0_a3_a0_em2,    a0_a3_a0_em2,    (VSubS)); \
    a4_a0_em2    = linear(b0_a4_a0_em2,    a0_a4_a0_em2,    (VSubS)); \
    p1_a0_em2    = linear(b0_p1_a0_em2,    a0_p1_a0_em2,    (VSubS)); \
    p2_a0_em2    = linear(b0_p2_a0_em2,    a0_p2_a0_em2,    (VSubS)); \
    p3_a0_em2    = linear(b0_p3_a0_em2,    a0_p3_a0_em2,    (VSubS)); \
    p4_a0_em2    = linear(b0_p4_a0_em2,    a0_p4_a0_em2,    (VSubS)); \
    b0_a1_em2    = linear(b0_b0_a1_em2,    a0_b0_a1_em2,    (VSubS)); \
    a0_a1_em2    = linear(b0_a0_a1_em2,    a0_a0_a1_em2,    (VSubS)); \
    a1_a1_em2    = linear(b0_a1_a1_em2,    a0_a1_a1_em2,    (VSubS)); \
    a2_a1_em2    = linear(b0_a2_a1_em2,    a0_a2_a1_em2,    (VSubS)); \
    a3_a1_em2    = linear(b0_a3_a1_em2,    a0_a3_a1_em2,    (VSubS)); \
    a4_a1_em2    = linear(b0_a4_a1_em2,    a0_a4_a1_em2,    (VSubS)); \
    p1_a1_em2    = linear(b0_p1_a1_em2,    a0_p1_a1_em2,    (VSubS)); \
    p2_a1_em2    = linear(b0_p2_a1_em2,    a0_p2_a1_em2,    (VSubS)); \
    p3_a1_em2    = linear(b0_p3_a1_em2,    a0_p3_a1_em2,    (VSubS)); \
    p4_a1_em2    = linear(b0_p4_a1_em2,    a0_p4_a1_em2,    (VSubS)); \
    b0_a2_em2    = linear(b0_b0_a2_em2,    a0_b0_a2_em2,    (VSubS)); \
    a0_a2_em2    = linear(b0_a0_a2_em2,    a0_a0_a2_em2,    (VSubS)); \
    a1_a2_em2    = linear(b0_a1_a2_em2,    a0_a1_a2_em2,    (VSubS)); \
    a2_a2_em2    = linear(b0_a2_a2_em2,    a0_a2_a2_em2,    (VSubS)); \
    a3_a2_em2    = linear(b0_a3_a2_em2,    a0_a3_a2_em2,    (VSubS)); \
    a4_a2_em2    = linear(b0_a4_a2_em2,    a0_a4_a2_em2,    (VSubS)); \
    p1_a2_em2    = linear(b0_p1_a2_em2,    a0_p1_a2_em2,    (VSubS)); \
    p2_a2_em2    = linear(b0_p2_a2_em2,    a0_p2_a2_em2,    (VSubS)); \
    p3_a2_em2    = linear(b0_p3_a2_em2,    a0_p3_a2_em2,    (VSubS)); \
    p4_a2_em2    = linear(b0_p4_a2_em2,    a0_p4_a2_em2,    (VSubS)); \
    b0_a3_em2    = linear(b0_b0_a3_em2,    a0_b0_a3_em2,    (VSubS)); \
    a0_a3_em2    = linear(b0_a0_a3_em2,    a0_a0_a3_em2,    (VSubS)); \
    a1_a3_em2    = linear(b0_a1_a3_em2,    a0_a1_a3_em2,    (VSubS)); \
    a2_a3_em2    = linear(b0_a2_a3_em2,    a0_a2_a3_em2,    (VSubS)); \
    a3_a3_em2    = linear(b0_a3_a3_em2,    a0_a3_a3_em2,    (VSubS)); \
    a4_a3_em2    = linear(b0_a4_a3_em2,    a0_a4_a3_em2,    (VSubS)); \
    p1_a3_em2    = linear(b0_p1_a3_em2,    a0_p1_a3_em2,    (VSubS)); \
    p2_a3_em2    = linear(b0_p2_a3_em2,    a0_p2_a3_em2,    (VSubS)); \
    p3_a3_em2    = linear(b0_p3_a3_em2,    a0_p3_a3_em2,    (VSubS)); \
    p4_a3_em2    = linear(b0_p4_a3_em2,    a0_p4_a3_em2,    (VSubS)); \
    b0_a4_em2    = linear(b0_b0_a4_em2,    a0_b0_a4_em2,    (VSubS)); \
    a0_a4_em2    = linear(b0_a0_a4_em2,    a0_a0_a4_em2,    (VSubS)); \
    a1_a4_em2    = linear(b0_a1_a4_em2,    a0_a1_a4_em2,    (VSubS)); \
    a2_a4_em2    = linear(b0_a2_a4_em2,    a0_a2_a4_em2,    (VSubS)); \
    a3_a4_em2    = linear(b0_a3_a4_em2,    a0_a3_a4_em2,    (VSubS)); \
    a4_a4_em2    = linear(b0_a4_a4_em2,    a0_a4_a4_em2,    (VSubS)); \
    p1_a4_em2    = linear(b0_p1_a4_em2,    a0_p1_a4_em2,    (VSubS)); \
    p2_a4_em2    = linear(b0_p2_a4_em2,    a0_p2_a4_em2,    (VSubS)); \
    p3_a4_em2    = linear(b0_p3_a4_em2,    a0_p3_a4_em2,    (VSubS)); \
    p4_a4_em2    = linear(b0_p4_a4_em2,    a0_p4_a4_em2,    (VSubS)); \
    b0_p1_em2    = linear(b0_b0_p1_em2,    a0_b0_p1_em2,    (VSubS)); \
    a0_p1_em2    = linear(b0_a0_p1_em2,    a0_a0_p1_em2,    (VSubS)); \
    a1_p1_em2    = linear(b0_a1_p1_em2,    a0_a1_p1_em2,    (VSubS)); \
    a2_p1_em2    = linear(b0_a2_p1_em2,    a0_a2_p1_em2,    (VSubS)); \
    a3_p1_em2    = linear(b0_a3_p1_em2,    a0_a3_p1_em2,    (VSubS)); \
    a4_p1_em2    = linear(b0_a4_p1_em2,    a0_a4_p1_em2,    (VSubS)); \
    p1_p1_em2    = linear(b0_p1_p1_em2,    a0_p1_p1_em2,    (VSubS)); \
    p2_p1_em2    = linear(b0_p2_p1_em2,    a0_p2_p1_em2,    (VSubS)); \
    p3_p1_em2    = linear(b0_p3_p1_em2,    a0_p3_p1_em2,    (VSubS)); \
    p4_p1_em2    = linear(b0_p4_p1_em2,    a0_p4_p1_em2,    (VSubS)); \
    b0_p2_em2    = linear(b0_b0_p2_em2,    a0_b0_p2_em2,    (VSubS)); \
    a0_p2_em2    = linear(b0_a0_p2_em2,    a0_a0_p2_em2,    (VSubS)); \
    a1_p2_em2    = linear(b0_a1_p2_em2,    a0_a1_p2_em2,    (VSubS)); \
    a2_p2_em2    = linear(b0_a2_p2_em2,    a0_a2_p2_em2,    (VSubS)); \
    a3_p2_em2    = linear(b0_a3_p2_em2,    a0_a3_p2_em2,    (VSubS)); \
    a4_p2_em2    = linear(b0_a4_p2_em2,    a0_a4_p2_em2,    (VSubS)); \
    p1_p2_em2    = linear(b0_p1_p2_em2,    a0_p1_p2_em2,    (VSubS)); \
    p2_p2_em2    = linear(b0_p2_p2_em2,    a0_p2_p2_em2,    (VSubS)); \
    p3_p2_em2    = linear(b0_p3_p2_em2,    a0_p3_p2_em2,    (VSubS)); \
    p4_p2_em2    = linear(b0_p4_p2_em2,    a0_p4_p2_em2,    (VSubS)); \
    b0_p3_em2    = linear(b0_b0_p3_em2,    a0_b0_p3_em2,    (VSubS)); \
    a0_p3_em2    = linear(b0_a0_p3_em2,    a0_a0_p3_em2,    (VSubS)); \
    a1_p3_em2    = linear(b0_a1_p3_em2,    a0_a1_p3_em2,    (VSubS)); \
    a2_p3_em2    = linear(b0_a2_p3_em2,    a0_a2_p3_em2,    (VSubS)); \
    a3_p3_em2    = linear(b0_a3_p3_em2,    a0_a3_p3_em2,    (VSubS)); \
    a4_p3_em2    = linear(b0_a4_p3_em2,    a0_a4_p3_em2,    (VSubS)); \
    p1_p3_em2    = linear(b0_p1_p3_em2,    a0_p1_p3_em2,    (VSubS)); \
    p2_p3_em2    = linear(b0_p2_p3_em2,    a0_p2_p3_em2,    (VSubS)); \
    p3_p3_em2    = linear(b0_p3_p3_em2,    a0_p3_p3_em2,    (VSubS)); \
    p4_p3_em2    = linear(b0_p4_p3_em2,    a0_p4_p3_em2,    (VSubS)); \
    b0_p4_em2    = linear(b0_b0_p4_em2,    a0_b0_p4_em2,    (VSubS)); \
    a0_p4_em2    = linear(b0_a0_p4_em2,    a0_a0_p4_em2,    (VSubS)); \
    a1_p4_em2    = linear(b0_a1_p4_em2,    a0_a1_p4_em2,    (VSubS)); \
    a2_p4_em2    = linear(b0_a2_p4_em2,    a0_a2_p4_em2,    (VSubS)); \
    a3_p4_em2    = linear(b0_a3_p4_em2,    a0_a3_p4_em2,    (VSubS)); \
    a4_p4_em2    = linear(b0_a4_p4_em2,    a0_a4_p4_em2,    (VSubS)); \
    p1_p4_em2    = linear(b0_p1_p4_em2,    a0_p1_p4_em2,    (VSubS)); \
    p2_p4_em2    = linear(b0_p2_p4_em2,    a0_p2_p4_em2,    (VSubS)); \
    p3_p4_em2    = linear(b0_p3_p4_em2,    a0_p3_p4_em2,    (VSubS)); \
    p4_p4_em2    = linear(b0_p4_p4_em2,    a0_p4_p4_em2,    (VSubS)); \
    b0_em2 = linear_5reg(b0_b0_em2, a0_b0_em2, a1_b0_em2, a2_b0_em2, a3_b0_em2, a4_b0_em2, p1_b0_em2, p2_b0_em2, p3_b0_em2, p4_b0_em2, (VGS)); \
    a0_em2 = linear_5reg(b0_a0_em2, a0_a0_em2, a1_a0_em2, a2_a0_em2, a3_a0_em2, a4_a0_em2, p1_a0_em2, p2_a0_em2, p3_a0_em2, p4_a0_em2, (VGS)); \
    a1_em2 = linear_5reg(b0_a1_em2, a0_a1_em2, a1_a1_em2, a2_a1_em2, a3_a1_em2, a4_a1_em2, p1_a1_em2, p2_a1_em2, p3_a1_em2, p4_a1_em2, (VGS)); \
    a2_em2 = linear_5reg(b0_a2_em2, a0_a2_em2, a1_a2_em2, a2_a2_em2, a3_a2_em2, a4_a2_em2, p1_a2_em2, p2_a2_em2, p3_a2_em2, p4_a2_em2, (VGS)); \
    a3_em2 = linear_5reg(b0_a3_em2, a0_a3_em2, a1_a3_em2, a2_a3_em2, a3_a3_em2, a4_a3_em2, p1_a3_em2, p2_a3_em2, p3_a3_em2, p4_a3_em2, (VGS)); \
    a4_em2 = linear_5reg(b0_a4_em2, a0_a4_em2, a1_a4_em2, a2_a4_em2, a3_a4_em2, a4_a4_em2, p1_a4_em2, p2_a4_em2, p3_a4_em2, p4_a4_em2, (VGS)); \
    p1_em2 = linear_5reg(b0_p1_em2, a0_p1_em2, a1_p1_em2, a2_p1_em2, a3_p1_em2, a4_p1_em2, p1_p1_em2, p2_p1_em2, p3_p1_em2, p4_p1_em2, (VGS)); \
    p2_em2 = linear_5reg(b0_p2_em2, a0_p2_em2, a1_p2_em2, a2_p2_em2, a3_p2_em2, a4_p2_em2, p1_p2_em2, p2_p2_em2, p3_p2_em2, p4_p2_em2, (VGS)); \
    p3_em2 = linear_5reg(b0_p3_em2, a0_p3_em2, a1_p3_em2, a2_p3_em2, a3_p3_em2, a4_p3_em2, p1_p3_em2, p2_p3_em2, p3_p3_em2, p4_p3_em2, (VGS)); \
    p4_em2 = linear_5reg(b0_p4_em2, a0_p4_em2, a1_p4_em2, a2_p4_em2, a3_p4_em2, a4_p4_em2, p1_p4_em2, p2_p4_em2, p3_p4_em2, p4_p4_em2, (VGS)); \
    em2    = linear_5reg(b0_em2, a0_em2, a1_em2, a2_em2, a3_em2, a4_em2, p1_em2, p2_em2, p3_em2, p4_em2, (VDS));


module relimo_aging_nbti(d,g,s);
input d,g,s;
electrical d,g,s;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_nbti_aging_open_flag  = 0;
parameter real        relimo_pbti_aging_open_flag  = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
//parameter real        relimo_nh                    = 0.332;
//parameter real        relimo_vdd                   = 0.0;

parameter real        relimo_n                     = 1;
parameter real        relimo_intercept             = 1;
parameter real        relimo_c                     = 1;


// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, vdsmax, vgsmax; 
real dt, last_abstime; 
real damage, delta_damage, last_delta_damage, delta_vth; 
   
// Start simulatoin
analog begin
	if(relimo_nbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			vgs = -max(-vgs, -(vgs-vds));
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			vddtransistor = abs(vgs);
//			if(vgs <= 0 && abs(vgs) >= abs(vds) && abs(vds) <= relimo_nh*relimo_vdd) begin 
			if(vgs <= 0 && abs(vds) >= 0) begin 
                                if(vddtransistor==0) begin
					delta_damage = 0;
				end else begin
					delta_damage = relimo_intercept*pow(vddtransistor, relimo_c);
				end
			end else begin
				delta_damage = 0;
			end
//			$display ("%M, %e, %e, %e, %e", vddtransistor, delta_damage, vgs, vds);
			if($abstime>=relimo_aging_tstart) begin
				dt                = ($abstime - last_abstime);	
				last_abstime      = $abstime;			
				damage            = damage+dt/2*(delta_damage+last_delta_damage);
				last_delta_damage = delta_damage;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime   = $abstime;
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
				if ($abstime > relimo_aging_tstart) begin
					//damage = damage*relimo_aging_time/(24*365.24)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature)); 
					damage = (damage)*relimo_aging_time/($abstime-relimo_aging_tstart);    
				end else begin
					damage = 0;
				end
			end else begin
				damage = delta_damage*relimo_aging_time;      
      			end
			//delta_vth = relimo_a_vth*pow(damage, relimo_n);
			delta_vth = damage;
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s probe_name %s\n", relimo_device_name, relimo_probe_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", delta_vth);
			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", relimo_n);
			
			$fwrite (results_aging_bi, "instance %M delta_u0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_nbti %e\n", 0.0);

			if(relimo_pbti_aging_open_flag == 0) begin
				$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", 0.0);
				$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", 1.0);
				$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);

				$fwrite (results_aging_bi, "instance %M delta_u0_bi_pbti %e\n", 0.0);
				$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_pbti %e\n", 0.0);
				$fwrite (results_aging_bi, "instance %M delta_a0_bi_pbti %e\n", 0.0);
			end
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
			if ($abstime > relimo_aging_tstart) begin
				damage = (damage)*(relimo_aging_time)*(24*365.24)/($abstime-relimo_aging_tstart);     
			end else begin
				damage = 0;
      			end
			delta_vth = damage;
			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", delta_vth);
			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", relimo_n);
			
			$fwrite (results_aging_op, "instance %M delta_u0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_nbti %e\n", 0.0);

			if(relimo_pbti_aging_open_flag == 0) begin
				$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", 0.0);
				$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", 1.0);
				$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);

				$fwrite (results_aging_op, "instance %M delta_u0_op_pbti %e\n", 0.0);
				$fwrite (results_aging_op, "instance %M delta_rdsw_op_pbti %e\n", 0.0);
				$fwrite (results_aging_op, "instance %M delta_a0_op_pbti %e\n", 0.0);
			end
		end
	end	
end
endmodule

module relimo_aging_pbti;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_pbti_aging_open_flag  = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_technology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_nh                    = 0.332;
parameter real        relimo_vdd                   = 0.0;
parameter real        relimo_e                     = 1;
parameter real        relimo_n                     = 1;
parameter real        relimo_intercept             = 1;
parameter real        relimo_c                     = 1;
parameter real        relimo_kb                    = 1;
parameter real        relimo_a_vth                 = 1;
//parameter real        relimo_a_u0                  = 1;
//parameter real        relimo_a_rdsw                = 1;
//parameter real        relimo_a_vsat                = 1;

// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, vdsmax, vgsmax; 
real dt, last_abstime; 
real damage, delta_damage, last_delta_damage, delta_vth; 
   
// Start simulatoin
analog begin
	if(relimo_pbti_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = $simprobe(relimo_probe_name, "vgs");
			vds = $simprobe(relimo_probe_name, "vds");
			vgs = max(vgs, vgs-vds);
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			vddtransistor = max(abs(vds), abs(vgs));
			
//			if(vgs >= 0 && abs(vgs) >= abs(vds) && abs(vds) <= relimo_nh*relimo_vdd) begin 
			if(vgs >= 0 && abs(vds) <= relimo_nh*relimo_vdd) begin 
                                if(vddtransistor==0) begin
					delta_damage = 0;
				end else begin
					delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
				end
			end else begin
				delta_damage = 0;
			end
			if($abstime>=relimo_aging_tstart) begin
				dt                = ($abstime - last_abstime);	
				last_abstime      = $abstime;			
				damage            = damage+dt/2*(delta_damage+last_delta_damage);
				last_delta_damage = delta_damage;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime   = $abstime;
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
				if ($abstime > relimo_aging_tstart) begin
					damage = damage*relimo_aging_time/(24*365.24)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));     
				end else begin
					damage = 0;
				end
			end else begin
				damage = delta_damage*relimo_aging_time/(24*365.24)*exp(-1*relimo_e/relimo_kb/$temperature);      
      			end
			delta_vth = relimo_a_vth*pow(damage, relimo_n);
			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);

			$fwrite (results_aging_bi, "instance %M relimo_n_nbti %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_nbti %e\n", 0.0);

			$fwrite (results_aging_bi, "instance %M delta_u0_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_nbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_nbti %e\n", 0.0);

			$fwrite (results_aging_bi, "instance %M delta_vth_bi_pbti %e\n", delta_vth);
			$fwrite (results_aging_bi, "instance %M relimo_n_pbti %e\n", relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_pbti %e delta_vth_bi_pbti_spl %e\n", 0.0, 1.0);

			$fwrite (results_aging_bi, "instance %M delta_u0_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_rdsw_bi_pbti %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_a0_bi_pbti %e\n", 0.0);
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
			if ($abstime > relimo_aging_tstart) begin
				damage = damage*relimo_aging_time/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));     
			end else begin
				damage = 0;
      			end
			delta_vth = relimo_a_vth*pow(damage, relimo_n);
			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);

			$fwrite (results_aging_op, "instance %M relimo_n_nbti %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_vth_op_nbti %e\n", 0.0);

			$fwrite (results_aging_op, "instance %M delta_u0_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_nbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_nbti %e\n", 0.0);

			$fwrite (results_aging_op, "instance %M delta_vth_op_pbti %e\n", delta_vth);
			$fwrite (results_aging_op, "instance %M relimo_n_pbti %e\n", relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_pbti %e delta_vth_op_pbti_spl %e\n", 0.0, 1.0);

			$fwrite (results_aging_op, "instance %M delta_u0_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_rdsw_op_pbti %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_a0_op_pbti %e\n", 0.0);
		end
	end	
end
endmodule

module relimo_aging_hci1(d,g,s);
input d,g,s;
electrical d,g,s;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
//parameter real        relimo_e                     = 0;
//parameter real        relimo_kb                    = 0;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;
parameter real        relimo_vgsCutoff             = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, vdsmax, vgsmax;
real delta_damage, last_delta_damage, damage;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real work;
   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_m + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage = 0;
			if (vddtransistor == 0) begin
				delta_damage = 0;
			end else begin
				if(relimo_vth > 0) begin
					if(vgs > relimo_vgsCutoff) begin
						work = 1;
					end else begin
						work = 0;
					end
					if(work == 1) begin 
						delta_damage = exp(relimo_intercept-relimo_c/relimo_n/vddtransistor);
					end
				end else begin
					if(vgs < relimo_vgsCutoff) begin
						work = 1;
					end else begin
						work = 0;
					end
					if(work == 1) begin 
						delta_damage = exp(relimo_intercept-relimo_c/relimo_n/vddtransistor);
						//delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
					end
				end
				
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage = damage + dt/2*(delta_damage + last_delta_damage);
				last_delta_damage = delta_damage;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					//damage = (damage_s+damage_d)*(relimo_aging_time/(24*365.24))/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
					damage = damage*relimo_aging_time/($abstime-relimo_aging_tstart);
				end else begin
					damage = 0;
				end
			end else begin
				//damage = delta_damage*relimo_aging_time/(24*365.24)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage = delta_damage*relimo_aging_time;
      			end
			delta_idsat = damage*pow(relimo_a_idsat,1/relimo_n);
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s probe_name %s\n", relimo_device_name, relimo_probe_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
		
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage = damage*(relimo_aging_time)*(24*365.24)/($abstime-relimo_aging_tstart);
			end else begin
				damage = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = damage*pow(relimo_a_idsat,1/relimo_n);
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci2;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
//parameter real        relimo_nh                    = 0.332;
//parameter real        relimo_vdd                   = 1.0;
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
//parameter real        relimo_e                     = 0;
//parameter real        relimo_kb                    = 0;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 2;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage, delta_damage_d, delta_damage_s, damage_d, damage_s, last_delta_damage, damage;
real dt, last_abstime;  
real temp, temp1;
real delta_idsat;
real work;
   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = $simprobe(relimo_probe_name, "vgs");
			vds = $simprobe(relimo_probe_name, "vds");
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.

			id = abs($simprobe(relimo_probe_name, "id"));
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			if (vddtransistor == 0) begin
				delta_damage = 0;
			end else begin
				if(relimo_vth > 0) begin
					if(vgs >= 0 && abs(vds) >= 0.0) begin
						work = 1;
					end else begin
						work = 0;
					end
					if(work == 1 && relimo_function == 1 && abs(vds) > abs(vgs)) begin 
						delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
					end
					if(work == 1 && relimo_function == 2 && abs(vds) <= abs(vgs)) begin 
						delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
					end
				end else begin
					if(vgs <= 0 && abs(vds) >= 0.0) begin
						work = 1;
					end else begin
						work = 0;
					end
					if(work == 1 && relimo_function == 1 && abs(vds) > abs(vgs)) begin 
						delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
					end
					if(work == 1 && relimo_function == 2 && abs(vds) <= abs(vgs)) begin 
						delta_damage = exp(relimo_intercept-relimo_c/vddtransistor);
					end
				end
				
			end
			delta_damage = delta_damage;
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				if (id > 0) begin
					delta_damage_d = delta_damage;
					damage_d = damage_d + dt/2*(delta_damage + last_delta_damage);
				end else begin
					delta_damage_s = delta_damage;
					damage_s = damage_s + dt/2*(delta_damage + last_delta_damage);
				end
				last_delta_damage = delta_damage;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_vth < 0) begin
			temp = delta_damage_s;
			delta_damage_s = delta_damage_d;
			delta_damage_d = temp;
			temp = damage_s;
			damage_s = damage_d;
			damage_d = temp;
		end
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					//damage = (damage_s+damage_d)*(relimo_aging_time/(24*365.24))/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
					damage = (damage_s+damage_d)*relimo_aging_time/($abstime-relimo_aging_tstart);
				end else begin
					damage = 0;
				end
			end else begin
				//damage = delta_damage*relimo_aging_time/(24*365.24)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage = delta_damage*relimo_aging_time;
      			end
			//delta_idsat = 10*pow((damage*(1/relimo_a_idsat)*pow(r,-m)), (1/relimo_n));
			delta_idsat = damage*(1/relimo_a_idsat)*pow(relimo_r,-relimo_m);
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage = (damage_s+damage_d)*(relimo_aging_time)*(24*365.24)/($abstime-relimo_aging_tstart);
			end else begin
				damage = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = damage*(1/relimo_a_idsat)*pow(relimo_r,-relimo_m);
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_nld45(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 24300 ;
parameter real a0_b0_b0_a1_em = -9.46 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -51400 ;
parameter real a0_b0_a1_a1_em = 51.3 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -3760 ;
parameter real a0_b0_a2_a1_em = 16.1 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -9450 ;
parameter real a0_b0_a3_a1_em = 3.73 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.447 ;
parameter real a0_b0_p1_a1_em = -0.000712 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 0.531 ;
parameter real a0_b0_p2_a1_em = -8.20E-07 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 2.3 ;
parameter real a0_b0_p3_a1_em = -0.00126 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 2.95 ;
parameter real a0_b0_p4_a1_em = -7.95E-05 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 11300 ;
parameter real a0_b0_b0_a2_em = -2.26 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -12900 ;
parameter real a0_b0_a1_a2_em = 10.6 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 2300 ;
parameter real a0_b0_a2_a2_em = -4.02 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -5210 ;
parameter real a0_b0_a3_a2_em = 2.19 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.709 ;
parameter real a0_b0_p1_a2_em = -0.000898 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 0.416 ;
parameter real a0_b0_p2_a2_em = 0.000245 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 0.788 ;
parameter real a0_b0_p3_a2_em = 0.00232 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3.69 ;
parameter real a0_b0_p4_a2_em = 0.000118 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 4030 ;
parameter real a0_b0_b0_a3_em = 0.967 ;
parameter real b0_a0_b0_a3_em = 23.9 ;
parameter real a0_a0_b0_a3_em = -0.0269 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 1610 ;
parameter real a0_b0_a1_a3_em = 21.2 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 1220 ;
parameter real a0_b0_a2_a3_em = -8.18 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -6040 ;
parameter real a0_b0_a3_a3_em = 5.4 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 0.778 ;
parameter real a0_b0_p2_a3_em = -0.00101 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.36 ;
parameter real a0_b0_p3_a3_em = -0.00189 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 2 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 4010 ;
parameter real a0_b0_b0_a4_em = 0.0686 ;
parameter real b0_a0_b0_a4_em = -5.13 ;
parameter real a0_a0_b0_a4_em = 0.0232 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = -6620 ;
parameter real a0_b0_a1_a4_em = 28.3 ;
parameter real b0_a0_a1_a4_em = 0 ;
parameter real a0_a0_a1_a4_em = 0 ;
parameter real b0_b0_a2_a4_em = -17600 ;
parameter real a0_b0_a2_a4_em = 22 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0 ;
parameter real b0_b0_a3_a4_em = 1500 ;
parameter real a0_b0_a3_a4_em = -2.56 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0 ;
parameter real a0_b0_p1_a4_em = 0 ;
parameter real b0_a0_p1_a4_em = 0 ;
parameter real a0_a0_p1_a4_em = 0 ;
parameter real b0_b0_p2_a4_em = 2.15 ;
parameter real a0_b0_p2_a4_em = -0.00289 ;
parameter real b0_a0_p2_a4_em = 0 ;
parameter real a0_a0_p2_a4_em = 0 ;
parameter real b0_b0_p3_a4_em = 1.54 ;
parameter real a0_b0_p3_a4_em = 0.000389 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 4.09 ;
parameter real a0_b0_p4_a4_em = -0.000378 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -2.91 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.858 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -1.96 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -7.53 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -9.72 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.45 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.25 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 2.93 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 9.25 ;
parameter real a0_b0_b0_p2_em = 0.0062 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0 ;
parameter real a0_b0_a1_p2_em = 0 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0 ;
parameter real a0_b0_a2_p2_em = 0 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 0 ;
parameter real a0_b0_a3_p2_em = 0 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 0 ;
parameter real a0_b0_p2_p2_em = 0 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 0 ;
parameter real a0_b0_p3_p2_em = 0 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 0 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 22 ;
parameter real a0_b0_b0_p3_em = 0 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0 ;
parameter real a0_b0_a1_p3_em = 0 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0 ;
parameter real a0_b0_a2_p3_em = 0 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0 ;
parameter real a0_b0_a3_p3_em = 0 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0 ;
parameter real a0_b0_p1_p3_em = 0 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 0 ;
parameter real a0_b0_p2_p3_em = 0 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 0 ;
parameter real a0_b0_p3_p3_em = 0 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 0 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 40.5 ;
parameter real a0_b0_b0_p4_em = -0.0089 ;
parameter real b0_a0_b0_p4_em = -0.0405 ;
parameter real a0_a0_b0_p4_em = 3.28E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 3.49 ;
parameter real a0_b0_a1_p4_em = -0.00724 ;
parameter real b0_a0_a1_p4_em = 0 ;
parameter real a0_a0_a1_p4_em = 0 ;
parameter real b0_b0_a2_p4_em = -1.75 ;
parameter real a0_b0_a2_p4_em = 0.00419 ;
parameter real b0_a0_a2_p4_em = 0 ;
parameter real a0_a0_a2_p4_em = 0 ;
parameter real b0_b0_a3_p4_em = 1.39 ;
parameter real a0_b0_a3_p4_em = 0.000782 ;
parameter real b0_a0_a3_p4_em = 0 ;
parameter real a0_a0_a3_p4_em = 0 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0.1 ;
parameter real a0_b0_p1_p4_em = 0 ;
parameter real b0_a0_p1_p4_em = 0 ;
parameter real a0_a0_p1_p4_em = 0 ;
parameter real b0_b0_p2_p4_em = 1.47 ;
parameter real a0_b0_p2_p4_em = -0.000691 ;
parameter real b0_a0_p2_p4_em = 0 ;
parameter real a0_a0_p2_p4_em = 0 ;
parameter real b0_b0_p3_p4_em = 6.09 ;
parameter real a0_b0_p3_p4_em = -0.0116 ;
parameter real b0_a0_p3_p4_em = 0 ;
parameter real a0_a0_p3_p4_em = 0 ;
parameter real b0_b0_p4_p4_em = 4 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;



parameter real        relimo_d_hci1 = 1.0;

parameter real        relimo_lamda0 = 8.06e-7;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_fstat1 = 0.00347;
parameter real        relimo_alpha1 = 1.35e-8;
parameter real        relimo_m1 = 1.77;
parameter real        relimo_Feb = 3.2;
parameter real        relimo_a1 = 0.773;
parameter real        relimo_a2 = 1.27;
parameter real        relimo_c1 = 3.71e5;
parameter real        relimo_fstat2 = 0.0133;
parameter real        relimo_alpha2 = 2.91E+11;
parameter real        relimo_beta2 = 3.44E-08;
parameter real        relimo_gama2 = 17.773;
parameter real        relimo_eps2 = 5.6824;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 1.4629;
parameter real        relimo_rth = 0.019243;
parameter real        relimo_n_hci3 = 0.389;
parameter real        relimo_a_hci3 = 283;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "id"));
			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, relimo_alpha2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, relimo_rth, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*abs(V(sub)-V(s))), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			
			
		end	
	end
end
endmodule

module relimo_aging_hci_nld45b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 24300 ;
parameter real a0_b0_b0_a1_em = -9.46 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -51400 ;
parameter real a0_b0_a1_a1_em = 51.3 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -3760 ;
parameter real a0_b0_a2_a1_em = 16.1 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -9450 ;
parameter real a0_b0_a3_a1_em = 3.73 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.447 ;
parameter real a0_b0_p1_a1_em = -0.000712 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 0.531 ;
parameter real a0_b0_p2_a1_em = -8.20E-07 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 2.3 ;
parameter real a0_b0_p3_a1_em = -0.00126 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 2.95 ;
parameter real a0_b0_p4_a1_em = -7.95E-05 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 11300 ;
parameter real a0_b0_b0_a2_em = -2.26 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -12900 ;
parameter real a0_b0_a1_a2_em = 10.6 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 2300 ;
parameter real a0_b0_a2_a2_em = -4.02 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -5210 ;
parameter real a0_b0_a3_a2_em = 2.19 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 0.709 ;
parameter real a0_b0_p1_a2_em = -0.000898 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 0.416 ;
parameter real a0_b0_p2_a2_em = 0.000245 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 0.788 ;
parameter real a0_b0_p3_a2_em = 0.00232 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3.69 ;
parameter real a0_b0_p4_a2_em = 0.000118 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 4030 ;
parameter real a0_b0_b0_a3_em = 0.967 ;
parameter real b0_a0_b0_a3_em = 23.9 ;
parameter real a0_a0_b0_a3_em = -0.0269 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 1610 ;
parameter real a0_b0_a1_a3_em = 21.2 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 1220 ;
parameter real a0_b0_a2_a3_em = -8.18 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -6040 ;
parameter real a0_b0_a3_a3_em = 5.4 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 0.778 ;
parameter real a0_b0_p2_a3_em = -0.00101 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.36 ;
parameter real a0_b0_p3_a3_em = -0.00189 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 2 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 4010 ;
parameter real a0_b0_b0_a4_em = 0.0686 ;
parameter real b0_a0_b0_a4_em = -5.13 ;
parameter real a0_a0_b0_a4_em = 0.0232 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = -6620 ;
parameter real a0_b0_a1_a4_em = 28.3 ;
parameter real b0_a0_a1_a4_em = 0 ;
parameter real a0_a0_a1_a4_em = 0 ;
parameter real b0_b0_a2_a4_em = -17600 ;
parameter real a0_b0_a2_a4_em = 22 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0 ;
parameter real b0_b0_a3_a4_em = 1500 ;
parameter real a0_b0_a3_a4_em = -2.56 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0 ;
parameter real a0_b0_p1_a4_em = 0 ;
parameter real b0_a0_p1_a4_em = 0 ;
parameter real a0_a0_p1_a4_em = 0 ;
parameter real b0_b0_p2_a4_em = 2.15 ;
parameter real a0_b0_p2_a4_em = -0.00289 ;
parameter real b0_a0_p2_a4_em = 0 ;
parameter real a0_a0_p2_a4_em = 0 ;
parameter real b0_b0_p3_a4_em = 1.54 ;
parameter real a0_b0_p3_a4_em = 0.000389 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 4.09 ;
parameter real a0_b0_p4_a4_em = -0.000378 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -2.91 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.858 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -1.96 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -7.53 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -9.72 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.45 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.25 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 2.93 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 9.25 ;
parameter real a0_b0_b0_p2_em = 0.0062 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0 ;
parameter real a0_b0_a1_p2_em = 0 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0 ;
parameter real a0_b0_a2_p2_em = 0 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 0 ;
parameter real a0_b0_a3_p2_em = 0 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 0 ;
parameter real a0_b0_p2_p2_em = 0 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 0 ;
parameter real a0_b0_p3_p2_em = 0 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 0 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 22 ;
parameter real a0_b0_b0_p3_em = 0 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0 ;
parameter real a0_b0_a1_p3_em = 0 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0 ;
parameter real a0_b0_a2_p3_em = 0 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0 ;
parameter real a0_b0_a3_p3_em = 0 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0 ;
parameter real a0_b0_p1_p3_em = 0 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 0 ;
parameter real a0_b0_p2_p3_em = 0 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 0 ;
parameter real a0_b0_p3_p3_em = 0 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 0 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 40.5 ;
parameter real a0_b0_b0_p4_em = -0.0089 ;
parameter real b0_a0_b0_p4_em = -0.0405 ;
parameter real a0_a0_b0_p4_em = 3.28E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 3.49 ;
parameter real a0_b0_a1_p4_em = -0.00724 ;
parameter real b0_a0_a1_p4_em = 0 ;
parameter real a0_a0_a1_p4_em = 0 ;
parameter real b0_b0_a2_p4_em = -1.75 ;
parameter real a0_b0_a2_p4_em = 0.00419 ;
parameter real b0_a0_a2_p4_em = 0 ;
parameter real a0_a0_a2_p4_em = 0 ;
parameter real b0_b0_a3_p4_em = 1.39 ;
parameter real a0_b0_a3_p4_em = 0.000782 ;
parameter real b0_a0_a3_p4_em = 0 ;
parameter real a0_a0_a3_p4_em = 0 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0.1 ;
parameter real a0_b0_p1_p4_em = 0 ;
parameter real b0_a0_p1_p4_em = 0 ;
parameter real a0_a0_p1_p4_em = 0 ;
parameter real b0_b0_p2_p4_em = 1.47 ;
parameter real a0_b0_p2_p4_em = -0.000691 ;
parameter real b0_a0_p2_p4_em = 0 ;
parameter real a0_a0_p2_p4_em = 0 ;
parameter real b0_b0_p3_p4_em = 6.09 ;
parameter real a0_b0_p3_p4_em = -0.0116 ;
parameter real b0_a0_p3_p4_em = 0 ;
parameter real a0_a0_p3_p4_em = 0 ;
parameter real b0_b0_p4_p4_em = 4 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;



parameter real        relimo_d_hci1 = 1.0;

parameter real        relimo_lamda0 = 8.06e-7;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_fstat1 = 0.00347;
parameter real        relimo_alpha1 = 1.35e-8;
parameter real        relimo_m1 = 1.77;
parameter real        relimo_Feb = 3.2;
parameter real        relimo_a1 = 0.773;
parameter real        relimo_a2 = 1.27;
parameter real        relimo_c1 = 3.71e5;
parameter real        relimo_fstat2 = 0.0133;
parameter real        relimo_alpha2 = 2.91E+11;
parameter real        relimo_beta2 = 3.44E-08;
parameter real        relimo_gama2 = 17.773;
parameter real        relimo_eps2 = 5.6824;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 1.4629;
parameter real        relimo_rth = 0.019243;
parameter real        relimo_n_hci3 = 0.389;
parameter real        relimo_a_hci3 = 283;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, id1, id2, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id1 = $simprobe(relimo_probe_name, "ide");
			id2 = $simprobe("mpowermosb", "ide");
			id = abs(id1+id2*0);

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, relimo_alpha2, w, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, relimo_rth, id, vds);
        	//$display("Parameter MULT in device %e, %e, %e, %e", w, relimo_rth*id*vds, relimo_rth*id, relimo_eta2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", exp(-1*relimo_eta2*abs(V(sub)-V(s))), delta_damage3, ($temperature+relimo_rth*id*vds/(w*1e-6)), relimo_ea2);
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule



module relimo_aging_hci_nld45_he(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 44100 ;
parameter real a0_b0_b0_a1_em = -8.26 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -24200 ;
parameter real a0_b0_a1_a1_em = 12.7 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 44600 ;
parameter real a0_b0_a2_a1_em = -51.1 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 15600 ;
parameter real a0_b0_a3_a1_em = -114 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 1.83 ;
parameter real a0_b0_p1_a1_em = -0.00143 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 3.15 ;
parameter real a0_b0_p2_a1_em = -0.00119 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.41 ;
parameter real a0_b0_p3_a1_em = -0.000995 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.5 ;
parameter real a0_b0_p4_a1_em = -0.00265 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 12100 ;
parameter real a0_b0_b0_a2_em = 1.94 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 1300 ;
parameter real a0_b0_a1_a2_em = -1.82 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 1020 ;
parameter real a0_b0_a2_a2_em = 0.177 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -5410 ;
parameter real a0_b0_a3_a2_em = 0.922 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -0.715 ;
parameter real a0_b0_p1_a2_em = -0.000869 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = -0.512 ;
parameter real a0_b0_p2_a2_em = 0.00359 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 1.15 ;
parameter real a0_b0_p3_a2_em = -3.68E-05 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 6230 ;
parameter real a0_b0_b0_a3_em = 2.16 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 1640 ;
parameter real a0_b0_a1_a3_em = -13 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 1.21 ;
parameter real a0_b0_a2_a3_em = 0.996 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -1530 ;
parameter real a0_b0_a3_a3_em = 2.84 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 1.35 ;
parameter real a0_b0_p1_a3_em = 0.000208 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 2.56 ;
parameter real a0_b0_p2_a3_em = -0.000218 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = -0.81 ;
parameter real a0_b0_p3_a3_em = 0.00252 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 2.56 ;
parameter real a0_b0_p4_a3_em = 0.00359 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 2780 ;
parameter real a0_b0_b0_a4_em = 2.16 ;
parameter real b0_a0_b0_a4_em = 0.277 ;
parameter real a0_a0_b0_a4_em = 0.0148 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 25700 ;
parameter real a0_b0_a1_a4_em = -30 ;
parameter real b0_a0_a1_a4_em = -0.177 ;
parameter real a0_a0_a1_a4_em = -0.024 ;
parameter real b0_b0_a2_a4_em = -346 ;
parameter real a0_b0_a2_a4_em = -10.4 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0.0601 ;
parameter real b0_b0_a3_a4_em = -7.79 ;
parameter real a0_b0_a3_a4_em = -0.00113 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 2.48 ;
parameter real a0_b0_p1_a4_em = -0.000237 ;
parameter real b0_a0_p1_a4_em = 0.000614 ;
parameter real a0_a0_p1_a4_em = -2.39E-06 ;
parameter real b0_b0_p2_a4_em = 4.04 ;
parameter real a0_b0_p2_a4_em = 0.000126 ;
parameter real b0_a0_p2_a4_em = -0.00024 ;
parameter real a0_a0_p2_a4_em = 1.52E-06 ;
parameter real b0_b0_p3_a4_em = -39.8 ;
parameter real a0_b0_p3_a4_em = 0.197 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 5.65 ;
parameter real a0_b0_p4_a4_em = -0.000628 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -3.5 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 1.16 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 0 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 12.2 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -1 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.6 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.89 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 5.12 ;
parameter real a0_b0_b0_p2_em = 0.00286 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0.798 ;
parameter real a0_b0_a1_p2_em = -0.000226 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 4.48 ;
parameter real a0_b0_a2_p2_em = 0.00529 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 37.1 ;
parameter real a0_b0_a3_p2_em = -0.0747 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.79 ;
parameter real a0_b0_p2_p2_em = -0.00123 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 2.51 ;
parameter real a0_b0_p3_p2_em = -0.000964 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 2.38 ;
parameter real a0_b0_p4_p2_em = -0.000171 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 17.1 ;
parameter real a0_b0_b0_p3_em = -0.00513 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0.443 ;
parameter real a0_b0_a1_p3_em = -0.000315 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 14.3 ;
parameter real a0_b0_a2_p3_em = -0.0142 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -9.19 ;
parameter real a0_b0_a3_p3_em = 0.0304 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 4.05 ;
parameter real a0_b0_p1_p3_em = -0.0118 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 1.18 ;
parameter real a0_b0_p2_p3_em = 0.00021 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 1.59 ;
parameter real a0_b0_p3_p3_em = -9.01E-05 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 2 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 32 ;
parameter real a0_b0_b0_p4_em = -0.0084 ;
parameter real b0_a0_b0_p4_em = 0.0545 ;
parameter real a0_a0_b0_p4_em = -7.63E-06 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 1.66 ;
parameter real a0_b0_a1_p4_em = -0.00388 ;
parameter real b0_a0_a1_p4_em = -0.0109 ;
parameter real a0_a0_a1_p4_em = 2.14E-05 ;
parameter real b0_b0_a2_p4_em = -25.6 ;
parameter real a0_b0_a2_p4_em = 0.0363 ;
parameter real b0_a0_a2_p4_em = 0.0775 ;
parameter real a0_a0_a2_p4_em = -0.000109 ;
parameter real b0_b0_a3_p4_em = 3.55 ;
parameter real a0_b0_a3_p4_em = 0.111 ;
parameter real b0_a0_a3_p4_em = 0.224 ;
parameter real a0_a0_a3_p4_em = -0.000755 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = -0.069 ;
parameter real a0_b0_p1_p4_em = -0.00169 ;
parameter real b0_a0_p1_p4_em = -0.0915 ;
parameter real a0_a0_p1_p4_em = 8.09E-05 ;
parameter real b0_b0_p2_p4_em = 2.55 ;
parameter real a0_b0_p2_p4_em = -0.000145 ;
parameter real b0_a0_p2_p4_em = -0.0127 ;
parameter real a0_a0_p2_p4_em = 2.64E-05 ;
parameter real b0_b0_p3_p4_em = 2.74 ;
parameter real a0_b0_p3_p4_em = -0.000499 ;
parameter real b0_a0_p3_p4_em = -6.82E-06 ;
parameter real a0_a0_p3_p4_em = -1.23E-06 ;
parameter real b0_b0_p4_p4_em = 3.25 ;
parameter real a0_b0_p4_p4_em = -0.00084 ;
parameter real b0_a0_p4_p4_em = 0.000639 ;
parameter real a0_a0_p4_p4_em = -9.65E-07 ;
   

parameter real        relimo_d_hci1 = 1.0;

parameter real        relimo_Feb = 3.2;
parameter real        relimo_Ep = 0.063;

parameter real        relimo_a1 = 0.637;
parameter real        relimo_a2 = 1.16;
parameter real        relimo_c1 = 1.21e5;
parameter real        relimo_alpha1 = 7.01e-15;
parameter real        relimo_m1 = 1.43;
parameter real        relimo_lamda0 = 2.10e-7;
parameter real        relimo_fstat1 = 0.00443;

parameter real        relimo_a_hci3 = 330;
parameter real        relimo_n_hci3 = 0.501;
parameter real        relimo_alpha2 = 1.41E+24;
parameter real        relimo_beta2 = 2.76E-14;
parameter real        relimo_gama2 = 17.4;
parameter real        relimo_eps2 = 9.53;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.61;
parameter real        relimo_rth = 2.25E-14;
parameter real        relimo_fstat2 = 0.0223;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter MULT in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_nld45b_he(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 44100 ;
parameter real a0_b0_b0_a1_em = -8.26 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -24200 ;
parameter real a0_b0_a1_a1_em = 12.7 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 44600 ;
parameter real a0_b0_a2_a1_em = -51.1 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = 15600 ;
parameter real a0_b0_a3_a1_em = -114 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 1.83 ;
parameter real a0_b0_p1_a1_em = -0.00143 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 3.15 ;
parameter real a0_b0_p2_a1_em = -0.00119 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 3.41 ;
parameter real a0_b0_p3_a1_em = -0.000995 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.5 ;
parameter real a0_b0_p4_a1_em = -0.00265 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 12100 ;
parameter real a0_b0_b0_a2_em = 1.94 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 1300 ;
parameter real a0_b0_a1_a2_em = -1.82 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 1020 ;
parameter real a0_b0_a2_a2_em = 0.177 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -5410 ;
parameter real a0_b0_a3_a2_em = 0.922 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -0.715 ;
parameter real a0_b0_p1_a2_em = -0.000869 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = -0.512 ;
parameter real a0_b0_p2_a2_em = 0.00359 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 1.15 ;
parameter real a0_b0_p3_a2_em = -3.68E-05 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 6230 ;
parameter real a0_b0_b0_a3_em = 2.16 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 1640 ;
parameter real a0_b0_a1_a3_em = -13 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 1.21 ;
parameter real a0_b0_a2_a3_em = 0.996 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -1530 ;
parameter real a0_b0_a3_a3_em = 2.84 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 1.35 ;
parameter real a0_b0_p1_a3_em = 0.000208 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 2.56 ;
parameter real a0_b0_p2_a3_em = -0.000218 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = -0.81 ;
parameter real a0_b0_p3_a3_em = 0.00252 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 2.56 ;
parameter real a0_b0_p4_a3_em = 0.00359 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 2780 ;
parameter real a0_b0_b0_a4_em = 2.16 ;
parameter real b0_a0_b0_a4_em = 0.277 ;
parameter real a0_a0_b0_a4_em = 0.0148 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 25700 ;
parameter real a0_b0_a1_a4_em = -30 ;
parameter real b0_a0_a1_a4_em = -0.177 ;
parameter real a0_a0_a1_a4_em = -0.024 ;
parameter real b0_b0_a2_a4_em = -346 ;
parameter real a0_b0_a2_a4_em = -10.4 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0.0601 ;
parameter real b0_b0_a3_a4_em = -7.79 ;
parameter real a0_b0_a3_a4_em = -0.00113 ;
parameter real b0_a0_a3_a4_em = 0 ;
parameter real a0_a0_a3_a4_em = 0 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 2.48 ;
parameter real a0_b0_p1_a4_em = -0.000237 ;
parameter real b0_a0_p1_a4_em = 0.000614 ;
parameter real a0_a0_p1_a4_em = -2.39E-06 ;
parameter real b0_b0_p2_a4_em = 4.04 ;
parameter real a0_b0_p2_a4_em = 0.000126 ;
parameter real b0_a0_p2_a4_em = -0.00024 ;
parameter real a0_a0_p2_a4_em = 1.52E-06 ;
parameter real b0_b0_p3_a4_em = -39.8 ;
parameter real a0_b0_p3_a4_em = 0.197 ;
parameter real b0_a0_p3_a4_em = 0 ;
parameter real a0_a0_p3_a4_em = 0 ;
parameter real b0_b0_p4_a4_em = 5.65 ;
parameter real a0_b0_p4_a4_em = -0.000628 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0 ;
parameter real b0_b0_b0_p1_em = -3.5 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 1.16 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 0 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 12.2 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -1 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.6 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.89 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 4 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 5.12 ;
parameter real a0_b0_b0_p2_em = 0.00286 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0.798 ;
parameter real a0_b0_a1_p2_em = -0.000226 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 4.48 ;
parameter real a0_b0_a2_p2_em = 0.00529 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 37.1 ;
parameter real a0_b0_a3_p2_em = -0.0747 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.79 ;
parameter real a0_b0_p2_p2_em = -0.00123 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 2.51 ;
parameter real a0_b0_p3_p2_em = -0.000964 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 2.38 ;
parameter real a0_b0_p4_p2_em = -0.000171 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 17.1 ;
parameter real a0_b0_b0_p3_em = -0.00513 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0.443 ;
parameter real a0_b0_a1_p3_em = -0.000315 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 14.3 ;
parameter real a0_b0_a2_p3_em = -0.0142 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -9.19 ;
parameter real a0_b0_a3_p3_em = 0.0304 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 4.05 ;
parameter real a0_b0_p1_p3_em = -0.0118 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 1.18 ;
parameter real a0_b0_p2_p3_em = 0.00021 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 1.59 ;
parameter real a0_b0_p3_p3_em = -9.01E-05 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 2 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 32 ;
parameter real a0_b0_b0_p4_em = -0.0084 ;
parameter real b0_a0_b0_p4_em = 0.0545 ;
parameter real a0_a0_b0_p4_em = -7.63E-06 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 1.66 ;
parameter real a0_b0_a1_p4_em = -0.00388 ;
parameter real b0_a0_a1_p4_em = -0.0109 ;
parameter real a0_a0_a1_p4_em = 2.14E-05 ;
parameter real b0_b0_a2_p4_em = -25.6 ;
parameter real a0_b0_a2_p4_em = 0.0363 ;
parameter real b0_a0_a2_p4_em = 0.0775 ;
parameter real a0_a0_a2_p4_em = -0.000109 ;
parameter real b0_b0_a3_p4_em = 3.55 ;
parameter real a0_b0_a3_p4_em = 0.111 ;
parameter real b0_a0_a3_p4_em = 0.224 ;
parameter real a0_a0_a3_p4_em = -0.000755 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = -0.069 ;
parameter real a0_b0_p1_p4_em = -0.00169 ;
parameter real b0_a0_p1_p4_em = -0.0915 ;
parameter real a0_a0_p1_p4_em = 8.09E-05 ;
parameter real b0_b0_p2_p4_em = 2.55 ;
parameter real a0_b0_p2_p4_em = -0.000145 ;
parameter real b0_a0_p2_p4_em = -0.0127 ;
parameter real a0_a0_p2_p4_em = 2.64E-05 ;
parameter real b0_b0_p3_p4_em = 2.74 ;
parameter real a0_b0_p3_p4_em = -0.000499 ;
parameter real b0_a0_p3_p4_em = -6.82E-06 ;
parameter real a0_a0_p3_p4_em = -1.23E-06 ;
parameter real b0_b0_p4_p4_em = 3.25 ;
parameter real a0_b0_p4_p4_em = -0.00084 ;
parameter real b0_a0_p4_p4_em = 0.000639 ;
parameter real a0_a0_p4_p4_em = -9.65E-07 ;
   

parameter real        relimo_d_hci1 = 1.0;

parameter real        relimo_Feb = 3.2;
parameter real        relimo_Ep = 0.063;

parameter real        relimo_a1 = 0.637;
parameter real        relimo_a2 = 1.16;
parameter real        relimo_c1 = 1.21e5;
parameter real        relimo_alpha1 = 7.01e-15;
parameter real        relimo_m1 = 1.43;
parameter real        relimo_lamda0 = 2.10e-7;
parameter real        relimo_fstat1 = 0.00443;

parameter real        relimo_a_hci3 = 330;
parameter real        relimo_n_hci3 = 0.501;
parameter real        relimo_alpha2 = 1.41E+24;
parameter real        relimo_beta2 = 2.76E-14;
parameter real        relimo_gama2 = 17.4;
parameter real        relimo_eps2 = 9.53;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.61;
parameter real        relimo_rth = 2.25E-14;
parameter real        relimo_fstat2 = 0.0223;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, id1, id2, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id1 = $simprobe(relimo_probe_name, "ide");
			id2 = $simprobe("mpowermosb", "ide");
			id = abs(id1+id2*0);

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter MULT in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter MULT in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter MULT in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule


module relimo_aging_hci_nld45_tlp(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 17400 ;
parameter real a0_b0_b0_a1_em = -3.27 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -1400 ;
parameter real a0_b0_a1_a1_em = 0.27 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 12000 ;
parameter real a0_b0_a2_a1_em = 26.4 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -2320 ;
parameter real a0_b0_a3_a1_em = -7.53 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -2.71 ;
parameter real a0_b0_p1_a1_em = -7.37E-06 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.03 ;
parameter real a0_b0_p2_a1_em = 0.000163 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 1.36 ;
parameter real a0_b0_p3_a1_em = 0.000102 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 5200 ;
parameter real a0_b0_b0_a2_em = 0 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 0 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 0 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = 0 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 1 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 2 ;
parameter real a0_b0_p2_a2_em = 0 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 3 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 4 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 2480 ;
parameter real a0_b0_b0_a3_em = 0.502 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 634 ;
parameter real a0_b0_a1_a3_em = -17.6 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 25500 ;
parameter real a0_b0_a2_a3_em = -33.6 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -672 ;
parameter real a0_b0_a3_a3_em = -0.973 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0.598 ;
parameter real a0_b0_p1_a3_em = 0.000857 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.28 ;
parameter real a0_b0_p2_a3_em = 8.13E-05 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.26 ;
parameter real a0_b0_p3_a3_em = 0.000714 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 5.83 ;
parameter real a0_b0_p4_a3_em = -0.00405 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 1040 ;
parameter real a0_b0_b0_a4_em = -0.0325 ;
parameter real b0_a0_b0_a4_em = 12.7 ;
parameter real a0_a0_b0_a4_em = -0.0121 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 5270 ;
parameter real a0_b0_a1_a4_em = -12.4 ;
parameter real b0_a0_a1_a4_em = 0.556 ;
parameter real a0_a0_a1_a4_em = 0.286 ;
parameter real b0_b0_a2_a4_em = -303 ;
parameter real a0_b0_a2_a4_em = 1.36 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.00683 ;
parameter real b0_b0_a3_a4_em = 6350 ;
parameter real a0_b0_a3_a4_em = -6.57 ;
parameter real b0_a0_a3_a4_em = 17.6 ;
parameter real a0_a0_a3_a4_em = -0.0552 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0.545 ;
parameter real a0_b0_p1_a4_em = 1.09E-03 ;
parameter real b0_a0_p1_a4_em = 0.00483 ;
parameter real a0_a0_p1_a4_em = -2.32E-05 ;
parameter real b0_b0_p2_a4_em = 0.994 ;
parameter real a0_b0_p2_a4_em = 0.000526 ;
parameter real b0_a0_p2_a4_em = 6.02E-05 ;
parameter real a0_a0_p2_a4_em = -1.86E-05 ;
parameter real b0_b0_p3_a4_em = 3.16 ;
parameter real a0_b0_p3_a4_em = 1.19E-05 ;
parameter real b0_a0_p3_a4_em = 0.000843 ;
parameter real a0_a0_p3_a4_em = 3.55E-06 ;
parameter real b0_b0_p4_a4_em = 4.7 ;
parameter real a0_b0_p4_a4_em = -0.000241 ;
parameter real b0_a0_p4_a4_em = -0.00231 ;
parameter real a0_a0_p4_a4_em = 1.02E-05 ;
parameter real b0_b0_b0_p1_em = -4.68 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 17.2 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -0.159 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 1.41 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 1.08 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.43 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.01 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 2.3 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 6.78 ;
parameter real a0_b0_b0_p2_em = 0.00226 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 1.27 ;
parameter real a0_b0_a1_p2_em = -0.000307 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0.285 ;
parameter real a0_b0_a2_p2_em = -0.13 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 6.22 ;
parameter real a0_b0_a3_p2_em = -0.0235 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.36 ;
parameter real a0_b0_p2_p2_em = 5.54E-05 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 1.4 ;
parameter real a0_b0_p3_p2_em = 0 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 2 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 15.9 ;
parameter real a0_b0_b0_p3_em = 0.00466 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 3.95 ;
parameter real a0_b0_a1_p3_em = 0.0218 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = -9.77 ;
parameter real a0_b0_a2_p3_em = -0.0391 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -4.21 ;
parameter real a0_b0_a3_p3_em = -0.00335 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0.761 ;
parameter real a0_b0_p1_p3_em = 0.00122 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.1 ;
parameter real a0_b0_p2_p3_em = 1.16E-05 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 2.82 ;
parameter real a0_b0_p3_p3_em = -0.000961 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 3.16 ;
parameter real a0_b0_p4_p3_em = 0.00349 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 28.4 ;
parameter real a0_b0_b0_p4_em = 0.0078 ;
parameter real b0_a0_b0_p4_em = 0.27 ;
parameter real a0_a0_b0_p4_em = -0.000461 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 4.74 ;
parameter real a0_b0_a1_p4_em = -0.0104 ;
parameter real b0_a0_a1_p4_em = -0.0955 ;
parameter real a0_a0_a1_p4_em = 0.000172 ;
parameter real b0_b0_a2_p4_em = -30.8 ;
parameter real a0_b0_a2_p4_em = 0.0767 ;
parameter real b0_a0_a2_p4_em = 0.452 ;
parameter real a0_a0_a2_p4_em = -0.00128 ;
parameter real b0_b0_a3_p4_em = 91.8 ;
parameter real a0_b0_a3_p4_em = 0.0253 ;
parameter real b0_a0_a3_p4_em = 1.83 ;
parameter real a0_a0_a3_p4_em = -0.00492 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0.867 ;
parameter real a0_b0_p1_p4_em = -0.00466 ;
parameter real b0_a0_p1_p4_em = -0.196 ;
parameter real a0_a0_p1_p4_em = 0.000438 ;
parameter real b0_b0_p2_p4_em = 1.71 ;
parameter real a0_b0_p2_p4_em = -0.000729 ;
parameter real b0_a0_p2_p4_em = -0.0515 ;
parameter real a0_a0_p2_p4_em = 0.000102 ;
parameter real b0_b0_p3_p4_em = 2.95 ;
parameter real a0_b0_p3_p4_em = -9.66E-05 ;
parameter real b0_a0_p3_p4_em = 0.00906 ;
parameter real a0_a0_p3_p4_em = -2.63E-05 ;
parameter real b0_b0_p4_p4_em = 3.49 ;
parameter real a0_b0_p4_p4_em = -0.00113 ;
parameter real b0_a0_p4_p4_em = 0.00189 ;
parameter real a0_a0_p4_p4_em = -4.62E-06 ;
     
   


parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.698;
parameter real        relimo_a2 = 1.38;
parameter real        relimo_c1 = 8.38e5;
parameter real        relimo_alpha1 = 5.27e-13;
parameter real        relimo_m1 = 1.07;
parameter real        relimo_lamda0 = 6.14e-7;
parameter real        relimo_fstat1 = 0.00254;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 351;
parameter real        relimo_n_hci3 = 0.419;
parameter real        relimo_alpha2 = 7.44E+19;
parameter real        relimo_beta2 = 4.68E-08;
parameter real        relimo_gama2 = 17.9;
parameter real        relimo_eps2 = 7.62;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.81;
parameter real        relimo_rth = 0.00571;
parameter real        relimo_fstat2 = 0.0146;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule

module relimo_aging_hci_nld45b_tlp(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 17400 ;
parameter real a0_b0_b0_a1_em = -3.27 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -1400 ;
parameter real a0_b0_a1_a1_em = 0.27 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 12000 ;
parameter real a0_b0_a2_a1_em = 26.4 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -2320 ;
parameter real a0_b0_a3_a1_em = -7.53 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -2.71 ;
parameter real a0_b0_p1_a1_em = -7.37E-06 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.03 ;
parameter real a0_b0_p2_a1_em = 0.000163 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 1.36 ;
parameter real a0_b0_p3_a1_em = 0.000102 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 5200 ;
parameter real a0_b0_b0_a2_em = 0 ;
parameter real b0_a0_b0_a2_em = 0 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 0 ;
parameter real a0_b0_a1_a2_em = 0 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 0 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = 0 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = 1 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 2 ;
parameter real a0_b0_p2_a2_em = 0 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 3 ;
parameter real a0_b0_p3_a2_em = 0 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 4 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 2480 ;
parameter real a0_b0_b0_a3_em = 0.502 ;
parameter real b0_a0_b0_a3_em = 0 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 634 ;
parameter real a0_b0_a1_a3_em = -17.6 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 25500 ;
parameter real a0_b0_a2_a3_em = -33.6 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -672 ;
parameter real a0_b0_a3_a3_em = -0.973 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = 0.598 ;
parameter real a0_b0_p1_a3_em = 0.000857 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.28 ;
parameter real a0_b0_p2_a3_em = 8.13E-05 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.26 ;
parameter real a0_b0_p3_a3_em = 0.000714 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 5.83 ;
parameter real a0_b0_p4_a3_em = -0.00405 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 1040 ;
parameter real a0_b0_b0_a4_em = -0.0325 ;
parameter real b0_a0_b0_a4_em = 12.7 ;
parameter real a0_a0_b0_a4_em = -0.0121 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 5270 ;
parameter real a0_b0_a1_a4_em = -12.4 ;
parameter real b0_a0_a1_a4_em = 0.556 ;
parameter real a0_a0_a1_a4_em = 0.286 ;
parameter real b0_b0_a2_a4_em = -303 ;
parameter real a0_b0_a2_a4_em = 1.36 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.00683 ;
parameter real b0_b0_a3_a4_em = 6350 ;
parameter real a0_b0_a3_a4_em = -6.57 ;
parameter real b0_a0_a3_a4_em = 17.6 ;
parameter real a0_a0_a3_a4_em = -0.0552 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = 0.545 ;
parameter real a0_b0_p1_a4_em = 1.09E-03 ;
parameter real b0_a0_p1_a4_em = 0.00483 ;
parameter real a0_a0_p1_a4_em = -2.32E-05 ;
parameter real b0_b0_p2_a4_em = 0.994 ;
parameter real a0_b0_p2_a4_em = 0.000526 ;
parameter real b0_a0_p2_a4_em = 6.02E-05 ;
parameter real a0_a0_p2_a4_em = -1.86E-05 ;
parameter real b0_b0_p3_a4_em = 3.16 ;
parameter real a0_b0_p3_a4_em = 1.19E-05 ;
parameter real b0_a0_p3_a4_em = 0.000843 ;
parameter real a0_a0_p3_a4_em = 3.55E-06 ;
parameter real b0_b0_p4_a4_em = 4.7 ;
parameter real a0_b0_p4_a4_em = -0.000241 ;
parameter real b0_a0_p4_a4_em = -0.00231 ;
parameter real a0_a0_p4_a4_em = 1.02E-05 ;
parameter real b0_b0_b0_p1_em = -4.68 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 17.2 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -0.159 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 1.41 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = 1.08 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.43 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.01 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 2.3 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 6.78 ;
parameter real a0_b0_b0_p2_em = 0.00226 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 1.27 ;
parameter real a0_b0_a1_p2_em = -0.000307 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0.285 ;
parameter real a0_b0_a2_p2_em = -0.13 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 6.22 ;
parameter real a0_b0_a3_p2_em = -0.0235 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 1.36 ;
parameter real a0_b0_p2_p2_em = 5.54E-05 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 1.4 ;
parameter real a0_b0_p3_p2_em = 0 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 2 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 15.9 ;
parameter real a0_b0_b0_p3_em = 0.00466 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 3.95 ;
parameter real a0_b0_a1_p3_em = 0.0218 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = -9.77 ;
parameter real a0_b0_a2_p3_em = -0.0391 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -4.21 ;
parameter real a0_b0_a3_p3_em = -0.00335 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0.761 ;
parameter real a0_b0_p1_p3_em = 0.00122 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 2.1 ;
parameter real a0_b0_p2_p3_em = 1.16E-05 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 2.82 ;
parameter real a0_b0_p3_p3_em = -0.000961 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 3.16 ;
parameter real a0_b0_p4_p3_em = 0.00349 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 28.4 ;
parameter real a0_b0_b0_p4_em = 0.0078 ;
parameter real b0_a0_b0_p4_em = 0.27 ;
parameter real a0_a0_b0_p4_em = -0.000461 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 4.74 ;
parameter real a0_b0_a1_p4_em = -0.0104 ;
parameter real b0_a0_a1_p4_em = -0.0955 ;
parameter real a0_a0_a1_p4_em = 0.000172 ;
parameter real b0_b0_a2_p4_em = -30.8 ;
parameter real a0_b0_a2_p4_em = 0.0767 ;
parameter real b0_a0_a2_p4_em = 0.452 ;
parameter real a0_a0_a2_p4_em = -0.00128 ;
parameter real b0_b0_a3_p4_em = 91.8 ;
parameter real a0_b0_a3_p4_em = 0.0253 ;
parameter real b0_a0_a3_p4_em = 1.83 ;
parameter real a0_a0_a3_p4_em = -0.00492 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0.867 ;
parameter real a0_b0_p1_p4_em = -0.00466 ;
parameter real b0_a0_p1_p4_em = -0.196 ;
parameter real a0_a0_p1_p4_em = 0.000438 ;
parameter real b0_b0_p2_p4_em = 1.71 ;
parameter real a0_b0_p2_p4_em = -0.000729 ;
parameter real b0_a0_p2_p4_em = -0.0515 ;
parameter real a0_a0_p2_p4_em = 0.000102 ;
parameter real b0_b0_p3_p4_em = 2.95 ;
parameter real a0_b0_p3_p4_em = -9.66E-05 ;
parameter real b0_a0_p3_p4_em = 0.00906 ;
parameter real a0_a0_p3_p4_em = -2.63E-05 ;
parameter real b0_b0_p4_p4_em = 3.49 ;
parameter real a0_b0_p4_p4_em = -0.00113 ;
parameter real b0_a0_p4_p4_em = 0.00189 ;
parameter real a0_a0_p4_p4_em = -4.62E-06 ;
     
   


parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.698;
parameter real        relimo_a2 = 1.38;
parameter real        relimo_c1 = 8.38e5;
parameter real        relimo_alpha1 = 5.27e-13;
parameter real        relimo_m1 = 1.07;
parameter real        relimo_lamda0 = 6.14e-7;
parameter real        relimo_fstat1 = 0.00254;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 351;
parameter real        relimo_n_hci3 = 0.419;
parameter real        relimo_alpha2 = 7.44E+19;
parameter real        relimo_beta2 = 4.68E-08;
parameter real        relimo_gama2 = 17.9;
parameter real        relimo_eps2 = 7.62;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.81;
parameter real        relimo_rth = 0.00571;
parameter real        relimo_fstat2 = 0.0146;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, id1, id2, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id1 = $simprobe(relimo_probe_name, "ide");
			id2 = $simprobe("mpowermosb", "ide");
			id = abs(id1+id2*0);

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
				
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
			
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule


module relimo_aging_hci_nld30b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 14100 ;
parameter real a0_b0_b0_a1_em = -2.74 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = -0.004 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = -2930 ;
parameter real a0_b0_a1_a1_em = -1.28 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = -3670 ;
parameter real a0_b0_a2_a1_em = -4.21 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -4750 ;
parameter real a0_b0_a3_a1_em = 2.8 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = 0.815 ;
parameter real a0_b0_p1_a1_em = 6.05E-04 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 2.05 ;
parameter real a0_b0_p2_a1_em = 0.000903 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 2.92 ;
parameter real a0_b0_p3_a1_em = -0.000182 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 3.7 ;
parameter real a0_b0_p4_a1_em = 0 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 8500 ;
parameter real a0_b0_b0_a2_em = 0.5 ;
parameter real b0_a0_b0_a2_em = 3.55 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0.0005 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = 933 ;
parameter real a0_b0_a1_a2_em = 0.0005 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = -3000 ;
parameter real a0_b0_a2_a2_em = 0 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -2000 ;
parameter real a0_b0_a3_a2_em = 0 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -1 ;
parameter real a0_b0_p1_a2_em = 0 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 0.3 ;
parameter real a0_b0_p2_a2_em = 0.0005 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 1.7 ;
parameter real a0_b0_p3_a2_em = 5.00E-04 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3.3 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 6000 ;
parameter real a0_b0_b0_a3_em = 4 ;
parameter real b0_a0_b0_a3_em = 3.55 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 0 ;
parameter real a0_b0_a1_a3_em = 0 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = -6000 ;
parameter real a0_b0_a2_a3_em = 0 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = 0 ;
parameter real a0_b0_a3_a3_em = 0 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = -1 ;
parameter real a0_b0_p1_a3_em = 0 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.8 ;
parameter real a0_b0_p2_a3_em = 0.00E+00 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 2.5 ;
parameter real a0_b0_p3_a3_em = 0 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 3.1 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 6000 ;
parameter real a0_b0_b0_a4_em = 10.7 ;
parameter real b0_a0_b0_a4_em = -0.0357 ;
parameter real a0_a0_b0_a4_em = -0.0155 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = 0.51 ;
parameter real a0_b0_a1_a4_em = -0.354 ;
parameter real b0_a0_a1_a4_em = -0.594 ;
parameter real a0_a0_a1_a4_em = 0.00315 ;
parameter real b0_b0_a2_a4_em = -3 ;
parameter real a0_b0_a2_a4_em = -1.56 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = -0.000627 ;
parameter real b0_b0_a3_a4_em = 9.16 ;
parameter real a0_b0_a3_a4_em = 2.71 ;
parameter real b0_a0_a3_a4_em = 0.408 ;
parameter real a0_a0_a3_a4_em = -0.0433 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = -15.8 ;
parameter real a0_b0_p1_a4_em = -2.82E-02 ;
parameter real b0_a0_p1_a4_em = -0.265 ;
parameter real a0_a0_p1_a4_em = 1.43E-03 ;
parameter real b0_b0_p2_a4_em = 1.37 ;
parameter real a0_b0_p2_a4_em = -0.00684 ;
parameter real b0_a0_p2_a4_em = 0.0618 ;
parameter real a0_a0_p2_a4_em = -2.31E-04 ;
parameter real b0_b0_p3_a4_em = 2.46 ;
parameter real a0_b0_p3_a4_em = 0.000591 ;
parameter real b0_a0_p3_a4_em = -0.046 ;
parameter real a0_a0_p3_a4_em = 1.80E-04 ;
parameter real b0_b0_p4_a4_em = 3.5 ;
parameter real a0_b0_p4_a4_em = 0.0073 ;
parameter real b0_a0_p4_a4_em = 0 ;
parameter real a0_a0_p4_a4_em = 0.00E+00 ;
parameter real b0_b0_b0_p1_em = 3.63 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 1.5 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = -2.94 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = -9.23 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -0.6 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 2.47 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 3.7 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 20.5 ;
parameter real a0_b0_b0_p2_em = 0 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 0 ;
parameter real a0_b0_a1_p2_em = 0 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = 0 ;
parameter real a0_b0_a2_p2_em = 0 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 0 ;
parameter real a0_b0_a3_p2_em = 0 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = 0 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 0 ;
parameter real a0_b0_p2_p2_em = 0 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 0 ;
parameter real a0_b0_p3_p2_em = 0 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 0 ;
parameter real a0_b0_p4_p2_em = 0 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 25.4 ;
parameter real a0_b0_b0_p3_em = 0.0072 ;
parameter real b0_a0_b0_p3_em = 0 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = 0 ;
parameter real a0_b0_a1_p3_em = 0 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0 ;
parameter real a0_b0_a2_p3_em = 0 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = 0 ;
parameter real a0_b0_a3_p3_em = 0 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 0 ;
parameter real a0_b0_p1_p3_em = 0 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 0 ;
parameter real a0_b0_p2_p3_em = 0 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 0 ;
parameter real a0_b0_p3_p3_em = 0 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 0 ;
parameter real a0_b0_p4_p3_em = 0 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 25.8 ;
parameter real a0_b0_b0_p4_em = 0.0172 ;
parameter real b0_a0_b0_p4_em = 0.0279 ;
parameter real a0_a0_b0_p4_em = -2.33E-04 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 0 ;
parameter real a0_b0_a1_p4_em = 0 ;
parameter real b0_a0_a1_p4_em = 0 ;
parameter real a0_a0_a1_p4_em = 0 ;
parameter real b0_b0_a2_p4_em = 0 ;
parameter real a0_b0_a2_p4_em = 0 ;
parameter real b0_a0_a2_p4_em = 0 ;
parameter real a0_a0_a2_p4_em = 0 ;
parameter real b0_b0_a3_p4_em = 0 ;
parameter real a0_b0_a3_p4_em = 0 ;
parameter real b0_a0_a3_p4_em = 0 ;
parameter real a0_a0_a3_p4_em = 0 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 0 ;
parameter real a0_b0_p1_p4_em = 0 ;
parameter real b0_a0_p1_p4_em = 0 ;
parameter real a0_a0_p1_p4_em = 0 ;
parameter real b0_b0_p2_p4_em = 0 ;
parameter real a0_b0_p2_p4_em = 0 ;
parameter real b0_a0_p2_p4_em = 0 ;
parameter real a0_a0_p2_p4_em = 0 ;
parameter real b0_b0_p3_p4_em = 0 ;
parameter real a0_b0_p3_p4_em = 0 ;
parameter real b0_a0_p3_p4_em = 0 ;
parameter real a0_a0_p3_p4_em = 0 ;
parameter real b0_b0_p4_p4_em = 0 ;
parameter real a0_b0_p4_p4_em = 0 ;
parameter real b0_a0_p4_p4_em = 0 ;
parameter real a0_a0_p4_p4_em = 0 ;     
   


parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.835;
parameter real        relimo_a2 = 0.982;
parameter real        relimo_c1 = 7.63e3;
parameter real        relimo_alpha1 = 9.36e-11;
parameter real        relimo_m1 = 2.03;
parameter real        relimo_lamda0 = 5.96e-7;
parameter real        relimo_fstat1 = 0.00308;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 428.10;
parameter real        relimo_n_hci3 = 0.42;
parameter real        relimo_alpha2 = 6.8726632e20;
parameter real        relimo_beta2 = 5.4e-5;
parameter real        relimo_gama2 = 18.13;
parameter real        relimo_eps2 = 9.97;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.82;
parameter real        relimo_rth = 0.00952;
parameter real        relimo_fstat2 = 0.033855;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
real b0_b0_p4_em, a0_b0_p4_em, b0_a0_p4_em, a0_a0_p4_em, b0_a1_p4_em;
real a0_a1_p4_em, b0_a2_p4_em, a0_a2_p4_em, b0_a3_p4_em, a0_a3_p4_em;
real b0_a4_p4_em, a0_a4_p4_em, b0_p1_p4_em, a0_p1_p4_em, b0_p2_p4_em;
real a0_p2_p4_em, b0_p3_p4_em, a0_p3_p4_em, b0_p4_p4_em, a0_p4_p4_em;
real b0_b0_em, a0_b0_em, a1_b0_em, a2_b0_em, a3_b0_em, a4_b0_em, p1_b0_em;
real p2_b0_em, p3_b0_em, p4_b0_em, b0_a0_em, a0_a0_em, a1_a0_em, a2_a0_em;
real a3_a0_em, a4_a0_em, p1_a0_em, p2_a0_em, p3_a0_em, p4_a0_em, b0_a1_em;
real a0_a1_em, a1_a1_em, a2_a1_em, a3_a1_em, a4_a1_em, p1_a1_em, p2_a1_em;
real p3_a1_em, p4_a1_em, b0_a2_em, a0_a2_em, a1_a2_em, a2_a2_em, a3_a2_em;
real a4_a2_em, p1_a2_em, p2_a2_em, p3_a2_em, p4_a2_em, b0_a3_em, a0_a3_em;
real a1_a3_em, a2_a3_em, a3_a3_em, a4_a3_em, p1_a3_em, p2_a3_em, p3_a3_em;
real p4_a3_em, b0_a4_em, a0_a4_em, a1_a4_em, a2_a4_em, a3_a4_em, a4_a4_em;
real p1_a4_em, p2_a4_em, p3_a4_em, p4_a4_em, b0_p1_em, a0_p1_em, a1_p1_em;
real a2_p1_em, a3_p1_em, a4_p1_em, p1_p1_em, p2_p1_em, p3_p1_em, p4_p1_em;
real b0_p2_em, a0_p2_em, a1_p2_em, a2_p2_em, a3_p2_em, a4_p2_em, p1_p2_em;
real p2_p2_em, p3_p2_em, p4_p2_em, b0_p3_em, a0_p3_em, a1_p3_em, a2_p3_em;
real a3_p3_em, a4_p3_em, p1_p3_em, p2_p3_em, p3_p3_em, p4_p3_em, b0_p4_em;
real a0_p4_em, a1_p4_em, a2_p4_em, a3_p4_em, a4_p4_em, p1_p4_em, p2_p4_em;
real p3_p4_em, p4_p4_em;
real b0_em, a0_em, a1_em, a2_em, a3_em, a4_em, p1_em, p2_em, p3_em, p4_em, em;


  analog function real linear;
    input b, a, x;
    real  b, a, x;
    begin
      linear = a * x + b;
    end
  endfunction // linear

  analog function real linear_5reg;
    input b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b0, a0, a1, a2, a3, a4, p1, p2, p3, p4, x;
    real  b1, b2, b3, b4;
    begin
      b1 = (a0 - a1) * p1 + b0;
      b2 = (a1 - a2) * p2 + b1;
      b3 = (a2 - a3) * p3 + b2;
      b4 = (a3 - a4) * p4 + b3;

      if      (x < p1) linear_5reg = a0 * x + b0;
      else if (x < p2) linear_5reg = a1 * x + b1;
      else if (x < p3) linear_5reg = a2 * x + b2;
      else if (x < p4) linear_5reg = a3 * x + b3;
      else             linear_5reg = a4 * x + b4;
    end
  endfunction // linear_5reg

   
// Start simulatoin
analog begin
	if(relimo_hci_aging_open_flag == 1) begin
		if((relimo_bi_aging_flag == 1) || (relimo_op_aging_flag == 1)) begin
			vgs = V(g)-V(s);
			vds = V(d)-V(s);
			
			if(relimo_vth > 0) begin
				vgs = max(vgs, vgs-vds);			
			end else begin
				vgs = -max(-vgs, -(vgs-vds));
			end
			
			if(vgs > 0 && vgs < 1e-6) begin
				vgs = 1e-6;
			end
			if(vgs < 0 && vgs > -1e-6) begin
				vgs = -1e-6;
			end
			if(vds > 0 && vds < 1e-6) begin
				vds = 1e-6;
			end
			if(vds < 0 && vds > -1e-6) begin
				vds = -1e-6;
			end
			
			//dummy lines for avoiding warnings.
			temp1 = relimo_condvg + relimo_condvd;
			temp1 = relimo_intercept + relimo_r;
			vddtransistor = temp1;
			//finish dummy lines for avoiding warnings.
			
			id = abs($simprobe(relimo_probe_name, "ide"));

			//id = id*0.5*(1.0+(-1.0*vgs+vgs_cutoff_HCI)*pow(pow(-1.0*vgs+vgs_cutoff_HCI,2.0*m_cutoff_HCI)+pow(delta_cutoff_HCI,2.0*m_cutoff_HCI),-1.0/2.0/m_cutoff_HCI));

			if (id == 0) begin
				id = id+1e-15;
			end
			if(relimo_function == 1) begin
				vddtransistor = abs(vds);
			end else begin
				vddtransistor = abs(vgs);
			end
			
			delta_damage1 = 0;
			delta_damage2 = 0;
			delta_damage3 = 0;
			if(relimo_vth > 0) begin
				if(vds > 1e-5) begin	// off state HCI.
					delta_damage1 = 1/exp(relimo_intercept-relimo_c*vddtransistor)*1/(relimo_a_idsat*relimo_m)*exp(-1*relimo_e/(relimo_kb*$temperature));
        				//$display("Zhichen Debug 111 in device %e, %e, %e, %e,  %e, %e, %e, %e", relimo_intercept, relimo_c, relimo_a_idsat, relimo_m,relimo_e,relimo_intercept-relimo_c*vddtransistor,relimo_intercept,vddtransistor);
				end
				
				`EM($temperature, vgs, vds, (V(sub)-V(s)))
				if (em == 0) begin
					lamda = 0;
					delta_damage2 = 0;
				end else begin
					lamda = relimo_lamda0*tanh(relimo_Ep/(2.0*relimo_kb*$temperature));
					delta_damage2 = 1.0/(relimo_fstat1*relimo_alpha1*pow(w*1e-6/id,relimo_m1)*relimo_Feb/(em*lamda)*exp(relimo_Feb/(em*lamda)));
				end
        			//$display("Parameter MULT in device %e, %e, %e, %e,  %e, %e, %e, %e", pow(w*1e-6/id,relimo_m1), relimo_Feb/(em*lamda), exp(relimo_Feb/(em*lamda)), id,relimo_m1,em,relimo_Feb,delta_damage2);
				
				if(vds > 0 && vgs > 0) begin	// High V HCI.
					delta_damage3 = 1.0/(relimo_fstat2*relimo_alpha2*pow(w*1e-6/id,relimo_beta2)*pow(vgs,-1*relimo_gama2)*pow(vds,-1*relimo_eps2)*exp(-1*relimo_eta2*abs(V(sub)-V(s)))*exp(relimo_ea2/relimo_kb/($temperature+relimo_rth*id*vds/(w*1e-6))));
				end
			
			end
			if($abstime>=relimo_aging_tstart) begin
				dt = ($abstime - last_abstime);	
				last_abstime = $abstime;			
				damage1 = damage1 + dt/2*(delta_damage1 + last_delta_damage1);
				damage2 = damage2 + dt/2*(delta_damage2 + last_delta_damage2);
				damage3 = damage3 + dt/2*(delta_damage3 + last_delta_damage3);
				last_delta_damage1 = delta_damage1;
				last_delta_damage2 = delta_damage2;
				last_delta_damage3 = delta_damage3;
				if (abs(vgs) > vgsmax) begin
					vgsmax = abs(vgs);
				end
				if (abs(vds) > vdsmax) begin
					vdsmax = abs(vds);
				end
			end else begin
				last_abstime = $abstime;
			end
		end
	end
	@(final_step) begin
        	//$display("Parameter %M in device %e, %e, %e, %e", em, delta_damage2, lamda, id);
        	//$display("Parameter %M in device %e, %e, %e, %e", $temperature, vgs, vds, (V(sub)-V(s)));
        	//$display("Parameter %M in device %e, %e, %e, %e", relimo_eps2, relimo_eta2, (V(sub)-V(s)), relimo_ea2);
        	//$display("Parameter %M in device %e, %e, %e, %e", ($temperature+relimo_rth*id*vds/(w*1e-6)), delta_damage3, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
		results_aged = $fopen ("./aged.output");
  		$fwrite (results_aged, "instance=%M dela_vth_relimo=%e delr_u0_relimo=%e delr_rdsw_relimo=%e delr_a0_relimo=%e\n", dela_vth_relimo, delr_u0_relimo, delr_rdsw_relimo, delr_a0_relimo);
  		$fclose (results_aged);
		if (relimo_bi_aging_flag==1) begin
      			if (analysis("tran")&&($abstime > 0)) begin
      				if ($abstime > relimo_aging_tstart) begin
					damage1 = damage1*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage2 = damage2*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
					damage3 = damage3*relimo_aging_time*3600/($abstime-relimo_aging_tstart);
				end else begin
					damage1 = 0;
					damage2 = 0;
					damage3 = 0;
				end
			end else begin
				damage1 = delta_damage1*relimo_aging_time*3600;
				damage2 = delta_damage2*relimo_aging_time*3600;
				damage3 = delta_damage3*relimo_aging_time*3600;
      			end
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
			//delta_idlin = relimo_a_idlin * delta_idsat;
 			//delta_gm = relimo_a_gm * delta_idsat;
 			//delta_vth = relimo_a_vth * delta_idsat;
        		//$display("Parameter MULT in device %e, %e, %e, %e", vds, vgs, (V(sub)-V(s)), relimo_a1*ln(1+damage2)+relimo_a2*ln(1+1/relimo_c1*damage2));
     			results_aging_bi = $fopen ("bi_aging.dat");
			$fwrite (results_aging_bi, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_bi, "instance %M relimo_aging_time_bi %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_bi, "instance %M delta_idsat_bi_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_bi, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_bi, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hci %e\n", damage1);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hci %e\n", damage2);
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_bi, "instance %M delta_vth_bi_hci %e\n", damage3);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_bi, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_bi, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_bi, "instance %M delta_ron1_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron2_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_bi, "instance %M delta_ron3_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron4_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M delta_ron5_bi_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_bi, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_bi, "instance %M relimo_ratio_vth %e\n", 1.0);
				
		end
		if ((relimo_op_aging_flag==1)&&(analysis("tran"))&&($abstime > 0)) begin
      			if ($abstime > relimo_aging_tstart) begin
				//damage = (damage_s+damage_d)*(relimo_aging_time)/($abstime-relimo_aging_tstart)*exp(-1*relimo_e/(relimo_kb*$temperature));
				damage1 = damage1*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage2 = damage2*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
				damage3 = damage3*(relimo_aging_time)*(24*365.24*3600)/($abstime-relimo_aging_tstart);
			end else begin
				damage1 = 0;
				damage2 = 0;
				damage3 = 0;
      			end
			//delta_idsat = relimo_a_idsat * pow(damage, relimo_n);
			delta_idsat = 0;
			if (damage1 == 0) begin
				damage1 = 1e-12;
			end
			if (damage2 == 0) begin
				damage2 = 1e-12;
			end
			if (damage3 == 0) begin
				damage3 = 1e-12;
			end
     			results_aging_op = $fopen ("op_aging.dat");
			$fwrite (results_aging_op, "instance %M device_name %s\n", relimo_device_name);
			$fwrite (results_aging_op, "instance %M relimo_aging_time_op %e vds_max %e vgs_max %e\n", relimo_aging_time, vdsmax, vgsmax);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_a %e relimo_ratio2_a %e relimo_ratio3_a %e\n", relimo_ratio1_a, relimo_ratio2_a, relimo_ratio3_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_a %e relimo_ratio5_a %e relimo_ratio6_a %e\n", relimo_ratio4_a, relimo_ratio5_a, relimo_ratio6_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_a %e relimo_ratio8_a %e relimo_ratio9_a %e relimo_ratio10_a %e\n", relimo_ratio7_a, relimo_ratio8_a, relimo_ratio9_a, relimo_ratio10_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_a %e relimo_ratio12_a %e relimo_ratio13_a %e\n", relimo_ratio11_a, relimo_ratio12_a, relimo_ratio13_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_a %e relimo_ratio15_a %e relimo_ratio16_a %e\n", relimo_ratio14_a, relimo_ratio15_a, relimo_ratio16_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio1_b %e relimo_ratio2_b %e relimo_ratio3_b %e\n", relimo_ratio1_b, relimo_ratio2_b, relimo_ratio3_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio4_b %e relimo_ratio5_b %e relimo_ratio6_b %e\n", relimo_ratio4_b, relimo_ratio5_b, relimo_ratio6_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio7_b %e relimo_ratio8_b %e relimo_ratio9_b %e relimo_ratio10_b %e\n", relimo_ratio7_b, relimo_ratio8_b, relimo_ratio9_b, relimo_ratio10_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio11_b %e relimo_ratio12_b %e relimo_ratio13_b %e\n", relimo_ratio11_b, relimo_ratio12_b, relimo_ratio13_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio14_b %e relimo_ratio15_b %e relimo_ratio16_b %e\n", relimo_ratio14_b, relimo_ratio15_b, relimo_ratio16_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth2a0 %e relimo_ratio_rdsw2vth_a %e relimo_ratio_rdsw2vth_b %e relimo_ratio_rdsw2vth_c %e\n", relimo_ratio_vth2a0, 0.0, 0.0, 0.0);
			
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_%d %e relimo_n_hci_%d %e\n", relimo_function, delta_idsat, relimo_function, relimo_n);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_%d %e\n", relimo_function, relimo_a_idlin);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_%d %e\n", relimo_function, relimo_a_gm);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_%d %e\n", relimo_function, relimo_a_vth);
			$fwrite (results_aging_op, "instance %M delta_idsat_op_hci_2 %e relimo_n_hci_2 %e\n", 0.0, 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_idlin_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_gm_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a_vth_hci_2 %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_a %e\n", relimo_ratio20_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio20_b %e\n", relimo_ratio20_b);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_a %e\n", relimo_ratio21_a);
			$fwrite (results_aging_op, "instance %M relimo_ratio21_b %e\n", relimo_ratio21_b);
			$fwrite (results_aging_op, "instance %M delta_ron_flag %e\n", 1.0*relimo_hci_aging_open_flag);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hci %e\n", damage1);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hci %e\n", damage2);
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hci %e\n", 1.0/relimo_c1*damage2);
			$fwrite (results_aging_op, "instance %M delta_vth_op_hci %e\n", damage3);
			$fwrite (results_aging_op, "instance %M relimo_a1_hci %e\n", relimo_a1);
			$fwrite (results_aging_op, "instance %M relimo_a2_hci %e\n", relimo_a2);
			$fwrite (results_aging_op, "instance %M relimo_a_hci3 %e\n", relimo_a_hci3);
			$fwrite (results_aging_op, "instance %M relimo_n_hci3 %e\n", relimo_n_hci3);
			$fwrite (results_aging_op, "instance %M relimo_d_hci1 %e\n", relimo_d_hci1);
			$fwrite (results_aging_op, "instance %M delta_ron1_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron2_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a1_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a2_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n1_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_n2_hciphv %e\n", 1.0);
			
			$fwrite (results_aging_op, "instance %M delta_ron3_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron4_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M delta_ron5_op_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_a3_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_a4_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_b_hciphv %e\n", 0.0);
			$fwrite (results_aging_op, "instance %M relimo_n_hciphv %e\n", 1.0);
			$fwrite (results_aging_op, "instance %M relimo_ratio_vth %e\n", 1.0);
			
		end	
	end
end
endmodule


module relimo_aging_hci_nld65b(d,g,s,sub);
input d,g,s,sub;
electrical d,g,s,sub;

// relimo_aged parameters in model file
parameter real        dela_vth_relimo              = 0;			
parameter real        delr_u0_relimo               = 0;			
parameter real        delr_rdsw_relimo             = 0;			
parameter real        delr_a0_relimo               = 0;			
parameter real        w               		   = 0;			

// User-defined Simulation relimo_control Inputs
parameter real        relimo_hci_aging_open_flag   = 0;
parameter real        relimo_bi_aging_flag         = 0;
parameter real        relimo_op_aging_flag         = 0;
   							
// User-defined relimo_aging Inputs 
parameter real        relimo_aging_tstart          = 0;
parameter real        relimo_aging_time            = 10;		
   
// relimo_nechnology-specified parameters
parameter string      relimo_device_name           = "fet";
parameter string      relimo_probe_name            = "fet";
parameter real        relimo_vth                   = 0.51;			
parameter real        relimo_intercept             = 0;			
parameter real        relimo_c                     = 0;			
parameter real        relimo_e                     = 0;
parameter real        relimo_kb                    = 8.62e-5;
parameter real        relimo_m                     = 0;
parameter real        relimo_n                     = 1;
parameter real        relimo_r                     = 0;
parameter real        relimo_a_idsat               = 0;
parameter real        relimo_a_idlin               = 0;
parameter real        relimo_a_gm                  = 0;
parameter real        relimo_a_vth                 = 0;
parameter integer     relimo_function              = 1;

parameter real        relimo_condvg                = 0;
parameter real        relimo_condvd                = 0;


// relimo_ratios
parameter real        relimo_ratio1_a                = 1;
parameter real        relimo_ratio2_a                = 1;
parameter real        relimo_ratio3_a                = 1;
parameter real        relimo_ratio4_a                = 1;
parameter real        relimo_ratio5_a                = 1;
parameter real        relimo_ratio6_a                = 1;
parameter real        relimo_ratio7_a                = 1;
parameter real        relimo_ratio8_a                = 1;
parameter real        relimo_ratio9_a                = 1;
parameter real        relimo_ratio10_a               = 1;
parameter real        relimo_ratio11_a               = 1;
parameter real        relimo_ratio12_a               = 1;
parameter real        relimo_ratio13_a               = 1;
parameter real        relimo_ratio14_a               = 1;
parameter real        relimo_ratio15_a               = 1;
parameter real        relimo_ratio16_a               = 1;

parameter real        relimo_ratio1_b                = 0;
parameter real        relimo_ratio2_b                = 0;
parameter real        relimo_ratio3_b                = 0;
parameter real        relimo_ratio4_b                = 0;
parameter real        relimo_ratio5_b                = 0;
parameter real        relimo_ratio6_b                = 0;
parameter real        relimo_ratio7_b                = 0;
parameter real        relimo_ratio8_b                = 0;
parameter real        relimo_ratio9_b                = 0;
parameter real        relimo_ratio10_b               = 0;
parameter real        relimo_ratio11_b               = 0;
parameter real        relimo_ratio12_b               = 0;
parameter real        relimo_ratio13_b               = 0;
parameter real        relimo_ratio14_b               = 0;
parameter real        relimo_ratio15_b               = 0;
parameter real        relimo_ratio16_b               = 0;

parameter real        relimo_ratio20_a               = 1;
parameter real        relimo_ratio20_b               = 0;
parameter real        relimo_ratio21_a               = 1;
parameter real        relimo_ratio21_b               = 0;

parameter real        relimo_ratio_vth2a0            = 16;

parameter real b0_b0_b0_b0_em = 0 ;
parameter real a0_b0_b0_b0_em = 0 ;
parameter real b0_a0_b0_b0_em = 0 ;
parameter real a0_a0_b0_b0_em = 0 ;
parameter real b0_b0_a0_b0_em = 0 ;
parameter real a0_b0_a0_b0_em = 0 ;
parameter real b0_a0_a0_b0_em = 0 ;
parameter real a0_a0_a0_b0_em = 0 ;
parameter real b0_b0_a1_b0_em = 0 ;
parameter real a0_b0_a1_b0_em = 0 ;
parameter real b0_a0_a1_b0_em = 0 ;
parameter real a0_a0_a1_b0_em = 0 ;
parameter real b0_b0_a2_b0_em = 0 ;
parameter real a0_b0_a2_b0_em = 0 ;
parameter real b0_a0_a2_b0_em = 0 ;
parameter real a0_a0_a2_b0_em = 0 ;
parameter real b0_b0_a3_b0_em = 0 ;
parameter real a0_b0_a3_b0_em = 0 ;
parameter real b0_a0_a3_b0_em = 0 ;
parameter real a0_a0_a3_b0_em = 0 ;
parameter real b0_b0_a4_b0_em = 0 ;
parameter real a0_b0_a4_b0_em = 0 ;
parameter real b0_a0_a4_b0_em = 0 ;
parameter real a0_a0_a4_b0_em = 0 ;
parameter real b0_b0_p1_b0_em = 0 ;
parameter real a0_b0_p1_b0_em = 0 ;
parameter real b0_a0_p1_b0_em = 0 ;
parameter real a0_a0_p1_b0_em = 0 ;
parameter real b0_b0_p2_b0_em = 0 ;
parameter real a0_b0_p2_b0_em = 0 ;
parameter real b0_a0_p2_b0_em = 0 ;
parameter real a0_a0_p2_b0_em = 0 ;
parameter real b0_b0_p3_b0_em = 0 ;
parameter real a0_b0_p3_b0_em = 0 ;
parameter real b0_a0_p3_b0_em = 0 ;
parameter real a0_a0_p3_b0_em = 0 ;
parameter real b0_b0_p4_b0_em = 0 ;
parameter real a0_b0_p4_b0_em = 0 ;
parameter real b0_a0_p4_b0_em = 0 ;
parameter real a0_a0_p4_b0_em = 0 ;
parameter real b0_b0_b0_a0_em = 0 ;
parameter real a0_b0_b0_a0_em = 0 ;
parameter real b0_a0_b0_a0_em = 0 ;
parameter real a0_a0_b0_a0_em = 0 ;
parameter real b0_b0_a0_a0_em = 0 ;
parameter real a0_b0_a0_a0_em = 0 ;
parameter real b0_a0_a0_a0_em = 0 ;
parameter real a0_a0_a0_a0_em = 0 ;
parameter real b0_b0_a1_a0_em = 0 ;
parameter real a0_b0_a1_a0_em = 0 ;
parameter real b0_a0_a1_a0_em = 0 ;
parameter real a0_a0_a1_a0_em = 0 ;
parameter real b0_b0_a2_a0_em = 0 ;
parameter real a0_b0_a2_a0_em = 0 ;
parameter real b0_a0_a2_a0_em = 0 ;
parameter real a0_a0_a2_a0_em = 0 ;
parameter real b0_b0_a3_a0_em = 0 ;
parameter real a0_b0_a3_a0_em = 0 ;
parameter real b0_a0_a3_a0_em = 0 ;
parameter real a0_a0_a3_a0_em = 0 ;
parameter real b0_b0_a4_a0_em = 0 ;
parameter real a0_b0_a4_a0_em = 0 ;
parameter real b0_a0_a4_a0_em = 0 ;
parameter real a0_a0_a4_a0_em = 0 ;
parameter real b0_b0_p1_a0_em = 0 ;
parameter real a0_b0_p1_a0_em = 0 ;
parameter real b0_a0_p1_a0_em = 0 ;
parameter real a0_a0_p1_a0_em = 0 ;
parameter real b0_b0_p2_a0_em = 0 ;
parameter real a0_b0_p2_a0_em = 0 ;
parameter real b0_a0_p2_a0_em = 0 ;
parameter real a0_a0_p2_a0_em = 0 ;
parameter real b0_b0_p3_a0_em = 0 ;
parameter real a0_b0_p3_a0_em = 0 ;
parameter real b0_a0_p3_a0_em = 0 ;
parameter real a0_a0_p3_a0_em = 0 ;
parameter real b0_b0_p4_a0_em = 0 ;
parameter real a0_b0_p4_a0_em = 0 ;
parameter real b0_a0_p4_a0_em = 0 ;
parameter real a0_a0_p4_a0_em = 0 ;
parameter real b0_b0_b0_a1_em = 12500 ;
parameter real a0_b0_b0_a1_em = -1.76 ;
parameter real b0_a0_b0_a1_em = 0 ;
parameter real a0_a0_b0_a1_em = 0 ;
parameter real b0_b0_a0_a1_em = 0 ;
parameter real a0_b0_a0_a1_em = 0 ;
parameter real b0_a0_a0_a1_em = 0 ;
parameter real a0_a0_a0_a1_em = 0 ;
parameter real b0_b0_a1_a1_em = 740 ;
parameter real a0_b0_a1_a1_em = -3.88 ;
parameter real b0_a0_a1_a1_em = 0 ;
parameter real a0_a0_a1_a1_em = 0 ;
parameter real b0_b0_a2_a1_em = 3540 ;
parameter real a0_b0_a2_a1_em = -6.25 ;
parameter real b0_a0_a2_a1_em = 0 ;
parameter real a0_a0_a2_a1_em = 0 ;
parameter real b0_b0_a3_a1_em = -5450 ;
parameter real a0_b0_a3_a1_em = 6.53 ;
parameter real b0_a0_a3_a1_em = 0 ;
parameter real a0_a0_a3_a1_em = 0 ;
parameter real b0_b0_a4_a1_em = 0 ;
parameter real a0_b0_a4_a1_em = 0 ;
parameter real b0_a0_a4_a1_em = 0 ;
parameter real a0_a0_a4_a1_em = 0 ;
parameter real b0_b0_p1_a1_em = -2.01 ;
parameter real a0_b0_p1_a1_em = 0.00665 ;
parameter real b0_a0_p1_a1_em = 0 ;
parameter real a0_a0_p1_a1_em = 0 ;
parameter real b0_b0_p2_a1_em = 1.89 ;
parameter real a0_b0_p2_a1_em = -0.00137 ;
parameter real b0_a0_p2_a1_em = 0 ;
parameter real a0_a0_p2_a1_em = 0 ;
parameter real b0_b0_p3_a1_em = 4.93 ;
parameter real a0_b0_p3_a1_em = -0.00502 ;
parameter real b0_a0_p3_a1_em = 0 ;
parameter real a0_a0_p3_a1_em = 0 ;
parameter real b0_b0_p4_a1_em = 4.9 ;
parameter real a0_b0_p4_a1_em = -0.0017 ;
parameter real b0_a0_p4_a1_em = 0 ;
parameter real a0_a0_p4_a1_em = 0 ;
parameter real b0_b0_b0_a2_em = 9610 ;
parameter real a0_b0_b0_a2_em = -11.6 ;
parameter real b0_a0_b0_a2_em = 10.1 ;
parameter real a0_a0_b0_a2_em = 0 ;
parameter real b0_b0_a0_a2_em = 0 ;
parameter real a0_b0_a0_a2_em = 0 ;
parameter real b0_a0_a0_a2_em = 0 ;
parameter real a0_a0_a0_a2_em = 0 ;
parameter real b0_b0_a1_a2_em = -1830 ;
parameter real a0_b0_a1_a2_em = 5.24 ;
parameter real b0_a0_a1_a2_em = 0 ;
parameter real a0_a0_a1_a2_em = 0 ;
parameter real b0_b0_a2_a2_em = 823 ;
parameter real a0_b0_a2_a2_em = 1.05 ;
parameter real b0_a0_a2_a2_em = 0 ;
parameter real a0_a0_a2_a2_em = 0 ;
parameter real b0_b0_a3_a2_em = -1660 ;
parameter real a0_b0_a3_a2_em = -1.95 ;
parameter real b0_a0_a3_a2_em = 0 ;
parameter real a0_a0_a3_a2_em = 0 ;
parameter real b0_b0_a4_a2_em = 0 ;
parameter real a0_b0_a4_a2_em = 0 ;
parameter real b0_a0_a4_a2_em = 0 ;
parameter real a0_a0_a4_a2_em = 0 ;
parameter real b0_b0_p1_a2_em = -0.29 ;
parameter real a0_b0_p1_a2_em = -0.00378 ;
parameter real b0_a0_p1_a2_em = 0 ;
parameter real a0_a0_p1_a2_em = 0 ;
parameter real b0_b0_p2_a2_em = 2.36 ;
parameter real a0_b0_p2_a2_em = -0.00521 ;
parameter real b0_a0_p2_a2_em = 0 ;
parameter real a0_a0_p2_a2_em = 0 ;
parameter real b0_b0_p3_a2_em = 2.17 ;
parameter real a0_b0_p3_a2_em = -0.0021 ;
parameter real b0_a0_p3_a2_em = 0 ;
parameter real a0_a0_p3_a2_em = 0 ;
parameter real b0_b0_p4_a2_em = 3 ;
parameter real a0_b0_p4_a2_em = 0 ;
parameter real b0_a0_p4_a2_em = 0 ;
parameter real a0_a0_p4_a2_em = 0 ;
parameter real b0_b0_b0_a3_em = 156 ;
parameter real a0_b0_b0_a3_em = 24.4 ;
parameter real b0_a0_b0_a3_em = 25 ;
parameter real a0_a0_b0_a3_em = 0 ;
parameter real b0_b0_a0_a3_em = 0 ;
parameter real a0_b0_a0_a3_em = 0 ;
parameter real b0_a0_a0_a3_em = 0 ;
parameter real a0_a0_a0_a3_em = 0 ;
parameter real b0_b0_a1_a3_em = 1690 ;
parameter real a0_b0_a1_a3_em = -1.69 ;
parameter real b0_a0_a1_a3_em = 0 ;
parameter real a0_a0_a1_a3_em = 0 ;
parameter real b0_b0_a2_a3_em = 0.33 ;
parameter real a0_b0_a2_a3_em = 0.302 ;
parameter real b0_a0_a2_a3_em = 0 ;
parameter real a0_a0_a2_a3_em = 0 ;
parameter real b0_b0_a3_a3_em = -4020 ;
parameter real a0_b0_a3_a3_em = 0.0695 ;
parameter real b0_a0_a3_a3_em = 0 ;
parameter real a0_a0_a3_a3_em = 0 ;
parameter real b0_b0_a4_a3_em = 0 ;
parameter real a0_b0_a4_a3_em = 0 ;
parameter real b0_a0_a4_a3_em = 0 ;
parameter real a0_a0_a4_a3_em = 0 ;
parameter real b0_b0_p1_a3_em = -0.413 ;
parameter real a0_b0_p1_a3_em = -0.00101 ;
parameter real b0_a0_p1_a3_em = 0 ;
parameter real a0_a0_p1_a3_em = 0 ;
parameter real b0_b0_p2_a3_em = 1.16 ;
parameter real a0_b0_p2_a3_em = -0.00153 ;
parameter real b0_a0_p2_a3_em = 0 ;
parameter real a0_a0_p2_a3_em = 0 ;
parameter real b0_b0_p3_a3_em = 1.88 ;
parameter real a0_b0_p3_a3_em = -0.0035 ;
parameter real b0_a0_p3_a3_em = 0 ;
parameter real a0_a0_p3_a3_em = 0 ;
parameter real b0_b0_p4_a3_em = 3.1 ;
parameter real a0_b0_p4_a3_em = 0 ;
parameter real b0_a0_p4_a3_em = 0 ;
parameter real a0_a0_p4_a3_em = 0 ;
parameter real b0_b0_b0_a4_em = 1690 ;
parameter real a0_b0_b0_a4_em = 1.24 ;
parameter real b0_a0_b0_a4_em = 0.583 ;
parameter real a0_a0_b0_a4_em = 0.0392 ;
parameter real b0_b0_a0_a4_em = 0 ;
parameter real a0_b0_a0_a4_em = 0 ;
parameter real b0_a0_a0_a4_em = 0 ;
parameter real a0_a0_a0_a4_em = 0 ;
parameter real b0_b0_a1_a4_em = -111 ;
parameter real a0_b0_a1_a4_em = 0.778 ;
parameter real b0_a0_a1_a4_em = 0.587 ;
parameter real a0_a0_a1_a4_em = 0.0311 ;
parameter real b0_b0_a2_a4_em = -1830 ;
parameter real a0_b0_a2_a4_em = 3.04 ;
parameter real b0_a0_a2_a4_em = 0 ;
parameter real a0_a0_a2_a4_em = 0.0019 ;
parameter real b0_b0_a3_a4_em = -205 ;
parameter real a0_b0_a3_a4_em = 8.19 ;
parameter real b0_a0_a3_a4_em = 0.00514 ;
parameter real a0_a0_a3_a4_em = -0.0249 ;
parameter real b0_b0_a4_a4_em = 0 ;
parameter real a0_b0_a4_a4_em = 0 ;
parameter real b0_a0_a4_a4_em = 0 ;
parameter real a0_a0_a4_a4_em = 0 ;
parameter real b0_b0_p1_a4_em = -5.6 ;
parameter real a0_b0_p1_a4_em = 0.0109 ;
parameter real b0_a0_p1_a4_em = 0.055 ;
parameter real a0_a0_p1_a4_em = -5.47E-05 ;
parameter real b0_b0_p2_a4_em = 2.32 ;
parameter real a0_b0_p2_a4_em = -0.00363 ;
parameter real b0_a0_p2_a4_em = -0.0314 ;
parameter real a0_a0_p2_a4_em = 8.40E-05 ;
parameter real b0_b0_p3_a4_em = 1.67 ;
parameter real a0_b0_p3_a4_em = 0.00271 ;
parameter real b0_a0_p3_a4_em = -0.00569 ;
parameter real a0_a0_p3_a4_em = 3.25E-05 ;
parameter real b0_b0_p4_a4_em = 4.77 ;
parameter real a0_b0_p4_a4_em = -0.00147 ;
parameter real b0_a0_p4_a4_em = 0.00822 ;
parameter real a0_a0_p4_a4_em = -1.44E-05 ;
parameter real b0_b0_b0_p1_em = 1.67 ;
parameter real a0_b0_b0_p1_em = 0 ;
parameter real b0_a0_b0_p1_em = 0 ;
parameter real a0_a0_b0_p1_em = 0 ;
parameter real b0_b0_a0_p1_em = 0 ;
parameter real a0_b0_a0_p1_em = 0 ;
parameter real b0_a0_a0_p1_em = 0 ;
parameter real a0_a0_a0_p1_em = 0 ;
parameter real b0_b0_a1_p1_em = 0.524 ;
parameter real a0_b0_a1_p1_em = 0 ;
parameter real b0_a0_a1_p1_em = 0 ;
parameter real a0_a0_a1_p1_em = 0 ;
parameter real b0_b0_a2_p1_em = 3.49 ;
parameter real a0_b0_a2_p1_em = 0 ;
parameter real b0_a0_a2_p1_em = 0 ;
parameter real a0_a0_a2_p1_em = 0 ;
parameter real b0_b0_a3_p1_em = 11.6 ;
parameter real a0_b0_a3_p1_em = 0 ;
parameter real b0_a0_a3_p1_em = 0 ;
parameter real a0_a0_a3_p1_em = 0 ;
parameter real b0_b0_a4_p1_em = 0 ;
parameter real a0_b0_a4_p1_em = 0 ;
parameter real b0_a0_a4_p1_em = 0 ;
parameter real a0_a0_a4_p1_em = 0 ;
parameter real b0_b0_p1_p1_em = -1 ;
parameter real a0_b0_p1_p1_em = 0 ;
parameter real b0_a0_p1_p1_em = 0 ;
parameter real a0_a0_p1_p1_em = 0 ;
parameter real b0_b0_p2_p1_em = 1.48 ;
parameter real a0_b0_p2_p1_em = 0 ;
parameter real b0_a0_p2_p1_em = 0 ;
parameter real a0_a0_p2_p1_em = 0 ;
parameter real b0_b0_p3_p1_em = 3.27 ;
parameter real a0_b0_p3_p1_em = 0 ;
parameter real b0_a0_p3_p1_em = 0 ;
parameter real a0_a0_p3_p1_em = 0 ;
parameter real b0_b0_p4_p1_em = 3.81 ;
parameter real a0_b0_p4_p1_em = 0 ;
parameter real b0_a0_p4_p1_em = 0 ;
parameter real a0_a0_p4_p1_em = 0 ;
parameter real b0_b0_b0_p2_em = 20.5 ;
parameter real a0_b0_b0_p2_em = 0.0101 ;
parameter real b0_a0_b0_p2_em = 0 ;
parameter real a0_a0_b0_p2_em = 0 ;
parameter real b0_b0_a0_p2_em = 0 ;
parameter real a0_b0_a0_p2_em = 0 ;
parameter real b0_a0_a0_p2_em = 0 ;
parameter real a0_a0_a0_p2_em = 0 ;
parameter real b0_b0_a1_p2_em = 2.86 ;
parameter real a0_b0_a1_p2_em = -0.00763 ;
parameter real b0_a0_a1_p2_em = 0 ;
parameter real a0_a0_a1_p2_em = 0 ;
parameter real b0_b0_a2_p2_em = -7 ;
parameter real a0_b0_a2_p2_em = 0.0136 ;
parameter real b0_a0_a2_p2_em = 0 ;
parameter real a0_a0_a2_p2_em = 0 ;
parameter real b0_b0_a3_p2_em = 3.64 ;
parameter real a0_b0_a3_p2_em = 0.0153 ;
parameter real b0_a0_a3_p2_em = 0 ;
parameter real a0_a0_a3_p2_em = 0 ;
parameter real b0_b0_a4_p2_em = 0 ;
parameter real a0_b0_a4_p2_em = 0 ;
parameter real b0_a0_a4_p2_em = 0 ;
parameter real a0_a0_a4_p2_em = 0 ;
parameter real b0_b0_p1_p2_em = -1 ;
parameter real a0_b0_p1_p2_em = 0 ;
parameter real b0_a0_p1_p2_em = 0 ;
parameter real a0_a0_p1_p2_em = 0 ;
parameter real b0_b0_p2_p2_em = 0.975 ;
parameter real a0_b0_p2_p2_em = 0.00158 ;
parameter real b0_a0_p2_p2_em = 0 ;
parameter real a0_a0_p2_p2_em = 0 ;
parameter real b0_b0_p3_p2_em = 3.07 ;
parameter real a0_b0_p3_p2_em = -0.000216 ;
parameter real b0_a0_p3_p2_em = 0 ;
parameter real a0_a0_p3_p2_em = 0 ;
parameter real b0_b0_p4_p2_em = 4.49 ;
parameter real a0_b0_p4_p2_em = -0.00132 ;
parameter real b0_a0_p4_p2_em = 0 ;
parameter real a0_a0_p4_p2_em = 0 ;
parameter real b0_b0_b0_p3_em = 35.1 ;
parameter real a0_b0_b0_p3_em = 0.00167 ;
parameter real b0_a0_b0_p3_em = 0.1 ;
parameter real a0_a0_b0_p3_em = 0 ;
parameter real b0_b0_a0_p3_em = 0 ;
parameter real a0_b0_a0_p3_em = 0 ;
parameter real b0_a0_a0_p3_em = 0 ;
parameter real a0_a0_a0_p3_em = 0 ;
parameter real b0_b0_a1_p3_em = -3.61 ;
parameter real a0_b0_a1_p3_em = -0.00246 ;
parameter real b0_a0_a1_p3_em = 0 ;
parameter real a0_a0_a1_p3_em = 0 ;
parameter real b0_b0_a2_p3_em = 0.567 ;
parameter real a0_b0_a2_p3_em = 0.0088 ;
parameter real b0_a0_a2_p3_em = 0 ;
parameter real a0_a0_a2_p3_em = 0 ;
parameter real b0_b0_a3_p3_em = -7.07 ;
parameter real a0_b0_a3_p3_em = 0.0274 ;
parameter real b0_a0_a3_p3_em = 0 ;
parameter real a0_a0_a3_p3_em = 0 ;
parameter real b0_b0_a4_p3_em = 0 ;
parameter real a0_b0_a4_p3_em = 0 ;
parameter real b0_a0_a4_p3_em = 0 ;
parameter real a0_a0_a4_p3_em = 0 ;
parameter real b0_b0_p1_p3_em = 5.27 ;
parameter real a0_b0_p1_p3_em = -0.00953 ;
parameter real b0_a0_p1_p3_em = 0 ;
parameter real a0_a0_p1_p3_em = 0 ;
parameter real b0_b0_p2_p3_em = 3.94 ;
parameter real a0_b0_p2_p3_em = -0.00176 ;
parameter real b0_a0_p2_p3_em = 0 ;
parameter real a0_a0_p2_p3_em = 0 ;
parameter real b0_b0_p3_p3_em = 7.09 ;
parameter real a0_b0_p3_p3_em = -0.0154 ;
parameter real b0_a0_p3_p3_em = 0 ;
parameter real a0_a0_p3_p3_em = 0 ;
parameter real b0_b0_p4_p3_em = 4.01 ;
parameter real a0_b0_p4_p3_em = 0.000286 ;
parameter real b0_a0_p4_p3_em = 0 ;
parameter real a0_a0_p4_p3_em = 0 ;
parameter real b0_b0_b0_p4_em = 39 ;
parameter real a0_b0_b0_p4_em = -0.00378 ;
parameter real b0_a0_b0_p4_em = 0.136 ;
parameter real a0_a0_b0_p4_em = -4.67E-05 ;
parameter real b0_b0_a0_p4_em = 0 ;
parameter real a0_b0_a0_p4_em = 0 ;
parameter real b0_a0_a0_p4_em = 0 ;
parameter real a0_a0_a0_p4_em = 0 ;
parameter real b0_b0_a1_p4_em = 4.95 ;
parameter real a0_b0_a1_p4_em = -0.0139 ;
parameter real b0_a0_a1_p4_em = -0.0295 ;
parameter real a0_a0_a1_p4_em = 4.85E-05 ;
parameter real b0_b0_a2_p4_em = 4.77 ;
parameter real a0_b0_a2_p4_em = -0.0203 ;
parameter real b0_a0_a2_p4_em = -0.0575 ;
parameter real a0_a0_a2_p4_em = 0.000154 ;
parameter real b0_b0_a3_p4_em = 9.25 ;
parameter real a0_b0_a3_p4_em = 0.0477 ;
parameter real b0_a0_a3_p4_em = 0.161 ;
parameter real a0_a0_a3_p4_em = -0.000342 ;
parameter real b0_b0_a4_p4_em = 0 ;
parameter real a0_b0_a4_p4_em = 0 ;
parameter real b0_a0_a4_p4_em = 0 ;
parameter real a0_a0_a4_p4_em = 0 ;
parameter real b0_b0_p1_p4_em = 1.07 ;
parameter real a0_b0_p1_p4_em = -0.00175 ;
parameter real b0_a0_p1_p4_em = -0.00381 ;
parameter real a0_a0_p1_p4_em = -6.05E-06 ;
parameter real b0_b0_p2_p4_em = -0.68 ;
parameter real a0_b0_p2_p4_em = 0.00784 ;
parameter real b0_a0_p2_p4_em = 0.00449 ;
parameter real a0_a0_p2_p4_em = -4.46E-05 ;
parameter real b0_b0_p3_p4_em = 3.2 ;
parameter real a0_b0_p3_p4_em = -0.00137 ;
parameter real b0_a0_p3_p4_em = -0.00153 ;
parameter real a0_a0_p3_p4_em = 4.00E-06 ;
parameter real b0_b0_p4_p4_em = 3.38 ;
parameter real a0_b0_p4_p4_em = -0.000311 ;
parameter real b0_a0_p4_p4_em = -0.00355 ;
parameter real a0_a0_p4_p4_em = 1.40E-05 ;


parameter real        relimo_d_hci1 = 10.0;

parameter real        relimo_a1 = 0.767;
parameter real        relimo_a2 = 0.643;
parameter real        relimo_c1 = 1350;
parameter real        relimo_alpha1 = 7.51e-13;
parameter real        relimo_m1 = 0.993;
parameter real        relimo_lamda0 = 3.94e-7;
parameter real        relimo_fstat1 = 0.00368;
parameter real        relimo_Ep = 0.063;
parameter real        relimo_Feb = 3.2;

parameter real        relimo_a_hci3 = 305;
parameter real        relimo_n_hci3 = 0.459;
parameter real        relimo_alpha2 = 9.49e27;
parameter real        relimo_beta2 = 0.854;
parameter real        relimo_gama2 = 20.9;
parameter real        relimo_eps2 = 10.1;
parameter real        relimo_eta2 = 0;
parameter real        relimo_ea2 = 0.701;
parameter real        relimo_rth = 0.00283;
parameter real        relimo_fstat2 = 0.0696;

			
			
			
   
// General parameters
integer results_aging_bi, results_aging_op, results_aged;				
real vgs, vds, vddtransistor, id, vdsmax, vgsmax;
real delta_damage1, delta_damage2, delta_damage3, last_delta_damage1, last_delta_damage2, last_delta_damage3, damage1, damage2, damage3;
real dt, last_abstime;  
real temp1;
real delta_idsat;
real lamda;

real b0_b0_b0_em, a0_b0_b0_em, b0_a0_b0_em, a0_a0_b0_em, b0_a1_b0_em;
real a0_a1_b0_em, b0_a2_b0_em, a0_a2_b0_em, b0_a3_b0_em, a0_a3_b0_em;
real b0_a4_b0_em, a0_a4_b0_em, b0_p1_b0_em, a0_p1_b0_em, b0_p2_b0_em;
real a0_p2_b0_em, b0_p3_b0_em, a0_p3_b0_em, b0_p4_b0_em, a0_p4_b0_em;
real b0_b0_a0_em, a0_b0_a0_em, b0_a0_a0_em, a0_a0_a0_em, b0_a1_a0_em;
real a0_a1_a0_em, b0_a2_a0_em, a0_a2_a0_em, b0_a3_a0_em, a0_a3_a0_em;
real b0_a4_a0_em, a0_a4_a0_em, b0_p1_a0_em, a0_p1_a0_em, b0_p2_a0_em;
real a0_p2_a0_em, b0_p3_a0_em, a0_p3_a0_em, b0_p4_a0_em, a0_p4_a0_em;
real b0_b0_a1_em, a0_b0_a1_em, b0_a0_a1_em, a0_a0_a1_em, b0_a1_a1_em;
real a0_a1_a1_em, b0_a2_a1_em, a0_a2_a1_em, b0_a3_a1_em, a0_a3_a1_em;
real b0_a4_a1_em, a0_a4_a1_em, b0_p1_a1_em, a0_p1_a1_em, b0_p2_a1_em;
real a0_p2_a1_em, b0_p3_a1_em, a0_p3_a1_em, b0_p4_a1_em, a0_p4_a1_em;
real b0_b0_a2_em, a0_b0_a2_em, b0_a0_a2_em, a0_a0_a2_em, b0_a1_a2_em;
real a0_a1_a2_em, b0_a2_a2_em, a0_a2_a2_em, b0_a3_a2_em, a0_a3_a2_em;
real b0_a4_a2_em, a0_a4_a2_em, b0_p1_a2_em, a0_p1_a2_em, b0_p2_a2_em;
real a0_p2_a2_em, b0_p3_a2_em, a0_p3_a2_em, b0_p4_a2_em, a0_p4_a2_em;
real b0_b0_a3_em, a0_b0_a3_em, b0_a0_a3_em, a0_a0_a3_em, b0_a1_a3_em;
real a0_a1_a3_em, b0_a2_a3_em, a0_a2_a3_em, b0_a3_a3_em, a0_a3_a3_em;
real b0_a4_a3_em, a0_a4_a3_em, b0_p1_a3_em, a0_p1_a3_em, b0_p2_a3_em;
real a0_p2_a3_em, b0_p3_a3_em, a0_p3_a3_em, b0_p4_a3_em, a0_p4_a3_em;
real b0_b0_a4_em, a0_b0_a4_em, b0_a0_a4_em, a0_a0_a4_em, b0_a1_a4_em;
real a0_a1_a4_em, b0_a2_a4_em, a0_a2_a4_em, b0_a3_a4_em, a0_a3_a4_em;
real b0_a4_a4_em, a0_a4_a4_em, b0_p1_a4_em, a0_p1_a4_em, b0_p2_a4_em;
real a0_p2_a4_em, b0_p3_a4_em, a0_p3_a4_em, b0_p4_a4_em, a0_p4_a4_em;
real b0_b0_p1_em, a0_b0_p1_em, b0_a0_p1_em, a0_a0_p1_em, b0_a1_p1_em;
real a0_a1_p1_em, b0_a2_p1_em, a0_a2_p1_em, b0_a3_p1_em, a0_a3_p1_em;
real b0_a4_p1_em, a0_a4_p1_em, b0_p1_p1_em, a0_p1_p1_em, b0_p2_p1_em;
real a0_p2_p1_em, b0_p3_p1_em, a0_p3_p1_em, b0_p4_p1_em, a0_p4_p1_em;
real b0_b0_p2_em, a0_b0_p2_em, b0_a0_p2_em, a0_a0_p2_em, b0_a1_p2_em;
real a0_a1_p2_em, b0_a2_p2_em, a0_a2_p2_em, b0_a3_p2_em, a0_a3_p2_em;
real b0_a4_p2_em, a0_a4_p2_em, b0_p1_p2_em, a0_p1_p2_em, b0_p2_p2_em;
real a0_p2_p2_em, b0_p3_p2_em, a0_p3_p2_em, b0_p4_p2_em, a0_p4_p2_em;
real b0_b0_p3_em, a0_b0_p3_em, b0_a0_p3_em, a0_a0_p3_em, b0_a1_p3_em;
real a0_a1_p3_em, b0_a2_p3_em, a0_a2_p3_em, b0_a3_p3_em, a0_a3_p3_em;
real b0_a4_p3_em, a0_a4_p3_em, b0_p1_p3_em, a0_p1_p3_em, b0_p2_p3_em;
real a0_p2_p3_em, b0_p3_p3_em, a0_p3_p3_em, b0_p4_p3_em, a0_p4_p3_em;
