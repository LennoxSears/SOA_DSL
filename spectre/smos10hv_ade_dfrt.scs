anld45_10hv_esdchk_1 (d g s sub) monitor_esd_nld45_10hv ruleNum=1 enable=soa rule="esd_nld45_Vt1=61p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_2 (d g s sub) monitor_esd_nld45_10hv ruleNum=2 enable=soa rule="esd_nld45_Vt1>61p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.7
anld45_10hv_esdchk_3 (d g s sub) monitor_esd_nld45_10hv ruleNum=3 enable=soa rule="esd_nld45_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))-61.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_4 (d g s sub) monitor_esd_nld45_10hv ruleNum=4 enable=soa rule="esd_nld45_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))) > 61.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.7
anld45_10hv_esdchk_5 (d g s sub) monitor_esd_nld45_10hv ruleNum=5 enable=soa rule="esd_nld45_Vt1=58p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-58.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_6 (d g s sub) monitor_esd_nld45_10hv ruleNum=6 enable=soa rule="esd_nld45_Vt1>58p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 58.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=58.1
anld45_10hv_esdchk_7 (d g s sub) monitor_esd_nld45_10hv ruleNum=7 enable=soa rule="esd_nld45_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(3.5*(V(g)-V(s)-1.5))-58.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_8 (d g s sub) monitor_esd_nld45_10hv ruleNum=8 enable=soa rule="esd_nld45_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(3.5*(V(g)-V(s)-1.5))) > 58.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=58.1
anld45_10hv_esdchk_9 (d g s sub) monitor_esd_nld45_10hv ruleNum=9 enable=soa rule="esd_nld45_Vt1=54p6_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-54.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_10 (d g s sub) monitor_esd_nld45_10hv ruleNum=10 enable=soa rule="esd_nld45_Vt1>54p6_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 54.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=54.6
anld45_10hv_esdchk_11 (d g s sub) monitor_esd_nld45_10hv ruleNum=11 enable=soa rule="esd_nld45_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(4.9*(V(g)-V(s)-2.5))-54.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_12 (d g s sub) monitor_esd_nld45_10hv ruleNum=12 enable=soa rule="esd_nld45_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(4.9*(V(g)-V(s)-2.5))) > 54.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=54.6
anld45_10hv_esdchk_13 (d g s sub) monitor_esd_nld45_10hv ruleNum=13 enable=soa rule="esd_nld45_Vt1=49p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_14 (d g s sub) monitor_esd_nld45_10hv ruleNum=14 enable=soa rule="esd_nld45_Vt1>49p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.7
anld45_10hv_esdchk_15 (d g s sub) monitor_esd_nld45_10hv ruleNum=15 enable=soa rule="esd_nld45_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(5.1*(V(g)-V(s)-3.5))-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_16 (d g s sub) monitor_esd_nld45_10hv ruleNum=16 enable=soa rule="esd_nld45_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(5.1*(V(g)-V(s)-3.5))) > 49.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.7
anld45_10hv_esdchk_17 (d g s sub) monitor_esd_nld45_10hv ruleNum=17 enable=soa rule="esd_nld45_Vt1=44p6_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_18 (d g s sub) monitor_esd_nld45_10hv ruleNum=18 enable=soa rule="esd_nld45_Vt1>44p6_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 44.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=44.6
anld45_10hv_esdchk_19 (d g s sub) monitor_esd_nld45_10hv ruleNum=19 enable=soa rule="esd_nld45_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(10.0*(V(g)-V(s)-4.5))-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_20 (d g s sub) monitor_esd_nld45_10hv ruleNum=20 enable=soa rule="esd_nld45_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(10.0*(V(g)-V(s)-4.5))) > 44.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=44.6
anld45_10hv_esdchk_21 (d g s sub) monitor_esd_nld45_10hv ruleNum=21 enable=soa rule="esd_nld45_Vt1=34p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-34.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_22 (d g s sub) monitor_esd_nld45_10hv ruleNum=22 enable=soa rule="esd_nld45_Vt1>34p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 34.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=34.6
anld45_10hv_esdchk_23 (d g s sub) monitor_esd_nld45_10hv ruleNum=23 enable=soa rule="esd_nld45_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(4.2*(V(g)-V(s)-5.5))-34.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_24 (d g s sub) monitor_esd_nld45_10hv ruleNum=24 enable=soa rule="esd_nld45_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(4.2*(V(g)-V(s)-5.5))) > 34.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=34.6
anld45_10hv_esdchk_25 (d g s sub) monitor_esd_nld45_10hv ruleNum=25 enable=soa rule="esd_nld45_Vt1=32p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-32.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_26 (d g s sub) monitor_esd_nld45_10hv ruleNum=26 enable=soa rule="esd_nld45_Vt1>32p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 32.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=32.5
anld45_10hv_esdchk_27 (d g s sub) monitor_esd_nld45_10hv ruleNum=27 enable=soa rule="esd_nld45_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))-32.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_10hv_esdchk_28 (d g s sub) monitor_esd_nld45_10hv ruleNum=28 enable=soa rule="esd_nld45_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))) > 32.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=32.5
anld45_10hv_esdchk_29 (d g s sub) monitor_esd_nld45_10hv ruleNum=29 enable=soa rule="esd_nld45_Vt1=25p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-25.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_30 (d g s sub) monitor_esd_nld45_10hv ruleNum=30 enable=soa rule="esd_nld45_Vt1>25p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 25.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=25.8
anld45_10hv_esdchk_31 (d g s sub) monitor_esd_nld45_10hv ruleNum=31 enable=soa rule="esd_nld45_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-25.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nld45_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 25.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=25.8
anld45_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_nld45_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_nld45_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 61.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=61.7
anld45_10hv_esdchk_35 (d sub) monitor2t enable=soa rule="esd_nld45_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_10hv_esdchk_36 (sub s) monitor2t enable=soa rule="esd_nld45_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_10hv_esdchk_37 (s d) monitor2t enable=soa rule="esd_nld45_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00347
+ hcia1           = 0.773*presto_idRatio
+ hcia2           = 1.27*presto_idRatio
+ hcic1           = 3.71E5
+ hcilambdael0    = 8.06e-7
+ hcialpha1       = 1.35e-8
+ hcibeta1        = 1.77
+ offa1           = 100*presto_idRatio             //Off state HCI part
+ offn1           = 0.235
+ offfstattau1    = 0.068
+ offalpha1       = 8.43E+9
+ offbeta1legacy  = 0.167
+ offea1          = 0.45
+ hvgsfstat       = 0.0133         // High Vgs HCI part
+ hvgsa           = 283*presto_vthRatio
+ hvgsn           = 0.389
+ hvgsalpha       = 2.91E11
+ hvgsbeta        = 3.44E-8
+ hvgsgamma       = 17.773
+ hvgsdelta       = 5.6824
+ hvgsepsilon     = 0
+ hvgsea          = 1.4629
+ hvgsrth         = 0.019243
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 24300 
+ a0_b0_b0_a1_em1 = -9.46 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -51400 
+ a0_b0_a1_a1_em1 = 51.3 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -3760 
+ a0_b0_a2_a1_em1 = 16.1 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -9450 
+ a0_b0_a3_a1_em1 = 3.73 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.447 
+ a0_b0_p1_a1_em1 = -0.000712 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 0.531 
+ a0_b0_p2_a1_em1 = -8.20E-07 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 2.3 
+ a0_b0_p3_a1_em1 = -0.00126 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 2.95 
+ a0_b0_p4_a1_em1 = -7.95E-05 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 11300 
+ a0_b0_b0_a2_em1 = -2.26 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -12900 
+ a0_b0_a1_a2_em1 = 10.6 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 2300 
+ a0_b0_a2_a2_em1 = -4.02 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -5210 
+ a0_b0_a3_a2_em1 = 2.19 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.709 
+ a0_b0_p1_a2_em1 = -0.000898 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 0.416 
+ a0_b0_p2_a2_em1 = 0.000245 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 0.788 
+ a0_b0_p3_a2_em1 = 0.00232 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3.69 
+ a0_b0_p4_a2_em1 = 0.000118 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 4030 
+ a0_b0_b0_a3_em1 = 0.967 
+ b0_a0_b0_a3_em1 = 23.9 
+ a0_a0_b0_a3_em1 = -0.0269 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 1610 
+ a0_b0_a1_a3_em1 = 21.2 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 1220 
+ a0_b0_a2_a3_em1 = -8.18 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -6040 
+ a0_b0_a3_a3_em1 = 5.4 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 0.778 
+ a0_b0_p2_a3_em1 = -0.00101 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.36 
+ a0_b0_p3_a3_em1 = -0.00189 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 2 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 4010 
+ a0_b0_b0_a4_em1 = 0.0686 
+ b0_a0_b0_a4_em1 = -5.13 
+ a0_a0_b0_a4_em1 = 0.0232 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -6620 
+ a0_b0_a1_a4_em1 = 28.3 
+ b0_a0_a1_a4_em1 = 0 
+ a0_a0_a1_a4_em1 = 0 
+ b0_b0_a2_a4_em1 = -17600 
+ a0_b0_a2_a4_em1 = 22 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0 
+ b0_b0_a3_a4_em1 = 1500 
+ a0_b0_a3_a4_em1 = -2.56 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0 
+ a0_b0_p1_a4_em1 = 0 
+ b0_a0_p1_a4_em1 = 0 
+ a0_a0_p1_a4_em1 = 0 
+ b0_b0_p2_a4_em1 = 2.15 
+ a0_b0_p2_a4_em1 = -0.00289 
+ b0_a0_p2_a4_em1 = 0 
+ a0_a0_p2_a4_em1 = 0 
+ b0_b0_p3_a4_em1 = 1.54 
+ a0_b0_p3_a4_em1 = 0.000389 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 4.09 
+ a0_b0_p4_a4_em1 = -0.000378 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -2.91 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.858 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -1.96 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -7.53 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -9.72 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.45 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.25 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 2.93 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 9.25 
+ a0_b0_b0_p2_em1 = 0.0062 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0 
+ a0_b0_a1_p2_em1 = 0 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0 
+ a0_b0_a2_p2_em1 = 0 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 0 
+ a0_b0_a3_p2_em1 = 0 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 0 
+ a0_b0_p2_p2_em1 = 0 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 0 
+ a0_b0_p3_p2_em1 = 0 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 0 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 22 
+ a0_b0_b0_p3_em1 = 0 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0 
+ a0_b0_a1_p3_em1 = 0 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0 
+ a0_b0_a2_p3_em1 = 0 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0 
+ a0_b0_a3_p3_em1 = 0 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0 
+ a0_b0_p1_p3_em1 = 0 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 0 
+ a0_b0_p2_p3_em1 = 0 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 0 
+ a0_b0_p3_p3_em1 = 0 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 0 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 40.5 
+ a0_b0_b0_p4_em1 = -0.0089 
+ b0_a0_b0_p4_em1 = -0.0405 
+ a0_a0_b0_p4_em1 = 3.28E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 3.49 
+ a0_b0_a1_p4_em1 = -0.00724 
+ b0_a0_a1_p4_em1 = 0 
+ a0_a0_a1_p4_em1 = 0 
+ b0_b0_a2_p4_em1 = -1.75 
+ a0_b0_a2_p4_em1 = 0.00419 
+ b0_a0_a2_p4_em1 = 0 
+ a0_a0_a2_p4_em1 = 0 
+ b0_b0_a3_p4_em1 = 1.39 
+ a0_b0_a3_p4_em1 = 0.000782 
+ b0_a0_a3_p4_em1 = 0 
+ a0_a0_a3_p4_em1 = 0 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0.1 
+ a0_b0_p1_p4_em1 = 0 
+ b0_a0_p1_p4_em1 = 0 
+ a0_a0_p1_p4_em1 = 0 
+ b0_b0_p2_p4_em1 = 1.47 
+ a0_b0_p2_p4_em1 = -0.000691 
+ b0_a0_p2_p4_em1 = 0 
+ a0_a0_p2_p4_em1 = 0 
+ b0_b0_p3_p4_em1 = 6.09 
+ a0_b0_p3_p4_em1 = -0.0116 
+ b0_a0_p3_p4_em1 = 0 
+ a0_a0_p3_p4_em1 = 0 
+ b0_b0_p4_p4_em1 = 4 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0 
}
endsection nld45_10hv_dfrt

section nld45b_10hv_dfrt
include "soachecks_top.scs" section=nld45b_10hv_soa
if (enable_relimo == 1) {
anld45_10hv_hci3 (d g s sub) relimo_aging_hci_nld45b w=w*ng relimo_ratio20_a=1.075 relimo_ratio20_b=0 relimo_ratio21_a=0.58 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_10hv relimo_c=relimo_c_1_hci_nld45_10hv relimo_condvd=relimo_condvd_hci_nld45_10hv relimo_condvg=relimo_condvg_hci_nld45_10hv relimo_intercept=relimo_intercept_1_hci_nld45_10hv relimo_m=relimo_m_1_hci_nld45_10hv relimo_n=relimo_n_1_hci_nld45_10hv relimo_r=relimo_r_1_hci_nld45_10hv relimo_e=relimo_e_hci_nld45_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_10hv relimo_vth=relimo_vth_hci_nld45_10hv
anld45_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld45b_10hv_esdchk_1 (d g s sub) monitor_esd_nld45b_10hv ruleNum=1 enable=soa rule="esd_nld45b_Vt1=61p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_2 (d g s sub) monitor_esd_nld45b_10hv ruleNum=2 enable=soa rule="esd_nld45b_Vt1>61p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.7
anld45b_10hv_esdchk_3 (d g s sub) monitor_esd_nld45b_10hv ruleNum=3 enable=soa rule="esd_nld45b_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))-61.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_4 (d g s sub) monitor_esd_nld45b_10hv ruleNum=4 enable=soa rule="esd_nld45b_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))) > 61.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.7
anld45b_10hv_esdchk_5 (d g s sub) monitor_esd_nld45b_10hv ruleNum=5 enable=soa rule="esd_nld45b_Vt1=58p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-58.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_6 (d g s sub) monitor_esd_nld45b_10hv ruleNum=6 enable=soa rule="esd_nld45b_Vt1>58p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 58.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=58.1
anld45b_10hv_esdchk_7 (d g s sub) monitor_esd_nld45b_10hv ruleNum=7 enable=soa rule="esd_nld45b_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(3.5*(V(g)-V(s)-1.5))-58.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_8 (d g s sub) monitor_esd_nld45b_10hv ruleNum=8 enable=soa rule="esd_nld45b_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(3.5*(V(g)-V(s)-1.5))) > 58.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=58.1
anld45b_10hv_esdchk_9 (d g s sub) monitor_esd_nld45b_10hv ruleNum=9 enable=soa rule="esd_nld45b_Vt1=54p6_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-54.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_10 (d g s sub) monitor_esd_nld45b_10hv ruleNum=10 enable=soa rule="esd_nld45b_Vt1>54p6_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 54.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=54.6
anld45b_10hv_esdchk_11 (d g s sub) monitor_esd_nld45b_10hv ruleNum=11 enable=soa rule="esd_nld45b_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(4.9*(V(g)-V(s)-2.5))-54.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_12 (d g s sub) monitor_esd_nld45b_10hv ruleNum=12 enable=soa rule="esd_nld45b_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(4.9*(V(g)-V(s)-2.5))) > 54.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=54.6
anld45b_10hv_esdchk_13 (d g s sub) monitor_esd_nld45b_10hv ruleNum=13 enable=soa rule="esd_nld45b_Vt1=49p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_14 (d g s sub) monitor_esd_nld45b_10hv ruleNum=14 enable=soa rule="esd_nld45b_Vt1>49p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.7
anld45b_10hv_esdchk_15 (d g s sub) monitor_esd_nld45b_10hv ruleNum=15 enable=soa rule="esd_nld45b_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(5.1*(V(g)-V(s)-3.5))-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_16 (d g s sub) monitor_esd_nld45b_10hv ruleNum=16 enable=soa rule="esd_nld45b_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(5.1*(V(g)-V(s)-3.5))) > 49.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.7
anld45b_10hv_esdchk_17 (d g s sub) monitor_esd_nld45b_10hv ruleNum=17 enable=soa rule="esd_nld45b_Vt1=44p6_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_18 (d g s sub) monitor_esd_nld45b_10hv ruleNum=18 enable=soa rule="esd_nld45b_Vt1>44p6_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 44.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=44.6
anld45b_10hv_esdchk_19 (d g s sub) monitor_esd_nld45b_10hv ruleNum=19 enable=soa rule="esd_nld45b_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(10.0*(V(g)-V(s)-4.5))-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_20 (d g s sub) monitor_esd_nld45b_10hv ruleNum=20 enable=soa rule="esd_nld45b_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(10.0*(V(g)-V(s)-4.5))) > 44.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=44.6
anld45b_10hv_esdchk_21 (d g s sub) monitor_esd_nld45b_10hv ruleNum=21 enable=soa rule="esd_nld45b_Vt1=34p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-34.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_22 (d g s sub) monitor_esd_nld45b_10hv ruleNum=22 enable=soa rule="esd_nld45b_Vt1>34p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 34.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=34.6
anld45b_10hv_esdchk_23 (d g s sub) monitor_esd_nld45b_10hv ruleNum=23 enable=soa rule="esd_nld45b_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(4.2*(V(g)-V(s)-5.5))-34.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_24 (d g s sub) monitor_esd_nld45b_10hv ruleNum=24 enable=soa rule="esd_nld45b_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(4.2*(V(g)-V(s)-5.5))) > 34.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=34.6
anld45b_10hv_esdchk_25 (d g s sub) monitor_esd_nld45b_10hv ruleNum=25 enable=soa rule="esd_nld45b_Vt1=32p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-32.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_26 (d g s sub) monitor_esd_nld45b_10hv ruleNum=26 enable=soa rule="esd_nld45b_Vt1>32p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 32.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=32.5
anld45b_10hv_esdchk_27 (d g s sub) monitor_esd_nld45b_10hv ruleNum=27 enable=soa rule="esd_nld45b_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))-32.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_10hv_esdchk_28 (d g s sub) monitor_esd_nld45b_10hv ruleNum=28 enable=soa rule="esd_nld45b_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))) > 32.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=32.5
anld45b_10hv_esdchk_29 (d g s sub) monitor_esd_nld45b_10hv ruleNum=29 enable=soa rule="esd_nld45b_Vt1=25p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-25.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_30 (d g s sub) monitor_esd_nld45b_10hv ruleNum=30 enable=soa rule="esd_nld45b_Vt1>25p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 25.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=25.8
anld45b_10hv_esdchk_31 (d g s sub) monitor_esd_nld45b_10hv ruleNum=31 enable=soa rule="esd_nld45b_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-25.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nld45b_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 25.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=25.8
anld45b_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_nld45b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45b_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_nld45b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 61.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=61.7
anld45b_10hv_esdchk_35 (d sub) monitor2t enable=soa rule="esd_nld45b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_10hv_esdchk_36 (sub s) monitor2t enable=soa rule="esd_nld45b_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_10hv_esdchk_37 (s d) monitor2t enable=soa rule="esd_nld45b_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00347
+ hcia1           = 0.773*presto_idRatio
+ hcia2           = 1.27*presto_idRatio
+ hcic1           = 3.71E5
+ hcilambdael0    = 8.06e-7
+ hcialpha1       = 1.35e-8
+ hcibeta1        = 1.77
+ offa1           = 100*presto_idRatio             //Off state HCI part
+ offn1           = 0.235
+ offfstattau1    = 0.068
+ offalpha1       = 8.43E+9
+ offbeta1legacy  = 0.167
+ offea1          = 0.45
+ hvgsfstat       = 0.0133         // High Vgs HCI part
+ hvgsa           = 283*presto_vthRatio
+ hvgsn           = 0.389
+ hvgsalpha       = 2.91E11
+ hvgsbeta        = 3.44E-8
+ hvgsgamma       = 17.773
+ hvgsdelta       = 5.6824
+ hvgsepsilon     = 0
+ hvgsea          = 1.4629
+ hvgsrth         = 0.019243
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 24300 
+ a0_b0_b0_a1_em1 = -9.46 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -51400 
+ a0_b0_a1_a1_em1 = 51.3 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -3760 
+ a0_b0_a2_a1_em1 = 16.1 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -9450 
+ a0_b0_a3_a1_em1 = 3.73 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.447 
+ a0_b0_p1_a1_em1 = -0.000712 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 0.531 
+ a0_b0_p2_a1_em1 = -8.20E-07 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 2.3 
+ a0_b0_p3_a1_em1 = -0.00126 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 2.95 
+ a0_b0_p4_a1_em1 = -7.95E-05 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 11300 
+ a0_b0_b0_a2_em1 = -2.26 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -12900 
+ a0_b0_a1_a2_em1 = 10.6 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 2300 
+ a0_b0_a2_a2_em1 = -4.02 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -5210 
+ a0_b0_a3_a2_em1 = 2.19 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.709 
+ a0_b0_p1_a2_em1 = -0.000898 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 0.416 
+ a0_b0_p2_a2_em1 = 0.000245 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 0.788 
+ a0_b0_p3_a2_em1 = 0.00232 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3.69 
+ a0_b0_p4_a2_em1 = 0.000118 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 4030 
+ a0_b0_b0_a3_em1 = 0.967 
+ b0_a0_b0_a3_em1 = 23.9 
+ a0_a0_b0_a3_em1 = -0.0269 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 1610 
+ a0_b0_a1_a3_em1 = 21.2 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 1220 
+ a0_b0_a2_a3_em1 = -8.18 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -6040 
+ a0_b0_a3_a3_em1 = 5.4 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 0.778 
+ a0_b0_p2_a3_em1 = -0.00101 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.36 
+ a0_b0_p3_a3_em1 = -0.00189 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 2 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 4010 
+ a0_b0_b0_a4_em1 = 0.0686 
+ b0_a0_b0_a4_em1 = -5.13 
+ a0_a0_b0_a4_em1 = 0.0232 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -6620 
+ a0_b0_a1_a4_em1 = 28.3 
+ b0_a0_a1_a4_em1 = 0 
+ a0_a0_a1_a4_em1 = 0 
+ b0_b0_a2_a4_em1 = -17600 
+ a0_b0_a2_a4_em1 = 22 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0 
+ b0_b0_a3_a4_em1 = 1500 
+ a0_b0_a3_a4_em1 = -2.56 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0 
+ a0_b0_p1_a4_em1 = 0 
+ b0_a0_p1_a4_em1 = 0 
+ a0_a0_p1_a4_em1 = 0 
+ b0_b0_p2_a4_em1 = 2.15 
+ a0_b0_p2_a4_em1 = -0.00289 
+ b0_a0_p2_a4_em1 = 0 
+ a0_a0_p2_a4_em1 = 0 
+ b0_b0_p3_a4_em1 = 1.54 
+ a0_b0_p3_a4_em1 = 0.000389 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 4.09 
+ a0_b0_p4_a4_em1 = -0.000378 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -2.91 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.858 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -1.96 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -7.53 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -9.72 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.45 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.25 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 2.93 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 9.25 
+ a0_b0_b0_p2_em1 = 0.0062 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0 
+ a0_b0_a1_p2_em1 = 0 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0 
+ a0_b0_a2_p2_em1 = 0 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 0 
+ a0_b0_a3_p2_em1 = 0 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 0 
+ a0_b0_p2_p2_em1 = 0 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 0 
+ a0_b0_p3_p2_em1 = 0 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 0 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 22 
+ a0_b0_b0_p3_em1 = 0 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0 
+ a0_b0_a1_p3_em1 = 0 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0 
+ a0_b0_a2_p3_em1 = 0 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0 
+ a0_b0_a3_p3_em1 = 0 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0 
+ a0_b0_p1_p3_em1 = 0 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 0 
+ a0_b0_p2_p3_em1 = 0 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 0 
+ a0_b0_p3_p3_em1 = 0 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 0 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 40.5 
+ a0_b0_b0_p4_em1 = -0.0089 
+ b0_a0_b0_p4_em1 = -0.0405 
+ a0_a0_b0_p4_em1 = 3.28E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 3.49 
+ a0_b0_a1_p4_em1 = -0.00724 
+ b0_a0_a1_p4_em1 = 0 
+ a0_a0_a1_p4_em1 = 0 
+ b0_b0_a2_p4_em1 = -1.75 
+ a0_b0_a2_p4_em1 = 0.00419 
+ b0_a0_a2_p4_em1 = 0 
+ a0_a0_a2_p4_em1 = 0 
+ b0_b0_a3_p4_em1 = 1.39 
+ a0_b0_a3_p4_em1 = 0.000782 
+ b0_a0_a3_p4_em1 = 0 
+ a0_a0_a3_p4_em1 = 0 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0.1 
+ a0_b0_p1_p4_em1 = 0 
+ b0_a0_p1_p4_em1 = 0 
+ a0_a0_p1_p4_em1 = 0 
+ b0_b0_p2_p4_em1 = 1.47 
+ a0_b0_p2_p4_em1 = -0.000691 
+ b0_a0_p2_p4_em1 = 0 
+ a0_a0_p2_p4_em1 = 0 
+ b0_b0_p3_p4_em1 = 6.09 
+ a0_b0_p3_p4_em1 = -0.0116 
+ b0_a0_p3_p4_em1 = 0 
+ a0_a0_p3_p4_em1 = 0 
+ b0_b0_p4_p4_em1 = 4 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0 
}
endsection nld45b_10hv_dfrt

section nld45_he_10hv_dfrt
include "soachecks_top.scs" section=nld45b_he_10hv_soa
if (enable_relimo == 1) {
anld45_he_10hv_hci3 (d g s sub) relimo_aging_hci_nld45_he w=w*ng relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1.6 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_he_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_he_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_he_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_he_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_he_10hv relimo_c=relimo_c_1_hci_nld45_he_10hv relimo_condvd=relimo_condvd_hci_nld45_he_10hv relimo_condvg=relimo_condvg_hci_nld45_he_10hv relimo_intercept=relimo_intercept_1_hci_nld45_he_10hv relimo_m=relimo_m_1_hci_nld45_he_10hv relimo_n=relimo_n_1_hci_nld45_he_10hv relimo_r=relimo_r_1_hci_nld45_he_10hv relimo_e=relimo_e_hci_nld45_he_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_he_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_he_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_he_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_he_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_he_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_he_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_he_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_he_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_he_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_he_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_he_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_he_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_he_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_he_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_he_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_he_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_he_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_he_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_he_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_he_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_he_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_he_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_he_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_he_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_he_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_he_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_he_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_he_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_he_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_he_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_he_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_he_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_he_10hv relimo_vth=relimo_vth_hci_nld45_he_10hv
anld45_he_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_he_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld45_he_10hv_esdchk_1 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=1 enable=soa rule="esd_nld45_he_Vt1=63p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_2 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=2 enable=soa rule="esd_nld45_he_Vt1>63p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.6
anld45_he_10hv_esdchk_3 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=3 enable=soa rule="esd_nld45_he_=Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_he_10hv_esdchk_4 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=4 enable=soa rule="esd_nld45_he_>Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 63.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.6
anld45_he_10hv_esdchk_5 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=5 enable=soa rule="esd_nld45_he_Vt1=63p6_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_6 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=6 enable=soa rule="esd_nld45_he_Vt1>63p6_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.6
anld45_he_10hv_esdchk_7 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=7 enable=soa rule="esd_nld45_he_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_he_10hv_esdchk_8 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=8 enable=soa rule="esd_nld45_he_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))) > 63.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.6
anld45_he_10hv_esdchk_9 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=9 enable=soa rule="esd_nld45_he_Vt1=63p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_10 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=10 enable=soa rule="esd_nld45_he_Vt1>63p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.0
anld45_he_10hv_esdchk_11 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=11 enable=soa rule="esd_nld45_he_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-4.5))-63.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_he_10hv_esdchk_12 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=12 enable=soa rule="esd_nld45_he_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-4.5))) > 63.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.0
anld45_he_10hv_esdchk_13 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=13 enable=soa rule="esd_nld45_he_Vt1=62p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_14 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=14 enable=soa rule="esd_nld45_he_Vt1>62p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 62.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.0
anld45_he_10hv_esdchk_15 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=15 enable=soa rule="esd_nld45_he_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-5.5))-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_he_10hv_esdchk_16 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=16 enable=soa rule="esd_nld45_he_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-5.5))) > 62.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.0
anld45_he_10hv_esdchk_17 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=17 enable=soa rule="esd_nld45_he_Vt1=61p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_18 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=18 enable=soa rule="esd_nld45_he_Vt1>61p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.5
anld45_he_10hv_esdchk_19 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=19 enable=soa rule="esd_nld45_he_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(1.1*(V(g)-V(s)-6.0))-61.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_he_10hv_esdchk_20 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=20 enable=soa rule="esd_nld45_he_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(1.1*(V(g)-V(s)-6.0))) > 61.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.5
anld45_he_10hv_esdchk_21 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=21 enable=soa rule="esd_nld45_he_Vt1=60p4_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-60.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_22 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=22 enable=soa rule="esd_nld45_he_Vt1>60p4_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 60.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.4
anld45_he_10hv_esdchk_23 (d g s sub) monitor_esd_nld45_he_10hv ruleNum=23 enable=soa rule="esd_nld45_he_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-60.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_he_10hv_esdchk_24 (g s d s) monitor4t enable=soa rule="esd_nld45_he_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 60.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.4
anld45_he_10hv_esdchk_25 (g s) monitor2t enable=soa rule="esd_nld45_he_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45_he_10hv_esdchk_26 (g d) monitor2t enable=soa rule="esd_nld45_he_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 63.6 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=63.6
anld45_he_10hv_esdchk_27 (d sub) monitor2t enable=soa rule="esd_nld45_he_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_he_10hv_esdchk_28 (sub s) monitor2t enable=soa rule="esd_nld45_he_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_he_10hv_esdchk_29 (s d) monitor2t enable=soa rule="esd_nld45_he_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00443
+ hcia1           = 0.637*presto_idRatio
+ hcia2           = 1.16*presto_idRatio
+ hcic1           = 1.21E5
+ hcilambdael0    = 2.10e-7
+ hcialpha1       = 7.01e-15
+ hcibeta1        = 1.43
+ offa1           = 100*presto_idRatio             //Off state HCI part
+ offn1           = 0.268
+ offfstattau1    = 0.011
+ offalpha1       = 1.27E+10
+ offbeta1legacy  = 0.18
+ offea1          = 0.35
+ hvgsfstat       = 0.0223         // High Vgs HCI part
+ hvgsa           = 330*presto_vthRatio
+ hvgsn           = 0.501
+ hvgsalpha       = 1.41E24
+ hvgsbeta        = 2.76E-14
+ hvgsgamma       = 17.4
+ hvgsdelta       = 9.53
+ hvgsepsilon     = 0
+ hvgsea          = 0.61
+ hvgsrth         = 2.25E-14
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 44100 
+ a0_b0_b0_a1_em1 = -8.26 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -24200 
+ a0_b0_a1_a1_em1 = 12.7 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 44600 
+ a0_b0_a2_a1_em1 = -51.1 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 15600 
+ a0_b0_a3_a1_em1 = -114 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 1.83 
+ a0_b0_p1_a1_em1 = -0.00143 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 3.15 
+ a0_b0_p2_a1_em1 = -0.00119 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.41 
+ a0_b0_p3_a1_em1 = -0.000995 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.5 
+ a0_b0_p4_a1_em1 = -0.00265 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 12100 
+ a0_b0_b0_a2_em1 = 1.94 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 1300 
+ a0_b0_a1_a2_em1 = -1.82 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 1020 
+ a0_b0_a2_a2_em1 = 0.177 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -5410 
+ a0_b0_a3_a2_em1 = 0.922 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -0.715 
+ a0_b0_p1_a2_em1 = -0.000869 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = -0.512 
+ a0_b0_p2_a2_em1 = 0.00359 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 1.15 
+ a0_b0_p3_a2_em1 = -3.68E-05 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 6230 
+ a0_b0_b0_a3_em1 = 2.16 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 1640 
+ a0_b0_a1_a3_em1 = -13 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 1.21 
+ a0_b0_a2_a3_em1 = 0.996 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -1530 
+ a0_b0_a3_a3_em1 = 2.84 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 1.35 
+ a0_b0_p1_a3_em1 = 0.000208 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 2.56 
+ a0_b0_p2_a3_em1 = -0.000218 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = -0.81 
+ a0_b0_p3_a3_em1 = 0.00252 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 2.56 
+ a0_b0_p4_a3_em1 = 0.00359 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 2780 
+ a0_b0_b0_a4_em1 = 2.16 
+ b0_a0_b0_a4_em1 = 0.277 
+ a0_a0_b0_a4_em1 = 0.0148 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 25700 
+ a0_b0_a1_a4_em1 = -30 
+ b0_a0_a1_a4_em1 = -0.177 
+ a0_a0_a1_a4_em1 = -0.024 
+ b0_b0_a2_a4_em1 = -346 
+ a0_b0_a2_a4_em1 = -10.4 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0.0601 
+ b0_b0_a3_a4_em1 = -7.79 
+ a0_b0_a3_a4_em1 = -0.00113 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 2.48 
+ a0_b0_p1_a4_em1 = -0.000237 
+ b0_a0_p1_a4_em1 = 0.000614 
+ a0_a0_p1_a4_em1 = -2.39E-06 
+ b0_b0_p2_a4_em1 = 4.04 
+ a0_b0_p2_a4_em1 = 0.000126 
+ b0_a0_p2_a4_em1 = -0.00024 
+ a0_a0_p2_a4_em1 = 1.52E-06 
+ b0_b0_p3_a4_em1 = -39.8 
+ a0_b0_p3_a4_em1 = 0.197 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 5.65 
+ a0_b0_p4_a4_em1 = -0.000628 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -3.5 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 1.16 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 0 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 12.2 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -1 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.6 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.89 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 5.12 
+ a0_b0_b0_p2_em1 = 0.00286 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0.798 
+ a0_b0_a1_p2_em1 = -0.000226 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 4.48 
+ a0_b0_a2_p2_em1 = 0.00529 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 37.1 
+ a0_b0_a3_p2_em1 = -0.0747 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.79 
+ a0_b0_p2_p2_em1 = -0.00123 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.51 
+ a0_b0_p3_p2_em1 = -0.000964 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 2.38 
+ a0_b0_p4_p2_em1 = -0.000171 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 17.1 
+ a0_b0_b0_p3_em1 = -0.00513 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0.443 
+ a0_b0_a1_p3_em1 = -0.000315 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 14.3 
+ a0_b0_a2_p3_em1 = -0.0142 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -9.19 
+ a0_b0_a3_p3_em1 = 0.0304 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 4.05 
+ a0_b0_p1_p3_em1 = -0.0118 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 1.18 
+ a0_b0_p2_p3_em1 = 0.00021 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 1.59 
+ a0_b0_p3_p3_em1 = -9.01E-05 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 2 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 32 
+ a0_b0_b0_p4_em1 = -0.0084 
+ b0_a0_b0_p4_em1 = 0.0545 
+ a0_a0_b0_p4_em1 = -7.63E-06 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 1.66 
+ a0_b0_a1_p4_em1 = -0.00388 
+ b0_a0_a1_p4_em1 = -0.0109 
+ a0_a0_a1_p4_em1 = 2.14E-05 
+ b0_b0_a2_p4_em1 = -25.6 
+ a0_b0_a2_p4_em1 = 0.0363 
+ b0_a0_a2_p4_em1 = 0.0775 
+ a0_a0_a2_p4_em1 = -0.000109 
+ b0_b0_a3_p4_em1 = 3.55 
+ a0_b0_a3_p4_em1 = 0.111 
+ b0_a0_a3_p4_em1 = 0.224 
+ a0_a0_a3_p4_em1 = -0.000755 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = -0.069 
+ a0_b0_p1_p4_em1 = -0.00169 
+ b0_a0_p1_p4_em1 = -0.0915 
+ a0_a0_p1_p4_em1 = 8.09E-05 
+ b0_b0_p2_p4_em1 = 2.55 
+ a0_b0_p2_p4_em1 = -0.000145 
+ b0_a0_p2_p4_em1 = -0.0127 
+ a0_a0_p2_p4_em1 = 2.64E-05 
+ b0_b0_p3_p4_em1 = 2.74 
+ a0_b0_p3_p4_em1 = -0.000499 
+ b0_a0_p3_p4_em1 = -6.82E-06 
+ a0_a0_p3_p4_em1 = -1.23E-06 
+ b0_b0_p4_p4_em1 = 3.25 
+ a0_b0_p4_p4_em1 = -0.00084 
+ b0_a0_p4_p4_em1 = 0.000639 
+ a0_a0_p4_p4_em1 = -9.65E-07 
}
endsection nld45_he_10hv_dfrt

section nld45b_he_10hv_dfrt
include "soachecks_top.scs" section=nld45b_he_10hv_soa
if (enable_relimo == 1) {
anld45_he_10hv_hci3 (d g s sub) relimo_aging_hci_nld45b_he w=w*ng relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1.6 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_he_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_he_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_he_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_he_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_he_10hv relimo_c=relimo_c_1_hci_nld45_he_10hv relimo_condvd=relimo_condvd_hci_nld45_he_10hv relimo_condvg=relimo_condvg_hci_nld45_he_10hv relimo_intercept=relimo_intercept_1_hci_nld45_he_10hv relimo_m=relimo_m_1_hci_nld45_he_10hv relimo_n=relimo_n_1_hci_nld45_he_10hv relimo_r=relimo_r_1_hci_nld45_he_10hv relimo_e=relimo_e_hci_nld45_he_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_he_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_he_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_he_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_he_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_he_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_he_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_he_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_he_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_he_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_he_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_he_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_he_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_he_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_he_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_he_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_he_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_he_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_he_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_he_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_he_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_he_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_he_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_he_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_he_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_he_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_he_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_he_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_he_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_he_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_he_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_he_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_he_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_he_10hv relimo_vth=relimo_vth_hci_nld45_he_10hv
anld45_he_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_he_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld45b_he_10hv_esdchk_1 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=1 enable=soa rule="esd_nld45b_he_Vt1=63p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_2 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=2 enable=soa rule="esd_nld45b_he_Vt1>63p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.6
anld45b_he_10hv_esdchk_3 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=3 enable=soa rule="esd_nld45b_he_=Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_he_10hv_esdchk_4 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=4 enable=soa rule="esd_nld45b_he_>Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 63.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.6
anld45b_he_10hv_esdchk_5 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=5 enable=soa rule="esd_nld45b_he_Vt1=63p6_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_6 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=6 enable=soa rule="esd_nld45b_he_Vt1>63p6_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.6
anld45b_he_10hv_esdchk_7 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=7 enable=soa rule="esd_nld45b_he_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))-63.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_he_10hv_esdchk_8 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=8 enable=soa rule="esd_nld45b_he_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))) > 63.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.6
anld45b_he_10hv_esdchk_9 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=9 enable=soa rule="esd_nld45b_he_Vt1=63p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_10 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=10 enable=soa rule="esd_nld45b_he_Vt1>63p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.0
anld45b_he_10hv_esdchk_11 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=11 enable=soa rule="esd_nld45b_he_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-4.5))-63.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_he_10hv_esdchk_12 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=12 enable=soa rule="esd_nld45b_he_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-4.5))) > 63.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.0
anld45b_he_10hv_esdchk_13 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=13 enable=soa rule="esd_nld45b_he_Vt1=62p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_14 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=14 enable=soa rule="esd_nld45b_he_Vt1>62p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 62.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.0
anld45b_he_10hv_esdchk_15 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=15 enable=soa rule="esd_nld45b_he_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-5.5))-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_he_10hv_esdchk_16 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=16 enable=soa rule="esd_nld45b_he_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-5.5))) > 62.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.0
anld45b_he_10hv_esdchk_17 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=17 enable=soa rule="esd_nld45b_he_Vt1=61p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_18 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=18 enable=soa rule="esd_nld45b_he_Vt1>61p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.5
anld45b_he_10hv_esdchk_19 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=19 enable=soa rule="esd_nld45b_he_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(1.1*(V(g)-V(s)-6.0))-61.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_he_10hv_esdchk_20 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=20 enable=soa rule="esd_nld45b_he_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(1.1*(V(g)-V(s)-6.0))) > 61.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.5
anld45b_he_10hv_esdchk_21 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=21 enable=soa rule="esd_nld45b_he_Vt1=60p4_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-60.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_22 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=22 enable=soa rule="esd_nld45b_he_Vt1>60p4_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 60.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.4
anld45b_he_10hv_esdchk_23 (d g s sub) monitor_esd_nld45b_he_10hv ruleNum=23 enable=soa rule="esd_nld45b_he_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-60.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_he_10hv_esdchk_24 (g s d s) monitor4t enable=soa rule="esd_nld45b_he_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 60.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.4
anld45b_he_10hv_esdchk_25 (g s) monitor2t enable=soa rule="esd_nld45b_he_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45b_he_10hv_esdchk_26 (g d) monitor2t enable=soa rule="esd_nld45b_he_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 63.6 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=63.6
anld45b_he_10hv_esdchk_27 (d sub) monitor2t enable=soa rule="esd_nld45b_he_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_he_10hv_esdchk_28 (sub s) monitor2t enable=soa rule="esd_nld45b_he_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_he_10hv_esdchk_29 (s d) monitor2t enable=soa rule="esd_nld45b_he_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00443
+ hcia1           = 0.637*presto_idRatio
+ hcia2           = 1.16*presto_idRatio
+ hcic1           = 1.21E5
+ hcilambdael0    = 2.10e-7
+ hcialpha1       = 7.01e-15
+ hcibeta1        = 1.43
+ offa1           = 100*presto_idRatio             //Off state HCI part
+ offn1           = 0.268
+ offfstattau1    = 0.011
+ offalpha1       = 1.27E+10
+ offbeta1legacy  = 0.18
+ offea1          = 0.35
+ hvgsfstat       = 0.0223         // High Vgs HCI part
+ hvgsa           = 330*presto_vthRatio
+ hvgsn           = 0.501
+ hvgsalpha       = 1.41E24
+ hvgsbeta        = 2.76E-14
+ hvgsgamma       = 17.4
+ hvgsdelta       = 9.53
+ hvgsepsilon     = 0
+ hvgsea          = 0.61
+ hvgsrth         = 2.25E-14
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 44100 
+ a0_b0_b0_a1_em1 = -8.26 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -24200 
+ a0_b0_a1_a1_em1 = 12.7 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 44600 
+ a0_b0_a2_a1_em1 = -51.1 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 15600 
+ a0_b0_a3_a1_em1 = -114 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 1.83 
+ a0_b0_p1_a1_em1 = -0.00143 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 3.15 
+ a0_b0_p2_a1_em1 = -0.00119 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.41 
+ a0_b0_p3_a1_em1 = -0.000995 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.5 
+ a0_b0_p4_a1_em1 = -0.00265 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 12100 
+ a0_b0_b0_a2_em1 = 1.94 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 1300 
+ a0_b0_a1_a2_em1 = -1.82 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 1020 
+ a0_b0_a2_a2_em1 = 0.177 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -5410 
+ a0_b0_a3_a2_em1 = 0.922 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -0.715 
+ a0_b0_p1_a2_em1 = -0.000869 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = -0.512 
+ a0_b0_p2_a2_em1 = 0.00359 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 1.15 
+ a0_b0_p3_a2_em1 = -3.68E-05 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 6230 
+ a0_b0_b0_a3_em1 = 2.16 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 1640 
+ a0_b0_a1_a3_em1 = -13 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 1.21 
+ a0_b0_a2_a3_em1 = 0.996 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -1530 
+ a0_b0_a3_a3_em1 = 2.84 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 1.35 
+ a0_b0_p1_a3_em1 = 0.000208 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 2.56 
+ a0_b0_p2_a3_em1 = -0.000218 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = -0.81 
+ a0_b0_p3_a3_em1 = 0.00252 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 2.56 
+ a0_b0_p4_a3_em1 = 0.00359 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 2780 
+ a0_b0_b0_a4_em1 = 2.16 
+ b0_a0_b0_a4_em1 = 0.277 
+ a0_a0_b0_a4_em1 = 0.0148 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 25700 
+ a0_b0_a1_a4_em1 = -30 
+ b0_a0_a1_a4_em1 = -0.177 
+ a0_a0_a1_a4_em1 = -0.024 
+ b0_b0_a2_a4_em1 = -346 
+ a0_b0_a2_a4_em1 = -10.4 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0.0601 
+ b0_b0_a3_a4_em1 = -7.79 
+ a0_b0_a3_a4_em1 = -0.00113 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 2.48 
+ a0_b0_p1_a4_em1 = -0.000237 
+ b0_a0_p1_a4_em1 = 0.000614 
+ a0_a0_p1_a4_em1 = -2.39E-06 
+ b0_b0_p2_a4_em1 = 4.04 
+ a0_b0_p2_a4_em1 = 0.000126 
+ b0_a0_p2_a4_em1 = -0.00024 
+ a0_a0_p2_a4_em1 = 1.52E-06 
+ b0_b0_p3_a4_em1 = -39.8 
+ a0_b0_p3_a4_em1 = 0.197 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 5.65 
+ a0_b0_p4_a4_em1 = -0.000628 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -3.5 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 1.16 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 0 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 12.2 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -1 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.6 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.89 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 5.12 
+ a0_b0_b0_p2_em1 = 0.00286 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0.798 
+ a0_b0_a1_p2_em1 = -0.000226 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 4.48 
+ a0_b0_a2_p2_em1 = 0.00529 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 37.1 
+ a0_b0_a3_p2_em1 = -0.0747 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.79 
+ a0_b0_p2_p2_em1 = -0.00123 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.51 
+ a0_b0_p3_p2_em1 = -0.000964 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 2.38 
+ a0_b0_p4_p2_em1 = -0.000171 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 17.1 
+ a0_b0_b0_p3_em1 = -0.00513 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0.443 
+ a0_b0_a1_p3_em1 = -0.000315 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 14.3 
+ a0_b0_a2_p3_em1 = -0.0142 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -9.19 
+ a0_b0_a3_p3_em1 = 0.0304 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 4.05 
+ a0_b0_p1_p3_em1 = -0.0118 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 1.18 
+ a0_b0_p2_p3_em1 = 0.00021 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 1.59 
+ a0_b0_p3_p3_em1 = -9.01E-05 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 2 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 32 
+ a0_b0_b0_p4_em1 = -0.0084 
+ b0_a0_b0_p4_em1 = 0.0545 
+ a0_a0_b0_p4_em1 = -7.63E-06 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 1.66 
+ a0_b0_a1_p4_em1 = -0.00388 
+ b0_a0_a1_p4_em1 = -0.0109 
+ a0_a0_a1_p4_em1 = 2.14E-05 
+ b0_b0_a2_p4_em1 = -25.6 
+ a0_b0_a2_p4_em1 = 0.0363 
+ b0_a0_a2_p4_em1 = 0.0775 
+ a0_a0_a2_p4_em1 = -0.000109 
+ b0_b0_a3_p4_em1 = 3.55 
+ a0_b0_a3_p4_em1 = 0.111 
+ b0_a0_a3_p4_em1 = 0.224 
+ a0_a0_a3_p4_em1 = -0.000755 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = -0.069 
+ a0_b0_p1_p4_em1 = -0.00169 
+ b0_a0_p1_p4_em1 = -0.0915 
+ a0_a0_p1_p4_em1 = 8.09E-05 
+ b0_b0_p2_p4_em1 = 2.55 
+ a0_b0_p2_p4_em1 = -0.000145 
+ b0_a0_p2_p4_em1 = -0.0127 
+ a0_a0_p2_p4_em1 = 2.64E-05 
+ b0_b0_p3_p4_em1 = 2.74 
+ a0_b0_p3_p4_em1 = -0.000499 
+ b0_a0_p3_p4_em1 = -6.82E-06 
+ a0_a0_p3_p4_em1 = -1.23E-06 
+ b0_b0_p4_p4_em1 = 3.25 
+ a0_b0_p4_p4_em1 = -0.00084 
+ b0_a0_p4_p4_em1 = 0.000639 
+ a0_a0_p4_p4_em1 = -9.65E-07 
}
endsection nld45b_he_10hv_dfrt

section pld5_10hv_dfrt
include "soachecks_top.scs" section=pld5_10hv_soa
if (enable_relimo == 1) {
apld5_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.28 relimo_ratio20_a=relimo_ratio20_a_bti_pld5_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pld5_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pld5_10hv relimo_probe_name=mpld5_10hv relimo_a_gm=relimo_a_gm_1_hci_pld5_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pld5_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pld5_10hv relimo_a_vth=relimo_a_vth_1_hci_pld5_10hv relimo_c=relimo_c_1_hci_pld5_10hv relimo_condvd=relimo_condvd_hci_pld5_10hv relimo_condvg=relimo_condvg_hci_pld5_10hv relimo_intercept=relimo_intercept_1_hci_pld5_10hv relimo_m=relimo_m_1_hci_pld5_10hv relimo_n=relimo_n_1_hci_pld5_10hv relimo_r=relimo_r_1_hci_pld5_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pld5_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pld5_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pld5_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pld5_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pld5_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pld5_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pld5_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pld5_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pld5_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pld5_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pld5_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pld5_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pld5_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pld5_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pld5_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pld5_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pld5_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pld5_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pld5_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pld5_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pld5_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pld5_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pld5_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pld5_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pld5_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pld5_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pld5_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pld5_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pld5_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pld5_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pld5_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pld5_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pld5_10hv relimo_vth=relimo_vth_hci_pld5_10hv
apld5_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld5_10hv_esdchk_1 (d g s sub) monitor_esd_pld5_10hv ruleNum=1 enable=soa rule="esd_pld5_Vt1=9p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-9.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld5_10hv_esdchk_2 (d g s sub) monitor_esd_pld5_10hv ruleNum=2 enable=soa rule="esd_pld5_Vt1>9p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 9.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.1
apld5_10hv_esdchk_3 (d g s sub) monitor_esd_pld5_10hv ruleNum=3 enable=soa rule="esd_pld5_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-9.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld5_10hv_esdchk_4 (d g s sub) monitor_esd_pld5_10hv ruleNum=4 enable=soa rule="esd_pld5_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 9.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=9.1
apld5_10hv_esdchk_5 (d g s sub) monitor_esd_pld5_10hv ruleNum=5 enable=soa rule="esd_pld5_Vt1=9p1_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-9.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld5_10hv_esdchk_6 (d g s sub) monitor_esd_pld5_10hv ruleNum=6 enable=soa rule="esd_pld5_Vt1>9p1_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 9.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.1
apld5_10hv_esdchk_7 (d g s sub) monitor_esd_pld5_10hv ruleNum=7 enable=soa rule="esd_pld5_=Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="(abs(V(s)-V(d)-9.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld5_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pld5_>Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="absV(s-to-d) > 9.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.1
apld5_10hv_esdchk_9 (g s) monitor2t enable=soa rule="esd_pld5_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld5_10hv_esdchk_10 (g d) monitor2t enable=soa rule="esd_pld5_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld5_10hv_esdchk_11 (s sub) monitor2t enable=soa rule="esd_pld5_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld5_10hv_esdchk_12 (sub d) monitor2t enable=soa rule="esd_pld5_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld5_10hv_esdchk_13 (d s) monitor2t enable=soa rule="esd_pld5_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pld5_avth
+ bvth      = presto_hci_pld5_bvth
+ ai        = presto_hci_pld5_ai
+ bi        = presto_hci_pld5_bi
+ nvth      = presto_hci_pld5_n_vth
+ ni        = presto_hci_pld5_n_i
+ gammai    = presto_hci_pld5_gammai
+ alphamve  = presto_hci_pld5_alphamve
+ fstatmve  = presto_hci_pld5_fstatmve
+ vdpowmve  = presto_hci_pld5_vdpowmve
+ vgpowmve  = presto_hci_pld5_vgpowmve
+ vdexpmve  = presto_hci_pld5_vdexpmve
+ eamve     = presto_hci_pld5_eamve
+ lexpmve   = presto_hci_pld5_lexpmve
+ lpowmve   = presto_hci_pld5_lpowmve
+ wpowmve   = presto_hci_pld5_wpowmve
+ vbsexpmve = presto_hci_pld5_vbsexpmve
+ vc1mve    = presto_hci_pld5_vc1mve
+ vc2mve    = presto_hci_pld5_vc2mve
+ alphahe   = presto_hci_pld5_alphahe
+ fstathe   = presto_hci_pld5_fstathe
+ vdpowhe   = presto_hci_pld5_vdpowhe
+ vgpowhe   = presto_hci_pld5_vgpowhe
+ vdexphe   = presto_hci_pld5_vdexphe
+ eahe      = presto_hci_pld5_eahe
+ lexphe    = presto_hci_pld5_lexphe
+ lpowhe    = presto_hci_pld5_lpowhe
+ wpowhe    = presto_hci_pld5_wpowhe
+ vbsexphe  = presto_hci_pld5_vbsexphe
+ vc1he     = presto_hci_pld5_vc1he
+ vc2he     = presto_hci_pld5_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pld5_10hv_dfrt

section nld5_10hv_dfrt
include "soachecks_top.scs" section=nld5_10hv_soa
if (enable_relimo == 1) {
anld5_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.75 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld5_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld5_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld5_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld5_10hv relimo_a_vth=relimo_a_vth_1_hci_nld5_10hv relimo_c=relimo_c_1_hci_nld5_10hv relimo_condvd=relimo_condvd_hci_nld5_10hv relimo_condvg=relimo_condvg_hci_nld5_10hv relimo_intercept=relimo_intercept_1_hci_nld5_10hv relimo_m=relimo_m_1_hci_nld5_10hv relimo_n=relimo_n_1_hci_nld5_10hv relimo_r=relimo_r_1_hci_nld5_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld5_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld5_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld5_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld5_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld5_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld5_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld5_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld5_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld5_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld5_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld5_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld5_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld5_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld5_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld5_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld5_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld5_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld5_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld5_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld5_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld5_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld5_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld5_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld5_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld5_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld5_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld5_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld5_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld5_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld5_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld5_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld5_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld5_10hv relimo_vth=relimo_vth_hci_nld5_10hv
anld5_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld5_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld5_10hv_esdchk_1 (d g s sub) monitor_esd_nld5_10hv ruleNum=1 enable=soa rule="esd_nld5_Vt1=10p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_2 (d g s sub) monitor_esd_nld5_10hv ruleNum=2 enable=soa rule="esd_nld5_Vt1>10p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.5
anld5_10hv_esdchk_3 (d g s sub) monitor_esd_nld5_10hv ruleNum=3 enable=soa rule="esd_nld5_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_10hv_esdchk_4 (d g s sub) monitor_esd_nld5_10hv ruleNum=4 enable=soa rule="esd_nld5_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 10.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=10.5
anld5_10hv_esdchk_5 (d g s sub) monitor_esd_nld5_10hv ruleNum=5 enable=soa rule="esd_nld5_Vt1=10p5_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_6 (d g s sub) monitor_esd_nld5_10hv ruleNum=6 enable=soa rule="esd_nld5_Vt1>10p5_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.5
anld5_10hv_esdchk_7 (d g s sub) monitor_esd_nld5_10hv ruleNum=7 enable=soa rule="esd_nld5_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_10hv_esdchk_8 (d g s sub) monitor_esd_nld5_10hv ruleNum=8 enable=soa rule="esd_nld5_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))) > 10.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=10.5
anld5_10hv_esdchk_9 (d g s sub) monitor_esd_nld5_10hv ruleNum=9 enable=soa rule="esd_nld5_Vt1=10p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_10 (d g s sub) monitor_esd_nld5_10hv ruleNum=10 enable=soa rule="esd_nld5_Vt1>10p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.5
anld5_10hv_esdchk_11 (d g s sub) monitor_esd_nld5_10hv ruleNum=11 enable=soa rule="esd_nld5_=Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(2.1*(V(g)-V(s)-1.0))-10.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_10hv_esdchk_12 (d g s sub) monitor_esd_nld5_10hv ruleNum=12 enable=soa rule="esd_nld5_>Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(2.1*(V(g)-V(s)-1.0))) > 10.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=10.5
anld5_10hv_esdchk_13 (d g s sub) monitor_esd_nld5_10hv ruleNum=13 enable=soa rule="esd_nld5_Vt1=8p4_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_14 (d g s sub) monitor_esd_nld5_10hv ruleNum=14 enable=soa rule="esd_nld5_Vt1>8p4_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.4
anld5_10hv_esdchk_15 (d g s sub) monitor_esd_nld5_10hv ruleNum=15 enable=soa rule="esd_nld5_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.0))-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_10hv_esdchk_16 (d g s sub) monitor_esd_nld5_10hv ruleNum=16 enable=soa rule="esd_nld5_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.0))) > 8.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=8.4
anld5_10hv_esdchk_17 (d g s sub) monitor_esd_nld5_10hv ruleNum=17 enable=soa rule="esd_nld5_Vt1=8p4_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_18 (d g s sub) monitor_esd_nld5_10hv ruleNum=18 enable=soa rule="esd_nld5_Vt1>8p4_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.4
anld5_10hv_esdchk_19 (d g s sub) monitor_esd_nld5_10hv ruleNum=19 enable=soa rule="esd_nld5_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-3.0))-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_10hv_esdchk_20 (d g s sub) monitor_esd_nld5_10hv ruleNum=20 enable=soa rule="esd_nld5_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-3.0))) > 8.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=8.4
anld5_10hv_esdchk_21 (d g s sub) monitor_esd_nld5_10hv ruleNum=21 enable=soa rule="esd_nld5_Vt1=8p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_22 (d g s sub) monitor_esd_nld5_10hv ruleNum=22 enable=soa rule="esd_nld5_Vt1>8p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.4
anld5_10hv_esdchk_23 (d g s sub) monitor_esd_nld5_10hv ruleNum=23 enable=soa rule="esd_nld5_=Vt1_Vgs>4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="(abs(V(d)-V(s)-8.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_10hv_esdchk_24 (g s d s) monitor4t enable=soa rule="esd_nld5_>Vt1_Vgs>4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(d-to-s) > 8.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.4
anld5_10hv_esdchk_25 (g s) monitor2t enable=soa rule="esd_nld5_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld5_10hv_esdchk_26 (g d) monitor2t enable=soa rule="esd_nld5_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld5_10hv_esdchk_27 (d sub) monitor2t enable=soa rule="esd_nld5_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld5_10hv_esdchk_28 (sub s) monitor2t enable=soa rule="esd_nld5_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld5_10hv_esdchk_29 (s d) monitor2t enable=soa rule="esd_nld5_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nld5_avth
+ bvth      = presto_hci_nld5_bvth
+ ai        = presto_hci_nld5_ai
+ bi        = presto_hci_nld5_bi
+ nvth      = presto_hci_nld5_n_vth
+ ni        = presto_hci_nld5_n_i
+ gammai    = presto_hci_nld5_gammai
+ alphamve  = presto_hci_nld5_alphamve
+ fstatmve  = presto_hci_nld5_fstatmve
+ vdpowmve  = presto_hci_nld5_vdpowmve
+ vgpowmve  = presto_hci_nld5_vgpowmve
+ vdexpmve  = presto_hci_nld5_vdexpmve
+ eamve     = presto_hci_nld5_eamve
+ lexpmve   = presto_hci_nld5_lexpmve
+ lpowmve   = presto_hci_nld5_lpowmve
+ wpowmve   = presto_hci_nld5_wpowmve
+ vbsexpmve = presto_hci_nld5_vbsexpmve
+ vc1mve    = presto_hci_nld5_vc1mve
+ vc2mve    = presto_hci_nld5_vc2mve
+ alphahe   = presto_hci_nld5_alphahe
+ fstathe   = presto_hci_nld5_fstathe
+ vdpowhe   = presto_hci_nld5_vdpowhe
+ vgpowhe   = presto_hci_nld5_vgpowhe
+ vdexphe   = presto_hci_nld5_vdexphe
+ eahe      = presto_hci_nld5_eahe
+ lexphe    = presto_hci_nld5_lexphe
+ lpowhe    = presto_hci_nld5_lpowhe
+ wpowhe    = presto_hci_nld5_wpowhe
+ vbsexphe  = presto_hci_nld5_vbsexphe
+ vc1he     = presto_hci_nld5_vc1he
+ vc2he     = presto_hci_nld5_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nld5_10hv_dfrt

section nld5_lvt_10hv_dfrt
include "soachecks_top.scs" section=nld5_lvt_10hv_soa
if (enable_relimo == 1) {
anld5_lvt_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.5 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld5_lvt_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld5_lvt_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld5_lvt_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld5_lvt_10hv relimo_a_vth=relimo_a_vth_1_hci_nld5_lvt_10hv relimo_c=relimo_c_1_hci_nld5_lvt_10hv relimo_condvd=relimo_condvd_hci_nld5_lvt_10hv relimo_condvg=relimo_condvg_hci_nld5_lvt_10hv relimo_intercept=relimo_intercept_1_hci_nld5_lvt_10hv relimo_m=relimo_m_1_hci_nld5_lvt_10hv relimo_n=relimo_n_1_hci_nld5_lvt_10hv relimo_r=relimo_r_1_hci_nld5_lvt_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld5_lvt_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld5_lvt_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld5_lvt_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld5_lvt_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld5_lvt_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld5_lvt_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld5_lvt_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld5_lvt_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld5_lvt_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld5_lvt_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld5_lvt_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld5_lvt_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld5_lvt_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld5_lvt_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld5_lvt_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld5_lvt_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld5_lvt_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld5_lvt_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld5_lvt_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld5_lvt_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld5_lvt_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld5_lvt_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld5_lvt_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld5_lvt_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld5_lvt_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld5_lvt_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld5_lvt_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld5_lvt_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld5_lvt_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld5_lvt_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld5_lvt_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld5_lvt_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld5_lvt_10hv relimo_vth=relimo_vth_hci_nld5_lvt_10hv
anld5_lvt_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld5_lvt_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld5_lvt_10hv_esdchk_1 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=1 enable=soa rule="esd_nld5_lvt_Vt1=9p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-9.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_lvt_10hv_esdchk_2 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=2 enable=soa rule="esd_nld5_lvt_Vt1>9p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 9.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.7
anld5_lvt_10hv_esdchk_3 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=3 enable=soa rule="esd_nld5_lvt_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(0.8*(V(g)-V(s)-0.0))-9.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_lvt_10hv_esdchk_4 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=4 enable=soa rule="esd_nld5_lvt_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(0.8*(V(g)-V(s)-0.0))) > 9.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=9.7
anld5_lvt_10hv_esdchk_5 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=5 enable=soa rule="esd_nld5_lvt_Vt1=9p3_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-9.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_lvt_10hv_esdchk_6 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=6 enable=soa rule="esd_nld5_lvt_Vt1>9p3_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 9.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.3
anld5_lvt_10hv_esdchk_7 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=7 enable=soa rule="esd_nld5_lvt_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(2.6*(V(g)-V(s)-0.5))-9.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld5_lvt_10hv_esdchk_8 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=8 enable=soa rule="esd_nld5_lvt_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(2.6*(V(g)-V(s)-0.5))) > 9.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=9.3
anld5_lvt_10hv_esdchk_9 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=9 enable=soa rule="esd_nld5_lvt_Vt1=8p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_lvt_10hv_esdchk_10 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=10 enable=soa rule="esd_nld5_lvt_Vt1>8p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.0
anld5_lvt_10hv_esdchk_11 (d g s sub) monitor_esd_nld5_lvt_10hv ruleNum=11 enable=soa rule="esd_nld5_lvt_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(d)-V(s)-8.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld5_lvt_10hv_esdchk_12 (g s d s) monitor4t enable=soa rule="esd_nld5_lvt_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(d-to-s) > 8.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.0
anld5_lvt_10hv_esdchk_13 (g s) monitor2t enable=soa rule="esd_nld5_lvt_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld5_lvt_10hv_esdchk_14 (g d) monitor2t enable=soa rule="esd_nld5_lvt_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld5_lvt_10hv_esdchk_15 (d sub) monitor2t enable=soa rule="esd_nld5_lvt_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld5_lvt_10hv_esdchk_16 (sub s) monitor2t enable=soa rule="esd_nld5_lvt_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld5_lvt_10hv_esdchk_17 (s d) monitor2t enable=soa rule="esd_nld5_lvt_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nld5_avth
+ bvth      = presto_hci_nld5_bvth
+ ai        = presto_hci_nld5_ai
+ bi        = presto_hci_nld5_bi
+ nvth      = presto_hci_nld5_n_vth
+ ni        = presto_hci_nld5_n_i
+ gammai    = presto_hci_nld5_gammai
+ alphamve  = presto_hci_nld5_alphamve
+ fstatmve  = presto_hci_nld5_fstatmve
+ vdpowmve  = presto_hci_nld5_vdpowmve
+ vgpowmve  = presto_hci_nld5_vgpowmve
+ vdexpmve  = presto_hci_nld5_vdexpmve
+ eamve     = presto_hci_nld5_eamve
+ lexpmve   = presto_hci_nld5_lexpmve
+ lpowmve   = presto_hci_nld5_lpowmve
+ wpowmve   = presto_hci_nld5_wpowmve
+ vbsexpmve = presto_hci_nld5_vbsexpmve
+ vc1mve    = presto_hci_nld5_vc1mve
+ vc2mve    = presto_hci_nld5_vc2mve
+ alphahe   = presto_hci_nld5_alphahe
+ fstathe   = presto_hci_nld5_fstathe
+ vdpowhe   = presto_hci_nld5_vdpowhe
+ vgpowhe   = presto_hci_nld5_vgpowhe
+ vdexphe   = presto_hci_nld5_vdexphe
+ eahe      = presto_hci_nld5_eahe
+ lexphe    = presto_hci_nld5_lexphe
+ lpowhe    = presto_hci_nld5_lpowhe
+ wpowhe    = presto_hci_nld5_wpowhe
+ vbsexphe  = presto_hci_nld5_vbsexphe
+ vc1he     = presto_hci_nld5_vc1he
+ vc2he     = presto_hci_nld5_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nld5_lvt_10hv_dfrt

section pld10_10hv_dfrt
include "soachecks_top.scs" section=pld10_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=relimo_ratio20_a_bti_pld10_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pld10_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apld10_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld10_10hv_esdchk_1 (d g s sub) monitor_esd_pld10_10hv ruleNum=1 enable=soa rule="esd_pld10_Vt1=19p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10_10hv_esdchk_2 (d g s sub) monitor_esd_pld10_10hv ruleNum=2 enable=soa rule="esd_pld10_Vt1>19p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.0
apld10_10hv_esdchk_3 (d g s sub) monitor_esd_pld10_10hv ruleNum=3 enable=soa rule="esd_pld10_=Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-19.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld10_10hv_esdchk_4 (d g s sub) monitor_esd_pld10_10hv ruleNum=4 enable=soa rule="esd_pld10_>Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 19.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=19.0
apld10_10hv_esdchk_5 (d g s sub) monitor_esd_pld10_10hv ruleNum=5 enable=soa rule="esd_pld10_Vt1=19p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10_10hv_esdchk_6 (d g s sub) monitor_esd_pld10_10hv ruleNum=6 enable=soa rule="esd_pld10_Vt1>19p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.0
apld10_10hv_esdchk_7 (d g s sub) monitor_esd_pld10_10hv ruleNum=7 enable=soa rule="esd_pld10_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-1.0))-19.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld10_10hv_esdchk_8 (d g s sub) monitor_esd_pld10_10hv ruleNum=8 enable=soa rule="esd_pld10_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-1.0)))) > 19.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=19.0
apld10_10hv_esdchk_9 (d g s sub) monitor_esd_pld10_10hv ruleNum=9 enable=soa rule="esd_pld10_Vt1=18p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-18.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10_10hv_esdchk_10 (d g s sub) monitor_esd_pld10_10hv ruleNum=10 enable=soa rule="esd_pld10_Vt1>18p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 18.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=18.1
apld10_10hv_esdchk_11 (d g s sub) monitor_esd_pld10_10hv ruleNum=11 enable=soa rule="esd_pld10_=Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(2.2*(V(s)-V(g)-1.5))-18.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld10_10hv_esdchk_12 (d g s sub) monitor_esd_pld10_10hv ruleNum=12 enable=soa rule="esd_pld10_>Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(2.2*(V(s)-V(g)-1.5)))) > 18.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=18.1
apld10_10hv_esdchk_13 (d g s sub) monitor_esd_pld10_10hv ruleNum=13 enable=soa rule="esd_pld10_Vt1=17p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-17.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10_10hv_esdchk_14 (d g s sub) monitor_esd_pld10_10hv ruleNum=14 enable=soa rule="esd_pld10_Vt1>17p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 17.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=17.0
apld10_10hv_esdchk_15 (d g s sub) monitor_esd_pld10_10hv ruleNum=15 enable=soa rule="esd_pld10_=Vt1_Vgs>2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="(abs(V(s)-V(d)-17.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10_10hv_esdchk_16 (s g s d) monitor4t enable=soa rule="esd_pld10_>Vt1_Vgs>2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="absV(s-to-d) > 17.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=17.0
apld10_10hv_esdchk_17 (g s) monitor2t enable=soa rule="esd_pld10_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld10_10hv_esdchk_18 (g d) monitor2t enable=soa rule="esd_pld10_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 19.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=19.0
apld10_10hv_esdchk_19 (s sub) monitor2t enable=soa rule="esd_pld10_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld10_10hv_esdchk_20 (sub d) monitor2t enable=soa rule="esd_pld10_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld10_10hv_esdchk_21 (d s) monitor2t enable=soa rule="esd_pld10_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pld10_10hv_dfrt

section pld10b_10hv_dfrt
include "soachecks_top.scs" section=pld10b_10hv_soa
if (enable_relimo == 1) {
apld10b_hci (d g s sub) relimo_aging_hci_pld10b w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apld10b_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld10b_10hv_esdchk_1 (d g s sub) monitor_esd_pld10b_10hv ruleNum=1 enable=soa rule="esd_pld10b_Vt1=18p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-18.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10b_10hv_esdchk_2 (d g s sub) monitor_esd_pld10b_10hv ruleNum=2 enable=soa rule="esd_pld10b_Vt1>18p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 18.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=18.9
apld10b_10hv_esdchk_3 (d g s sub) monitor_esd_pld10b_10hv ruleNum=3 enable=soa rule="esd_pld10b_=Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-0.0))-18.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld10b_10hv_esdchk_4 (d g s sub) monitor_esd_pld10b_10hv ruleNum=4 enable=soa rule="esd_pld10b_>Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-0.0)))) > 18.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=18.9
apld10b_10hv_esdchk_5 (d g s sub) monitor_esd_pld10b_10hv ruleNum=5 enable=soa rule="esd_pld10b_Vt1=17p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-17.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10b_10hv_esdchk_6 (d g s sub) monitor_esd_pld10b_10hv ruleNum=6 enable=soa rule="esd_pld10b_Vt1>17p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 17.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=17.9
apld10b_10hv_esdchk_7 (d g s sub) monitor_esd_pld10b_10hv ruleNum=7 enable=soa rule="esd_pld10b_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(s)-V(d)-17.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld10b_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pld10b_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="absV(s-to-d) > 17.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=17.9
apld10b_10hv_esdchk_9 (g s) monitor2t enable=soa rule="esd_pld10b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld10b_10hv_esdchk_10 (g d) monitor2t enable=soa rule="esd_pld10b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 18.9 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=18.9
apld10b_10hv_esdchk_11 (s sub) monitor2t enable=soa rule="esd_pld10b_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld10b_10hv_esdchk_12 (sub d) monitor2t enable=soa rule="esd_pld10b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld10b_10hv_esdchk_13 (d s) monitor2t enable=soa rule="esd_pld10b_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mamost"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 0.769*presto_idRatio
+ hcia2           = 1.83E-08*presto_idRatio
+ hcic1           = 7.89E+12
+ hcib1           = 4.77*presto_idRatio
+ hcin            = 0.236
+ hcialpha1       = 0.00211
+ hcibeta1        = 1.18
+ hcilambdah0     = 4.09E-06
+ hcialpha2       = 0.14
+ hcibeta2        = 1.18
+ hcilambdael0    = 2.73E-06
+ hcifstattau1    = 0.018
+ hcifstattau2    = 0.018
+ hcifstattau12   = 1
+ hcifstattau21   = 1
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.6
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ hvgsa           = 1000*presto_vthRatio    	   // High Vgs HCI part
+ hvgsn           = 0.24
+ hvgsalpha       = 1.28E+07
+ hvgsbeta        = 5.90E-09
+ hvgsgamma       = 11.7
+ hvgsdelta       = 3.7
+ hvgsepsilon     = 0
+ hvgsea          = 1.28
+ hvgsrth         = 0.0601
+ hvgsfstat       = 0.0171  	
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 1010 
+ a0_b0_b0_a1_em1 = 0.00908 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = 5.34 
+ a0_b0_a1_a1_em1 = 0.00395 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -7.39 
+ a0_b0_a2_a1_em1 = -0.00369 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 5000 
+ a0_b0_a3_a1_em1 = -0.00713 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.842 
+ a0_b0_p1_a1_em1 = -0.000441 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.5 
+ a0_b0_p2_a1_em1 = 0.000898 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3 
+ a0_b0_p3_a1_em1 = -0.00176 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 6 
+ a0_b0_p4_a1_em1 = 0 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 24200 
+ a0_b0_b0_a2_em1 = 13.9 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -2940 
+ a0_b0_a1_a2_em1 = -6.55 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 3460 
+ a0_b0_a2_a2_em1 = -17.7 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = 2300 
+ a0_b0_a3_a2_em1 = -0.318 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -1.18 
+ a0_b0_p1_a2_em1 = 0.00238 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 4 
+ a0_b0_p2_a2_em1 = -0.0112 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 6.53 
+ a0_b0_p3_a2_em1 = -0.00537 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 6 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 28500 
+ a0_b0_b0_a3_em1 = -7.78 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 5110 
+ a0_b0_a1_a3_em1 = -12.7 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -1820 
+ a0_b0_a2_a3_em1 = 2.79 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -4090 
+ a0_b0_a3_a3_em1 = 0.117 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = -1.07 
+ a0_b0_p1_a3_em1 = 0.00538 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 0.0341 
+ a0_b0_p2_a3_em1 = 0.00216 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.58 
+ a0_b0_p3_a3_em1 = 0.00378 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 6 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 12300 
+ a0_b0_b0_a4_em1 = 16.8 
+ b0_a0_b0_a4_em1 = -0.0175 
+ a0_a0_b0_a4_em1 = -0.171 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -1360 
+ a0_b0_a1_a4_em1 = 13.6 
+ b0_a0_a1_a4_em1 = -0.000497 
+ a0_a0_a1_a4_em1 = 0.203 
+ b0_b0_a2_a4_em1 = -3260 
+ a0_b0_a2_a4_em1 = 15.5 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0.0318 
+ b0_b0_a3_a4_em1 = -6010 
+ a0_b0_a3_a4_em1 = 8.15 
+ b0_a0_a3_a4_em1 = 0.00471 
+ a0_a0_a3_a4_em1 = 0.0382 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = -1.42 
+ a0_b0_p1_a4_em1 = 0.000549 
+ b0_a0_p1_a4_em1 = 0.55 
+ a0_a0_p1_a4_em1 = -0.00166 
+ b0_b0_p2_a4_em1 = 5.89 
+ a0_b0_p2_a4_em1 = -0.0234 
+ b0_a0_p2_a4_em1 = -0.33 
+ a0_a0_p2_a4_em1 = 0.0013 
+ b0_b0_p3_a4_em1 = 5.73 
+ a0_b0_p3_a4_em1 = -0.0103 
+ b0_a0_p3_a4_em1 = 0.0191 
+ a0_a0_p3_a4_em1 = -5.95E-05 
+ b0_b0_p4_a4_em1 = 3.71 
+ a0_b0_p4_a4_em1 = 0.00308 
+ b0_a0_p4_a4_em1 = 0.00956 
+ a0_a0_p4_a4_em1 = 2.32E-06 
+ b0_b0_b0_p1_em1 = 2.05 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 22.3 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -1.07 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -2.11 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 1.2 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.3 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.18 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 3.4 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 4.72 
+ a0_b0_b0_p2_em1 = 0.00247 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = -0.549 
+ a0_b0_a1_p2_em1 = 0.00244 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0.596 
+ a0_b0_a2_p2_em1 = -0.00241 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 2.79 
+ a0_b0_a3_p2_em1 = -0.0264 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 4.38 
+ a0_b0_p2_p2_em1 = -0.00737 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 3.69 
+ a0_b0_p3_p2_em1 = -3.90E-05 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 5.19 
+ a0_b0_p4_p2_em1 = -0.00243 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 10 
+ a0_b0_b0_p3_em1 = 0 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0 
+ a0_b0_a1_p3_em1 = 0 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0 
+ a0_b0_a2_p3_em1 = 0 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0 
+ a0_b0_a3_p3_em1 = 0 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = -1 
+ a0_b0_p1_p3_em1 = 0 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.5 
+ a0_b0_p2_p3_em1 = 0 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 4 
+ a0_b0_p3_p3_em1 = 0 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 6 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 13.4 
+ a0_b0_b0_p4_em1 = 0.0028 
+ b0_a0_b0_p4_em1 = 0.0163 
+ a0_a0_b0_p4_em1 = 3.54E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 1.32 
+ a0_b0_a1_p4_em1 = -0.00399 
+ b0_a0_a1_p4_em1 = -0.0222 
+ a0_a0_a1_p4_em1 = 5.70E-05 
+ b0_b0_a2_p4_em1 = 4.36 
+ a0_b0_a2_p4_em1 = -0.00947 
+ b0_a0_a2_p4_em1 = 0.00211 
+ a0_a0_a2_p4_em1 = -2.04E-05 
+ b0_b0_a3_p4_em1 = -3.68 
+ a0_b0_a3_p4_em1 = 0.00288 
+ b0_a0_a3_p4_em1 = -0.0495 
+ a0_a0_a3_p4_em1 = 0.000178 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = -0.453 
+ a0_b0_p1_p4_em1 = 0.00529 
+ b0_a0_p1_p4_em1 = 0.0436 
+ a0_a0_p1_p4_em1 = -0.000176 
+ b0_b0_p2_p4_em1 = 3.47 
+ a0_b0_p2_p4_em1 = -0.0054 
+ b0_a0_p2_p4_em1 = -0.0938 
+ a0_a0_p2_p4_em1 = 0.00039 
+ b0_b0_p3_p4_em1 = 3.64 
+ a0_b0_p3_p4_em1 = -0.00292 
+ b0_a0_p3_p4_em1 = -0.0362 
+ a0_a0_p3_p4_em1 = 0.000122 
+ b0_b0_p4_p4_em1 = 4.16 
+ a0_b0_p4_p4_em1 = -0.000635 
+ b0_a0_p4_p4_em1 = -0.063 
+ a0_a0_p4_p4_em1 = 0.000171 
+ b0_b0_b0_b0_em2 = 0 
+ a0_b0_b0_b0_em2 = 0 
+ b0_a0_b0_b0_em2 = 0 
+ a0_a0_b0_b0_em2 = 0 
+ b0_b0_a0_b0_em2 = 0 
+ a0_b0_a0_b0_em2 = 0 
+ b0_a0_a0_b0_em2 = 0 
+ a0_a0_a0_b0_em2 = 0 
+ b0_b0_a1_b0_em2 = 0 
+ a0_b0_a1_b0_em2 = 0 
+ b0_a0_a1_b0_em2 = 0 
+ a0_a0_a1_b0_em2 = 0 
+ b0_b0_a2_b0_em2 = 0 
+ a0_b0_a2_b0_em2 = 0 
+ b0_a0_a2_b0_em2 = 0 
+ a0_a0_a2_b0_em2 = 0 
+ b0_b0_a3_b0_em2 = 0 
+ a0_b0_a3_b0_em2 = 0 
+ b0_a0_a3_b0_em2 = 0 
+ a0_a0_a3_b0_em2 = 0 
+ b0_b0_a4_b0_em2 = 0 
+ a0_b0_a4_b0_em2 = 0 
+ b0_a0_a4_b0_em2 = 0 
+ a0_a0_a4_b0_em2 = 0 
+ b0_b0_p1_b0_em2 = 0 
+ a0_b0_p1_b0_em2 = 0 
+ b0_a0_p1_b0_em2 = 0 
+ a0_a0_p1_b0_em2 = 0 
+ b0_b0_p2_b0_em2 = 0 
+ a0_b0_p2_b0_em2 = 0 
+ b0_a0_p2_b0_em2 = 0 
+ a0_a0_p2_b0_em2 = 0 
+ b0_b0_p3_b0_em2 = 0 
+ a0_b0_p3_b0_em2 = 0 
+ b0_a0_p3_b0_em2 = 0 
+ a0_a0_p3_b0_em2 = 0 
+ b0_b0_p4_b0_em2 = 0 
+ a0_b0_p4_b0_em2 = 0 
+ b0_a0_p4_b0_em2 = 0 
+ a0_a0_p4_b0_em2 = 0 
+ b0_b0_b0_a0_em2 = 0 
+ a0_b0_b0_a0_em2 = 0 
+ b0_a0_b0_a0_em2 = 0 
+ a0_a0_b0_a0_em2 = 0 
+ b0_b0_a0_a0_em2 = 0 
+ a0_b0_a0_a0_em2 = 0 
+ b0_a0_a0_a0_em2 = 0 
+ a0_a0_a0_a0_em2 = 0 
+ b0_b0_a1_a0_em2 = 0 
+ a0_b0_a1_a0_em2 = 0 
+ b0_a0_a1_a0_em2 = 0 
+ a0_a0_a1_a0_em2 = 0 
+ b0_b0_a2_a0_em2 = 0 
+ a0_b0_a2_a0_em2 = 0 
+ b0_a0_a2_a0_em2 = 0 
+ a0_a0_a2_a0_em2 = 0 
+ b0_b0_a3_a0_em2 = 0 
+ a0_b0_a3_a0_em2 = 0 
+ b0_a0_a3_a0_em2 = 0 
+ a0_a0_a3_a0_em2 = 0 
+ b0_b0_a4_a0_em2 = 0 
+ a0_b0_a4_a0_em2 = 0 
+ b0_a0_a4_a0_em2 = 0 
+ a0_a0_a4_a0_em2 = 0 
+ b0_b0_p1_a0_em2 = 0 
+ a0_b0_p1_a0_em2 = 0 
+ b0_a0_p1_a0_em2 = 0 
+ a0_a0_p1_a0_em2 = 0 
+ b0_b0_p2_a0_em2 = 0 
+ a0_b0_p2_a0_em2 = 0 
+ b0_a0_p2_a0_em2 = 0 
+ a0_a0_p2_a0_em2 = 0 
+ b0_b0_p3_a0_em2 = 0 
+ a0_b0_p3_a0_em2 = 0 
+ b0_a0_p3_a0_em2 = 0 
+ a0_a0_p3_a0_em2 = 0 
+ b0_b0_p4_a0_em2 = 0 
+ a0_b0_p4_a0_em2 = 0 
+ b0_a0_p4_a0_em2 = 0 
+ a0_a0_p4_a0_em2 = 0 
+ b0_b0_b0_a1_em2 = 1010 
+ a0_b0_b0_a1_em2 = 0.00908 
+ b0_a0_b0_a1_em2 = 0 
+ a0_a0_b0_a1_em2 = 0 
+ b0_b0_a0_a1_em2 = 0 
+ a0_b0_a0_a1_em2 = 0 
+ b0_a0_a0_a1_em2 = 0 
+ a0_a0_a0_a1_em2 = 0 
+ b0_b0_a1_a1_em2 = 5.34 
+ a0_b0_a1_a1_em2 = 0.00395 
+ b0_a0_a1_a1_em2 = 0 
+ a0_a0_a1_a1_em2 = 0 
+ b0_b0_a2_a1_em2 = -7.39 
+ a0_b0_a2_a1_em2 = -0.00369 
+ b0_a0_a2_a1_em2 = 0 
+ a0_a0_a2_a1_em2 = 0 
+ b0_b0_a3_a1_em2 = 5000 
+ a0_b0_a3_a1_em2 = -0.00713 
+ b0_a0_a3_a1_em2 = 0 
+ a0_a0_a3_a1_em2 = 0 
+ b0_b0_a4_a1_em2 = 0 
+ a0_b0_a4_a1_em2 = 0 
+ b0_a0_a4_a1_em2 = 0 
+ a0_a0_a4_a1_em2 = 0 
+ b0_b0_p1_a1_em2 = 0.842 
+ a0_b0_p1_a1_em2 = -0.000441 
+ b0_a0_p1_a1_em2 = 0 
+ a0_a0_p1_a1_em2 = 0 
+ b0_b0_p2_a1_em2 = 1.5 
+ a0_b0_p2_a1_em2 = 0.000898 
+ b0_a0_p2_a1_em2 = 0 
+ a0_a0_p2_a1_em2 = 0 
+ b0_b0_p3_a1_em2 = 3 
+ a0_b0_p3_a1_em2 = -0.00176 
+ b0_a0_p3_a1_em2 = 0 
+ a0_a0_p3_a1_em2 = 0 
+ b0_b0_p4_a1_em2 = 6 
+ a0_b0_p4_a1_em2 = 0 
+ b0_a0_p4_a1_em2 = 0 
+ a0_a0_p4_a1_em2 = 0 
+ b0_b0_b0_a2_em2 = 24200 
+ a0_b0_b0_a2_em2 = 13.9 
+ b0_a0_b0_a2_em2 = 0 
+ a0_a0_b0_a2_em2 = 0 
+ b0_b0_a0_a2_em2 = 0 
+ a0_b0_a0_a2_em2 = 0 
+ b0_a0_a0_a2_em2 = 0 
+ a0_a0_a0_a2_em2 = 0 
+ b0_b0_a1_a2_em2 = -2940 
+ a0_b0_a1_a2_em2 = -6.55 
+ b0_a0_a1_a2_em2 = 0 
+ a0_a0_a1_a2_em2 = 0 
+ b0_b0_a2_a2_em2 = 3460 
+ a0_b0_a2_a2_em2 = -17.7 
+ b0_a0_a2_a2_em2 = 0 
+ a0_a0_a2_a2_em2 = 0 
+ b0_b0_a3_a2_em2 = 2300 
+ a0_b0_a3_a2_em2 = -0.318 
+ b0_a0_a3_a2_em2 = 0 
+ a0_a0_a3_a2_em2 = 0 
+ b0_b0_a4_a2_em2 = 0 
+ a0_b0_a4_a2_em2 = 0 
+ b0_a0_a4_a2_em2 = 0 
+ a0_a0_a4_a2_em2 = 0 
+ b0_b0_p1_a2_em2 = -1.18 
+ a0_b0_p1_a2_em2 = 0.00238 
+ b0_a0_p1_a2_em2 = 0 
+ a0_a0_p1_a2_em2 = 0 
+ b0_b0_p2_a2_em2 = 4 
+ a0_b0_p2_a2_em2 = -0.0112 
+ b0_a0_p2_a2_em2 = 0 
+ a0_a0_p2_a2_em2 = 0 
+ b0_b0_p3_a2_em2 = 6.53 
+ a0_b0_p3_a2_em2 = -0.00537 
+ b0_a0_p3_a2_em2 = 0 
+ a0_a0_p3_a2_em2 = 0 
+ b0_b0_p4_a2_em2 = 6 
+ a0_b0_p4_a2_em2 = 0 
+ b0_a0_p4_a2_em2 = 0 
+ a0_a0_p4_a2_em2 = 0 
+ b0_b0_b0_a3_em2 = 28500 
+ a0_b0_b0_a3_em2 = -7.78 
+ b0_a0_b0_a3_em2 = 0 
+ a0_a0_b0_a3_em2 = 0 
+ b0_b0_a0_a3_em2 = 0 
+ a0_b0_a0_a3_em2 = 0 
+ b0_a0_a0_a3_em2 = 0 
+ a0_a0_a0_a3_em2 = 0 
+ b0_b0_a1_a3_em2 = 5110 
+ a0_b0_a1_a3_em2 = -12.7 
+ b0_a0_a1_a3_em2 = 0 
+ a0_a0_a1_a3_em2 = 0 
+ b0_b0_a2_a3_em2 = -1820 
+ a0_b0_a2_a3_em2 = 2.79 
+ b0_a0_a2_a3_em2 = 0 
+ a0_a0_a2_a3_em2 = 0 
+ b0_b0_a3_a3_em2 = -4090 
+ a0_b0_a3_a3_em2 = 0.117 
+ b0_a0_a3_a3_em2 = 0 
+ a0_a0_a3_a3_em2 = 0 
+ b0_b0_a4_a3_em2 = 0 
+ a0_b0_a4_a3_em2 = 0 
+ b0_a0_a4_a3_em2 = 0 
+ a0_a0_a4_a3_em2 = 0 
+ b0_b0_p1_a3_em2 = -1.07 
+ a0_b0_p1_a3_em2 = 0.00538 
+ b0_a0_p1_a3_em2 = 0 
+ a0_a0_p1_a3_em2 = 0 
+ b0_b0_p2_a3_em2 = 0.0341 
+ a0_b0_p2_a3_em2 = 0.00216 
+ b0_a0_p2_a3_em2 = 0 
+ a0_a0_p2_a3_em2 = 0 
+ b0_b0_p3_a3_em2 = 1.58 
+ a0_b0_p3_a3_em2 = 0.00378 
+ b0_a0_p3_a3_em2 = 0 
+ a0_a0_p3_a3_em2 = 0 
+ b0_b0_p4_a3_em2 = 6 
+ a0_b0_p4_a3_em2 = 0 
+ b0_a0_p4_a3_em2 = 0 
+ a0_a0_p4_a3_em2 = 0 
+ b0_b0_b0_a4_em2 = 12300 
+ a0_b0_b0_a4_em2 = 16.8 
+ b0_a0_b0_a4_em2 = -0.0175 
+ a0_a0_b0_a4_em2 = -0.171 
+ b0_b0_a0_a4_em2 = 0 
+ a0_b0_a0_a4_em2 = 0 
+ b0_a0_a0_a4_em2 = 0 
+ a0_a0_a0_a4_em2 = 0 
+ b0_b0_a1_a4_em2 = -1360 
+ a0_b0_a1_a4_em2 = 13.6 
+ b0_a0_a1_a4_em2 = -0.000497 
+ a0_a0_a1_a4_em2 = 0.203 
+ b0_b0_a2_a4_em2 = -3260 
+ a0_b0_a2_a4_em2 = 15.5 
+ b0_a0_a2_a4_em2 = 0 
+ a0_a0_a2_a4_em2 = 0.0318 
+ b0_b0_a3_a4_em2 = -6010 
+ a0_b0_a3_a4_em2 = 8.15 
+ b0_a0_a3_a4_em2 = 0.00471 
+ a0_a0_a3_a4_em2 = 0.0382 
+ b0_b0_a4_a4_em2 = 0 
+ a0_b0_a4_a4_em2 = 0 
+ b0_a0_a4_a4_em2 = 0 
+ a0_a0_a4_a4_em2 = 0 
+ b0_b0_p1_a4_em2 = -1.42 
+ a0_b0_p1_a4_em2 = 0.000549 
+ b0_a0_p1_a4_em2 = 0.55 
+ a0_a0_p1_a4_em2 = -0.00166 
+ b0_b0_p2_a4_em2 = 5.89 
+ a0_b0_p2_a4_em2 = -0.0234 
+ b0_a0_p2_a4_em2 = -0.33 
+ a0_a0_p2_a4_em2 = 0.0013 
+ b0_b0_p3_a4_em2 = 5.73 
+ a0_b0_p3_a4_em2 = -0.0103 
+ b0_a0_p3_a4_em2 = 0.0191 
+ a0_a0_p3_a4_em2 = -5.95E-05 
+ b0_b0_p4_a4_em2 = 3.71 
+ a0_b0_p4_a4_em2 = 0.00308 
+ b0_a0_p4_a4_em2 = 0.00956 
+ a0_a0_p4_a4_em2 = 2.32E-06 
+ b0_b0_b0_p1_em2 = 2.05 
+ a0_b0_b0_p1_em2 = 0 
+ b0_a0_b0_p1_em2 = 0 
+ a0_a0_b0_p1_em2 = 0 
+ b0_b0_a0_p1_em2 = 0 
+ a0_b0_a0_p1_em2 = 0 
+ b0_a0_a0_p1_em2 = 0 
+ a0_a0_a0_p1_em2 = 0 
+ b0_b0_a1_p1_em2 = 22.3 
+ a0_b0_a1_p1_em2 = 0 
+ b0_a0_a1_p1_em2 = 0 
+ a0_a0_a1_p1_em2 = 0 
+ b0_b0_a2_p1_em2 = -1.07 
+ a0_b0_a2_p1_em2 = 0 
+ b0_a0_a2_p1_em2 = 0 
+ a0_a0_a2_p1_em2 = 0 
+ b0_b0_a3_p1_em2 = -2.11 
+ a0_b0_a3_p1_em2 = 0 
+ b0_a0_a3_p1_em2 = 0 
+ a0_a0_a3_p1_em2 = 0 
+ b0_b0_a4_p1_em2 = 0 
+ a0_b0_a4_p1_em2 = 0 
+ b0_a0_a4_p1_em2 = 0 
+ a0_a0_a4_p1_em2 = 0 
+ b0_b0_p1_p1_em2 = 1.2 
+ a0_b0_p1_p1_em2 = 0 
+ b0_a0_p1_p1_em2 = 0 
+ a0_a0_p1_p1_em2 = 0 
+ b0_b0_p2_p1_em2 = 1.3 
+ a0_b0_p2_p1_em2 = 0 
+ b0_a0_p2_p1_em2 = 0 
+ a0_a0_p2_p1_em2 = 0 
+ b0_b0_p3_p1_em2 = 2.18 
+ a0_b0_p3_p1_em2 = 0 
+ b0_a0_p3_p1_em2 = 0 
+ a0_a0_p3_p1_em2 = 0 
+ b0_b0_p4_p1_em2 = 3.4 
+ a0_b0_p4_p1_em2 = 0 
+ b0_a0_p4_p1_em2 = 0 
+ a0_a0_p4_p1_em2 = 0 
+ b0_b0_b0_p2_em2 = 4.72 
+ a0_b0_b0_p2_em2 = 0.00247 
+ b0_a0_b0_p2_em2 = 0 
+ a0_a0_b0_p2_em2 = 0 
+ b0_b0_a0_p2_em2 = 0 
+ a0_b0_a0_p2_em2 = 0 
+ b0_a0_a0_p2_em2 = 0 
+ a0_a0_a0_p2_em2 = 0 
+ b0_b0_a1_p2_em2 = -0.549 
+ a0_b0_a1_p2_em2 = 0.00244 
+ b0_a0_a1_p2_em2 = 0 
+ a0_a0_a1_p2_em2 = 0 
+ b0_b0_a2_p2_em2 = 0.596 
+ a0_b0_a2_p2_em2 = -0.00241 
+ b0_a0_a2_p2_em2 = 0 
+ a0_a0_a2_p2_em2 = 0 
+ b0_b0_a3_p2_em2 = 2.79 
+ a0_b0_a3_p2_em2 = -0.0264 
+ b0_a0_a3_p2_em2 = 0 
+ a0_a0_a3_p2_em2 = 0 
+ b0_b0_a4_p2_em2 = 0 
+ a0_b0_a4_p2_em2 = 0 
+ b0_a0_a4_p2_em2 = 0 
+ a0_a0_a4_p2_em2 = 0 
+ b0_b0_p1_p2_em2 = -1 
+ a0_b0_p1_p2_em2 = 0 
+ b0_a0_p1_p2_em2 = 0 
+ a0_a0_p1_p2_em2 = 0 
+ b0_b0_p2_p2_em2 = 4.38 
+ a0_b0_p2_p2_em2 = -0.00737 
+ b0_a0_p2_p2_em2 = 0 
+ a0_a0_p2_p2_em2 = 0 
+ b0_b0_p3_p2_em2 = 3.69 
+ a0_b0_p3_p2_em2 = -3.90E-05 
+ b0_a0_p3_p2_em2 = 0 
+ a0_a0_p3_p2_em2 = 0 
+ b0_b0_p4_p2_em2 = 5.19 
+ a0_b0_p4_p2_em2 = -0.00243 
+ b0_a0_p4_p2_em2 = 0 
+ a0_a0_p4_p2_em2 = 0 
+ b0_b0_b0_p3_em2 = 10 
+ a0_b0_b0_p3_em2 = 0 
+ b0_a0_b0_p3_em2 = 0 
+ a0_a0_b0_p3_em2 = 0 
+ b0_b0_a0_p3_em2 = 0 
+ a0_b0_a0_p3_em2 = 0 
+ b0_a0_a0_p3_em2 = 0 
+ a0_a0_a0_p3_em2 = 0 
+ b0_b0_a1_p3_em2 = 0 
+ a0_b0_a1_p3_em2 = 0 
+ b0_a0_a1_p3_em2 = 0 
+ a0_a0_a1_p3_em2 = 0 
+ b0_b0_a2_p3_em2 = 0 
+ a0_b0_a2_p3_em2 = 0 
+ b0_a0_a2_p3_em2 = 0 
+ a0_a0_a2_p3_em2 = 0 
+ b0_b0_a3_p3_em2 = 0 
+ a0_b0_a3_p3_em2 = 0 
+ b0_a0_a3_p3_em2 = 0 
+ a0_a0_a3_p3_em2 = 0 
+ b0_b0_a4_p3_em2 = 0 
+ a0_b0_a4_p3_em2 = 0 
+ b0_a0_a4_p3_em2 = 0 
+ a0_a0_a4_p3_em2 = 0 
+ b0_b0_p1_p3_em2 = -1 
+ a0_b0_p1_p3_em2 = 0 
+ b0_a0_p1_p3_em2 = 0 
+ a0_a0_p1_p3_em2 = 0 
+ b0_b0_p2_p3_em2 = 2.5 
+ a0_b0_p2_p3_em2 = 0 
+ b0_a0_p2_p3_em2 = 0 
+ a0_a0_p2_p3_em2 = 0 
+ b0_b0_p3_p3_em2 = 4 
+ a0_b0_p3_p3_em2 = 0 
+ b0_a0_p3_p3_em2 = 0 
+ a0_a0_p3_p3_em2 = 0 
+ b0_b0_p4_p3_em2 = 6 
+ a0_b0_p4_p3_em2 = 0 
+ b0_a0_p4_p3_em2 = 0 
+ a0_a0_p4_p3_em2 = 0 
+ b0_b0_b0_p4_em2 = 13.4 
+ a0_b0_b0_p4_em2 = 0.0028 
+ b0_a0_b0_p4_em2 = 0.0163 
+ a0_a0_b0_p4_em2 = 3.54E-05 
+ b0_b0_a0_p4_em2 = 0 
+ a0_b0_a0_p4_em2 = 0 
+ b0_a0_a0_p4_em2 = 0 
+ a0_a0_a0_p4_em2 = 0 
+ b0_b0_a1_p4_em2 = 1.32 
+ a0_b0_a1_p4_em2 = -0.00399 
+ b0_a0_a1_p4_em2 = -0.0222 
+ a0_a0_a1_p4_em2 = 5.70E-05 
+ b0_b0_a2_p4_em2 = 4.36 
+ a0_b0_a2_p4_em2 = -0.00947 
+ b0_a0_a2_p4_em2 = 0.00211 
+ a0_a0_a2_p4_em2 = -2.04E-05 
+ b0_b0_a3_p4_em2 = -3.68 
+ a0_b0_a3_p4_em2 = 0.00288 
+ b0_a0_a3_p4_em2 = -0.0495 
+ a0_a0_a3_p4_em2 = 0.000178 
+ b0_b0_a4_p4_em2 = 0 
+ a0_b0_a4_p4_em2 = 0 
+ b0_a0_a4_p4_em2 = 0 
+ a0_a0_a4_p4_em2 = 0 
+ b0_b0_p1_p4_em2 = -0.453 
+ a0_b0_p1_p4_em2 = 0.00529 
+ b0_a0_p1_p4_em2 = 0.0436 
+ a0_a0_p1_p4_em2 = -0.000176 
+ b0_b0_p2_p4_em2 = 3.47 
+ a0_b0_p2_p4_em2 = -0.0054 
+ b0_a0_p2_p4_em2 = -0.0938 
+ a0_a0_p2_p4_em2 = 0.00039 
+ b0_b0_p3_p4_em2 = 3.64 
+ a0_b0_p3_p4_em2 = -0.00292 
+ b0_a0_p3_p4_em2 = -0.0362 
+ a0_a0_p3_p4_em2 = 0.000122 
+ b0_b0_p4_p4_em2 = 4.16 
+ a0_b0_p4_p4_em2 = -0.000635 
+ b0_a0_p4_p4_em2 = -0.063 
+ a0_a0_p4_p4_em2 = 0.000171 
}
endsection pld10b_10hv_dfrt

section pld30_10hv_dfrt
include "soachecks_top.scs" section=pld30_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=1.0 relimo_ratio20_b=0.0 relimo_ratio21_a=1 relimo_ratio21_b=0.0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apld30_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld30_10hv_esdchk_1 (d g s sub) monitor_esd_pld30_10hv ruleNum=1 enable=soa rule="esd_pld30_Vt1=42p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-42.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30_10hv_esdchk_2 (d g s sub) monitor_esd_pld30_10hv ruleNum=2 enable=soa rule="esd_pld30_Vt1>42p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 42.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.9
apld30_10hv_esdchk_3 (d g s sub) monitor_esd_pld30_10hv ruleNum=3 enable=soa rule="esd_pld30_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-4.0*(V(s)-V(g)-0.0))-42.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld30_10hv_esdchk_4 (d g s sub) monitor_esd_pld30_10hv ruleNum=4 enable=soa rule="esd_pld30_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-4.0*(V(s)-V(g)-0.0)))) > 42.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=42.9
apld30_10hv_esdchk_5 (d g s sub) monitor_esd_pld30_10hv ruleNum=5 enable=soa rule="esd_pld30_Vt1=44p9_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-44.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30_10hv_esdchk_6 (d g s sub) monitor_esd_pld30_10hv ruleNum=6 enable=soa rule="esd_pld30_Vt1>44p9_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 44.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=44.9
apld30_10hv_esdchk_7 (d g s sub) monitor_esd_pld30_10hv ruleNum=7 enable=soa rule="esd_pld30_=Vt1_Vgs_0p5_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-0.5))-44.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld30_10hv_esdchk_8 (d g s sub) monitor_esd_pld30_10hv ruleNum=8 enable=soa rule="esd_pld30_>Vt1_Vgs_0p5_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-0.5)))) > 44.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=44.9
apld30_10hv_esdchk_9 (d g s sub) monitor_esd_pld30_10hv ruleNum=9 enable=soa rule="esd_pld30_Vt1=41p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-41.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30_10hv_esdchk_10 (d g s sub) monitor_esd_pld30_10hv ruleNum=10 enable=soa rule="esd_pld30_Vt1>41p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 41.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=41.8
apld30_10hv_esdchk_11 (d g s sub) monitor_esd_pld30_10hv ruleNum=11 enable=soa rule="esd_pld30_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-41.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30_10hv_esdchk_12 (s g s d) monitor4t enable=soa rule="esd_pld30_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 41.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=41.8
apld30_10hv_esdchk_13 (g s) monitor2t enable=soa rule="esd_pld30_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld30_10hv_esdchk_14 (g d) monitor2t enable=soa rule="esd_pld30_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 42.9 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=42.9
apld30_10hv_esdchk_15 (s sub) monitor2t enable=soa rule="esd_pld30_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld30_10hv_esdchk_16 (sub d) monitor2t enable=soa rule="esd_pld30_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld30_10hv_esdchk_17 (d s) monitor2t enable=soa rule="esd_pld30_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pld30_10hv_dfrt

section pld30b_10hv_dfrt
include "soachecks_top.scs" section=pld30b_10hv_soa
if (enable_relimo == 1) {
apld30b_hci (d g s sub) relimo_aging_hci_pld30b w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apld30b_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld30b_10hv_esdchk_1 (d g s sub) monitor_esd_pld30b_10hv ruleNum=1 enable=soa rule="esd_pld30b_Vt1=45p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-45.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30b_10hv_esdchk_2 (d g s sub) monitor_esd_pld30b_10hv ruleNum=2 enable=soa rule="esd_pld30b_Vt1>45p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 45.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=45.4
apld30b_10hv_esdchk_3 (d g s sub) monitor_esd_pld30b_10hv ruleNum=3 enable=soa rule="esd_pld30b_=Vt1_Vgs_0p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(0.3*(V(s)-V(g)-0.0))-45.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld30b_10hv_esdchk_4 (d g s sub) monitor_esd_pld30b_10hv ruleNum=4 enable=soa rule="esd_pld30b_>Vt1_Vgs_0p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(0.3*(V(s)-V(g)-0.0)))) > 45.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=45.4
apld30b_10hv_esdchk_5 (d g s sub) monitor_esd_pld30b_10hv ruleNum=5 enable=soa rule="esd_pld30b_Vt1=43p9_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-43.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30b_10hv_esdchk_6 (d g s sub) monitor_esd_pld30b_10hv ruleNum=6 enable=soa rule="esd_pld30b_Vt1>43p9_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 43.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=43.9
apld30b_10hv_esdchk_7 (d g s sub) monitor_esd_pld30b_10hv ruleNum=7 enable=soa rule="esd_pld30b_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(0.1*(V(s)-V(g)-5.0))-43.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld30b_10hv_esdchk_8 (d g s sub) monitor_esd_pld30b_10hv ruleNum=8 enable=soa rule="esd_pld30b_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(0.1*(V(s)-V(g)-5.0)))) > 43.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=43.9
apld30b_10hv_esdchk_9 (d g s sub) monitor_esd_pld30b_10hv ruleNum=9 enable=soa rule="esd_pld30b_Vt1=43p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-43.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30b_10hv_esdchk_10 (d g s sub) monitor_esd_pld30b_10hv ruleNum=10 enable=soa rule="esd_pld30b_Vt1>43p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 43.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=43.8
apld30b_10hv_esdchk_11 (d g s sub) monitor_esd_pld30b_10hv ruleNum=11 enable=soa rule="esd_pld30b_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-6.0))-43.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld30b_10hv_esdchk_12 (d g s sub) monitor_esd_pld30b_10hv ruleNum=12 enable=soa rule="esd_pld30b_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-6.0)))) > 43.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=43.8
apld30b_10hv_esdchk_13 (d g s sub) monitor_esd_pld30b_10hv ruleNum=13 enable=soa rule="esd_pld30b_Vt1=41p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-41.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30b_10hv_esdchk_14 (d g s sub) monitor_esd_pld30b_10hv ruleNum=14 enable=soa rule="esd_pld30b_Vt1>41p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 41.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=41.8
apld30b_10hv_esdchk_15 (d g s sub) monitor_esd_pld30b_10hv ruleNum=15 enable=soa rule="esd_pld30b_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-41.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld30b_10hv_esdchk_16 (s g s d) monitor4t enable=soa rule="esd_pld30b_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 41.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=41.8
apld30b_10hv_esdchk_17 (g s) monitor2t enable=soa rule="esd_pld30b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld30b_10hv_esdchk_18 (g d) monitor2t enable=soa rule="esd_pld30b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 45.4 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=45.4
apld30b_10hv_esdchk_19 (s sub) monitor2t enable=soa rule="esd_pld30b_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld30b_10hv_esdchk_20 (sub d) monitor2t enable=soa rule="esd_pld30b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld30b_10hv_esdchk_21 (d s) monitor2t enable=soa rule="esd_pld30b_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 1.5199*presto_idRatio
+ hcia2           = 3.4802*presto_idRatio
+ hcic1           = 288.96
+ hcib1           = 0.032351*presto_idRatio
+ hcin            = 1.8297
+ hcialpha1       = 0.000404
+ hcibeta1        = 1.35
+ hcilambdah0     = 9.56E-07
+ hcialpha2       = 7.86E-31
+ hcibeta2        = 0.874
+ hcilambdael0    = 3.25E-07
+ hcifstattau1    = 0.0299
+ hcifstattau2    = 0.00269
+ hcifstattau12   = 152
+ hcifstattau21   = 152
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.3
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 12.7*presto_idRatio  	   //Off state HCI part
+ offn1           = 0.15
+ offa2           = 2.02*presto_idRatio
+ offn2           = 0.463
+ offalpha1       = 93900
+ offbeta1        = 0.229
+ offea1          = 0.666
+ offalpha2       = 5.61
+ offbeta2        = 0.325
+ offea2          = 0.469
+ offfstattau1    = 0.0134
+ offfstattau2    = 0.0707
+ offfstattau12   = 56.3
+ offfstattau21   = 56.3
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.5*presto_idRatio
+ hvgsa           = 1000*presto_vthRatio    	   // High Vgs HCI part
+ hvgsn           = 0.234
+ hvgsalpha       = 2.16E+28
+ hvgsbeta        = 2.76
+ hvgsgamma       = 14.8
+ hvgsdelta       = 8.91
+ hvgsepsilon     = 0
+ hvgsea          = 0.751
+ hvgsrth         = 0.00743
+ hvgsfstat       = 0.0409  	
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 48300 
+ a0_b0_b0_a1_em1 = -40.7 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -580 
+ a0_b0_a1_a1_em1 = 0.71 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -1370 
+ a0_b0_a2_a1_em1 = -3.46 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 1990 
+ a0_b0_a3_a1_em1 = -1.79 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -54.2 
+ a0_b0_p1_a1_em1 = 0.00138 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.28 
+ a0_b0_p2_a1_em1 = 0.000574 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 2.46 
+ a0_b0_p3_a1_em1 = -4.67E-05 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 12500 
+ a0_b0_b0_a2_em1 = -1.63 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 966 
+ a0_b0_a1_a2_em1 = -1.55 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = -2660 
+ a0_b0_a2_a2_em1 = 3.18 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -515 
+ a0_b0_a3_a2_em1 = -0.108 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 4.38 
+ a0_b0_p1_a2_em1 = -0.0111 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 2.02 
+ a0_b0_p2_a2_em1 = -0.002 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 1.98 
+ a0_b0_p3_a2_em1 = 0.00105 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 9040 
+ a0_b0_b0_a3_em1 = -0.397 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 613 
+ a0_b0_a1_a3_em1 = -2.07 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -7430 
+ a0_b0_a2_a3_em1 = 1.92 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -3220 
+ a0_b0_a3_a3_em1 = 1.16 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = -0.855 
+ a0_b0_p1_a3_em1 = 0.00486 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.5 
+ a0_b0_p2_a3_em1 = 0.00113 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.31 
+ a0_b0_p3_a3_em1 = 0.00125 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 4580 
+ a0_b0_b0_a4_em1 = 2.06 
+ b0_a0_b0_a4_em1 = -11.6 
+ a0_a0_b0_a4_em1 = 0.0349 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 1490 
+ a0_b0_a1_a4_em1 = -2.59 
+ b0_a0_a1_a4_em1 = 0.349 
+ a0_a0_a1_a4_em1 = 0.222 
+ b0_b0_a2_a4_em1 = -766 
+ a0_b0_a2_a4_em1 = 1.62 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.00571 
+ b0_b0_a3_a4_em1 = 1280 
+ a0_b0_a3_a4_em1 = -2.19 
+ b0_a0_a3_a4_em1 = -1.68 
+ a0_a0_a3_a4_em1 = 0.00401 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 1.69 
+ a0_b0_p1_a4_em1 = -0.000112 
+ b0_a0_p1_a4_em1 = 0.00464 
+ a0_a0_p1_a4_em1 = -1.99E-05 
+ b0_b0_p2_a4_em1 = 1.61 
+ a0_b0_p2_a4_em1 = 0.000945 
+ b0_a0_p2_a4_em1 = 0.00287 
+ a0_a0_p2_a4_em1 = -5.40E-06 
+ b0_b0_p3_a4_em1 = 2.43 
+ a0_b0_p3_a4_em1 = 0.00368 
+ b0_a0_p3_a4_em1 = -0.000645 
+ a0_a0_p3_a4_em1 = 4.65E-06 
+ b0_b0_p4_a4_em1 = 2.41 
+ a0_b0_p4_a4_em1 = 0.00876 
+ b0_a0_p4_a4_em1 = -0.0085 
+ a0_a0_p4_a4_em1 = 2.18E-05 
+ b0_b0_b0_p1_em1 = 1.62 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.216 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -2.41 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 2.69E-05 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -1.09 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.55 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.45 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 2.13 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 11.1 
+ a0_b0_b0_p2_em1 = 0.00576 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 1.2 
+ a0_b0_a1_p2_em1 = -0.00324 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = -10.7 
+ a0_b0_a2_p2_em1 = 0.0153 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -1.46 
+ a0_b0_a3_p2_em1 = -0.000321 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.97 
+ a0_b0_p2_p2_em1 = 0.000922 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.37 
+ a0_b0_p3_p2_em1 = 0.00127 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 4.94 
+ a0_b0_p4_p2_em1 = -0.00247 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 16.8 
+ a0_b0_b0_p3_em1 = 0.00252 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = -1.61 
+ a0_b0_a1_p3_em1 = 0.00304 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = -2.34 
+ a0_b0_a2_p3_em1 = -4.87E-05 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0.769 
+ a0_b0_a3_p3_em1 = -0.000416 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 2.09 
+ a0_b0_p1_p3_em1 = -0.00402 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.58 
+ a0_b0_p2_p3_em1 = -0.00036 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 4.83 
+ a0_b0_p3_p3_em1 = -0.00136 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 6 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 25.5 
+ a0_b0_b0_p4_em1 = -0.0011 
+ b0_a0_b0_p4_em1 = 0.02 
+ a0_a0_b0_p4_em1 = -6.04E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = -5.22 
+ a0_b0_a1_p4_em1 = 0.00888 
+ b0_a0_a1_p4_em1 = -0.0275 
+ a0_a0_a1_p4_em1 = 7.37E-05 
+ b0_b0_a2_p4_em1 = 12.5 
+ a0_b0_a2_p4_em1 = -0.0205 
+ b0_a0_a2_p4_em1 = 0.00131 
+ a0_a0_a2_p4_em1 = 3.13E-06 
+ b0_b0_a3_p4_em1 = -5.61 
+ a0_b0_a3_p4_em1 = 0.00578 
+ b0_a0_a3_p4_em1 = 0.0235 
+ a0_a0_a3_p4_em1 = -4.63E-05 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 1.24 
+ a0_b0_p1_p4_em1 = -0.000731 
+ b0_a0_p1_p4_em1 = 0.00394 
+ a0_a0_p1_p4_em1 = -9.11E-06 
+ b0_b0_p2_p4_em1 = 2.19 
+ a0_b0_p2_p4_em1 = -6.92E-05 
+ b0_a0_p2_p4_em1 = -0.00175 
+ a0_a0_p2_p4_em1 = 6.09E-06 
+ b0_b0_p3_p4_em1 = 2.6 
+ a0_b0_p3_p4_em1 = 0.000913 
+ b0_a0_p3_p4_em1 = -0.00121 
+ a0_a0_p3_p4_em1 = 2.12E-06 
+ b0_b0_p4_p4_em1 = 5.04 
+ a0_b0_p4_p4_em1 = 0.00206 
+ b0_a0_p4_p4_em1 = -0.0222 
+ a0_a0_p4_p4_em1 = 6.49E-05 
+ b0_b0_b0_b0_em2 = 0 
+ a0_b0_b0_b0_em2 = 0 
+ b0_a0_b0_b0_em2 = 0 
+ a0_a0_b0_b0_em2 = 0 
+ b0_b0_a0_b0_em2 = 0 
+ a0_b0_a0_b0_em2 = 0 
+ b0_a0_a0_b0_em2 = 0 
+ a0_a0_a0_b0_em2 = 0 
+ b0_b0_a1_b0_em2 = 0 
+ a0_b0_a1_b0_em2 = 0 
+ b0_a0_a1_b0_em2 = 0 
+ a0_a0_a1_b0_em2 = 0 
+ b0_b0_a2_b0_em2 = 0 
+ a0_b0_a2_b0_em2 = 0 
+ b0_a0_a2_b0_em2 = 0 
+ a0_a0_a2_b0_em2 = 0 
+ b0_b0_a3_b0_em2 = 0 
+ a0_b0_a3_b0_em2 = 0 
+ b0_a0_a3_b0_em2 = 0 
+ a0_a0_a3_b0_em2 = 0 
+ b0_b0_a4_b0_em2 = 0 
+ a0_b0_a4_b0_em2 = 0 
+ b0_a0_a4_b0_em2 = 0 
+ a0_a0_a4_b0_em2 = 0 
+ b0_b0_p1_b0_em2 = 0 
+ a0_b0_p1_b0_em2 = 0 
+ b0_a0_p1_b0_em2 = 0 
+ a0_a0_p1_b0_em2 = 0 
+ b0_b0_p2_b0_em2 = 0 
+ a0_b0_p2_b0_em2 = 0 
+ b0_a0_p2_b0_em2 = 0 
+ a0_a0_p2_b0_em2 = 0 
+ b0_b0_p3_b0_em2 = 0 
+ a0_b0_p3_b0_em2 = 0 
+ b0_a0_p3_b0_em2 = 0 
+ a0_a0_p3_b0_em2 = 0 
+ b0_b0_p4_b0_em2 = 0 
+ a0_b0_p4_b0_em2 = 0 
+ b0_a0_p4_b0_em2 = 0 
+ a0_a0_p4_b0_em2 = 0 
+ b0_b0_b0_a0_em2 = 0 
+ a0_b0_b0_a0_em2 = 0 
+ b0_a0_b0_a0_em2 = 0 
+ a0_a0_b0_a0_em2 = 0 
+ b0_b0_a0_a0_em2 = 0 
+ a0_b0_a0_a0_em2 = 0 
+ b0_a0_a0_a0_em2 = 0 
+ a0_a0_a0_a0_em2 = 0 
+ b0_b0_a1_a0_em2 = 0 
+ a0_b0_a1_a0_em2 = 0 
+ b0_a0_a1_a0_em2 = 0 
+ a0_a0_a1_a0_em2 = 0 
+ b0_b0_a2_a0_em2 = 0 
+ a0_b0_a2_a0_em2 = 0 
+ b0_a0_a2_a0_em2 = 0 
+ a0_a0_a2_a0_em2 = 0 
+ b0_b0_a3_a0_em2 = 0 
+ a0_b0_a3_a0_em2 = 0 
+ b0_a0_a3_a0_em2 = 0 
+ a0_a0_a3_a0_em2 = 0 
+ b0_b0_a4_a0_em2 = 0 
+ a0_b0_a4_a0_em2 = 0 
+ b0_a0_a4_a0_em2 = 0 
+ a0_a0_a4_a0_em2 = 0 
+ b0_b0_p1_a0_em2 = 0 
+ a0_b0_p1_a0_em2 = 0 
+ b0_a0_p1_a0_em2 = 0 
+ a0_a0_p1_a0_em2 = 0 
+ b0_b0_p2_a0_em2 = 0 
+ a0_b0_p2_a0_em2 = 0 
+ b0_a0_p2_a0_em2 = 0 
+ a0_a0_p2_a0_em2 = 0 
+ b0_b0_p3_a0_em2 = 0 
+ a0_b0_p3_a0_em2 = 0 
+ b0_a0_p3_a0_em2 = 0 
+ a0_a0_p3_a0_em2 = 0 
+ b0_b0_p4_a0_em2 = 0 
+ a0_b0_p4_a0_em2 = 0 
+ b0_a0_p4_a0_em2 = 0 
+ a0_a0_p4_a0_em2 = 0 
+ b0_b0_b0_a1_em2 = 11900 
+ a0_b0_b0_a1_em2 = -9.82 
+ b0_a0_b0_a1_em2 = 0 
+ a0_a0_b0_a1_em2 = 0 
+ b0_b0_a0_a1_em2 = 0 
+ a0_b0_a0_a1_em2 = 0 
+ b0_a0_a0_a1_em2 = 0 
+ a0_a0_a0_a1_em2 = 0 
+ b0_b0_a1_a1_em2 = 3350 
+ a0_b0_a1_a1_em2 = -0.864 
+ b0_a0_a1_a1_em2 = 0 
+ a0_a0_a1_a1_em2 = 0 
+ b0_b0_a2_a1_em2 = -2220 
+ a0_b0_a2_a1_em2 = 4.52 
+ b0_a0_a2_a1_em2 = 0 
+ a0_a0_a2_a1_em2 = 0 
+ b0_b0_a3_a1_em2 = -4050 
+ a0_b0_a3_a1_em2 = 2.43 
+ b0_a0_a3_a1_em2 = 0 
+ a0_a0_a3_a1_em2 = 0 
+ b0_b0_a4_a1_em2 = 0 
+ a0_b0_a4_a1_em2 = 0 
+ b0_a0_a4_a1_em2 = 0 
+ a0_a0_a4_a1_em2 = 0 
+ b0_b0_p1_a1_em2 = -0.0246 
+ a0_b0_p1_a1_em2 = -0.00041 
+ b0_a0_p1_a1_em2 = 0 
+ a0_a0_p1_a1_em2 = 0 
+ b0_b0_p2_a1_em2 = 0.975 
+ a0_b0_p2_a1_em2 = 0.000376 
+ b0_a0_p2_a1_em2 = 0 
+ a0_a0_p2_a1_em2 = 0 
+ b0_b0_p3_a1_em2 = 2.89 
+ a0_b0_p3_a1_em2 = -0.00123 
+ b0_a0_p3_a1_em2 = 0 
+ a0_a0_p3_a1_em2 = 0 
+ b0_b0_p4_a1_em2 = 3.9 
+ a0_b0_p4_a1_em2 = -0.0001 
+ b0_a0_p4_a1_em2 = 0 
+ a0_a0_p4_a1_em2 = 0 
+ b0_b0_b0_a2_em2 = 8160 
+ a0_b0_b0_a2_em2 = 3.34 
+ b0_a0_b0_a2_em2 = 0 
+ a0_a0_b0_a2_em2 = 0 
+ b0_b0_a0_a2_em2 = 0 
+ a0_b0_a0_a2_em2 = 0 
+ b0_a0_a0_a2_em2 = 0 
+ a0_a0_a0_a2_em2 = 0 
+ b0_b0_a1_a2_em2 = 714 
+ a0_b0_a1_a2_em2 = 9.39 
+ b0_a0_a1_a2_em2 = 0 
+ a0_a0_a1_a2_em2 = 0 
+ b0_b0_a2_a2_em2 = -3740 
+ a0_b0_a2_a2_em2 = 4.27 
+ b0_a0_a2_a2_em2 = 0 
+ a0_a0_a2_a2_em2 = 0 
+ b0_b0_a3_a2_em2 = 3050 
+ a0_b0_a3_a2_em2 = -10.9 
+ b0_a0_a3_a2_em2 = 0 
+ a0_a0_a3_a2_em2 = 0 
+ b0_b0_a4_a2_em2 = 0 
+ a0_b0_a4_a2_em2 = 0 
+ b0_a0_a4_a2_em2 = 0 
+ a0_a0_a4_a2_em2 = 0 
+ b0_b0_p1_a2_em2 = -0.887 
+ a0_b0_p1_a2_em2 = 0.00271 
+ b0_a0_p1_a2_em2 = 0 
+ a0_a0_p1_a2_em2 = 0 
+ b0_b0_p2_a2_em2 = 1.31 
+ a0_b0_p2_a2_em2 = -0.000751 
+ b0_a0_p2_a2_em2 = 0 
+ a0_a0_p2_a2_em2 = 0 
+ b0_b0_p3_a2_em2 = 2.83 
+ a0_b0_p3_a2_em2 = 0.00258 
+ b0_a0_p3_a2_em2 = 0 
+ a0_a0_p3_a2_em2 = 0 
+ b0_b0_p4_a2_em2 = 4 
+ a0_b0_p4_a2_em2 = 0 
+ b0_a0_p4_a2_em2 = 0 
+ a0_a0_p4_a2_em2 = 0 
+ b0_b0_b0_a3_em2 = 4270 
+ a0_b0_b0_a3_em2 = 13.4 
+ b0_a0_b0_a3_em2 = 0 
+ a0_a0_b0_a3_em2 = 0 
+ b0_b0_a0_a3_em2 = 0 
+ a0_b0_a0_a3_em2 = 0 
+ b0_a0_a0_a3_em2 = 0 
+ a0_a0_a0_a3_em2 = 0 
+ b0_b0_a1_a3_em2 = 514 
+ a0_b0_a1_a3_em2 = -4.08 
+ b0_a0_a1_a3_em2 = 0 
+ a0_a0_a1_a3_em2 = 0 
+ b0_b0_a2_a3_em2 = 3690 
+ a0_b0_a2_a3_em2 = -2.09 
+ b0_a0_a2_a3_em2 = 0 
+ a0_a0_a2_a3_em2 = 0 
+ b0_b0_a3_a3_em2 = -993 
+ a0_b0_a3_a3_em2 = -0.568 
+ b0_a0_a3_a3_em2 = 0 
+ a0_a0_a3_a3_em2 = 0 
+ b0_b0_a4_a3_em2 = 0 
+ a0_b0_a4_a3_em2 = 0 
+ b0_a0_a4_a3_em2 = 0 
+ a0_a0_a4_a3_em2 = 0 
+ b0_b0_p1_a3_em2 = 0.818 
+ a0_b0_p1_a3_em2 = -0.00394 
+ b0_a0_p1_a3_em2 = 0 
+ a0_a0_p1_a3_em2 = 0 
+ b0_b0_p2_a3_em2 = 0.281 
+ a0_b0_p2_a3_em2 = -0.000546 
+ b0_a0_p2_a3_em2 = 0 
+ a0_a0_p2_a3_em2 = 0 
+ b0_b0_p3_a3_em2 = 0.929 
+ a0_b0_p3_a3_em2 = -0.00049 
+ b0_a0_p3_a3_em2 = 0 
+ a0_a0_p3_a3_em2 = 0 
+ b0_b0_p4_a3_em2 = 4.5 
+ a0_b0_p4_a3_em2 = 0 
+ b0_a0_p4_a3_em2 = 0 
+ a0_a0_p4_a3_em2 = 0 
+ b0_b0_b0_a4_em2 = 6810 
+ a0_b0_b0_a4_em2 = -1.6 
+ b0_a0_b0_a4_em2 = -1.04 
+ a0_a0_b0_a4_em2 = 0.00305 
+ b0_b0_a0_a4_em2 = 0 
+ a0_b0_a0_a4_em2 = 0 
+ b0_a0_a0_a4_em2 = 0 
+ a0_a0_a0_a4_em2 = 0 
+ b0_b0_a1_a4_em2 = -1350 
+ a0_b0_a1_a4_em2 = 4.74 
+ b0_a0_a1_a4_em2 = -0.718 
+ a0_a0_a1_a4_em2 = 0.00231 
+ b0_b0_a2_a4_em2 = -73.4 
+ a0_b0_a2_a4_em2 = -2.2 
+ b0_a0_a2_a4_em2 = 0 
+ a0_a0_a2_a4_em2 = 0.00588 
+ b0_b0_a3_a4_em2 = -445 
+ a0_b0_a3_a4_em2 = 4.15 
+ b0_a0_a3_a4_em2 = 0.708 
+ a0_a0_a3_a4_em2 = -0.00966 
+ b0_b0_a4_a4_em2 = 0 
+ a0_b0_a4_a4_em2 = 0 
+ b0_a0_a4_a4_em2 = 0 
+ a0_a0_a4_a4_em2 = 0 
+ b0_b0_p1_a4_em2 = -0.011 
+ a0_b0_p1_a4_em2 = -0.00282 
+ b0_a0_p1_a4_em2 = 0.00387 
+ a0_a0_p1_a4_em2 = -8.04E-06 
+ b0_b0_p2_a4_em2 = -0.19 
+ a0_b0_p2_a4_em2 = 0.000581 
+ b0_a0_p2_a4_em2 = 0.00111 
+ a0_a0_p2_a4_em2 = -3.28E-06 
+ b0_b0_p3_a4_em2 = 2.19 
+ a0_b0_p3_a4_em2 = 0.00188 
+ b0_a0_p3_a4_em2 = -0.00511 
+ a0_a0_p3_a4_em2 = 1.02E-05 
+ b0_b0_p4_a4_em2 = 4.39 
+ a0_b0_p4_a4_em2 = -0.000239 
+ b0_a0_p4_a4_em2 = 0.00753 
+ a0_a0_p4_a4_em2 = -1.54E-05 
+ b0_b0_b0_p1_em2 = 4.7 
+ a0_b0_b0_p1_em2 = 0 
+ b0_a0_b0_p1_em2 = 0 
+ a0_a0_b0_p1_em2 = 0 
+ b0_b0_a0_p1_em2 = 0 
+ a0_b0_a0_p1_em2 = 0 
+ b0_a0_a0_p1_em2 = 0 
+ a0_a0_a0_p1_em2 = 0 
+ b0_b0_a1_p1_em2 = 4.15 
+ a0_b0_a1_p1_em2 = 0 
+ b0_a0_a1_p1_em2 = 0 
+ a0_a0_a1_p1_em2 = 0 
+ b0_b0_a2_p1_em2 = -1.88 
+ a0_b0_a2_p1_em2 = 0 
+ b0_a0_a2_p1_em2 = 0 
+ a0_a0_a2_p1_em2 = 0 
+ b0_b0_a3_p1_em2 = -5.05 
+ a0_b0_a3_p1_em2 = 0 
+ b0_a0_a3_p1_em2 = 0 
+ a0_a0_a3_p1_em2 = 0 
+ b0_b0_a4_p1_em2 = 0 
+ a0_b0_a4_p1_em2 = 0 
+ b0_a0_a4_p1_em2 = 0 
+ a0_a0_a4_p1_em2 = 0 
+ b0_b0_p1_p1_em2 = -0.233 
+ a0_b0_p1_p1_em2 = 0 
+ b0_a0_p1_p1_em2 = 0 
+ a0_a0_p1_p1_em2 = 0 
+ b0_b0_p2_p1_em2 = 1 
+ a0_b0_p2_p1_em2 = 0 
+ b0_a0_p2_p1_em2 = 0 
+ a0_a0_p2_p1_em2 = 0 
+ b0_b0_p3_p1_em2 = 2.56 
+ a0_b0_p3_p1_em2 = 0 
+ b0_a0_p3_p1_em2 = 0 
+ a0_a0_p3_p1_em2 = 0 
+ b0_b0_p4_p1_em2 = 3.9 
+ a0_b0_p4_p1_em2 = 0 
+ b0_a0_p4_p1_em2 = 0 
+ a0_a0_p4_p1_em2 = 0 
+ b0_b0_b0_p2_em2 = 15 
+ a0_b0_b0_p2_em2 = 0 
+ b0_a0_b0_p2_em2 = 0 
+ a0_a0_b0_p2_em2 = 0 
+ b0_b0_a0_p2_em2 = 0 
+ a0_b0_a0_p2_em2 = 0 
+ b0_a0_a0_p2_em2 = 0 
+ a0_a0_a0_p2_em2 = 0 
+ b0_b0_a1_p2_em2 = 0 
+ a0_b0_a1_p2_em2 = 0 
+ b0_a0_a1_p2_em2 = 0 
+ a0_a0_a1_p2_em2 = 0 
+ b0_b0_a2_p2_em2 = 0 
+ a0_b0_a2_p2_em2 = 0 
+ b0_a0_a2_p2_em2 = 0 
+ a0_a0_a2_p2_em2 = 0 
+ b0_b0_a3_p2_em2 = 0 
+ a0_b0_a3_p2_em2 = 0 
+ b0_a0_a3_p2_em2 = 0 
+ a0_a0_a3_p2_em2 = 0 
+ b0_b0_a4_p2_em2 = 0 
+ a0_b0_a4_p2_em2 = 0 
+ b0_a0_a4_p2_em2 = 0 
+ a0_a0_a4_p2_em2 = 0 
+ b0_b0_p1_p2_em2 = 0 
+ a0_b0_p1_p2_em2 = 0 
+ b0_a0_p1_p2_em2 = 0 
+ a0_a0_p1_p2_em2 = 0 
+ b0_b0_p2_p2_em2 = 1 
+ a0_b0_p2_p2_em2 = 0 
+ b0_a0_p2_p2_em2 = 0 
+ a0_a0_p2_p2_em2 = 0 
+ b0_b0_p3_p2_em2 = 2 
+ a0_b0_p3_p2_em2 = 0 
+ b0_a0_p3_p2_em2 = 0 
+ a0_a0_p3_p2_em2 = 0 
+ b0_b0_p4_p2_em2 = 3 
+ a0_b0_p4_p2_em2 = 0 
+ b0_a0_p4_p2_em2 = 0 
+ a0_a0_p4_p2_em2 = 0 
+ b0_b0_b0_p3_em2 = 20 
+ a0_b0_b0_p3_em2 = 0 
+ b0_a0_b0_p3_em2 = 0 
+ a0_a0_b0_p3_em2 = 0 
+ b0_b0_a0_p3_em2 = 0 
+ a0_b0_a0_p3_em2 = 0 
+ b0_a0_a0_p3_em2 = 0 
+ a0_a0_a0_p3_em2 = 0 
+ b0_b0_a1_p3_em2 = 0 
+ a0_b0_a1_p3_em2 = 0 
+ b0_a0_a1_p3_em2 = 0 
+ a0_a0_a1_p3_em2 = 0 
+ b0_b0_a2_p3_em2 = 0 
+ a0_b0_a2_p3_em2 = 0 
+ b0_a0_a2_p3_em2 = 0 
+ a0_a0_a2_p3_em2 = 0 
+ b0_b0_a3_p3_em2 = 0 
+ a0_b0_a3_p3_em2 = 0 
+ b0_a0_a3_p3_em2 = 0 
+ a0_a0_a3_p3_em2 = 0 
+ b0_b0_a4_p3_em2 = 0 
+ a0_b0_a4_p3_em2 = 0 
+ b0_a0_a4_p3_em2 = 0 
+ a0_a0_a4_p3_em2 = 0 
+ b0_b0_p1_p3_em2 = 0 
+ a0_b0_p1_p3_em2 = 0 
+ b0_a0_p1_p3_em2 = 0 
+ a0_a0_p1_p3_em2 = 0 
+ b0_b0_p2_p3_em2 = 1 
+ a0_b0_p2_p3_em2 = 0 
+ b0_a0_p2_p3_em2 = 0 
+ a0_a0_p2_p3_em2 = 0 
+ b0_b0_p3_p3_em2 = 2 
+ a0_b0_p3_p3_em2 = 0 
+ b0_a0_p3_p3_em2 = 0 
+ a0_a0_p3_p3_em2 = 0 
+ b0_b0_p4_p3_em2 = 3 
+ a0_b0_p4_p3_em2 = 0 
+ b0_a0_p4_p3_em2 = 0 
+ a0_a0_p4_p3_em2 = 0 
+ b0_b0_b0_p4_em2 = 24 
+ a0_b0_b0_p4_em2 = 0.00305 
+ b0_a0_b0_p4_em2 = 0.00419 
+ a0_a0_b0_p4_em2 = -1.06E-05 
+ b0_b0_a0_p4_em2 = 0 
+ a0_b0_a0_p4_em2 = 0 
+ b0_a0_a0_p4_em2 = 0 
+ a0_a0_a0_p4_em2 = 0 
+ b0_b0_a1_p4_em2 = 3.38 
+ a0_b0_a1_p4_em2 = -0.00505 
+ b0_a0_a1_p4_em2 = 0 
+ a0_a0_a1_p4_em2 = 0 
+ b0_b0_a2_p4_em2 = 2.74 
+ a0_b0_a2_p4_em2 = -0.00761 
+ b0_a0_a2_p4_em2 = 0 
+ a0_a0_a2_p4_em2 = 0 
+ b0_b0_a3_p4_em2 = -9.92 
+ a0_b0_a3_p4_em2 = 0.0464 
+ b0_a0_a3_p4_em2 = 0 
+ a0_a0_a3_p4_em2 = 0 
+ b0_b0_a4_p4_em2 = 0 
+ a0_b0_a4_p4_em2 = 0 
+ b0_a0_a4_p4_em2 = 0 
+ a0_a0_a4_p4_em2 = 0 
+ b0_b0_p1_p4_em2 = 1.92 
+ a0_b0_p1_p4_em2 = 0.0224 
+ b0_a0_p1_p4_em2 = 0 
+ a0_a0_p1_p4_em2 = 0 
+ b0_b0_p2_p4_em2 = 2.45 
+ a0_b0_p2_p4_em2 = 0.0139 
+ b0_a0_p2_p4_em2 = 0 
+ a0_a0_p2_p4_em2 = 0 
+ b0_b0_p3_p4_em2 = 4.6 
+ a0_b0_p3_p4_em2 = -0.000542 
+ b0_a0_p3_p4_em2 = 0 
+ a0_a0_p3_p4_em2 = 0 
+ b0_b0_p4_p4_em2 = 9.74 
+ a0_b0_p4_p4_em2 = -0.0153 
+ b0_a0_p4_p4_em2 = 0 
+ a0_a0_p4_p4_em2 = 0 
}
endsection pld30b_10hv_dfrt

section pld45_10hv_dfrt
include "soachecks_top.scs" section=pld45_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apld45_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld45_10hv_esdchk_1 (d g s sub) monitor_esd_pld45_10hv ruleNum=1 enable=soa rule="esd_pld45_Vt1=59p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-59.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_2 (d g s sub) monitor_esd_pld45_10hv ruleNum=2 enable=soa rule="esd_pld45_Vt1>59p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 59.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.7
apld45_10hv_esdchk_3 (d g s sub) monitor_esd_pld45_10hv ruleNum=3 enable=soa rule="esd_pld45_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-59.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_4 (d g s sub) monitor_esd_pld45_10hv ruleNum=4 enable=soa rule="esd_pld45_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 59.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=59.7
apld45_10hv_esdchk_5 (d g s sub) monitor_esd_pld45_10hv ruleNum=5 enable=soa rule="esd_pld45_Vt1=59p7_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-59.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_6 (d g s sub) monitor_esd_pld45_10hv ruleNum=6 enable=soa rule="esd_pld45_Vt1>59p7_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 59.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.7
apld45_10hv_esdchk_7 (d g s sub) monitor_esd_pld45_10hv ruleNum=7 enable=soa rule="esd_pld45_=Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-1.5))-59.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_8 (d g s sub) monitor_esd_pld45_10hv ruleNum=8 enable=soa rule="esd_pld45_>Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-1.5)))) > 59.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=59.7
apld45_10hv_esdchk_9 (d g s sub) monitor_esd_pld45_10hv ruleNum=9 enable=soa rule="esd_pld45_Vt1=58p9_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-58.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_10 (d g s sub) monitor_esd_pld45_10hv ruleNum=10 enable=soa rule="esd_pld45_Vt1>58p9_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 58.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=58.9
apld45_10hv_esdchk_11 (d g s sub) monitor_esd_pld45_10hv ruleNum=11 enable=soa rule="esd_pld45_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(1.3*(V(s)-V(g)-2.0))-58.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_12 (d g s sub) monitor_esd_pld45_10hv ruleNum=12 enable=soa rule="esd_pld45_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(1.3*(V(s)-V(g)-2.0)))) > 58.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=58.9
apld45_10hv_esdchk_13 (d g s sub) monitor_esd_pld45_10hv ruleNum=13 enable=soa rule="esd_pld45_Vt1=57p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-57.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_14 (d g s sub) monitor_esd_pld45_10hv ruleNum=14 enable=soa rule="esd_pld45_Vt1>57p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 57.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=57.6
apld45_10hv_esdchk_15 (d g s sub) monitor_esd_pld45_10hv ruleNum=15 enable=soa rule="esd_pld45_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(1.7*(V(s)-V(g)-3.0))-57.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_16 (d g s sub) monitor_esd_pld45_10hv ruleNum=16 enable=soa rule="esd_pld45_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(1.7*(V(s)-V(g)-3.0)))) > 57.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=57.6
apld45_10hv_esdchk_17 (d g s sub) monitor_esd_pld45_10hv ruleNum=17 enable=soa rule="esd_pld45_Vt1=55p9_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-55.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_18 (d g s sub) monitor_esd_pld45_10hv ruleNum=18 enable=soa rule="esd_pld45_Vt1>55p9_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 55.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=55.9
apld45_10hv_esdchk_19 (d g s sub) monitor_esd_pld45_10hv ruleNum=19 enable=soa rule="esd_pld45_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(0.8*(V(s)-V(g)-4.0))-55.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_20 (d g s sub) monitor_esd_pld45_10hv ruleNum=20 enable=soa rule="esd_pld45_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(0.8*(V(s)-V(g)-4.0)))) > 55.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=55.9
apld45_10hv_esdchk_21 (d g s sub) monitor_esd_pld45_10hv ruleNum=21 enable=soa rule="esd_pld45_Vt1=55p1_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-55.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_22 (d g s sub) monitor_esd_pld45_10hv ruleNum=22 enable=soa rule="esd_pld45_Vt1>55p1_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 55.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=55.1
apld45_10hv_esdchk_23 (d g s sub) monitor_esd_pld45_10hv ruleNum=23 enable=soa rule="esd_pld45_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(3.3*(V(s)-V(g)-5.0))-55.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_24 (d g s sub) monitor_esd_pld45_10hv ruleNum=24 enable=soa rule="esd_pld45_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(3.3*(V(s)-V(g)-5.0)))) > 55.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=55.1
apld45_10hv_esdchk_25 (d g s sub) monitor_esd_pld45_10hv ruleNum=25 enable=soa rule="esd_pld45_Vt1=51p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-51.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_26 (d g s sub) monitor_esd_pld45_10hv ruleNum=26 enable=soa rule="esd_pld45_Vt1>51p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 51.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=51.8
apld45_10hv_esdchk_27 (d g s sub) monitor_esd_pld45_10hv ruleNum=27 enable=soa rule="esd_pld45_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.3*(V(s)-V(g)-6.0))-51.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45_10hv_esdchk_28 (d g s sub) monitor_esd_pld45_10hv ruleNum=28 enable=soa rule="esd_pld45_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.3*(V(s)-V(g)-6.0)))) > 51.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=51.8
apld45_10hv_esdchk_29 (d g s sub) monitor_esd_pld45_10hv ruleNum=29 enable=soa rule="esd_pld45_Vt1=47p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-47.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_30 (d g s sub) monitor_esd_pld45_10hv ruleNum=30 enable=soa rule="esd_pld45_Vt1>47p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 47.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.5
apld45_10hv_esdchk_31 (d g s sub) monitor_esd_pld45_10hv ruleNum=31 enable=soa rule="esd_pld45_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-47.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pld45_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 47.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.5
apld45_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_pld45_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld45_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_pld45_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 59.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=59.7
apld45_10hv_esdchk_35 (s sub) monitor2t enable=soa rule="esd_pld45_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld45_10hv_esdchk_36 (sub d) monitor2t enable=soa rule="esd_pld45_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld45_10hv_esdchk_37 (d s) monitor2t enable=soa rule="esd_pld45_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pld45_10hv_dfrt

section pld45b_10hv_dfrt
include "soachecks_top.scs" section=pld45b_10hv_soa
if (enable_relimo == 1) {
apld45b_hci (d g s sub) relimo_aging_hci_pld45b w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apld45b_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld45b_10hv_esdchk_1 (d g s sub) monitor_esd_pld45b_10hv ruleNum=1 enable=soa rule="esd_pld45b_Vt1=62p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_2 (d g s sub) monitor_esd_pld45b_10hv ruleNum=2 enable=soa rule="esd_pld45b_Vt1>62p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 62.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.0
apld45b_10hv_esdchk_3 (d g s sub) monitor_esd_pld45b_10hv ruleNum=3 enable=soa rule="esd_pld45b_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-0.0))-62.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_4 (d g s sub) monitor_esd_pld45b_10hv ruleNum=4 enable=soa rule="esd_pld45b_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-0.0)))) > 62.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.0
apld45b_10hv_esdchk_5 (d g s sub) monitor_esd_pld45b_10hv ruleNum=5 enable=soa rule="esd_pld45b_Vt1=61p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-61.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_6 (d g s sub) monitor_esd_pld45b_10hv ruleNum=6 enable=soa rule="esd_pld45b_Vt1>61p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 61.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.1
apld45b_10hv_esdchk_7 (d g s sub) monitor_esd_pld45b_10hv ruleNum=7 enable=soa rule="esd_pld45b_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(-0.3*(V(s)-V(g)-1.5))-61.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_8 (d g s sub) monitor_esd_pld45b_10hv ruleNum=8 enable=soa rule="esd_pld45b_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(-0.3*(V(s)-V(g)-1.5)))) > 61.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.1
apld45b_10hv_esdchk_9 (d g s sub) monitor_esd_pld45b_10hv ruleNum=9 enable=soa rule="esd_pld45b_Vt1=61p4_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-61.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_10 (d g s sub) monitor_esd_pld45b_10hv ruleNum=10 enable=soa rule="esd_pld45b_Vt1>61p4_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 61.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.4
apld45b_10hv_esdchk_11 (d g s sub) monitor_esd_pld45b_10hv ruleNum=11 enable=soa rule="esd_pld45b_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-2.5))-61.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_12 (d g s sub) monitor_esd_pld45b_10hv ruleNum=12 enable=soa rule="esd_pld45b_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-2.5)))) > 61.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.4
apld45b_10hv_esdchk_13 (d g s sub) monitor_esd_pld45b_10hv ruleNum=13 enable=soa rule="esd_pld45b_Vt1=60p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-60.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_14 (d g s sub) monitor_esd_pld45b_10hv ruleNum=14 enable=soa rule="esd_pld45b_Vt1>60p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 60.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.8
apld45b_10hv_esdchk_15 (d g s sub) monitor_esd_pld45b_10hv ruleNum=15 enable=soa rule="esd_pld45b_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(2.1*(V(s)-V(g)-3.5))-60.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_16 (d g s sub) monitor_esd_pld45b_10hv ruleNum=16 enable=soa rule="esd_pld45b_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(2.1*(V(s)-V(g)-3.5)))) > 60.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=60.8
apld45b_10hv_esdchk_17 (d g s sub) monitor_esd_pld45b_10hv ruleNum=17 enable=soa rule="esd_pld45b_Vt1=58p7_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-58.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_18 (d g s sub) monitor_esd_pld45b_10hv ruleNum=18 enable=soa rule="esd_pld45b_Vt1>58p7_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 58.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=58.7
apld45b_10hv_esdchk_19 (d g s sub) monitor_esd_pld45b_10hv ruleNum=19 enable=soa rule="esd_pld45b_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(2.1*(V(s)-V(g)-4.5))-58.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_20 (d g s sub) monitor_esd_pld45b_10hv ruleNum=20 enable=soa rule="esd_pld45b_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(2.1*(V(s)-V(g)-4.5)))) > 58.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=58.7
apld45b_10hv_esdchk_21 (d g s sub) monitor_esd_pld45b_10hv ruleNum=21 enable=soa rule="esd_pld45b_Vt1=56p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_22 (d g s sub) monitor_esd_pld45b_10hv ruleNum=22 enable=soa rule="esd_pld45b_Vt1>56p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 56.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=56.6
apld45b_10hv_esdchk_23 (d g s sub) monitor_esd_pld45b_10hv ruleNum=23 enable=soa rule="esd_pld45b_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(9.6*(V(s)-V(g)-5.5))-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_24 (d g s sub) monitor_esd_pld45b_10hv ruleNum=24 enable=soa rule="esd_pld45b_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(9.6*(V(s)-V(g)-5.5)))) > 56.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=56.6
apld45b_10hv_esdchk_25 (d g s sub) monitor_esd_pld45b_10hv ruleNum=25 enable=soa rule="esd_pld45b_Vt1=51p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-51.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_26 (d g s sub) monitor_esd_pld45b_10hv ruleNum=26 enable=soa rule="esd_pld45b_Vt1>51p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 51.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=51.8
apld45b_10hv_esdchk_27 (d g s sub) monitor_esd_pld45b_10hv ruleNum=27 enable=soa rule="esd_pld45b_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.3*(V(s)-V(g)-6.0))-51.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld45b_10hv_esdchk_28 (d g s sub) monitor_esd_pld45b_10hv ruleNum=28 enable=soa rule="esd_pld45b_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.3*(V(s)-V(g)-6.0)))) > 51.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=51.8
apld45b_10hv_esdchk_29 (d g s sub) monitor_esd_pld45b_10hv ruleNum=29 enable=soa rule="esd_pld45b_Vt1=47p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-47.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_30 (d g s sub) monitor_esd_pld45b_10hv ruleNum=30 enable=soa rule="esd_pld45b_Vt1>47p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 47.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.5
apld45b_10hv_esdchk_31 (d g s sub) monitor_esd_pld45b_10hv ruleNum=31 enable=soa rule="esd_pld45b_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-47.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld45b_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pld45b_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 47.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.5
apld45b_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_pld45b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld45b_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_pld45b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 62.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=62.0
apld45b_10hv_esdchk_35 (s sub) monitor2t enable=soa rule="esd_pld45b_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld45b_10hv_esdchk_36 (sub d) monitor2t enable=soa rule="esd_pld45b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld45b_10hv_esdchk_37 (d s) monitor2t enable=soa rule="esd_pld45b_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 1.0483*presto_idRatio
+ hcia2           = 34.922*presto_idRatio
+ hcic1           = 1.48E+05
+ hcib1           = 7.44E-05*presto_idRatio
+ hcin            = 3
+ hcialpha1       = 0.342
+ hcibeta1        = 0.49
+ hcilambdah0     = 2.66E-06
+ hcialpha2       = 7.38E-40
+ hcibeta2        = 0.851
+ hcilambdael0    = 3.16E-07
+ hcifstattau1    = 0.0387
+ hcifstattau2    = 0.00333
+ hcifstattau12   = 96.8
+ hcifstattau21   = 96.8
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.9
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 14.5*presto_idRatio  	  //Off state HCI part
+ offn1           = 0.301
+ offa2           = 0.288*presto_idRatio
+ offn2           = 1.46
+ offalpha1       = 7330
+ offbeta1        = 0.112
+ offea1          = 0.368
+ offalpha2       = 0.0011
+ offbeta2        = 0.139
+ offea2          = 0.48
+ offfstattau1    = 0.0129
+ offfstattau2    = 0.0189
+ offfstattau12   = 18.2
+ offfstattau21   = 18.2
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.5*presto_idRatio
+ hvgsa           = 1000*presto_vthRatio    	   // High Vgs HCI part
+ hvgsn           = 0.241
+ hvgsalpha       = 5.12E+11
+ hvgsbeta        = 2.90E-08
+ hvgsgamma       = 15.7
+ hvgsdelta       = 4.56
+ hvgsepsilon     = 0
+ hvgsea          = 1.31
+ hvgsrth         = 0.0279
+ hvgsfstat       = 0.0142  	
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 13700 
+ a0_b0_b0_a1_em1 = -2.61 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = 466 
+ a0_b0_a1_a1_em1 = -0.885 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -2500 
+ a0_b0_a2_a1_em1 = -3.64 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 2120 
+ a0_b0_a3_a1_em1 = -1.8 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 2.15 
+ a0_b0_p1_a1_em1 = -0.00452 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.84 
+ a0_b0_p2_a1_em1 = 0.000795 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.65 
+ a0_b0_p3_a1_em1 = -0.000646 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 7250 
+ a0_b0_b0_a2_em1 = -0.926 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -344 
+ a0_b0_a1_a2_em1 = 3.25 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 1520 
+ a0_b0_a2_a2_em1 = -9.25 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -2780 
+ a0_b0_a3_a2_em1 = 3.52 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -0.214 
+ a0_b0_p1_a2_em1 = 0.00118 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 1.51 
+ a0_b0_p2_a2_em1 = 0.000344 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 2.37 
+ a0_b0_p3_a2_em1 = -0.000328 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 4340 
+ a0_b0_b0_a3_em1 = -0.16 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 623 
+ a0_b0_a1_a3_em1 = -1.83 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -7100 
+ a0_b0_a2_a3_em1 = 16.7 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -1760 
+ a0_b0_a3_a3_em1 = 1.81 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = -1.82 
+ a0_b0_p1_a3_em1 = 0.00979 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.69 
+ a0_b0_p2_a3_em1 = 0.00141 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.91 
+ a0_b0_p3_a3_em1 = 0.00058 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 2990 
+ a0_b0_b0_a4_em1 = 0.323 
+ b0_a0_b0_a4_em1 = -0.204 
+ a0_a0_b0_a4_em1 = 0.000505 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -470 
+ a0_b0_a1_a4_em1 = 1.79 
+ b0_a0_a1_a4_em1 = 0.0293 
+ a0_a0_a1_a4_em1 = 0.00881 
+ b0_b0_a2_a4_em1 = -413 
+ a0_b0_a2_a4_em1 = 0.531 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.00135 
+ b0_b0_a3_a4_em1 = 442 
+ a0_b0_a3_a4_em1 = -1.14 
+ b0_a0_a3_a4_em1 = -0.423 
+ a0_a0_a3_a4_em1 = -0.00545 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0.0428 
+ a0_b0_p1_a4_em1 = 0.00318 
+ b0_a0_p1_a4_em1 = -0.0223 
+ a0_a0_p1_a4_em1 = 6.39E-05 
+ b0_b0_p2_a4_em1 = 1.43 
+ a0_b0_p2_a4_em1 = -0.000456 
+ b0_a0_p2_a4_em1 = -0.00644 
+ a0_a0_p2_a4_em1 = 3.43E-05 
+ b0_b0_p3_a4_em1 = 2 
+ a0_b0_p3_a4_em1 = 0.00508 
+ b0_a0_p3_a4_em1 = -0.00732 
+ a0_a0_p3_a4_em1 = 1.42E-05 
+ b0_b0_p4_a4_em1 = 3.61 
+ a0_b0_p4_a4_em1 = 0.00576 
+ b0_a0_p4_a4_em1 = -0.0734 
+ a0_a0_p4_a4_em1 = 0.000243 
+ b0_b0_b0_p1_em1 = 4.05 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.827 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -0.877 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -4.88 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 0.116 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.7 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.5 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 3.46 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 14.2 
+ a0_b0_b0_p2_em1 = 0.0037 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0.327 
+ a0_b0_a1_p2_em1 = -0.0014 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = -1.5 
+ a0_b0_a2_p2_em1 = 0.00513 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -0.11 
+ a0_b0_a3_p2_em1 = -0.0172 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.09 
+ a0_b0_p2_p2_em1 = 0.0031 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 3.77 
+ a0_b0_p3_p2_em1 = -0.000521 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 4.78 
+ a0_b0_p4_p2_em1 = -0.00196 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 21.7 
+ a0_b0_b0_p3_em1 = 0.00308 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 1.82 
+ a0_b0_a1_p3_em1 = -0.000988 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 1.31 
+ a0_b0_a2_p3_em1 = -0.00202 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0.0916 
+ a0_b0_a3_p3_em1 = 0.00239 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 4.52 
+ a0_b0_p1_p3_em1 = -0.00217 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.32 
+ a0_b0_p2_p3_em1 = -0.00512 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 0.938 
+ a0_b0_p3_p3_em1 = 0.00601 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 4.02 
+ a0_b0_p4_p3_em1 = 0.0872 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 33.5 
+ a0_b0_b0_p4_em1 = 0.00418 
+ b0_a0_b0_p4_em1 = 0.0126 
+ a0_a0_b0_p4_em1 = -3.91E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 12.4 
+ a0_b0_a1_p4_em1 = 0.0683 
+ b0_a0_a1_p4_em1 = -0.0213 
+ a0_a0_a1_p4_em1 = 0.000322 
+ b0_b0_a2_p4_em1 = -14.9 
+ a0_b0_a2_p4_em1 = 0.0255 
+ b0_a0_a2_p4_em1 = -0.344 
+ a0_a0_a2_p4_em1 = 0.000792 
+ b0_b0_a3_p4_em1 = -15.9 
+ a0_b0_a3_p4_em1 = -0.0024 
+ b0_a0_a3_p4_em1 = 0.158 
+ a0_a0_a3_p4_em1 = -0.000578 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 1.89 
+ a0_b0_p1_p4_em1 = 0.00101 
+ b0_a0_p1_p4_em1 = 0.000923 
+ a0_a0_p1_p4_em1 = -1.13E-06 
+ b0_b0_p2_p4_em1 = 2.7 
+ a0_b0_p2_p4_em1 = -0.000443 
+ b0_a0_p2_p4_em1 = 0.00365 
+ a0_a0_p2_p4_em1 = -9.26E-06 
+ b0_b0_p3_p4_em1 = 3.19 
+ a0_b0_p3_p4_em1 = 0.00164 
+ b0_a0_p3_p4_em1 = 0.00461 
+ a0_a0_p3_p4_em1 = -8.57E-08 
+ b0_b0_p4_p4_em1 = 5.18 
+ a0_b0_p4_p4_em1 = -0.00168 
+ b0_a0_p4_p4_em1 = -0.00462 
+ a0_a0_p4_p4_em1 = 5.38E-06 
+ b0_b0_b0_b0_em2 = 0 
+ a0_b0_b0_b0_em2 = 0 
+ b0_a0_b0_b0_em2 = 0 
+ a0_a0_b0_b0_em2 = 0 
+ b0_b0_a0_b0_em2 = 0 
+ a0_b0_a0_b0_em2 = 0 
+ b0_a0_a0_b0_em2 = 0 
+ a0_a0_a0_b0_em2 = 0 
+ b0_b0_a1_b0_em2 = 0 
+ a0_b0_a1_b0_em2 = 0 
+ b0_a0_a1_b0_em2 = 0 
+ a0_a0_a1_b0_em2 = 0 
+ b0_b0_a2_b0_em2 = 0 
+ a0_b0_a2_b0_em2 = 0 
+ b0_a0_a2_b0_em2 = 0 
+ a0_a0_a2_b0_em2 = 0 
+ b0_b0_a3_b0_em2 = 0 
+ a0_b0_a3_b0_em2 = 0 
+ b0_a0_a3_b0_em2 = 0 
+ a0_a0_a3_b0_em2 = 0 
+ b0_b0_a4_b0_em2 = 0 
+ a0_b0_a4_b0_em2 = 0 
+ b0_a0_a4_b0_em2 = 0 
+ a0_a0_a4_b0_em2 = 0 
+ b0_b0_p1_b0_em2 = 0 
+ a0_b0_p1_b0_em2 = 0 
+ b0_a0_p1_b0_em2 = 0 
+ a0_a0_p1_b0_em2 = 0 
+ b0_b0_p2_b0_em2 = 0 
+ a0_b0_p2_b0_em2 = 0 
+ b0_a0_p2_b0_em2 = 0 
+ a0_a0_p2_b0_em2 = 0 
+ b0_b0_p3_b0_em2 = 0 
+ a0_b0_p3_b0_em2 = 0 
+ b0_a0_p3_b0_em2 = 0 
+ a0_a0_p3_b0_em2 = 0 
+ b0_b0_p4_b0_em2 = 0 
+ a0_b0_p4_b0_em2 = 0 
+ b0_a0_p4_b0_em2 = 0 
+ a0_a0_p4_b0_em2 = 0 
+ b0_b0_b0_a0_em2 = 0 
+ a0_b0_b0_a0_em2 = 0 
+ b0_a0_b0_a0_em2 = 0 
+ a0_a0_b0_a0_em2 = 0 
+ b0_b0_a0_a0_em2 = 0 
+ a0_b0_a0_a0_em2 = 0 
+ b0_a0_a0_a0_em2 = 0 
+ a0_a0_a0_a0_em2 = 0 
+ b0_b0_a1_a0_em2 = 0 
+ a0_b0_a1_a0_em2 = 0 
+ b0_a0_a1_a0_em2 = 0 
+ a0_a0_a1_a0_em2 = 0 
+ b0_b0_a2_a0_em2 = 0 
+ a0_b0_a2_a0_em2 = 0 
+ b0_a0_a2_a0_em2 = 0 
+ a0_a0_a2_a0_em2 = 0 
+ b0_b0_a3_a0_em2 = 0 
+ a0_b0_a3_a0_em2 = 0 
+ b0_a0_a3_a0_em2 = 0 
+ a0_a0_a3_a0_em2 = 0 
+ b0_b0_a4_a0_em2 = 0 
+ a0_b0_a4_a0_em2 = 0 
+ b0_a0_a4_a0_em2 = 0 
+ a0_a0_a4_a0_em2 = 0 
+ b0_b0_p1_a0_em2 = 0 
+ a0_b0_p1_a0_em2 = 0 
+ b0_a0_p1_a0_em2 = 0 
+ a0_a0_p1_a0_em2 = 0 
+ b0_b0_p2_a0_em2 = 0 
+ a0_b0_p2_a0_em2 = 0 
+ b0_a0_p2_a0_em2 = 0 
+ a0_a0_p2_a0_em2 = 0 
+ b0_b0_p3_a0_em2 = 0 
+ a0_b0_p3_a0_em2 = 0 
+ b0_a0_p3_a0_em2 = 0 
+ a0_a0_p3_a0_em2 = 0 
+ b0_b0_p4_a0_em2 = 0 
+ a0_b0_p4_a0_em2 = 0 
+ b0_a0_p4_a0_em2 = 0 
+ a0_a0_p4_a0_em2 = 0 
+ b0_b0_b0_a1_em2 = 11800 
+ a0_b0_b0_a1_em2 = -2.09 
+ b0_a0_b0_a1_em2 = 0 
+ a0_a0_b0_a1_em2 = 0 
+ b0_b0_a0_a1_em2 = 0 
+ a0_b0_a0_a1_em2 = 0 
+ b0_a0_a0_a1_em2 = 0 
+ a0_a0_a0_a1_em2 = 0 
+ b0_b0_a1_a1_em2 = -502 
+ a0_b0_a1_a1_em2 = 0.398 
+ b0_a0_a1_a1_em2 = 0 
+ a0_a0_a1_a1_em2 = 0 
+ b0_b0_a2_a1_em2 = -1520 
+ a0_b0_a2_a1_em2 = -0.915 
+ b0_a0_a2_a1_em2 = 0 
+ a0_a0_a2_a1_em2 = 0 
+ b0_b0_a3_a1_em2 = -1070 
+ a0_b0_a3_a1_em2 = 2.14 
+ b0_a0_a3_a1_em2 = 0 
+ a0_a0_a3_a1_em2 = 0 
+ b0_b0_a4_a1_em2 = 0 
+ a0_b0_a4_a1_em2 = 0 
+ b0_a0_a4_a1_em2 = 0 
+ a0_a0_a4_a1_em2 = 0 
+ b0_b0_p1_a1_em2 = -2.79 
+ a0_b0_p1_a1_em2 = 0.000263 
+ b0_a0_p1_a1_em2 = 0 
+ a0_a0_p1_a1_em2 = 0 
+ b0_b0_p2_a1_em2 = 2.54 
+ a0_b0_p2_a1_em2 = -0.00164 
+ b0_a0_p2_a1_em2 = 0 
+ a0_a0_p2_a1_em2 = 0 
+ b0_b0_p3_a1_em2 = 3.27 
+ a0_b0_p3_a1_em2 = -0.000853 
+ b0_a0_p3_a1_em2 = 0 
+ a0_a0_p3_a1_em2 = 0 
+ b0_b0_p4_a1_em2 = 4.9 
+ a0_b0_p4_a1_em2 = -0.0017 
+ b0_a0_p4_a1_em2 = 0 
+ a0_a0_p4_a1_em2 = 0 
+ b0_b0_b0_a2_em2 = 5700 
+ a0_b0_b0_a2_em2 = -1.7 
+ b0_a0_b0_a2_em2 = 0 
+ a0_a0_b0_a2_em2 = 0 
+ b0_b0_a0_a2_em2 = 0 
+ a0_b0_a0_a2_em2 = 0 
+ b0_a0_a0_a2_em2 = 0 
+ a0_a0_a0_a2_em2 = 0 
+ b0_b0_a1_a2_em2 = -1230 
+ a0_b0_a1_a2_em2 = 0.923 
+ b0_a0_a1_a2_em2 = 0 
+ a0_a0_a1_a2_em2 = 0 
+ b0_b0_a2_a2_em2 = 123 
+ a0_b0_a2_a2_em2 = 0.528 
+ b0_a0_a2_a2_em2 = 0 
+ a0_a0_a2_a2_em2 = 0 
+ b0_b0_a3_a2_em2 = -1720 
+ a0_b0_a3_a2_em2 = 1.83 
+ b0_a0_a3_a2_em2 = 0 
+ a0_a0_a3_a2_em2 = 0 
+ b0_b0_a4_a2_em2 = 0 
+ a0_b0_a4_a2_em2 = 0 
+ b0_a0_a4_a2_em2 = 0 
+ a0_a0_a4_a2_em2 = 0 
+ b0_b0_p1_a2_em2 = -1.45 
+ a0_b0_p1_a2_em2 = 0.00118 
+ b0_a0_p1_a2_em2 = 0 
+ a0_a0_p1_a2_em2 = 0 
+ b0_b0_p2_a2_em2 = -0.285 
+ a0_b0_p2_a2_em2 = 0.000212 
+ b0_a0_p2_a2_em2 = 0 
+ a0_a0_p2_a2_em2 = 0 
+ b0_b0_p3_a2_em2 = 2.72 
+ a0_b0_p3_a2_em2 = -0.0023 
+ b0_a0_p3_a2_em2 = 0 
+ a0_a0_p3_a2_em2 = 0 
+ b0_b0_p4_a2_em2 = 4 
+ a0_b0_p4_a2_em2 = 0 
+ b0_a0_p4_a2_em2 = 0 
+ a0_a0_p4_a2_em2 = 0 
+ b0_b0_b0_a3_em2 = 3160 
+ a0_b0_b0_a3_em2 = 0.264 
+ b0_a0_b0_a3_em2 = 0 
+ a0_a0_b0_a3_em2 = 0 
+ b0_b0_a0_a3_em2 = 0 
+ a0_b0_a0_a3_em2 = 0 
+ b0_a0_a0_a3_em2 = 0 
+ a0_a0_a0_a3_em2 = 0 
+ b0_b0_a1_a3_em2 = 311 
+ a0_b0_a1_a3_em2 = -1.12 
+ b0_a0_a1_a3_em2 = 0 
+ a0_a0_a1_a3_em2 = 0 
+ b0_b0_a2_a3_em2 = -2270 
+ a0_b0_a2_a3_em2 = 6.19 
+ b0_a0_a2_a3_em2 = 0 
+ a0_a0_a2_a3_em2 = 0 
+ b0_b0_a3_a3_em2 = -413 
+ a0_b0_a3_a3_em2 = -0.749 
+ b0_a0_a3_a3_em2 = 0 
+ a0_a0_a3_a3_em2 = 0 
+ b0_b0_a4_a3_em2 = 0 
+ a0_b0_a4_a3_em2 = 0 
+ b0_a0_a4_a3_em2 = 0 
+ a0_a0_a4_a3_em2 = 0 
+ b0_b0_p1_a3_em2 = -3.3 
+ a0_b0_p1_a3_em2 = 0.0102 
+ b0_a0_p1_a3_em2 = 0 
+ a0_a0_p1_a3_em2 = 0 
+ b0_b0_p2_a3_em2 = -1.15 
+ a0_b0_p2_a3_em2 = 0.0132 
+ b0_a0_p2_a3_em2 = 0 
+ a0_a0_p2_a3_em2 = 0 
+ b0_b0_p3_a3_em2 = -1.27 
+ a0_b0_p3_a3_em2 = 0.0126 
+ b0_a0_p3_a3_em2 = 0 
+ a0_a0_p3_a3_em2 = 0 
+ b0_b0_p4_a3_em2 = 4.5 
+ a0_b0_p4_a3_em2 = 0 
+ b0_a0_p4_a3_em2 = 0 
+ a0_a0_p4_a3_em2 = 0 
+ b0_b0_b0_a4_em2 = 2230 
+ a0_b0_b0_a4_em2 = 0.075 
+ b0_a0_b0_a4_em2 = -0.0157 
+ a0_a0_b0_a4_em2 = 0.00113 
+ b0_b0_a0_a4_em2 = 0 
+ a0_b0_a0_a4_em2 = 0 
+ b0_a0_a0_a4_em2 = 0 
+ a0_a0_a0_a4_em2 = 0 
+ b0_b0_a1_a4_em2 = 242 
+ a0_b0_a1_a4_em2 = -0.625 
+ b0_a0_a1_a4_em2 = 1.14 
+ a0_a0_a1_a4_em2 = -0.00266 
+ b0_b0_a2_a4_em2 = 11.8 
+ a0_b0_a2_a4_em2 = -0.239 
+ b0_a0_a2_a4_em2 = 0 
+ a0_a0_a2_a4_em2 = 9.01E-05 
+ b0_b0_a3_a4_em2 = 1540 
+ a0_b0_a3_a4_em2 = 16.4 
+ b0_a0_a3_a4_em2 = -0.000875 
+ a0_a0_a3_a4_em2 = -0.19 
+ b0_b0_a4_a4_em2 = 0 
+ a0_b0_a4_a4_em2 = 0 
+ b0_a0_a4_a4_em2 = 0 
+ a0_a0_a4_a4_em2 = 0 
+ b0_b0_p1_a4_em2 = -0.58 
+ a0_b0_p1_a4_em2 = 0.000326 
+ b0_a0_p1_a4_em2 = 0.109 
+ a0_a0_p1_a4_em2 = -0.000229 
+ b0_b0_p2_a4_em2 = -2.55 
+ a0_b0_p2_a4_em2 = 0.0103 
+ b0_a0_p2_a4_em2 = 0.0581 
+ a0_a0_p2_a4_em2 = -0.00014 
+ b0_b0_p3_a4_em2 = -4.34 
+ a0_b0_p3_a4_em2 = 0.037 
+ b0_a0_p3_a4_em2 = -8.81E-05 
+ a0_a0_p3_a4_em2 = -1.12E-05 
+ b0_b0_p4_a4_em2 = -4.38 
+ a0_b0_p4_a4_em2 = 0.0463 
+ b0_a0_p4_a4_em2 = 0 
+ a0_a0_p4_a4_em2 = 0 
+ b0_b0_b0_p1_em2 = 0.07 
+ a0_b0_b0_p1_em2 = 0 
+ b0_a0_b0_p1_em2 = 0 
+ a0_a0_b0_p1_em2 = 0 
+ b0_b0_a0_p1_em2 = 0 
+ a0_b0_a0_p1_em2 = 0 
+ b0_a0_a0_p1_em2 = 0 
+ a0_a0_a0_p1_em2 = 0 
+ b0_b0_a1_p1_em2 = 0.753 
+ a0_b0_a1_p1_em2 = 0 
+ b0_a0_a1_p1_em2 = 0 
+ a0_a0_a1_p1_em2 = 0 
+ b0_b0_a2_p1_em2 = 1.20E-08 
+ a0_b0_a2_p1_em2 = 0 
+ b0_a0_a2_p1_em2 = 0 
+ a0_a0_a2_p1_em2 = 0 
+ b0_b0_a3_p1_em2 = 7.53E-12 
+ a0_b0_a3_p1_em2 = 0 
+ b0_a0_a3_p1_em2 = 0 
+ a0_a0_a3_p1_em2 = 0 
+ b0_b0_a4_p1_em2 = 0 
+ a0_b0_a4_p1_em2 = 0 
+ b0_a0_a4_p1_em2 = 0 
+ a0_a0_a4_p1_em2 = 0 
+ b0_b0_p1_p1_em2 = -0.172 
+ a0_b0_p1_p1_em2 = 0 
+ b0_a0_p1_p1_em2 = 0 
+ a0_a0_p1_p1_em2 = 0 
+ b0_b0_p2_p1_em2 = 1.9 
+ a0_b0_p2_p1_em2 = 0 
+ b0_a0_p2_p1_em2 = 0 
+ a0_a0_p2_p1_em2 = 0 
+ b0_b0_p3_p1_em2 = 2 
+ a0_b0_p3_p1_em2 = 0 
+ b0_a0_p3_p1_em2 = 0 
+ a0_a0_p3_p1_em2 = 0 
+ b0_b0_p4_p1_em2 = 3 
+ a0_b0_p4_p1_em2 = 0 
+ b0_a0_p4_p1_em2 = 0 
+ a0_a0_p4_p1_em2 = 0 
+ b0_b0_b0_p2_em2 = 14.1 
+ a0_b0_b0_p2_em2 = 0.00409 
+ b0_a0_b0_p2_em2 = 0 
+ a0_a0_b0_p2_em2 = 0 
+ b0_b0_a0_p2_em2 = 0 
+ a0_b0_a0_p2_em2 = 0 
+ b0_a0_a0_p2_em2 = 0 
+ a0_a0_a0_p2_em2 = 0 
+ b0_b0_a1_p2_em2 = 1.03 
+ a0_b0_a1_p2_em2 = -0.00161 
+ b0_a0_a1_p2_em2 = 0 
+ a0_a0_a1_p2_em2 = 0 
+ b0_b0_a2_p2_em2 = -2.27 
+ a0_b0_a2_p2_em2 = 0.00625 
+ b0_a0_a2_p2_em2 = 0 
+ a0_a0_a2_p2_em2 = 0 
+ b0_b0_a3_p2_em2 = 1.64 
+ a0_b0_a3_p2_em2 = -0.0103 
+ b0_a0_a3_p2_em2 = 0 
+ a0_a0_a3_p2_em2 = 0 
+ b0_b0_a4_p2_em2 = 0 
+ a0_b0_a4_p2_em2 = 0 
+ b0_a0_a4_p2_em2 = 0 
+ a0_a0_a4_p2_em2 = 0 
+ b0_b0_p1_p2_em2 = -1 
+ a0_b0_p1_p2_em2 = 0 
+ b0_a0_p1_p2_em2 = 0 
+ a0_a0_p1_p2_em2 = 0 
+ b0_b0_p2_p2_em2 = 2.02 
+ a0_b0_p2_p2_em2 = -0.000541 
+ b0_a0_p2_p2_em2 = 0 
+ a0_a0_p2_p2_em2 = 0 
+ b0_b0_p3_p2_em2 = 3.04 
+ a0_b0_p3_p2_em2 = -0.000317 
+ b0_a0_p3_p2_em2 = 0 
+ a0_a0_p3_p2_em2 = 0 
+ b0_b0_p4_p2_em2 = 3.96 
+ a0_b0_p4_p2_em2 = -0.000614 
+ b0_a0_p4_p2_em2 = 0 
+ a0_a0_p4_p2_em2 = 0 
+ b0_b0_b0_p3_em2 = 6.79 
+ a0_b0_b0_p3_em2 = 0.0318 
+ b0_a0_b0_p3_em2 = 0 
+ a0_a0_b0_p3_em2 = 0 
+ b0_b0_a0_p3_em2 = 0 
+ a0_b0_a0_p3_em2 = 0 
+ b0_a0_a0_p3_em2 = 0 
+ a0_a0_a0_p3_em2 = 0 
+ b0_b0_a1_p3_em2 = 2.59 
+ a0_b0_a1_p3_em2 = 0.00113 
+ b0_a0_a1_p3_em2 = 0 
+ a0_a0_a1_p3_em2 = 0 
+ b0_b0_a2_p3_em2 = -0.142 
+ a0_b0_a2_p3_em2 = 0.00058 
+ b0_a0_a2_p3_em2 = 0 
+ a0_a0_a2_p3_em2 = 0 
+ b0_b0_a3_p3_em2 = -5.83 
+ a0_b0_a3_p3_em2 = 0.00774 
+ b0_a0_a3_p3_em2 = 0 
+ a0_a0_a3_p3_em2 = 0 
+ b0_b0_a4_p3_em2 = 0 
+ a0_b0_a4_p3_em2 = 0 
+ b0_a0_a4_p3_em2 = 0 
+ a0_a0_a4_p3_em2 = 0 
+ b0_b0_p1_p3_em2 = -6.44 
+ a0_b0_p1_p3_em2 = 0.0106 
+ b0_a0_p1_p3_em2 = 0 
+ a0_a0_p1_p3_em2 = 0 
+ b0_b0_p2_p3_em2 = -0.0982 
+ a0_b0_p2_p3_em2 = -0.000827 
+ b0_a0_p2_p3_em2 = 0 
+ a0_a0_p2_p3_em2 = 0 
+ b0_b0_p3_p3_em2 = 5.54 
+ a0_b0_p3_p3_em2 = -0.00496 
+ b0_a0_p3_p3_em2 = 0 
+ a0_a0_p3_p3_em2 = 0 
+ b0_b0_p4_p3_em2 = 4.15 
+ a0_b0_p4_p3_em2 = 0.00794 
+ b0_a0_p4_p3_em2 = 0 
+ a0_a0_p4_p3_em2 = 0 
+ b0_b0_b0_p4_em2 = 37.3 
+ a0_b0_b0_p4_em2 = 0.000597 
+ b0_a0_b0_p4_em2 = 0.0329 
+ a0_a0_b0_p4_em2 = -8.93E-05 
+ b0_b0_a0_p4_em2 = 0 
+ a0_b0_a0_p4_em2 = 0 
+ b0_a0_a0_p4_em2 = 0 
+ a0_a0_a0_p4_em2 = 0 
+ b0_b0_a1_p4_em2 = -72.8 
+ a0_b0_a1_p4_em2 = 0.305 
+ b0_a0_a1_p4_em2 = -0.455 
+ a0_a0_a1_p4_em2 = -5.93E-05 
+ b0_b0_a2_p4_em2 = -2.04 
+ a0_b0_a2_p4_em2 = 0.00132 
+ b0_a0_a2_p4_em2 = -0.0189 
+ a0_a0_a2_p4_em2 = 4.39E-05 
+ b0_b0_a3_p4_em2 = 23.5 
+ a0_b0_a3_p4_em2 = -0.0792 
+ b0_a0_a3_p4_em2 = -0.157 
+ a0_a0_a3_p4_em2 = 0.000532 
+ b0_b0_a4_p4_em2 = 0 
+ a0_b0_a4_p4_em2 = 0 
+ b0_a0_a4_p4_em2 = 0 
+ a0_a0_a4_p4_em2 = 0 
+ b0_b0_p1_p4_em2 = 2.28 
+ a0_b0_p1_p4_em2 = -0.00342 
+ b0_a0_p1_p4_em2 = 0.0392 
+ a0_a0_p1_p4_em2 = -9.06E-05 
+ b0_b0_p2_p4_em2 = 2.33 
+ a0_b0_p2_p4_em2 = -0.00345 
+ b0_a0_p2_p4_em2 = 0.0389 
+ a0_a0_p2_p4_em2 = -8.94E-05 
+ b0_b0_p3_p4_em2 = 1.22 
+ a0_b0_p3_p4_em2 = 0.00555 
+ b0_a0_p3_p4_em2 = -0.014 
+ a0_a0_p3_p4_em2 = 2.67E-05 
+ b0_b0_p4_p4_em2 = 5.44 
+ a0_b0_p4_p4_em2 = -0.00233 
+ b0_a0_p4_p4_em2 = -0.00146 
+ a0_a0_p4_p4_em2 = 6.28E-06 
}
endsection pld45b_10hv_dfrt

section clgo_box_sub_10hv_dfrt
include "soachecks_top.scs" section=clgo_box_sub_10hv_soa
endsection clgo_box_sub_10hv_dfrt

section cpwtub_box_sub_10hv_dfrt
include "soachecks_top.scs" section=cpwtub_box_sub_10hv_soa
endsection cpwtub_box_sub_10hv_dfrt

section cpwtub_box_sub_float_10hv_dfrt
include "soachecks_top.scs" section=cpwtub_box_sub_float_10hv_soa
endsection cpwtub_box_sub_float_10hv_dfrt

section cnwtub_box_sub_10hv_dfrt
include "soachecks_top.scs" section=cnwtub_box_sub_10hv_soa
endsection cnwtub_box_sub_10hv_dfrt

section cdgoptub_box_sub_10hv_dfrt
include "soachecks_top.scs" section=cdgoptub_box_sub_10hv_soa
endsection cdgoptub_box_sub_10hv_dfrt

section cdgontub_box_sub_10hv_dfrt
include "soachecks_top.scs" section=cdgontub_box_sub_10hv_soa
endsection cdgontub_box_sub_10hv_dfrt

section dz5_10hv_dfrt
include "soachecks_top.scs" section=dz5_10hv_soa
if (enable_esdsoa == 1) {
adz5_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dz5_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0
adz5_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dz5_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adz5_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_dz5_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adz5_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_dz5_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection dz5_10hv_dfrt

section drsf45_10hv_dfrt
include "soachecks_top.scs" section=drsf45b_10hv_soa
if (enable_esdsoa == 1) {
adrsf45_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_drsf45_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 61.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=61.7
adrsf45_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_drsf45_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adrsf45_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_drsf45_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adrsf45_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_drsf45_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection drsf45_10hv_dfrt

section drsf45b_10hv_dfrt
include "soachecks_top.scs" section=drsf45b_10hv_soa
if (enable_esdsoa == 1) {
adrsf45b_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_drsf45b_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 60.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=60.5
adrsf45b_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_drsf45b_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adrsf45b_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_drsf45b_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adrsf45b_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_drsf45b_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection drsf45b_10hv_dfrt

section drsf90_10hv_dfrt
include "soachecks_top.scs" section=drsf90b_10hv_soa
if (enable_esdsoa == 1) {
adrsf90_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_drsf90_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 112.8 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=112.8
adrsf90_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_drsf90_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adrsf90_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_drsf90_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adrsf90_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_drsf90_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection drsf90_10hv_dfrt

section drsf90b_10hv_dfrt
include "soachecks_top.scs" section=drsf90b_10hv_soa
if (enable_esdsoa == 1) {
adrsf90b_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_drsf90b_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 109.1 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=109.1
adrsf90b_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_drsf90b_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adrsf90b_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_drsf90b_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adrsf90b_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_drsf90b_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection drsf90b_10hv_dfrt

section dnplus_10hv_dfrt
include "soachecks_top.scs" section=dnplus_10hv_soa
if (enable_esdsoa == 1) {
adnplus_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dnplus_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 8.1 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=8.1
adnplus_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dnplus_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection dnplus_10hv_dfrt

section dpplus_10hv_dfrt
include "soachecks_top.scs" section=dpplus_10hv_soa
if (enable_esdsoa == 1) {
adpplus_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dpplus_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 8.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=8.3
adpplus_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dpplus_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection dpplus_10hv_dfrt

section dnfet_10hv_dfrt
include "soachecks_top.scs" section=dnfet_10hv_soa
if (enable_esdsoa == 1) {
adnfet_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dnfet_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 10.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.3
adnfet_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dnfet_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adnfet_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_dnfet_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adnfet_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_dnfet_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection dnfet_10hv_dfrt

section dpfet_10hv_dfrt
include "soachecks_top.scs" section=dpfet_10hv_soa
if (enable_esdsoa == 1) {
adpfet_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dpfet_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 10.9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.9
adpfet_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dpfet_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adpfet_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_dpfet_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adpfet_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_dpfet_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection dpfet_10hv_dfrt

section cdp_10hv_dfrt
include "soachecks_top.scs" section=cdp_10hv_soa
if (enable_esdsoa == 1) {
acdp_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cdp_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 24.1 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=24.1
acdp_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cdp_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acdp_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cdp_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cdp_10hv_dfrt

section cdpf_10hv_dfrt
include "soachecks_top.scs" section=cdp_10hv_soa
if (enable_esdsoa == 1) {
acdpf_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cdpf_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 24.1 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=24.1
acdpf_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cdpf_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acdpf_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cdpf_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cdpf_10hv_dfrt

section cdpf_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cdp_10hv_soa
if (enable_esdsoa == 1) {
acdpf_m1m2m3_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cdpf_m1m2m3_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 24.1 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=24.1
acdpf_m1m2m3_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cdpf_m1m2m3_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acdpf_m1m2m3_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cdpf_m1m2m3_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cdpf_m1m2m3_10hv_dfrt

section cglv_10hv_dfrt
include "soachecks_top.scs" section=cglv_10hv_soa
if (enable_esdsoa == 1) {
acglv_10hv_esdchk_1 (t nw) monitor2t enable=soa rule="esd_cglv_Vtnw_maxV" targetT=0.0 formulae_cond1="absV(t-to-nw) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
acglv_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cglv_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acglv_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cglv_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cglv_10hv_dfrt

section cghv_10hv_dfrt
include "soachecks_top.scs" section=cghv_10hv_soa
if (enable_esdsoa == 1) {
acghv_10hv_esdchk_1 (t nw) monitor2t enable=soa rule="esd_cghv_Vtnw_maxV" targetT=0.0 formulae_cond1="absV(t-to-nw) > 16.6 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.6
acghv_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cghv_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acghv_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cghv_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cghv_10hv_dfrt

section cghvf_10hv_dfrt
include "soachecks_top.scs" section=cghv_10hv_soa
if (enable_esdsoa == 1) {
acghvf_10hv_esdchk_1 (t nw) monitor2t enable=soa rule="esd_cghvf_Vtnw_maxV" targetT=0.0 formulae_cond1="absV(t-to-nw) > 16.6 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.6
acghvf_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cghvf_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acghvf_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cghvf_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cghvf_10hv_dfrt

section cghvf_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cghv_10hv_soa
if (enable_esdsoa == 1) {
acghvf_m1m2m3_10hv_esdchk_1 (t nw) monitor2t enable=soa rule="esd_cghvf_m1m2m3_Vtnw_maxV" targetT=0.0 formulae_cond1="absV(t-to-nw) > 16.6 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.6
acghvf_m1m2m3_10hv_esdchk_2 (nw sub) monitor2t enable=soa rule="esd_cghvf_m1m2m3_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acghvf_m1m2m3_10hv_esdchk_3 (sub nw) monitor2t enable=soa rule="esd_cghvf_m1m2m3_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cghvf_m1m2m3_10hv_dfrt

section cfrlv_10hv_dfrt
include "soachecks_top.scs" section=cfrlv_10hv_soa
if (enable_esdsoa == 1) {
acfrlv_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfrlv_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 183.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=183.8
acfrlv_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfrlv_Vtwell_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfrlv_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfrlv_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfrlv_10hv_dfrt

section cfrlv_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cfrlv_10hv_soa
if (enable_esdsoa == 1) {
acfrlv_m1m2m3_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfrlv_m1m2m3_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 183.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=183.8
acfrlv_m1m2m3_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfrlv_m1m2m3_Vtwell_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfrlv_m1m2m3_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfrlv_m1m2m3_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfrlv_m1m2m3_10hv_dfrt

section cfr45_10hv_dfrt
include "soachecks_top.scs" section=cfr45_10hv_soa
if (enable_esdsoa == 1) {
acfr45_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr45_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr45_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr45_Vtwell_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr45_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr45_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr45_10hv_dfrt

section cfr45_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cfr45_10hv_soa
if (enable_esdsoa == 1) {
acfr45_m1m2m3_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr45_m1m2m3_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr45_m1m2m3_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr45_m1m2m3_Vtwell_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr45_m1m2m3_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr45_m1m2m3_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr45_m1m2m3_10hv_dfrt

section cfr90_10hv_dfrt
include "soachecks_top.scs" section=cfr90_10hv_soa
if (enable_esdsoa == 1) {
acfr90_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr90_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr90_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr90_Vtwellsub_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr90_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr90_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr90_10hv_dfrt

section cfr90_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cfr90_10hv_soa
if (enable_esdsoa == 1) {
acfr90_m1m2m3_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr90_m1m2m3_Vtb_maxV" targetT=0.0 formulae_cond1="absV(t-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr90_m1m2m3_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr90_m1m2m3_Vtwellsub_maxV" targetT=0.0 formulae_cond1="V(t-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr90_m1m2m3_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr90_m1m2m3_Vbwell_maxV" targetT=0.0 formulae_cond1="V(b-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr90_m1m2m3_10hv_dfrt

section npn_10hv_dfrt
include "soachecks_top.scs" section=npn_b_10hv_soa
if (enable_esdsoa == 1) {
anpn_10hv_esdchk_1 (c b) monitor2t enable=soa rule="esd_npn_Vcb_maxV" targetT=0.0 formulae_cond1="V(c-to-b) > 60.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=60.4
anpn_10hv_esdchk_2 (e b) monitor2t enable=soa rule="esd_npn_Veb_maxV" targetT=0.0 formulae_cond1="V(e-to-b) > 17.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=17.4
anpn_10hv_esdchk_3 (c e) monitor2t enable=soa rule="esd_npn_Vce_maxV" targetT=0.0 formulae_cond1="V(c-to-e) > 29.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=29.3
anpn_10hv_esdchk_4 (c sub) monitor2t enable=soa rule="esd_npn_Vcsub_maxV" targetT=0.0 formulae_cond1="V(c-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
anpn_10hv_esdchk_5 (sub e) monitor2t enable=soa rule="esd_npn_Vsube_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-e) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection npn_10hv_dfrt

section pnp_10hv_dfrt
include "soachecks_top.scs" section=pnp_10hv_soa
if (enable_relimo == 1) {
apnp_10hv_aging (b e) relimo_aging_pnp w=we l=le relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo relimo_pnp_aging_open_flag=relimo_pnp_aging_open_flag 
}
if (enable_esdsoa == 1) {
apnp_10hv_esdchk_1 (b c) monitor2t enable=soa rule="esd_pnp_Vcb_maxV" targetT=0.0 formulae_cond1="V(b-to-c) > 57 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=57
apnp_10hv_esdchk_2 (b e) monitor2t enable=soa rule="esd_pnp_Veb_maxV" targetT=0.0 formulae_cond1="V(b-to-e) > 21.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=21.3
apnp_10hv_esdchk_3 (e c) monitor2t enable=soa rule="esd_pnp_Vce_maxV" targetT=0.0 formulae_cond1="V(e-to-c) > 57 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=57
apnp_10hv_esdchk_4 (e sub) monitor2t enable=soa rule="esd_pnp_Vesub_maxV" targetT=0.0 formulae_cond1="V(e-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
apnp_10hv_esdchk_5 (sub c) monitor2t enable=soa rule="esd_pnp_Vsubc_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-c) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
if (enable_aging == 1) {
// bjt aging checking
  rvbe (0 b e 0 0) mrvbesim2
+ damage    = rvbedamage
+ swmextram = 0
+ type      = -1
+ l         = le*1e-6
+ w         = we*1e-6
+ active    = presto_active * presto_device_active * presto_rvbe_active
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ fstat     = pow(0.00966,-0.2)
+ k         = pow(4.01E-38,0.2)*0.0000166
+ n         = 0.2
+ alpha     = 33.2*0.2
+ c         = 0
+ ea        = 0
}
endsection pnp_10hv_dfrt

section pnp_iso_10hv_dfrt
include "soachecks_top.scs" section=pnp_iso_10hv_soa
if (enable_relimo == 1) {
apnp_iso_10hv_aging (b e) relimo_aging_pnp w=we l=le relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo relimo_pnp_aging_open_flag=relimo_pnp_aging_open_flag 
}
if (enable_esdsoa == 1) {
apnp_iso_10hv_esdchk_1 (b c) monitor2t enable=soa rule="esd_pnp_iso_Vcb_maxV" targetT=0.0 formulae_cond1="V(b-to-c) > 57 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=57
apnp_iso_10hv_esdchk_2 (b e) monitor2t enable=soa rule="esd_pnp_iso_Veb_maxV" targetT=0.0 formulae_cond1="V(b-to-e) > 21.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=21.3
apnp_iso_10hv_esdchk_3 (e c) monitor2t enable=soa rule="esd_pnp_iso_Vce_maxV" targetT=0.0 formulae_cond1="V(e-to-c) > 57 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=57
apnp_iso_10hv_esdchk_4 (iso c) monitor2t enable=soa rule="esd_pnp_iso_Visoc_maxV" targetT=0.0 formulae_cond1="V(iso-to-c) > 57 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=57
apnp_iso_10hv_esdchk_5 (e sub) monitor2t enable=soa rule="esd_pnp_iso_Vesub_maxV" targetT=0.0 formulae_cond1="V(e-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
apnp_iso_10hv_esdchk_6 (sub c) monitor2t enable=soa rule="esd_pnp_iso_Vsubc_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-c) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
if (enable_aging == 1) {
// bjt aging checking
  rvbe (0 b e 0 0) mrvbesim2
+ damage    = rvbedamage
+ swmextram = 0
+ type      = -1
+ l         = le*1e-6
+ w         = we*1e-6
+ active    = presto_active * presto_device_active * presto_rvbe_active
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ fstat     = pow(0.00966,-0.2)
+ k         = pow(4.01E-38,0.2)*0.0000166
+ n         = 0.2
+ alpha     = 33.2*0.2
+ c         = 0
+ ea        = 0
}
endsection pnp_iso_10hv_dfrt

section dnsd_lvpw_10hv_dfrt
endsection dnsd_lvpw_10hv_dfrt

section dpsd_lvnw_10hv_dfrt
endsection dpsd_lvnw_10hv_dfrt

section dnsd_phv_10hv_dfrt
endsection dnsd_phv_10hv_dfrt

section dpsd_nhv_10hv_dfrt
endsection dpsd_nhv_10hv_dfrt

section dnw_pepi_10hv_dfrt
endsection dnw_pepi_10hv_dfrt

section dnw_pepi_tr_10hv_dfrt
endsection dnw_pepi_tr_10hv_dfrt

section dnhv_pepi_tr_10hv_dfrt
endsection dnhv_pepi_tr_10hv_dfrt

section dnbl_pepi_tr_10hv_dfrt
endsection dnbl_pepi_tr_10hv_dfrt

section nmos_10hv_dfrt
include "soachecks_top.scs" section=nmos_10hv_soa
if (enable_relimo == 1) {
anmos_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.09 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos_10hv relimo_probe_name=mnmos_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos_10hv relimo_c=relimo_c_1_hci_nmos_10hv relimo_condvd=relimo_condvd_hci_nmos_10hv relimo_condvg=relimo_condvg_hci_nmos_10hv relimo_intercept=relimo_intercept_1_hci_nmos_10hv relimo_m=relimo_m_1_hci_nmos_10hv relimo_n=relimo_n_1_hci_nmos_10hv relimo_r=relimo_r_1_hci_nmos_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos_10hv relimo_vth=relimo_vth_hci_nmos_10hv
anmos_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos_10hv relimo_probe_name=mnmos_10hv_i
}
if (enable_esdsoa == 1) {
anmos_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos_10hv ruleNum=1 enable=soa rule="esd_nmos_Vt1=5p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-5.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos_10hv ruleNum=2 enable=soa rule="esd_nmos_Vt1>5p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 5.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.1
anmos_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos_10hv ruleNum=3 enable=soa rule="esd_nmos_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-0.0))-5.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos_10hv ruleNum=4 enable=soa rule="esd_nmos_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-0.0))) > 5.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.1
anmos_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos_10hv ruleNum=5 enable=soa rule="esd_nmos_Vt1=4p5_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos_10hv ruleNum=6 enable=soa rule="esd_nmos_Vt1>4p5_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos_10hv ruleNum=7 enable=soa rule="esd_nmos_=Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_10hv_esdchk_8 (g s d s) monitor4t enable=soa rule="esd_nmos_>Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_nmos_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_nmos_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_nmos_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_10hv_esdchk_12 (s b) monitor2t enable=soa rule="esd_nmos_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
anmos_10hv_esdchk_13 (d b) monitor2t enable=soa rule="esd_nmos_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.1 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.1
anmos_10hv_esdchk_14 (d sub) monitor2t enable=soa rule="esd_nmos_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_10hv_esdchk_15 (sub b) monitor2t enable=soa rule="esd_nmos_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_10hv_esdchk_16 (b d) monitor2t enable=soa rule="esd_nmos_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos_avth
+ bvth      = presto_hci_nmos_bvth
+ ai        = presto_hci_nmos_ai
+ bi        = presto_hci_nmos_bi
+ nvth      = presto_hci_nmos_n_vth
+ ni        = presto_hci_nmos_n_i
+ gammai    = presto_hci_nmos_gammai
+ alphamve  = presto_hci_nmos_alphamve
+ fstatmve  = presto_hci_nmos_fstatmve
+ vdpowmve  = presto_hci_nmos_vdpowmve
+ vgpowmve  = presto_hci_nmos_vgpowmve
+ vdexpmve  = presto_hci_nmos_vdexpmve
+ eamve     = presto_hci_nmos_eamve
+ lexpmve   = presto_hci_nmos_lexpmve
+ lpowmve   = presto_hci_nmos_lpowmve
+ wpowmve   = presto_hci_nmos_wpowmve
+ vbsexpmve = presto_hci_nmos_vbsexpmve
+ vc1mve    = presto_hci_nmos_vc1mve
+ vc2mve    = presto_hci_nmos_vc2mve
+ alphahe   = presto_hci_nmos_alphahe
+ fstathe   = presto_hci_nmos_fstathe
+ vdpowhe   = presto_hci_nmos_vdpowhe
+ vgpowhe   = presto_hci_nmos_vgpowhe
+ vdexphe   = presto_hci_nmos_vdexphe
+ eahe      = presto_hci_nmos_eahe
+ lexphe    = presto_hci_nmos_lexphe
+ lpowhe    = presto_hci_nmos_lpowhe
+ wpowhe    = presto_hci_nmos_wpowhe
+ vbsexphe  = presto_hci_nmos_vbsexphe
+ vc1he     = presto_hci_nmos_vc1he
+ vc2he     = presto_hci_nmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos_10hv_dfrt

section nmos_ll_10hv_dfrt
include "soachecks_top.scs" section=nmos_ll_10hv_soa
if (enable_relimo == 1) {
anmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.2 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos_ll_10hv relimo_probe_name=mnmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos_ll_10hv relimo_c=relimo_c_1_hci_nmos_ll_10hv relimo_condvd=relimo_condvd_hci_nmos_ll_10hv relimo_condvg=relimo_condvg_hci_nmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_nmos_ll_10hv relimo_m=relimo_m_1_hci_nmos_ll_10hv relimo_n=relimo_n_1_hci_nmos_ll_10hv relimo_r=relimo_r_1_hci_nmos_ll_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos_ll_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos_ll_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos_ll_10hv relimo_vth=relimo_vth_hci_nmos_ll_10hv
anmos_ll_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos_ll_10hv relimo_probe_name=mnmos_ll_10hv_i
}
if (enable_esdsoa == 1) {
anmos_ll_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=1 enable=soa rule="esd_nmos_ll_Vt1=5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ll_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=2 enable=soa rule="esd_nmos_ll_Vt1>5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 5.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
anmos_ll_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=3 enable=soa rule="esd_nmos_ll_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-0.0))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ll_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=4 enable=soa rule="esd_nmos_ll_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-0.0))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
anmos_ll_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=5 enable=soa rule="esd_nmos_ll_Vt1=4p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-4.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ll_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=6 enable=soa rule="esd_nmos_ll_Vt1>4p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 4.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.6
anmos_ll_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=7 enable=soa rule="esd_nmos_ll_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))-4.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ll_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=8 enable=soa rule="esd_nmos_ll_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))) > 4.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=4.6
anmos_ll_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=9 enable=soa rule="esd_nmos_ll_Vt1=4p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ll_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=10 enable=soa rule="esd_nmos_ll_Vt1>4p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_ll_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos_ll_10hv ruleNum=11 enable=soa rule="esd_nmos_ll_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ll_10hv_esdchk_12 (g s d s) monitor4t enable=soa rule="esd_nmos_ll_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_ll_10hv_esdchk_13 (g b) monitor2t enable=soa rule="esd_nmos_ll_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ll_10hv_esdchk_14 (g s) monitor2t enable=soa rule="esd_nmos_ll_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ll_10hv_esdchk_15 (g d) monitor2t enable=soa rule="esd_nmos_ll_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ll_10hv_esdchk_16 (s b) monitor2t enable=soa rule="esd_nmos_ll_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
anmos_ll_10hv_esdchk_17 (d b) monitor2t enable=soa rule="esd_nmos_ll_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
anmos_ll_10hv_esdchk_18 (d sub) monitor2t enable=soa rule="esd_nmos_ll_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ll_10hv_esdchk_19 (sub b) monitor2t enable=soa rule="esd_nmos_ll_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ll_10hv_esdchk_20 (b d) monitor2t enable=soa rule="esd_nmos_ll_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos_avth
+ bvth      = presto_hci_nmos_bvth
+ ai        = presto_hci_nmos_ai
+ bi        = presto_hci_nmos_bi
+ nvth      = presto_hci_nmos_n_vth
+ ni        = presto_hci_nmos_n_i
+ gammai    = presto_hci_nmos_gammai
+ alphamve  = presto_hci_nmos_alphamve
+ fstatmve  = presto_hci_nmos_fstatmve
+ vdpowmve  = presto_hci_nmos_vdpowmve
+ vgpowmve  = presto_hci_nmos_vgpowmve
+ vdexpmve  = presto_hci_nmos_vdexpmve
+ eamve     = presto_hci_nmos_eamve
+ lexpmve   = presto_hci_nmos_lexpmve
+ lpowmve   = presto_hci_nmos_lpowmve
+ wpowmve   = presto_hci_nmos_wpowmve
+ vbsexpmve = presto_hci_nmos_vbsexpmve
+ vc1mve    = presto_hci_nmos_vc1mve
+ vc2mve    = presto_hci_nmos_vc2mve
+ alphahe   = presto_hci_nmos_alphahe
+ fstathe   = presto_hci_nmos_fstathe
+ vdpowhe   = presto_hci_nmos_vdpowhe
+ vgpowhe   = presto_hci_nmos_vgpowhe
+ vdexphe   = presto_hci_nmos_vdexphe
+ eahe      = presto_hci_nmos_eahe
+ lexphe    = presto_hci_nmos_lexphe
+ lpowhe    = presto_hci_nmos_lpowhe
+ wpowhe    = presto_hci_nmos_wpowhe
+ vbsexphe  = presto_hci_nmos_vbsexphe
+ vc1he     = presto_hci_nmos_vc1he
+ vc2he     = presto_hci_nmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos_ll_10hv_dfrt

section nmos_ull_10hv_dfrt
include "soachecks_top.scs" section=nmos_ull_10hv_soa
if (enable_relimo == 1) {
anmos_ull_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.2 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos_ll_10hv relimo_probe_name=mnmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos_ll_10hv relimo_c=relimo_c_1_hci_nmos_ll_10hv relimo_condvd=relimo_condvd_hci_nmos_ll_10hv relimo_condvg=relimo_condvg_hci_nmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_nmos_ll_10hv relimo_m=relimo_m_1_hci_nmos_ll_10hv relimo_n=relimo_n_1_hci_nmos_ll_10hv relimo_r=relimo_r_1_hci_nmos_ll_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos_ull_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos_ull_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos_ll_10hv relimo_vth=relimo_vth_hci_nmos_ll_10hv
anmos_ull_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos_ll_10hv relimo_probe_name=mnmos_ll_10hv_i
}
if (enable_esdsoa == 1) {
anmos_ull_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=1 enable=soa rule="esd_nmos_ull_Vt1=5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ull_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=2 enable=soa rule="esd_nmos_ull_Vt1>5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 5.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
anmos_ull_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=3 enable=soa rule="esd_nmos_ull_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-0.0))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ull_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=4 enable=soa rule="esd_nmos_ull_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-0.0))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
anmos_ull_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=5 enable=soa rule="esd_nmos_ull_Vt1=4p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-4.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ull_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=6 enable=soa rule="esd_nmos_ull_Vt1>4p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 4.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.6
anmos_ull_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=7 enable=soa rule="esd_nmos_ull_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))-4.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ull_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=8 enable=soa rule="esd_nmos_ull_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))) > 4.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=4.6
anmos_ull_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=9 enable=soa rule="esd_nmos_ull_Vt1=4p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ull_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=10 enable=soa rule="esd_nmos_ull_Vt1>4p5_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_ull_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos_ull_10hv ruleNum=11 enable=soa rule="esd_nmos_ull_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(d)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ull_10hv_esdchk_12 (g s d s) monitor4t enable=soa rule="esd_nmos_ull_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(d-to-s) > 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.5
anmos_ull_10hv_esdchk_13 (g b) monitor2t enable=soa rule="esd_nmos_ull_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ull_10hv_esdchk_14 (g s) monitor2t enable=soa rule="esd_nmos_ull_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ull_10hv_esdchk_15 (g d) monitor2t enable=soa rule="esd_nmos_ull_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ull_10hv_esdchk_16 (s b) monitor2t enable=soa rule="esd_nmos_ull_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
anmos_ull_10hv_esdchk_17 (d b) monitor2t enable=soa rule="esd_nmos_ull_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
anmos_ull_10hv_esdchk_18 (d sub) monitor2t enable=soa rule="esd_nmos_ull_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ull_10hv_esdchk_19 (sub b) monitor2t enable=soa rule="esd_nmos_ull_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ull_10hv_esdchk_20 (b d) monitor2t enable=soa rule="esd_nmos_ull_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos_avth
+ bvth      = presto_hci_nmos_bvth
+ ai        = presto_hci_nmos_ai
+ bi        = presto_hci_nmos_bi
+ nvth      = presto_hci_nmos_n_vth
+ ni        = presto_hci_nmos_n_i
+ gammai    = presto_hci_nmos_gammai
+ alphamve  = presto_hci_nmos_alphamve
+ fstatmve  = presto_hci_nmos_fstatmve
+ vdpowmve  = presto_hci_nmos_vdpowmve
+ vgpowmve  = presto_hci_nmos_vgpowmve
+ vdexpmve  = presto_hci_nmos_vdexpmve
+ eamve     = presto_hci_nmos_eamve
+ lexpmve   = presto_hci_nmos_lexpmve
+ lpowmve   = presto_hci_nmos_lpowmve
+ wpowmve   = presto_hci_nmos_wpowmve
+ vbsexpmve = presto_hci_nmos_vbsexpmve
+ vc1mve    = presto_hci_nmos_vc1mve
+ vc2mve    = presto_hci_nmos_vc2mve
+ alphahe   = presto_hci_nmos_alphahe
+ fstathe   = presto_hci_nmos_fstathe
+ vdpowhe   = presto_hci_nmos_vdpowhe
+ vgpowhe   = presto_hci_nmos_vgpowhe
+ vdexphe   = presto_hci_nmos_vdexphe
+ eahe      = presto_hci_nmos_eahe
+ lexphe    = presto_hci_nmos_lexphe
+ lpowhe    = presto_hci_nmos_lpowhe
+ wpowhe    = presto_hci_nmos_wpowhe
+ vbsexphe  = presto_hci_nmos_vbsexphe
+ vc1he     = presto_hci_nmos_vc1he
+ vc2he     = presto_hci_nmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos_ull_10hv_dfrt

section nmos_ana_10hv_dfrt
include "soachecks_top.scs" section=nmos_ana_10hv_soa
if (enable_relimo == 1) {
anmos_ana_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.08 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos_ana_10hv relimo_probe_name=mnmos_ana_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos_ana_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos_ana_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos_ana_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos_ana_10hv relimo_c=relimo_c_1_hci_nmos_ana_10hv relimo_condvd=relimo_condvd_hci_nmos_ana_10hv relimo_condvg=relimo_condvg_hci_nmos_ana_10hv relimo_intercept=relimo_intercept_1_hci_nmos_ana_10hv relimo_m=relimo_m_1_hci_nmos_ana_10hv relimo_n=relimo_n_1_hci_nmos_ana_10hv relimo_r=relimo_r_1_hci_nmos_ana_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos_ana_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos_ana_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos_ana_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos_ana_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos_ana_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos_ana_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos_ana_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos_ana_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos_ana_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos_ana_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos_ana_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos_ana_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos_ana_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos_ana_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos_ana_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos_ana_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos_ana_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos_ana_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos_ana_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos_ana_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos_ana_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos_ana_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos_ana_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos_ana_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos_ana_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos_ana_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos_ana_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos_ana_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos_ana_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos_ana_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos_ana_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos_ana_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos_ana_10hv relimo_vth=relimo_vth_hci_nmos_ana_10hv
anmos_ana_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos_ana_10hv relimo_probe_name=mnmos_ana_10hv_i
}
if (enable_esdsoa == 1) {
anmos_ana_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=1 enable=soa rule="esd_nmos_ana_Vt1=7p3_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=2 enable=soa rule="esd_nmos_ana_Vt1>7p3_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 7.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.3
anmos_ana_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=3 enable=soa rule="esd_nmos_ana_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(1.8*(V(g)-V(s)-0.0))-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ana_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=4 enable=soa rule="esd_nmos_ana_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(1.8*(V(g)-V(s)-0.0))) > 7.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=7.3
anmos_ana_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=5 enable=soa rule="esd_nmos_ana_Vt1=6p4_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-6.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=6 enable=soa rule="esd_nmos_ana_Vt1>6p4_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 6.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.4
anmos_ana_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=7 enable=soa rule="esd_nmos_ana_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-6.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ana_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=8 enable=soa rule="esd_nmos_ana_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))) > 6.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=6.4
anmos_ana_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=9 enable=soa rule="esd_nmos_ana_Vt1=6p4_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-6.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=10 enable=soa rule="esd_nmos_ana_Vt1>6p4_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 6.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.4
anmos_ana_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=11 enable=soa rule="esd_nmos_ana_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-1.0))-6.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ana_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=12 enable=soa rule="esd_nmos_ana_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-1.0))) > 6.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=6.4
anmos_ana_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=13 enable=soa rule="esd_nmos_ana_Vt1=6p2_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-6.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=14 enable=soa rule="esd_nmos_ana_Vt1>6p2_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 6.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.2
anmos_ana_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=15 enable=soa rule="esd_nmos_ana_=Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))-6.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos_ana_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=16 enable=soa rule="esd_nmos_ana_>Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))) > 6.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=6.2
anmos_ana_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=17 enable=soa rule="esd_nmos_ana_Vt1=6p1_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-6.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=18 enable=soa rule="esd_nmos_ana_Vt1>6p1_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 6.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.1
anmos_ana_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos_ana_10hv ruleNum=19 enable=soa rule="esd_nmos_ana_=Vt1_Vgs>2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="(abs(V(d)-V(s)-6.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos_ana_10hv_esdchk_20 (g s d s) monitor4t enable=soa rule="esd_nmos_ana_>Vt1_Vgs>2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(d-to-s) > 6.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.1
anmos_ana_10hv_esdchk_21 (g b) monitor2t enable=soa rule="esd_nmos_ana_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ana_10hv_esdchk_22 (g s) monitor2t enable=soa rule="esd_nmos_ana_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ana_10hv_esdchk_23 (g d) monitor2t enable=soa rule="esd_nmos_ana_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos_ana_10hv_esdchk_24 (s b) monitor2t enable=soa rule="esd_nmos_ana_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos_ana_10hv_esdchk_25 (d b) monitor2t enable=soa rule="esd_nmos_ana_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 7.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.3
anmos_ana_10hv_esdchk_26 (d sub) monitor2t enable=soa rule="esd_nmos_ana_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ana_10hv_esdchk_27 (sub b) monitor2t enable=soa rule="esd_nmos_ana_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos_ana_10hv_esdchk_28 (b d) monitor2t enable=soa rule="esd_nmos_ana_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos_ana_avth
+ bvth      = presto_hci_nmos_ana_bvth
+ ai        = presto_hci_nmos_ana_ai
+ bi        = presto_hci_nmos_ana_bi
+ nvth      = presto_hci_nmos_ana_n_vth
+ ni        = presto_hci_nmos_ana_n_i
+ gammai    = presto_hci_nmos_ana_gammai
+ alphamve  = presto_hci_nmos_ana_alphamve
+ fstatmve  = presto_hci_nmos_ana_fstatmve
+ vdpowmve  = presto_hci_nmos_ana_vdpowmve
+ vgpowmve  = presto_hci_nmos_ana_vgpowmve
+ vdexpmve  = presto_hci_nmos_ana_vdexpmve
+ eamve     = presto_hci_nmos_ana_eamve
+ lexpmve   = presto_hci_nmos_ana_lexpmve
+ lpowmve   = presto_hci_nmos_ana_lpowmve
+ wpowmve   = presto_hci_nmos_ana_wpowmve
+ vbsexpmve = presto_hci_nmos_ana_vbsexpmve
+ vc1mve    = presto_hci_nmos_ana_vc1mve
+ vc2mve    = presto_hci_nmos_ana_vc2mve
+ alphahe   = presto_hci_nmos_ana_alphahe
+ fstathe   = presto_hci_nmos_ana_fstathe
+ vdpowhe   = presto_hci_nmos_ana_vdpowhe
+ vgpowhe   = presto_hci_nmos_ana_vgpowhe
+ vdexphe   = presto_hci_nmos_ana_vdexphe
+ eahe      = presto_hci_nmos_ana_eahe
+ lexphe    = presto_hci_nmos_ana_lexphe
+ lpowhe    = presto_hci_nmos_ana_lpowhe
+ wpowhe    = presto_hci_nmos_ana_wpowhe
+ vbsexphe  = presto_hci_nmos_ana_vbsexphe
+ vc1he     = presto_hci_nmos_ana_vc1he
+ vc2he     = presto_hci_nmos_ana_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos_ana_10hv_dfrt

section pmos_10hv_dfrt
include "soachecks_top.scs" section=pmos_10hv_soa
if (enable_relimo == 1) {
apmos_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.08 relimo_ratio20_a=relimo_ratio20_a_bti_pmos_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos_10hv relimo_probe_name=mpmos_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_10hv relimo_c=relimo_c_1_hci_pmos_10hv relimo_condvd=relimo_condvd_hci_pmos_10hv relimo_condvg=relimo_condvg_hci_pmos_10hv relimo_intercept=relimo_intercept_1_hci_pmos_10hv relimo_m=relimo_m_1_hci_pmos_10hv relimo_n=relimo_n_1_hci_pmos_10hv relimo_r=relimo_r_1_hci_pmos_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_10hv relimo_vth=relimo_vth_hci_pmos_10hv
apmos_lgo_nbti (d g s) relimo_aging_nbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_device_name=pmos_10hv relimo_probe_name=mpmos_10hv_i relimo_c=relimo_c_nbti_lgo relimo_intercept=relimo_intercept_nbti_lgo relimo_n=relimo_n_nbti_lgo
}
if (enable_esdsoa == 1) {
apmos_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos_10hv ruleNum=1 enable=soa rule="esd_pmos_Vt1=5p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos_10hv ruleNum=2 enable=soa rule="esd_pmos_Vt1>5p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.9
apmos_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos_10hv ruleNum=3 enable=soa rule="esd_pmos_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-0.0))-5.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos_10hv ruleNum=4 enable=soa rule="esd_pmos_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-0.0)))) > 5.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.9
apmos_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos_10hv ruleNum=5 enable=soa rule="esd_pmos_Vt1=5p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos_10hv ruleNum=6 enable=soa rule="esd_pmos_Vt1>5p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.0
apmos_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos_10hv ruleNum=7 enable=soa rule="esd_pmos_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(0.4*(V(s)-V(g)-0.5))-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos_10hv ruleNum=8 enable=soa rule="esd_pmos_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(0.4*(V(s)-V(g)-0.5)))) > 5.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.0
apmos_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos_10hv ruleNum=9 enable=soa rule="esd_pmos_Vt1=4p8_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-4.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos_10hv ruleNum=10 enable=soa rule="esd_pmos_Vt1>4p8_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 4.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.8
apmos_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos_10hv ruleNum=11 enable=soa rule="esd_pmos_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(s)-V(d)-4.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_10hv_esdchk_12 (s g s d) monitor4t enable=soa rule="esd_pmos_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="absV(s-to-d) > 4.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.8
apmos_10hv_esdchk_13 (g b) monitor2t enable=soa rule="esd_pmos_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_10hv_esdchk_14 (g s) monitor2t enable=soa rule="esd_pmos_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_10hv_esdchk_15 (g d) monitor2t enable=soa rule="esd_pmos_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_10hv_esdchk_16 (b s) monitor2t enable=soa rule="esd_pmos_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
apmos_10hv_esdchk_17 (b d) monitor2t enable=soa rule="esd_pmos_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5.9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.9
apmos_10hv_esdchk_18 (b sub) monitor2t enable=soa rule="esd_pmos_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_10hv_esdchk_19 (sub d) monitor2t enable=soa rule="esd_pmos_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_10hv_esdchk_20 (d b) monitor2t enable=soa rule="esd_pmos_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go1_k
+ a         = presto_nbti_go1_a
+ fstat     = presto_nbti_go1_fstat
+ n         = presto_nbti_go1_n
+ m         = presto_nbti_go1_m
+ vgexp     = presto_nbti_go1_vgexp
+ ea        = presto_nbti_go1_ea
+ lpow      = presto_nbti_go1_lpow
+ wpow      = presto_nbti_go1_wpow
+ vbxexp    = presto_nbti_go1_vbxexp
+ lexp      = presto_nbti_go1_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos_avth
+ bvth      = presto_hci_pmos_bvth
+ ai        = presto_hci_pmos_ai
+ bi        = presto_hci_pmos_bi
+ nvth      = presto_hci_pmos_n_vth
+ ni        = presto_hci_pmos_n_i
+ gammai    = presto_hci_pmos_gammai
+ alphamve  = presto_hci_pmos_alphamve
+ fstatmve  = presto_hci_pmos_fstatmve
+ vdpowmve  = presto_hci_pmos_vdpowmve
+ vgpowmve  = presto_hci_pmos_vgpowmve
+ vdexpmve  = presto_hci_pmos_vdexpmve
+ eamve     = presto_hci_pmos_eamve
+ lexpmve   = presto_hci_pmos_lexpmve
+ lpowmve   = presto_hci_pmos_lpowmve
+ wpowmve   = presto_hci_pmos_wpowmve
+ vbsexpmve = presto_hci_pmos_vbsexpmve
+ vc1mve    = presto_hci_pmos_vc1mve
+ vc2mve    = presto_hci_pmos_vc2mve
+ alphahe   = presto_hci_pmos_alphahe
+ fstathe   = presto_hci_pmos_fstathe
+ vdpowhe   = presto_hci_pmos_vdpowhe
+ vgpowhe   = presto_hci_pmos_vgpowhe
+ vdexphe   = presto_hci_pmos_vdexphe
+ eahe      = presto_hci_pmos_eahe
+ lexphe    = presto_hci_pmos_lexphe
+ lpowhe    = presto_hci_pmos_lpowhe
+ wpowhe    = presto_hci_pmos_wpowhe
+ vbsexphe  = presto_hci_pmos_vbsexphe
+ vc1he     = presto_hci_pmos_vc1he
+ vc2he     = presto_hci_pmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos_10hv_dfrt

section pmos_ll_10hv_dfrt
include "soachecks_top.scs" section=pmos_ll_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.14 relimo_ratio20_a=relimo_ratio20_a_bti_pmos_ll_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos_ll_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos_ll_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos_ll_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apmos_lgo_nbti (d g s) relimo_aging_nbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_c=relimo_c_nbti_lgo relimo_intercept=relimo_intercept_nbti_lgo relimo_n=relimo_n_nbti_lgo
}
if (enable_esdsoa == 1) {
apmos_ll_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=1 enable=soa rule="esd_pmos_ll_Vt1=5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ll_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=2 enable=soa rule="esd_pmos_ll_Vt1>5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
apmos_ll_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=3 enable=soa rule="esd_pmos_ll_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ll_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=4 enable=soa rule="esd_pmos_ll_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
apmos_ll_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=5 enable=soa rule="esd_pmos_ll_Vt1=5p7_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ll_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=6 enable=soa rule="esd_pmos_ll_Vt1>5p7_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
apmos_ll_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=7 enable=soa rule="esd_pmos_ll_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.5))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ll_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=8 enable=soa rule="esd_pmos_ll_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.5)))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
apmos_ll_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=9 enable=soa rule="esd_pmos_ll_Vt1=4p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-4.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ll_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=10 enable=soa rule="esd_pmos_ll_Vt1>4p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 4.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.9
apmos_ll_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos_ll_10hv ruleNum=11 enable=soa rule="esd_pmos_ll_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(s)-V(d)-4.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ll_10hv_esdchk_12 (s g s d) monitor4t enable=soa rule="esd_pmos_ll_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="absV(s-to-d) > 4.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.9
apmos_ll_10hv_esdchk_13 (g b) monitor2t enable=soa rule="esd_pmos_ll_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ll_10hv_esdchk_14 (g s) monitor2t enable=soa rule="esd_pmos_ll_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ll_10hv_esdchk_15 (g d) monitor2t enable=soa rule="esd_pmos_ll_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ll_10hv_esdchk_16 (b s) monitor2t enable=soa rule="esd_pmos_ll_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
apmos_ll_10hv_esdchk_17 (b d) monitor2t enable=soa rule="esd_pmos_ll_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
apmos_ll_10hv_esdchk_18 (b sub) monitor2t enable=soa rule="esd_pmos_ll_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ll_10hv_esdchk_19 (sub d) monitor2t enable=soa rule="esd_pmos_ll_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ll_10hv_esdchk_20 (d b) monitor2t enable=soa rule="esd_pmos_ll_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go1_k
+ a         = presto_nbti_go1_a
+ fstat     = presto_nbti_go1_fstat
+ n         = presto_nbti_go1_n
+ m         = presto_nbti_go1_m
+ vgexp     = presto_nbti_go1_vgexp
+ ea        = presto_nbti_go1_ea
+ lpow      = presto_nbti_go1_lpow
+ wpow      = presto_nbti_go1_wpow
+ vbxexp    = presto_nbti_go1_vbxexp
+ lexp      = presto_nbti_go1_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos_avth
+ bvth      = presto_hci_pmos_bvth
+ ai        = presto_hci_pmos_ai
+ bi        = presto_hci_pmos_bi
+ nvth      = presto_hci_pmos_n_vth
+ ni        = presto_hci_pmos_n_i
+ gammai    = presto_hci_pmos_gammai
+ alphamve  = presto_hci_pmos_alphamve
+ fstatmve  = presto_hci_pmos_fstatmve
+ vdpowmve  = presto_hci_pmos_vdpowmve
