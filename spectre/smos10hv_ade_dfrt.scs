anmos90_10hv_esdchk_62 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=61 enable=soa rule="esd_nmos90_Vt1>64p0_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 64.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_63 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=62 enable=soa rule="esd_nmos90_=Vt1_Vgs>6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="(abs(V(d)-V(s)-64.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_64 (g s d s b s) monitor6t enable=soa rule="esd_nmos90_>Vt1_Vgs>6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(d-to-s) > 64.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_65 (g b) monitor2t enable=soa rule="esd_nmos90_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos90_10hv_esdchk_66 (g s) monitor2t enable=soa rule="esd_nmos90_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos90_10hv_esdchk_67 (g d) monitor2t enable=soa rule="esd_nmos90_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 135.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=135.0
anmos90_10hv_esdchk_68 (s b) monitor2t enable=soa rule="esd_nmos90_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos90_10hv_esdchk_69 (d b) monitor2t enable=soa rule="esd_nmos90_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 135.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=135.0
anmos90_10hv_esdchk_70 (d sub) monitor2t enable=soa rule="esd_nmos90_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos90_10hv_esdchk_71 (sub b) monitor2t enable=soa rule="esd_nmos90_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos90_10hv_esdchk_72 (b d) monitor2t enable=soa rule="esd_nmos90_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nmos90_10hv_dfrt

section nmos90b_10hv_dfrt
include "soachecks_top.scs" section=nmos90b_10hv_soa
if (enable_relimo == 1) {
anmos90b_10hv_hci_hv (d g s sub) relimo_aging_hv_hci_nmos90b w=w*ng relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_ratio21_a=0.74 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos90b_10hv relimo_probe_name=mamost relimo_a_gm=relimo_a_gm_1_hci_nmos90b_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos90b_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos90b_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos90b_10hv relimo_c=relimo_c_1_hci_nmos90b_10hv relimo_condvd=relimo_condvd_hci_nmos90b_10hv relimo_condvg=relimo_condvg_hci_nmos90b_10hv relimo_intercept=relimo_intercept_1_hci_nmos90b_10hv relimo_m=relimo_m_1_hci_nmos90b_10hv relimo_n=relimo_n_1_hci_nmos90b_10hv relimo_r=relimo_r_1_hci_nmos90b_10hv relimo_e=relimo_e_hci_nmos90b_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos90b_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos90b_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos90b_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos90b_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos90b_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos90b_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos90b_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos90b_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos90b_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos90b_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos90b_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos90b_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos90b_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos90b_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos90b_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos90b_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos90b_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos90b_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos90b_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos90b_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos90b_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos90b_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos90b_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos90b_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos90b_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos90b_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos90b_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos90b_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos90b_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos90b_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos90b_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos90b_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos90b_10hv relimo_vth=relimo_vth_hci_nmos90b_10hv
anmos90b_10hv_pbti_dummy relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos90b_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anmos90b_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=1 enable=soa rule="esd_nmos90b_Vt1=135p0_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=2 enable=soa rule="esd_nmos90b_Vt1>135p0_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 135.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=135.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=3 enable=soa rule="esd_nmos90b_=Vt1_Vgs_0p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(0.8*(V(g)-V(s)-0.0))-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=4 enable=soa rule="esd_nmos90b_>Vt1_Vgs_0p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(0.8*(V(g)-V(s)-0.0))) > 135.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=135.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=5 enable=soa rule="esd_nmos90b_Vt1=133p8_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=6 enable=soa rule="esd_nmos90b_Vt1>133p8_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=7 enable=soa rule="esd_nmos90b_=Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.5))-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=8 enable=soa rule="esd_nmos90b_>Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.5))) > 133.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.8 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=9 enable=soa rule="esd_nmos90b_Vt1=133p8_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=10 enable=soa rule="esd_nmos90b_Vt1>133p8_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=11 enable=soa rule="esd_nmos90b_=Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(0.8*(V(g)-V(s)-2.0))-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=12 enable=soa rule="esd_nmos90b_>Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(0.8*(V(g)-V(s)-2.0))) > 133.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.8 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=13 enable=soa rule="esd_nmos90b_Vt1=133p0_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=14 enable=soa rule="esd_nmos90b_Vt1>133p0_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=15 enable=soa rule="esd_nmos90b_=Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(2.7*(V(g)-V(s)-3.0))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=16 enable=soa rule="esd_nmos90b_>Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(2.7*(V(g)-V(s)-3.0))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=17 enable=soa rule="esd_nmos90b_Vt1=130p3_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-130.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=18 enable=soa rule="esd_nmos90b_Vt1>130p3_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 130.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=130.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=19 enable=soa rule="esd_nmos90b_=Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(3.1*(V(g)-V(s)-4.0))-130.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=20 enable=soa rule="esd_nmos90b_>Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(3.1*(V(g)-V(s)-4.0))) > 130.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=130.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=21 enable=soa rule="esd_nmos90b_Vt1=127p2_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-127.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=22 enable=soa rule="esd_nmos90b_Vt1>127p2_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 127.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=127.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=23 enable=soa rule="esd_nmos90b_=Vt1_Vgs_5p0_5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(6.8*(V(g)-V(s)-5.0))-127.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=24 enable=soa rule="esd_nmos90b_>Vt1_Vgs_5p0_5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(6.8*(V(g)-V(s)-5.0))) > 127.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=127.2 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=25 enable=soa rule="esd_nmos90b_Vt1=123p8_Vgs5p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=26 enable=soa rule="esd_nmos90b_Vt1>123p8_Vgs5p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=27 enable=soa rule="esd_nmos90b_=Vt1_Vgs_5p5_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-5.5))-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=28 enable=soa rule="esd_nmos90b_>Vt1_Vgs_5p5_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-5.5))) > 123.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=123.8 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90b_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=29 enable=soa rule="esd_nmos90b_Vt1=123p8_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=30 enable=soa rule="esd_nmos90b_Vt1>123p8_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=31 enable=soa rule="esd_nmos90b_=Vt1_Vgs>6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_32 (g s d s b s) monitor6t enable=soa rule="esd_nmos90b_>Vt1_Vgs>6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90b_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=32 enable=soa rule="esd_nmos90b_Vt1=110p1_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-110.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=33 enable=soa rule="esd_nmos90b_Vt1>110p1_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 110.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=110.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=34 enable=soa rule="esd_nmos90b_=Vt1_Vgs_0p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(1.5*(V(g)-V(s)-0.0))-110.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_36 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=35 enable=soa rule="esd_nmos90b_>Vt1_Vgs_0p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(1.5*(V(g)-V(s)-0.0))) > 110.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=110.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=36 enable=soa rule="esd_nmos90b_Vt1=107p8_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-107.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=37 enable=soa rule="esd_nmos90b_Vt1>107p8_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 107.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=107.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=38 enable=soa rule="esd_nmos90b_=Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(15.6*(V(g)-V(s)-1.5))-107.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_40 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=39 enable=soa rule="esd_nmos90b_>Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(15.6*(V(g)-V(s)-1.5))) > 107.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=107.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=40 enable=soa rule="esd_nmos90b_Vt1=92p2_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-92.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=41 enable=soa rule="esd_nmos90b_Vt1>92p2_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 92.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=92.2 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=42 enable=soa rule="esd_nmos90b_=Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(5.2*(V(g)-V(s)-2.5))-92.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_44 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=43 enable=soa rule="esd_nmos90b_>Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(5.2*(V(g)-V(s)-2.5))) > 92.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=92.2 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_45 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=44 enable=soa rule="esd_nmos90b_Vt1=87p0_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-87.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_46 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=45 enable=soa rule="esd_nmos90b_Vt1>87p0_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 87.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=87.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_47 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=46 enable=soa rule="esd_nmos90b_=Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(10.4*(V(g)-V(s)-3.5))-87.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_48 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=47 enable=soa rule="esd_nmos90b_>Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(10.4*(V(g)-V(s)-3.5))) > 87.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=87.0 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_49 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=48 enable=soa rule="esd_nmos90b_Vt1=76p6_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-76.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_50 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=49 enable=soa rule="esd_nmos90b_Vt1>76p6_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 76.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=76.6 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_51 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=50 enable=soa rule="esd_nmos90b_=Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(2.1*(V(g)-V(s)-4.5))-76.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_52 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=51 enable=soa rule="esd_nmos90b_>Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(2.1*(V(g)-V(s)-4.5))) > 76.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=76.6 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_53 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=52 enable=soa rule="esd_nmos90b_Vt1=74p5_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-74.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_54 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=53 enable=soa rule="esd_nmos90b_Vt1>74p5_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 74.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=74.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_55 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=54 enable=soa rule="esd_nmos90b_=Vt1_Vgs_5p5_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-5.5))-74.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_56 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=55 enable=soa rule="esd_nmos90b_>Vt1_Vgs_5p5_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-5.5))) > 74.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=74.5 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90b_10hv_esdchk_57 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=56 enable=soa rule="esd_nmos90b_Vt1=74p5_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-74.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_58 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=57 enable=soa rule="esd_nmos90b_Vt1>74p5_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 74.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=74.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_59 (d g s b sub) monitor_esd_nmos90b_10hv ruleNum=58 enable=soa rule="esd_nmos90b_=Vt1_Vgs>6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="(abs(V(d)-V(s)-74.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_60 (g s d s b s) monitor6t enable=soa rule="esd_nmos90b_>Vt1_Vgs>6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(d-to-s) > 74.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=74.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90b_10hv_esdchk_61 (g b) monitor2t enable=soa rule="esd_nmos90b_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos90b_10hv_esdchk_62 (g s) monitor2t enable=soa rule="esd_nmos90b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos90b_10hv_esdchk_63 (g d) monitor2t enable=soa rule="esd_nmos90b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 135.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=135.0
anmos90b_10hv_esdchk_64 (s b) monitor2t enable=soa rule="esd_nmos90b_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos90b_10hv_esdchk_65 (d b) monitor2t enable=soa rule="esd_nmos90b_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 135.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=135.0
anmos90b_10hv_esdchk_66 (d sub) monitor2t enable=soa rule="esd_nmos90b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos90b_10hv_esdchk_67 (sub b) monitor2t enable=soa rule="esd_nmos90b_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos90b_10hv_esdchk_68 (b d) monitor2t enable=soa rule="esd_nmos90b_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mamost"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00392
+ hcia1           = 0.078*presto_idRatio
+ hcia2           = 0.48*presto_idRatio
+ hcic1           = 964
+ hcilambdael0    = 3.09e-7
+ hcialpha1       = 1.96e-12
+ hcibeta1        = 1.1
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.26
+ offfstattau1    = 0.03
+ offalpha1       = 6.79E+16
+ offbeta1legacy  = 0.04
+ offea1          = 0.10
+ hvgsfstat       = 0.02            // High Vgs HCI part
+ hvgsa           = 283.76*presto_vthRatio
+ hvgsn           = 0.47
+ hvgsalpha       = 1.10E17
+ hvgsbeta        = 4.38E-5
+ hvgsgamma       = 11.99
+ hvgsdelta       = 4.87
+ hvgsepsilon     = 0
+ hvgsea          = 0.62
+ hvgsrth         = 0.002498665
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 20900 
+ a0_b0_b0_a1_em1 = -1.51 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = -2500 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = 3920 
+ a0_b0_a1_a1_em1 = -4.01 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -3420 
+ a0_b0_a2_a1_em1 = -23.1 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -38100 
+ a0_b0_a3_a1_em1 = 186 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.966 
+ a0_b0_p1_a1_em1 = 0.000674 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.59 
+ a0_b0_p2_a1_em1 = 0.00166 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.18 
+ a0_b0_p3_a1_em1 = 0.00033 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 3.5 
+ a0_b0_p4_a1_em1 = 0 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 5900 
+ a0_b0_b0_a2_em1 = 0.8 
+ b0_a0_b0_a2_em1 = 3.55 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0.5 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -2000 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 15300 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -10000 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.7 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 1.9 
+ a0_b0_p2_a2_em1 = 0.0005 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 2.7 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3.9 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 3000 
+ a0_b0_b0_a3_em1 = 0.5 
+ b0_a0_b0_a3_em1 = 10 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 3000 
+ a0_b0_a1_a3_em1 = -0.002 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -4500 
+ a0_b0_a2_a3_em1 = -0.000003 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = 0 
+ a0_b0_a3_a3_em1 = 0 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.9 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 2.5 
+ a0_b0_p2_a3_em1 = -0.0003 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 4 
+ a0_b0_p3_a3_em1 = -0.000004 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 4.5 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 889 
+ a0_b0_b0_a4_em1 = -1.05 
+ b0_a0_b0_a4_em1 = 17.5 
+ a0_a0_b0_a4_em1 = 0.0102 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 0 
+ a0_b0_a1_a4_em1 = 0 
+ b0_a0_a1_a4_em1 = 0 
+ a0_a0_a1_a4_em1 = 0 
+ b0_b0_a2_a4_em1 = 0 
+ a0_b0_a2_a4_em1 = 0 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0 
+ b0_b0_a3_a4_em1 = 0 
+ a0_b0_a3_a4_em1 = 0 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0 
+ a0_b0_p1_a4_em1 = 0 
+ b0_a0_p1_a4_em1 = 0 
+ a0_a0_p1_a4_em1 = 0 
+ b0_b0_p2_a4_em1 = 0 
+ a0_b0_p2_a4_em1 = 0 
+ b0_a0_p2_a4_em1 = 0 
+ a0_a0_p2_a4_em1 = 0 
+ b0_b0_p3_a4_em1 = 0 
+ a0_b0_p3_a4_em1 = 0 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 0 
+ a0_b0_p4_a4_em1 = 0 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -8 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = -0.1 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 9 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 0.1 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -0.9 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.4 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 3.08 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4.3 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 8.42 
+ a0_b0_b0_p2_em1 = 0.000999 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 1.66 
+ a0_b0_a0_p2_em1 = -0.0005 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = -4.56 
+ a0_b0_a1_p2_em1 = 0.0118 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 13.7 
+ a0_b0_a2_p2_em1 = -0.0153 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -10.2 
+ a0_b0_a3_p2_em1 = -0.00276 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0.7 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.36 
+ a0_b0_p2_p2_em1 = 0.00115 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.26 
+ a0_b0_p3_p2_em1 = 0.000641 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 3.1 
+ a0_b0_p4_p2_em1 = 0.000275 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 17.6 
+ a0_b0_b0_p3_em1 = 0.00292 
+ b0_a0_b0_p3_em1 = 0.1 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = -9.45 
+ a0_b0_a1_p3_em1 = -0.0435 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 17 
+ a0_b0_a2_p3_em1 = -0.0256 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0.457 
+ a0_b0_a3_p3_em1 = -0.0183 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0.35 
+ a0_b0_p1_p3_em1 = 0.00179 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 1.24 
+ a0_b0_p2_p3_em1 = 0.000298 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 2.21 
+ a0_b0_p3_p3_em1 = 0.00128 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 4 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 43.4 
+ a0_b0_b0_p4_em1 = -0.0144 
+ b0_a0_b0_p4_em1 = 0.313 
+ a0_a0_b0_p4_em1 = -0.000301 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = -18 
+ a0_b0_a1_p4_em1 = 0.0146 
+ b0_a0_a1_p4_em1 = -0.0649 
+ a0_a0_a1_p4_em1 = 0.0000371 
+ b0_b0_a2_p4_em1 = -18.1 
+ a0_b0_a2_p4_em1 = 0.137 
+ b0_a0_a2_p4_em1 = 0.945 
+ a0_a0_a2_p4_em1 = -0.00142 
+ b0_b0_a3_p4_em1 = 0.0315 
+ a0_b0_a3_p4_em1 = -0.183 
+ b0_a0_a3_p4_em1 = 1.55 
+ a0_a0_a3_p4_em1 = 0.00225 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 1.42 
+ a0_b0_p1_p4_em1 = -0.00115 
+ b0_a0_p1_p4_em1 = -0.00603 
+ a0_a0_p1_p4_em1 = 0.0000146 
+ b0_b0_p2_p4_em1 = 2.09 
+ a0_b0_p2_p4_em1 = 0.000857 
+ b0_a0_p2_p4_em1 = 0.00871 
+ a0_a0_p2_p4_em1 = -0.0000117 
+ b0_b0_p3_p4_em1 = 3.31 
+ a0_b0_p3_p4_em1 = 0.00286 
+ b0_a0_p3_p4_em1 = 0.0118 
+ a0_a0_p3_p4_em1 = -0.0001 
+ b0_b0_p4_p4_em1 = 4 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0 
}
endsection nmos90b_10hv_dfrt

section pmos90_10hv_dfrt
include "soachecks_top.scs" section=pmos90_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=relimo_ratio20_a_bti_pmos90_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos90_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apmos90_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos90_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=1 enable=soa rule="esd_pmos90_Vt1=119p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-119.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=2 enable=soa rule="esd_pmos90_Vt1>119p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 119.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=119.4
apmos90_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=3 enable=soa rule="esd_pmos90_=Vt1_Vgs_0p0_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(0.7*(V(s)-V(g)-0.0))-119.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=4 enable=soa rule="esd_pmos90_>Vt1_Vgs_0p0_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(0.7*(V(s)-V(g)-0.0)))) > 119.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=119.4
apmos90_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=5 enable=soa rule="esd_pmos90_Vt1=118p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-118.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=6 enable=soa rule="esd_pmos90_Vt1>118p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 118.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=118.0
apmos90_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=7 enable=soa rule="esd_pmos90_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(1.3*(V(s)-V(g)-2.0))-118.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=8 enable=soa rule="esd_pmos90_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(1.3*(V(s)-V(g)-2.0)))) > 118.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=118.0
apmos90_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=9 enable=soa rule="esd_pmos90_Vt1=116p7_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-116.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=10 enable=soa rule="esd_pmos90_Vt1>116p7_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 116.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.7
apmos90_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=11 enable=soa rule="esd_pmos90_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(4.4*(V(s)-V(g)-3.0))-116.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_12 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=12 enable=soa rule="esd_pmos90_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(4.4*(V(s)-V(g)-3.0)))) > 116.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=116.7
apmos90_10hv_esdchk_13 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=13 enable=soa rule="esd_pmos90_Vt1=112p3_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-112.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_14 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=14 enable=soa rule="esd_pmos90_Vt1>112p3_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 112.3 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=112.3
apmos90_10hv_esdchk_15 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=15 enable=soa rule="esd_pmos90_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-4.0))-112.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_16 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=16 enable=soa rule="esd_pmos90_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-4.0)))) > 112.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=112.3
apmos90_10hv_esdchk_17 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=17 enable=soa rule="esd_pmos90_Vt1=110p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-110.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_18 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=18 enable=soa rule="esd_pmos90_Vt1>110p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 110.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=110.5
apmos90_10hv_esdchk_19 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=19 enable=soa rule="esd_pmos90_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(2.4*(V(s)-V(g)-5.0))-110.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_20 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=20 enable=soa rule="esd_pmos90_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(2.4*(V(s)-V(g)-5.0)))) > 110.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=110.5
apmos90_10hv_esdchk_21 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=21 enable=soa rule="esd_pmos90_Vt1=108p1_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-108.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_22 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=22 enable=soa rule="esd_pmos90_Vt1>108p1_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 108.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=108.1
apmos90_10hv_esdchk_23 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=23 enable=soa rule="esd_pmos90_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(2.2*(V(s)-V(g)-6.0))-108.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90_10hv_esdchk_24 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=24 enable=soa rule="esd_pmos90_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(2.2*(V(s)-V(g)-6.0)))) > 108.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=108.1
apmos90_10hv_esdchk_25 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=25 enable=soa rule="esd_pmos90_Vt1=105p9_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-105.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_26 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=26 enable=soa rule="esd_pmos90_Vt1>105p9_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 105.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=105.9
apmos90_10hv_esdchk_27 (d g s b sub) monitor_esd_pmos90_10hv ruleNum=27 enable=soa rule="esd_pmos90_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-105.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90_10hv_esdchk_28 (s g s d) monitor4t enable=soa rule="esd_pmos90_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 105.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=105.9
apmos90_10hv_esdchk_29 (g b) monitor2t enable=soa rule="esd_pmos90_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos90_10hv_esdchk_30 (g s) monitor2t enable=soa rule="esd_pmos90_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos90_10hv_esdchk_31 (g d) monitor2t enable=soa rule="esd_pmos90_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 119.4 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=119.4
apmos90_10hv_esdchk_32 (b s) monitor2t enable=soa rule="esd_pmos90_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos90_10hv_esdchk_33 (b d) monitor2t enable=soa rule="esd_pmos90_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 119.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=119.4
apmos90_10hv_esdchk_34 (b sub) monitor2t enable=soa rule="esd_pmos90_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos90_10hv_esdchk_35 (sub d) monitor2t enable=soa rule="esd_pmos90_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos90_10hv_esdchk_36 (d b) monitor2t enable=soa rule="esd_pmos90_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pmos90_10hv_dfrt

section pmos90b_10hv_dfrt
include "soachecks_top.scs" section=pmos90b_10hv_soa
if (enable_relimo == 1) {
apmos90b_hci (d g s sub) relimo_aging_hci_pmos90b l=l w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apmos90b_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos90b_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=1 enable=soa rule="esd_pmos90b_Vt1=124p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90b_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=2 enable=soa rule="esd_pmos90b_Vt1>124p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apmos90b_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=3 enable=soa rule="esd_pmos90b_=Vt1_Vgs_0p0_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos90b_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=4 enable=soa rule="esd_pmos90b_>Vt1_Vgs_0p0_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 124.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=124.0
apmos90b_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=5 enable=soa rule="esd_pmos90b_Vt1=124p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90b_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=6 enable=soa rule="esd_pmos90b_Vt1>124p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apmos90b_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos90b_10hv ruleNum=7 enable=soa rule="esd_pmos90b_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos90b_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pmos90b_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apmos90b_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_pmos90b_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos90b_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_pmos90b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos90b_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_pmos90b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 124.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=124.0
apmos90b_10hv_esdchk_12 (b s) monitor2t enable=soa rule="esd_pmos90b_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos90b_10hv_esdchk_13 (b d) monitor2t enable=soa rule="esd_pmos90b_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 124.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=124.0
apmos90b_10hv_esdchk_14 (b sub) monitor2t enable=soa rule="esd_pmos90b_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos90b_10hv_esdchk_15 (sub d) monitor2t enable=soa rule="esd_pmos90b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos90b_10hv_esdchk_16 (d b) monitor2t enable=soa rule="esd_pmos90b_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mamost"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 0.78474*presto_idRatio
+ hcia2           = 5.2863*presto_idRatio
+ hcic1           = 86.407
+ hcib1           = 0.00025334*presto_idRatio
+ hcin            = 3
+ hcialpha1       = 0.00903
+ hcibeta1        = 0.99
+ hcilambdah0     = 1.34E-06
+ hcialpha2       = 8.67E-25
+ hcibeta2        = 1.07
+ hcilambdael0    = 4.81E-07
+ hcifstattau1    = 0.0102
+ hcifstattau2    = 0.0038
+ hcifstattau12   = 106
+ hcifstattau21   = 106
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.4
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 48.3*presto_idRatio             //Off state HCI part
+ offn1           = 0.22
+ offa2           = 3.18*presto_idRatio
+ offn2           = 0.586
+ offalpha1       = 4.83E+06
+ offbeta1        = 0.05
+ offea1          = 0.548
+ offalpha2       = 0.0424
+ offbeta2        = 0.129
+ offea2          = 0.734
+ offfstattau1    = 0.0272
+ offfstattau2    = 0.0616
+ offfstattau12   = 61.9
+ offfstattau21   = 61.9
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.5*presto_idRatio
+ hvgsa           = 1000*presto_vthRatio            // High Vgs HCI part
+ hvgsn           = 0.253
+ hvgsalpha       = 2.69E+43
+ hvgsbeta        = 5.22
+ hvgsgamma       = 13.3
+ hvgsdelta       = 10.7
+ hvgsepsilon     = 0
+ hvgsea          = 0.467
+ hvgsrth         = 1.12E-11
+ hvgsfstat       = 0.0269       
+ b0_b0_b0_b0_em1  =  0  
+ a0_b0_b0_b0_em1  =  0  
+ b0_a0_b0_b0_em1  =  0  
+ a0_a0_b0_b0_em1  =  0  
+ b0_b0_a0_b0_em1  =  0  
+ a0_b0_a0_b0_em1  =  0  
+ b0_a0_a0_b0_em1  =  0  
+ a0_a0_a0_b0_em1  =  0  
+ b0_b0_a1_b0_em1  =  0  
+ a0_b0_a1_b0_em1  =  0  
+ b0_a0_a1_b0_em1  =  0  
+ a0_a0_a1_b0_em1  =  0  
+ b0_b0_a2_b0_em1  =  0  
+ a0_b0_a2_b0_em1  =  0  
+ b0_a0_a2_b0_em1  =  0  
+ a0_a0_a2_b0_em1  =  0  
+ b0_b0_a3_b0_em1  =  0  
+ a0_b0_a3_b0_em1  =  0  
+ b0_a0_a3_b0_em1  =  0  
+ a0_a0_a3_b0_em1  =  0  
+ b0_b0_a4_b0_em1  =  0  
+ a0_b0_a4_b0_em1  =  0  
+ b0_a0_a4_b0_em1  =  0  
+ a0_a0_a4_b0_em1  =  0  
+ b0_b0_p1_b0_em1  =  0  
+ a0_b0_p1_b0_em1  =  0  
+ b0_a0_p1_b0_em1  =  0  
+ a0_a0_p1_b0_em1  =  0  
+ b0_b0_p2_b0_em1  =  0  
+ a0_b0_p2_b0_em1  =  0  
+ b0_a0_p2_b0_em1  =  0  
+ a0_a0_p2_b0_em1  =  0  
+ b0_b0_p3_b0_em1  =  0  
+ a0_b0_p3_b0_em1  =  0  
+ b0_a0_p3_b0_em1  =  0  
+ a0_a0_p3_b0_em1  =  0  
+ b0_b0_p4_b0_em1  =  0  
+ a0_b0_p4_b0_em1  =  0  
+ b0_a0_p4_b0_em1  =  0  
+ a0_a0_p4_b0_em1  =  0  
+ b0_b0_b0_a0_em1  =  0  
+ a0_b0_b0_a0_em1  =  0  
+ b0_a0_b0_a0_em1  =  0  
+ a0_a0_b0_a0_em1  =  0  
+ b0_b0_a0_a0_em1  =  0  
+ a0_b0_a0_a0_em1  =  0  
+ b0_a0_a0_a0_em1  =  0  
+ a0_a0_a0_a0_em1  =  0  
+ b0_b0_a1_a0_em1  =  0  
+ a0_b0_a1_a0_em1  =  0  
+ b0_a0_a1_a0_em1  =  0  
+ a0_a0_a1_a0_em1  =  0  
+ b0_b0_a2_a0_em1  =  0  
+ a0_b0_a2_a0_em1  =  0  
+ b0_a0_a2_a0_em1  =  0  
+ a0_a0_a2_a0_em1  =  0  
+ b0_b0_a3_a0_em1  =  0  
+ a0_b0_a3_a0_em1  =  0  
+ b0_a0_a3_a0_em1  =  0  
+ a0_a0_a3_a0_em1  =  0  
+ b0_b0_a4_a0_em1  =  0  
+ a0_b0_a4_a0_em1  =  0  
+ b0_a0_a4_a0_em1  =  0  
+ a0_a0_a4_a0_em1  =  0  
+ b0_b0_p1_a0_em1  =  0  
+ a0_b0_p1_a0_em1  =  0  
+ b0_a0_p1_a0_em1  =  0  
+ a0_a0_p1_a0_em1  =  0  
+ b0_b0_p2_a0_em1  =  0  
+ a0_b0_p2_a0_em1  =  0  
+ b0_a0_p2_a0_em1  =  0  
+ a0_a0_p2_a0_em1  =  0  
+ b0_b0_p3_a0_em1  =  0  
+ a0_b0_p3_a0_em1  =  0  
+ b0_a0_p3_a0_em1  =  0  
+ a0_a0_p3_a0_em1  =  0  
+ b0_b0_p4_a0_em1  =  0  
+ a0_b0_p4_a0_em1  =  0  
+ b0_a0_p4_a0_em1  =  0  
+ a0_a0_p4_a0_em1  =  0  
+ b0_b0_b0_a1_em1  =  13400  
+ a0_b0_b0_a1_em1  =  -1.5  
+ b0_a0_b0_a1_em1  =  0  
+ a0_a0_b0_a1_em1  =  0  
+ b0_b0_a0_a1_em1  =  -400  
+ a0_b0_a0_a1_em1  =  0  
+ b0_a0_a0_a1_em1  =  0  
+ a0_a0_a0_a1_em1  =  0  
+ b0_b0_a1_a1_em1  =  -525  
+ a0_b0_a1_a1_em1  =  -0.534  
+ b0_a0_a1_a1_em1  =  0  
+ a0_a0_a1_a1_em1  =  0  
+ b0_b0_a2_a1_em1  =  -760  
+ a0_b0_a2_a1_em1  =  -1.96  
+ b0_a0_a2_a1_em1  =  0  
+ a0_a0_a2_a1_em1  =  0  
+ b0_b0_a3_a1_em1  =  -553  
+ a0_b0_a3_a1_em1  =  0.516  
+ b0_a0_a3_a1_em1  =  0  
+ a0_a0_a3_a1_em1  =  0  
+ b0_b0_a4_a1_em1  =  0  
+ a0_b0_a4_a1_em1  =  0  
+ b0_a0_a4_a1_em1  =  0  
+ a0_a0_a4_a1_em1  =  0  
+ b0_b0_p1_a1_em1  =  -1.04  
+ a0_b0_p1_a1_em1  =  0.00126  
+ b0_a0_p1_a1_em1  =  0  
+ a0_a0_p1_a1_em1  =  0  
+ b0_b0_p2_a1_em1  =  1.47  
+ a0_b0_p2_a1_em1  =  -0.00025  
+ b0_a0_p2_a1_em1  =  0  
+ a0_a0_p2_a1_em1  =  0  
+ b0_b0_p3_a1_em1  =  3.78  
+ a0_b0_p3_a1_em1  =  -0.00129  
+ b0_a0_p3_a1_em1  =  0  
+ a0_a0_p3_a1_em1  =  0  
+ b0_b0_p4_a1_em1  =  5  
+ a0_b0_p4_a1_em1  =  0  
+ b0_a0_p4_a1_em1  =  0  
+ a0_a0_p4_a1_em1  =  0  
+ b0_b0_b0_a2_em1  =  4150  
+ a0_b0_b0_a2_em1  =  -0.0609  
+ b0_a0_b0_a2_em1  =  0  
+ a0_a0_b0_a2_em1  =  0  
+ b0_b0_a0_a2_em1  =  1200  
+ a0_b0_a0_a2_em1  =  0  
+ b0_a0_a0_a2_em1  =  0  
+ a0_a0_a0_a2_em1  =  0  
+ b0_b0_a1_a2_em1  =  152  
+ a0_b0_a1_a2_em1  =  -1.72  
+ b0_a0_a1_a2_em1  =  0  
+ a0_a0_a1_a2_em1  =  0  
+ b0_b0_a2_a2_em1  =  -3390  
+ a0_b0_a2_a2_em1  =  6.27  
+ b0_a0_a2_a2_em1  =  0  
+ a0_a0_a2_a2_em1  =  0  
+ b0_b0_a3_a2_em1  =  142  
+ a0_b0_a3_a2_em1  =  -1.76  
+ b0_a0_a3_a2_em1  =  0  
+ a0_a0_a3_a2_em1  =  0  
+ b0_b0_a4_a2_em1  =  0  
+ a0_b0_a4_a2_em1  =  0  
+ b0_a0_a4_a2_em1  =  0  
+ a0_a0_a4_a2_em1  =  0  
+ b0_b0_p1_a2_em1  =  0.492  
+ a0_b0_p1_a2_em1  =  -0.000612  
+ b0_a0_p1_a2_em1  =  0  
+ a0_a0_p1_a2_em1  =  0  
+ b0_b0_p2_a2_em1  =  1.54  
+ a0_b0_p2_a2_em1  =  0.000457  
+ b0_a0_p2_a2_em1  =  0  
+ a0_a0_p2_a2_em1  =  0  
+ b0_b0_p3_a2_em1  =  2.76  
+ a0_b0_p3_a2_em1  =  0.000362  
+ b0_a0_p3_a2_em1  =  0  
+ a0_a0_p3_a2_em1  =  0  
+ b0_b0_p4_a2_em1  =  4.5  
+ a0_b0_p4_a2_em1  =  0  
+ b0_a0_p4_a2_em1  =  0  
+ a0_a0_p4_a2_em1  =  0  
+ b0_b0_b0_a3_em1  =  598  
+ a0_b0_b0_a3_em1  =  1.47  
+ b0_a0_b0_a3_em1  =  2.74  
+ a0_a0_b0_a3_em1  =  0.00976  
+ b0_b0_a0_a3_em1  =  0  
+ a0_b0_a0_a3_em1  =  0  
+ b0_a0_a0_a3_em1  =  0  
+ a0_a0_a0_a3_em1  =  0  
+ b0_b0_a1_a3_em1  =  0  
+ a0_b0_a1_a3_em1  =  0  
+ b0_a0_a1_a3_em1  =  0  
+ a0_a0_a1_a3_em1  =  0  
+ b0_b0_a2_a3_em1  =  0  
+ a0_b0_a2_a3_em1  =  0  
+ b0_a0_a2_a3_em1  =  0  
+ a0_a0_a2_a3_em1  =  0  
+ b0_b0_a3_a3_em1  =  0  
+ a0_b0_a3_a3_em1  =  0  
+ b0_a0_a3_a3_em1  =  0  
+ a0_a0_a3_a3_em1  =  0  
+ b0_b0_a4_a3_em1  =  0  
+ a0_b0_a4_a3_em1  =  0  
+ b0_a0_a4_a3_em1  =  0  
+ a0_a0_a4_a3_em1  =  0  
+ b0_b0_p1_a3_em1  =  0  
+ a0_b0_p1_a3_em1  =  0  
+ b0_a0_p1_a3_em1  =  0  
+ a0_a0_p1_a3_em1  =  0  
+ b0_b0_p2_a3_em1  =  0  
+ a0_b0_p2_a3_em1  =  0  
+ b0_a0_p2_a3_em1  =  0  
+ a0_a0_p2_a3_em1  =  0  
+ b0_b0_p3_a3_em1  =  0  
+ a0_b0_p3_a3_em1  =  0  
+ b0_a0_p3_a3_em1  =  0  
+ a0_a0_p3_a3_em1  =  0  
+ b0_b0_p4_a3_em1  =  0  
+ a0_b0_p4_a3_em1  =  0  
+ b0_a0_p4_a3_em1  =  0  
+ a0_a0_p4_a3_em1  =  0  
+ b0_b0_b0_a4_em1  =  1050  
+ a0_b0_b0_a4_em1  =  1.08  
+ b0_a0_b0_a4_em1  =  0.388  
+ a0_a0_b0_a4_em1  =  0.0699  
+ b0_b0_a0_a4_em1  =  0  
+ a0_b0_a0_a4_em1  =  0  
+ b0_a0_a0_a4_em1  =  0  
+ a0_a0_a0_a4_em1  =  0  
+ b0_b0_a1_a4_em1  =  291  
+ a0_b0_a1_a4_em1  =  -0.671  
+ b0_a0_a1_a4_em1  =  2.24  
+ a0_a0_a1_a4_em1  =  -0.00555  
+ b0_b0_a2_a4_em1  =  -269  
+ a0_b0_a2_a4_em1  =  0.597  
+ b0_a0_a2_a4_em1  =  0  
+ a0_a0_a2_a4_em1  =  0.00655  
+ b0_b0_a3_a4_em1  =  22.3  
+ a0_b0_a3_a4_em1  =  -0.135  
+ b0_a0_a3_a4_em1  =  -0.937  
+ a0_a0_a3_a4_em1  =  0.00231  
+ b0_b0_a4_a4_em1  =  0  
+ a0_b0_a4_a4_em1  =  0  
+ b0_a0_a4_a4_em1  =  0  
+ a0_a0_a4_a4_em1  =  0  
+ b0_b0_p1_a4_em1  =  1.28  
+ a0_b0_p1_a4_em1  =  0.066  
+ b0_a0_p1_a4_em1  =  -1.45  
+ a0_a0_p1_a4_em1  =  0.00866  
+ b0_b0_p2_a4_em1  =  0.676  
+ a0_b0_p2_a4_em1  =  0.00266  
+ b0_a0_p2_a4_em1  =  0.0129  
+ a0_a0_p2_a4_em1  =  -0.00002  
+ b0_b0_p3_a4_em1  =  3.54  
+ a0_b0_p3_a4_em1  =  0.00136  
+ b0_a0_p3_a4_em1  =  0.0000722  
+ a0_a0_p3_a4_em1  =  -0.00000493  
+ b0_b0_p4_a4_em1  =  11.3  
+ a0_b0_p4_a4_em1  =  -0.00422  
+ b0_a0_p4_a4_em1  =  0  
+ a0_a0_p4_a4_em1  =  0  
+ b0_b0_b0_p1_em1  =  -3.6  
+ a0_b0_b0_p1_em1  =  0  
+ b0_a0_b0_p1_em1  =  0  
+ a0_a0_b0_p1_em1  =  0  
+ b0_b0_a0_p1_em1  =  0  
+ a0_b0_a0_p1_em1  =  0  
+ b0_a0_a0_p1_em1  =  0  
+ a0_a0_a0_p1_em1  =  0  
+ b0_b0_a1_p1_em1  =  0.313  
+ a0_b0_a1_p1_em1  =  0  
+ b0_a0_a1_p1_em1  =  0  
+ a0_a0_a1_p1_em1  =  0  
+ b0_b0_a2_p1_em1  =  -0.971  
+ a0_b0_a2_p1_em1  =  0  
+ b0_a0_a2_p1_em1  =  0  
+ a0_a0_a2_p1_em1  =  0  
+ b0_b0_a3_p1_em1  =  -0.162  
+ a0_b0_a3_p1_em1  =  0  
+ b0_a0_a3_p1_em1  =  0  
+ a0_a0_a3_p1_em1  =  0  
+ b0_b0_a4_p1_em1  =  0  
+ a0_b0_a4_p1_em1  =  0  
+ b0_a0_a4_p1_em1  =  0  
+ a0_a0_a4_p1_em1  =  0  
+ b0_b0_p1_p1_em1  =  0.8  
+ a0_b0_p1_p1_em1  =  0  
+ b0_a0_p1_p1_em1  =  0  
+ a0_a0_p1_p1_em1  =  0  
+ b0_b0_p2_p1_em1  =  1.63  
+ a0_b0_p2_p1_em1  =  0  
+ b0_a0_p2_p1_em1  =  0  
+ a0_a0_p2_p1_em1  =  0  
+ b0_b0_p3_p1_em1  =  3.61  
+ a0_b0_p3_p1_em1  =  0  
+ b0_a0_p3_p1_em1  =  0  
+ a0_a0_p3_p1_em1  =  0  
+ b0_b0_p4_p1_em1  =  5.61  
+ a0_b0_p4_p1_em1  =  0  
+ b0_a0_p4_p1_em1  =  0  
+ a0_a0_p4_p1_em1  =  0  
+ b0_b0_b0_p2_em1  =  14.6  
+ a0_b0_b0_p2_em1  =  0.00383  
+ b0_a0_b0_p2_em1  =  0  
+ a0_a0_b0_p2_em1  =  0  
+ b0_b0_a0_p2_em1  =  0  
+ a0_b0_a0_p2_em1  =  0  
+ b0_a0_a0_p2_em1  =  0  
+ a0_a0_a0_p2_em1  =  0  
+ b0_b0_a1_p2_em1  =  0.189  
+ a0_b0_a1_p2_em1  =  0.00296  
+ b0_a0_a1_p2_em1  =  0  
+ a0_a0_a1_p2_em1  =  0  
+ b0_b0_a2_p2_em1  =  -3.4  
+ a0_b0_a2_p2_em1  =  0.015  
+ b0_a0_a2_p2_em1  =  0  
+ a0_a0_a2_p2_em1  =  0  
+ b0_b0_a3_p2_em1  =  1.24  
+ a0_b0_a3_p2_em1  =  -0.00228  
+ b0_a0_a3_p2_em1  =  0  
+ a0_a0_a3_p2_em1  =  0  
+ b0_b0_a4_p2_em1  =  0  
+ a0_b0_a4_p2_em1  =  0  
+ b0_a0_a4_p2_em1  =  0  
+ a0_a0_a4_p2_em1  =  0  
+ b0_b0_p1_p2_em1  =  0.2  
+ a0_b0_p1_p2_em1  =  0  
+ b0_a0_p1_p2_em1  =  0  
+ a0_a0_p1_p2_em1  =  0  
+ b0_b0_p2_p2_em1  =  3.62  
+ a0_b0_p2_p2_em1  =  -0.000606  
+ b0_a0_p2_p2_em1  =  0  
+ a0_a0_p2_p2_em1  =  0  
+ b0_b0_p3_p2_em1  =  3.86  
+ a0_b0_p3_p2_em1  =  -0.00116  
+ b0_a0_p3_p2_em1  =  0  
+ a0_a0_p3_p2_em1  =  0  
+ b0_b0_p4_p2_em1  =  5.51  
+ a0_b0_p4_p2_em1  =  -0.00235  
+ b0_a0_p4_p2_em1  =  0  
+ a0_a0_p4_p2_em1  =  0  
+ b0_b0_b0_p3_em1  =  26.5  
+ a0_b0_b0_p3_em1  =  -0.00874  
+ b0_a0_b0_p3_em1  =  -0.0217  
+ a0_a0_b0_p3_em1  =  -0.00004  
+ b0_b0_a0_p3_em1  =  -2  
+ a0_b0_a0_p3_em1  =  0  
+ b0_a0_a0_p3_em1  =  0  
+ a0_a0_a0_p3_em1  =  0  
+ b0_b0_a1_p3_em1  =  2.49  
+ a0_b0_a1_p3_em1  =  -0.000866  
+ b0_a0_a1_p3_em1  =  -0.0119  
+ a0_a0_a1_p3_em1  =  0.0000336  
+ b0_b0_a2_p3_em1  =  -3.69  
+ a0_b0_a2_p3_em1  =  -0.00232  
+ b0_a0_a2_p3_em1  =  -0.0222  
+ a0_a0_a2_p3_em1  =  0.0000265  
+ b0_b0_a3_p3_em1  =  -2.14  
+ a0_b0_a3_p3_em1  =  0.00168  
+ b0_a0_a3_p3_em1  =  0  
+ a0_a0_a3_p3_em1  =  0  
+ b0_b0_a4_p3_em1  =  0  
+ a0_b0_a4_p3_em1  =  0  
+ b0_a0_a4_p3_em1  =  0  
+ a0_a0_a4_p3_em1  =  0  
+ b0_b0_p1_p3_em1  =  0.896  
+ a0_b0_p1_p3_em1  =  -0.0028  
+ b0_a0_p1_p3_em1  =  0.00212  
+ a0_a0_p1_p3_em1  =  -0.00000896  
+ b0_b0_p2_p3_em1  =  1.05  
+ a0_b0_p2_p3_em1  =  0.00998  
+ b0_a0_p2_p3_em1  =  0.00225  
+ a0_a0_p2_p3_em1  =  0.00000246  
+ b0_b0_p3_p3_em1  =  1.43  
+ a0_b0_p3_p3_em1  =  0.0219  
+ b0_a0_p3_p3_em1  =  0  
+ a0_a0_p3_p3_em1  =  0  
+ b0_b0_p4_p3_em1  =  7.75  
+ a0_b0_p4_p3_em1  =  -0.00726  
+ b0_a0_p4_p3_em1  =  0  
+ a0_a0_p4_p3_em1  =  0  
+ b0_b0_b0_p4_em1  =  51.9  
+ a0_b0_b0_p4_em1  =  -0.0622  
+ b0_a0_b0_p4_em1  =  -0.158  
+ a0_a0_b0_p4_em1  =  -0.000773  
+ b0_b0_a0_p4_em1  =  0  
+ a0_b0_a0_p4_em1  =  0  
+ b0_a0_a0_p4_em1  =  0  
+ a0_a0_a0_p4_em1  =  0  
+ b0_b0_a1_p4_em1  =  0  
+ a0_b0_a1_p4_em1  =  0  
+ b0_a0_a1_p4_em1  =  0  
+ a0_a0_a1_p4_em1  =  0  
+ b0_b0_a2_p4_em1  =  0  
+ a0_b0_a2_p4_em1  =  0  
+ b0_a0_a2_p4_em1  =  0  
+ a0_a0_a2_p4_em1  =  0  
+ b0_b0_a3_p4_em1  =  0  
+ a0_b0_a3_p4_em1  =  0  
+ b0_a0_a3_p4_em1  =  0  
+ a0_a0_a3_p4_em1  =  0  
+ b0_b0_a4_p4_em1  =  0  
+ a0_b0_a4_p4_em1  =  0  
+ b0_a0_a4_p4_em1  =  0  
+ a0_a0_a4_p4_em1  =  0  
+ b0_b0_p1_p4_em1  =  0  
+ a0_b0_p1_p4_em1  =  0  
+ b0_a0_p1_p4_em1  =  0  
+ a0_a0_p1_p4_em1  =  0  
+ b0_b0_p2_p4_em1  =  0  
+ a0_b0_p2_p4_em1  =  0  
+ b0_a0_p2_p4_em1  =  0  
+ a0_a0_p2_p4_em1  =  0  
+ b0_b0_p3_p4_em1  =  0  
+ a0_b0_p3_p4_em1  =  0  
+ b0_a0_p3_p4_em1  =  0  
+ a0_a0_p3_p4_em1  =  0  
+ b0_b0_p4_p4_em1  =  0  
+ a0_b0_p4_p4_em1  =  0  
+ b0_a0_p4_p4_em1  =  0  
+ a0_a0_p4_p4_em1  =  0  
+ b0_b0_b0_b0_em2  =  0  
+ a0_b0_b0_b0_em2  =  0  
+ b0_a0_b0_b0_em2  =  0  
+ a0_a0_b0_b0_em2  =  0  
+ b0_b0_a0_b0_em2  =  0  
+ a0_b0_a0_b0_em2  =  0  
+ b0_a0_a0_b0_em2  =  0  
+ a0_a0_a0_b0_em2  =  0  
+ b0_b0_a1_b0_em2  =  0  
+ a0_b0_a1_b0_em2  =  0  
+ b0_a0_a1_b0_em2  =  0  
+ a0_a0_a1_b0_em2  =  0  
+ b0_b0_a2_b0_em2  =  0  
+ a0_b0_a2_b0_em2  =  0  
+ b0_a0_a2_b0_em2  =  0  
+ a0_a0_a2_b0_em2  =  0  
+ b0_b0_a3_b0_em2  =  0  
+ a0_b0_a3_b0_em2  =  0  
+ b0_a0_a3_b0_em2  =  0  
+ a0_a0_a3_b0_em2  =  0  
+ b0_b0_a4_b0_em2  =  0  
+ a0_b0_a4_b0_em2  =  0  
+ b0_a0_a4_b0_em2  =  0  
+ a0_a0_a4_b0_em2  =  0  
+ b0_b0_p1_b0_em2  =  0  
+ a0_b0_p1_b0_em2  =  0  
+ b0_a0_p1_b0_em2  =  0  
+ a0_a0_p1_b0_em2  =  0  
+ b0_b0_p2_b0_em2  =  0  
+ a0_b0_p2_b0_em2  =  0  
+ b0_a0_p2_b0_em2  =  0  
+ a0_a0_p2_b0_em2  =  0  
+ b0_b0_p3_b0_em2  =  0  
+ a0_b0_p3_b0_em2  =  0  
+ b0_a0_p3_b0_em2  =  0  
+ a0_a0_p3_b0_em2  =  0  
+ b0_b0_p4_b0_em2  =  0  
+ a0_b0_p4_b0_em2  =  0  
+ b0_a0_p4_b0_em2  =  0  
+ a0_a0_p4_b0_em2  =  0  
+ b0_b0_b0_a0_em2  =  0  
+ a0_b0_b0_a0_em2  =  0  
+ b0_a0_b0_a0_em2  =  0  
+ a0_a0_b0_a0_em2  =  0  
+ b0_b0_a0_a0_em2  =  0  
+ a0_b0_a0_a0_em2  =  0  
+ b0_a0_a0_a0_em2  =  0  
+ a0_a0_a0_a0_em2  =  0  
+ b0_b0_a1_a0_em2  =  0  
+ a0_b0_a1_a0_em2  =  0  
+ b0_a0_a1_a0_em2  =  0  
+ a0_a0_a1_a0_em2  =  0  
+ b0_b0_a2_a0_em2  =  0  
+ a0_b0_a2_a0_em2  =  0  
+ b0_a0_a2_a0_em2  =  0  
+ a0_a0_a2_a0_em2  =  0  
+ b0_b0_a3_a0_em2  =  0  
+ a0_b0_a3_a0_em2  =  0  
+ b0_a0_a3_a0_em2  =  0  
+ a0_a0_a3_a0_em2  =  0  
+ b0_b0_a4_a0_em2  =  0  
+ a0_b0_a4_a0_em2  =  0  
+ b0_a0_a4_a0_em2  =  0  
+ a0_a0_a4_a0_em2  =  0  
+ b0_b0_p1_a0_em2  =  0  
+ a0_b0_p1_a0_em2  =  0  
+ b0_a0_p1_a0_em2  =  0  
+ a0_a0_p1_a0_em2  =  0  
+ b0_b0_p2_a0_em2  =  0  
+ a0_b0_p2_a0_em2  =  0  
+ b0_a0_p2_a0_em2  =  0  
+ a0_a0_p2_a0_em2  =  0  
+ b0_b0_p3_a0_em2  =  0  
+ a0_b0_p3_a0_em2  =  0  
+ b0_a0_p3_a0_em2  =  0  
+ a0_a0_p3_a0_em2  =  0  
+ b0_b0_p4_a0_em2  =  0  
+ a0_b0_p4_a0_em2  =  0  
+ b0_a0_p4_a0_em2  =  0  
+ a0_a0_p4_a0_em2  =  0  
+ b0_b0_b0_a1_em2  =  23700  
+ a0_b0_b0_a1_em2  =  -10.4  
+ b0_a0_b0_a1_em2  =  0  
+ a0_a0_b0_a1_em2  =  0  
+ b0_b0_a0_a1_em2  =  200  
+ a0_b0_a0_a1_em2  =  0  
+ b0_a0_a0_a1_em2  =  0  
+ a0_a0_a0_a1_em2  =  0  
+ b0_b0_a1_a1_em2  =  -3860  
+ a0_b0_a1_a1_em2  =  -1.64  
+ b0_a0_a1_a1_em2  =  0  
+ a0_a0_a1_a1_em2  =  0  
+ b0_b0_a2_a1_em2  =  998  
+ a0_b0_a2_a1_em2  =  -5.27  
+ b0_a0_a2_a1_em2  =  0  
+ a0_a0_a2_a1_em2  =  0  
+ b0_b0_a3_a1_em2  =  -657  
+ a0_b0_a3_a1_em2  =  0.141  
+ b0_a0_a3_a1_em2  =  0  
+ a0_a0_a3_a1_em2  =  0  
+ b0_b0_a4_a1_em2  =  0  
+ a0_b0_a4_a1_em2  =  0  
+ b0_a0_a4_a1_em2  =  0  
+ a0_a0_a4_a1_em2  =  0  
+ b0_b0_p1_a1_em2  =  0.631  
+ a0_b0_p1_a1_em2  =  0.000618  
+ b0_a0_p1_a1_em2  =  0  
+ a0_a0_p1_a1_em2  =  0  
+ b0_b0_p2_a1_em2  =  2.37  
+ a0_b0_p2_a1_em2  =  -0.000604  
+ b0_a0_p2_a1_em2  =  0  
+ a0_a0_p2_a1_em2  =  0  
+ b0_b0_p3_a1_em2  =  3.58  
+ a0_b0_p3_a1_em2  =  -0.00168  
+ b0_a0_p3_a1_em2  =  0  
+ a0_a0_p3_a1_em2  =  0  
+ b0_b0_p4_a1_em2  =  5.2  
+ a0_b0_p4_a1_em2  =  0  
+ b0_a0_p4_a1_em2  =  0  
+ a0_a0_p4_a1_em2  =  0  
+ b0_b0_b0_a2_em2  =  7430  
+ a0_b0_b0_a2_em2  =  -1.43  
+ b0_a0_b0_a2_em2  =  0  
+ a0_a0_b0_a2_em2  =  0  
+ b0_b0_a0_a2_em2  =  0  
+ a0_b0_a0_a2_em2  =  0  
+ b0_a0_a0_a2_em2  =  0  
+ a0_a0_a0_a2_em2  =  0  
+ b0_b0_a1_a2_em2  =  -602  
+ a0_b0_a1_a2_em2  =  -0.872  
+ b0_a0_a1_a2_em2  =  0  
+ a0_a0_a1_a2_em2  =  0  
+ b0_b0_a2_a2_em2  =  -112  
+ a0_b0_a2_a2_em2  =  -0.0495  
+ b0_a0_a2_a2_em2  =  0  
+ a0_a0_a2_a2_em2  =  0  
+ b0_b0_a3_a2_em2  =  -38.9  
+ a0_b0_a3_a2_em2  =  0.0361  
+ b0_a0_a3_a2_em2  =  0  
+ a0_a0_a3_a2_em2  =  0  
+ b0_b0_a4_a2_em2  =  0  
+ a0_b0_a4_a2_em2  =  0  
+ b0_a0_a4_a2_em2  =  0  
+ a0_a0_a4_a2_em2  =  0  
+ b0_b0_p1_a2_em2  =  0.911  
+ a0_b0_p1_a2_em2  =  0.00201  
+ b0_a0_p1_a2_em2  =  0  
+ a0_a0_p1_a2_em2  =  0  
+ b0_b0_p2_a2_em2  =  4.52  
+ a0_b0_p2_a2_em2  =  -0.00107  
+ b0_a0_p2_a2_em2  =  0  
+ a0_a0_p2_a2_em2  =  0  
+ b0_b0_p3_a2_em2  =  18.2  
+ a0_b0_p3_a2_em2  =  -0.00874  
+ b0_a0_p3_a2_em2  =  0  
+ a0_a0_p3_a2_em2  =  0  
+ b0_b0_p4_a2_em2  =  5.5  
+ a0_b0_p4_a2_em2  =  0  
+ b0_a0_p4_a2_em2  =  0  
+ a0_a0_p4_a2_em2  =  0  
+ b0_b0_b0_a3_em2  =  799  
+ a0_b0_b0_a3_em2  =  6.91  
+ b0_a0_b0_a3_em2  =  13.4  
+ a0_a0_b0_a3_em2  =  -0.0439  
+ b0_b0_a0_a3_em2  =  0  
+ a0_b0_a0_a3_em2  =  0  
+ b0_a0_a0_a3_em2  =  0  
+ a0_a0_a0_a3_em2  =  0  
+ b0_b0_a1_a3_em2  =  0  
+ a0_b0_a1_a3_em2  =  0  
+ b0_a0_a1_a3_em2  =  0  
+ a0_a0_a1_a3_em2  =  0  
+ b0_b0_a2_a3_em2  =  0  
+ a0_b0_a2_a3_em2  =  0  
+ b0_a0_a2_a3_em2  =  0  
+ a0_a0_a2_a3_em2  =  0  
+ b0_b0_a3_a3_em2  =  0  
+ a0_b0_a3_a3_em2  =  0  
+ b0_a0_a3_a3_em2  =  0  
+ a0_a0_a3_a3_em2  =  0  
+ b0_b0_a4_a3_em2  =  0  
+ a0_b0_a4_a3_em2  =  0  
+ b0_a0_a4_a3_em2  =  0  
+ a0_a0_a4_a3_em2  =  0  
+ b0_b0_p1_a3_em2  =  0  
+ a0_b0_p1_a3_em2  =  0  
+ b0_a0_p1_a3_em2  =  0  
+ a0_a0_p1_a3_em2  =  0  
+ b0_b0_p2_a3_em2  =  0  
+ a0_b0_p2_a3_em2  =  0  
+ b0_a0_p2_a3_em2  =  0  
+ a0_a0_p2_a3_em2  =  0  
+ b0_b0_p3_a3_em2  =  0  
+ a0_b0_p3_a3_em2  =  0  
+ b0_a0_p3_a3_em2  =  0  
+ a0_a0_p3_a3_em2  =  0  
+ b0_b0_p4_a3_em2  =  0  
+ a0_b0_p4_a3_em2  =  0  
+ b0_a0_p4_a3_em2  =  0  
+ a0_a0_p4_a3_em2  =  0  
+ b0_b0_b0_a4_em2  =  554  
+ a0_b0_b0_a4_em2  =  -0.503  
+ b0_a0_b0_a4_em2  =  -0.985  
+ a0_a0_b0_a4_em2  =  -0.0173  
+ b0_b0_a0_a4_em2  =  100  
+ a0_b0_a0_a4_em2  =  0  
+ b0_a0_a0_a4_em2  =  0  
+ a0_a0_a0_a4_em2  =  0  
+ b0_b0_a1_a4_em2  =  502  
+ a0_b0_a1_a4_em2  =  -1.66  
+ b0_a0_a1_a4_em2  =  0.061  
+ a0_a0_a1_a4_em2  =  -0.0078  
+ b0_b0_a2_a4_em2  =  -606  
+ a0_b0_a2_a4_em2  =  2.1  
+ b0_a0_a2_a4_em2  =  0  
+ a0_a0_a2_a4_em2  =  0.00263  
+ b0_b0_a3_a4_em2  =  -323  
+ a0_b0_a3_a4_em2  =  0.511  
+ b0_a0_a3_a4_em2  =  -5.73  
+ a0_a0_a3_a4_em2  =  0.0143  
+ b0_b0_a4_a4_em2  =  0  
+ a0_b0_a4_a4_em2  =  0  
+ b0_a0_a4_a4_em2  =  0  
+ a0_a0_a4_a4_em2  =  0  
+ b0_b0_p1_a4_em2  =  -12.1  
+ a0_b0_p1_a4_em2  =  0.0359  
+ b0_a0_p1_a4_em2  =  -0.239  
+ a0_a0_p1_a4_em2  =  0.000769  
+ b0_b0_p2_a4_em2  =  -0.756  
+ a0_b0_p2_a4_em2  =  0.00761  
+ b0_a0_p2_a4_em2  =  -0.0632  
+ a0_a0_p2_a4_em2  =  0.000261  
+ b0_b0_p3_a4_em2  =  5.78  
+ a0_b0_p3_a4_em2  =  -0.00883  
+ b0_a0_p3_a4_em2  =  0.0211  
+ a0_a0_p3_a4_em2  =  -0.0000494  
+ b0_b0_p4_a4_em2  =  2.41  
+ a0_b0_p4_a4_em2  =  0.00486  
+ b0_a0_p4_a4_em2  =  -0.0315  
+ a0_a0_p4_a4_em2  =  0.0000687  
+ b0_b0_b0_p1_em2  =  0.0893  
+ a0_b0_b0_p1_em2  =  0  
+ b0_a0_b0_p1_em2  =  0  
+ a0_a0_b0_p1_em2  =  0  
+ b0_b0_a0_p1_em2  =  0  
+ a0_b0_a0_p1_em2  =  0  
+ b0_a0_a0_p1_em2  =  0  
+ a0_a0_a0_p1_em2  =  0  
+ b0_b0_a1_p1_em2  =  0.613  
+ a0_b0_a1_p1_em2  =  0  
+ b0_a0_a1_p1_em2  =  0  
+ a0_a0_a1_p1_em2  =  0  
+ b0_b0_a2_p1_em2  =  -0.623  
+ a0_b0_a2_p1_em2  =  0  
+ b0_a0_a2_p1_em2  =  0  
+ a0_a0_a2_p1_em2  =  0  
+ b0_b0_a3_p1_em2  =  -0.0919  
+ a0_b0_a3_p1_em2  =  0  
+ b0_a0_a3_p1_em2  =  0  
+ a0_a0_a3_p1_em2  =  0  
+ b0_b0_a4_p1_em2  =  0  
+ a0_b0_a4_p1_em2  =  0  
+ b0_a0_a4_p1_em2  =  0  
+ a0_a0_a4_p1_em2  =  0  
+ b0_b0_p1_p1_em2  =  -0.96  
+ a0_b0_p1_p1_em2  =  0  
+ b0_a0_p1_p1_em2  =  0  
+ a0_a0_p1_p1_em2  =  0  
+ b0_b0_p2_p1_em2  =  1.03  
+ a0_b0_p2_p1_em2  =  0  
+ b0_a0_p2_p1_em2  =  0  
+ a0_a0_p2_p1_em2  =  0  
+ b0_b0_p3_p1_em2  =  2.32  
+ a0_b0_p3_p1_em2  =  0  
+ b0_a0_p3_p1_em2  =  0  
+ a0_a0_p3_p1_em2  =  0  
+ b0_b0_p4_p1_em2  =  5.5  
+ a0_b0_p4_p1_em2  =  0  
+ b0_a0_p4_p1_em2  =  0  
+ a0_a0_p4_p1_em2  =  0  
+ b0_b0_b0_p2_em2  =  6.48  
+ a0_b0_b0_p2_em2  =  0.00828  
+ b0_a0_b0_p2_em2  =  0  
+ a0_a0_b0_p2_em2  =  0  
+ b0_b0_a0_p2_em2  =  0.3  
+ a0_b0_a0_p2_em2  =  0  
+ b0_a0_a0_p2_em2  =  0  
+ a0_a0_a0_p2_em2  =  0  
+ b0_b0_a1_p2_em2  =  2  
+ a0_b0_a1_p2_em2  =  0.000539  
+ b0_a0_a1_p2_em2  =  0  
+ a0_a0_a1_p2_em2  =  0  
+ b0_b0_a2_p2_em2  =  0.153  
+ a0_b0_a2_p2_em2  =  -0.00243  
+ b0_a0_a2_p2_em2  =  0  
+ a0_a0_a2_p2_em2  =  0  
+ b0_b0_a3_p2_em2  =  2.38  
+ a0_b0_a3_p2_em2  =  -0.00359  
+ b0_a0_a3_p2_em2  =  0  
+ a0_a0_a3_p2_em2  =  0  
+ b0_b0_a4_p2_em2  =  0  
+ a0_b0_a4_p2_em2  =  0  
+ b0_a0_a4_p2_em2  =  0  
+ a0_a0_a4_p2_em2  =  0  
+ b0_b0_p1_p2_em2  =  0.7  
+ a0_b0_p1_p2_em2  =  0.0005  
+ b0_a0_p1_p2_em2  =  0  
+ a0_a0_p1_p2_em2  =  0  
+ b0_b0_p2_p2_em2  =  2.04  
+ a0_b0_p2_p2_em2  =  0.000444  
+ b0_a0_p2_p2_em2  =  0  
+ a0_a0_p2_p2_em2  =  0  
+ b0_b0_p3_p2_em2  =  4.7  
+ a0_b0_p3_p2_em2  =  -0.00315  
+ b0_a0_p3_p2_em2  =  0  
+ a0_a0_p3_p2_em2  =  0  
+ b0_b0_p4_p2_em2  =  3.9  
+ a0_b0_p4_p2_em2  =  0.00151  
+ b0_a0_p4_p2_em2  =  0  
+ a0_a0_p4_p2_em2  =  0  
+ b0_b0_b0_p3_em2  =  23.9  
+ a0_b0_b0_p3_em2  =  -0.00894  
+ b0_a0_b0_p3_em2  =  -0.0159  
+ a0_a0_b0_p3_em2  =  0.0000784  
+ b0_b0_a0_p3_em2  =  0  
+ a0_b0_a0_p3_em2  =  0  
+ b0_a0_a0_p3_em2  =  0  
+ a0_a0_a0_p3_em2  =  0  
+ b0_b0_a1_p3_em2  =  0  
+ a0_b0_a1_p3_em2  =  0  
+ b0_a0_a1_p3_em2  =  0  
+ a0_a0_a1_p3_em2  =  0  
+ b0_b0_a2_p3_em2  =  0  
+ a0_b0_a2_p3_em2  =  0  
+ b0_a0_a2_p3_em2  =  0  
+ a0_a0_a2_p3_em2  =  0  
+ b0_b0_a3_p3_em2  =  0  
+ a0_b0_a3_p3_em2  =  0  
+ b0_a0_a3_p3_em2  =  0  
+ a0_a0_a3_p3_em2  =  0  
+ b0_b0_a4_p3_em2  =  0  
+ a0_b0_a4_p3_em2  =  0  
+ b0_a0_a4_p3_em2  =  0  
+ a0_a0_a4_p3_em2  =  0  
+ b0_b0_p1_p3_em2  =  0  
+ a0_b0_p1_p3_em2  =  0  
+ b0_a0_p1_p3_em2  =  0  
+ a0_a0_p1_p3_em2  =  0  
+ b0_b0_p2_p3_em2  =  0  
+ a0_b0_p2_p3_em2  =  0  
+ b0_a0_p2_p3_em2  =  0  
+ a0_a0_p2_p3_em2  =  0  
+ b0_b0_p3_p3_em2  =  0  
+ a0_b0_p3_p3_em2  =  0  
+ b0_a0_p3_p3_em2  =  0  
+ a0_a0_p3_p3_em2  =  0  
+ b0_b0_p4_p3_em2  =  0  
+ a0_b0_p4_p3_em2  =  0  
+ b0_a0_p4_p3_em2  =  0  
+ a0_a0_p4_p3_em2  =  0  
+ b0_b0_b0_p4_em2  =  31.8  
+ a0_b0_b0_p4_em2  =  -0.00268  
+ b0_a0_b0_p4_em2  =  -0.0274  
+ a0_a0_b0_p4_em2  =  0.000119  
+ b0_b0_a0_p4_em2  =  0  
+ a0_b0_a0_p4_em2  =  0  
+ b0_a0_a0_p4_em2  =  0  
+ a0_a0_a0_p4_em2  =  0  
+ b0_b0_a1_p4_em2  =  0  
+ a0_b0_a1_p4_em2  =  0  
+ b0_a0_a1_p4_em2  =  0  
+ a0_a0_a1_p4_em2  =  0  
+ b0_b0_a2_p4_em2  =  0  
+ a0_b0_a2_p4_em2  =  0  
+ b0_a0_a2_p4_em2  =  0  
+ a0_a0_a2_p4_em2  =  0  
+ b0_b0_a3_p4_em2  =  0  
+ a0_b0_a3_p4_em2  =  0  
+ b0_a0_a3_p4_em2  =  0  
+ a0_a0_a3_p4_em2  =  0  
+ b0_b0_a4_p4_em2  =  0  
+ a0_b0_a4_p4_em2  =  0  
+ b0_a0_a4_p4_em2  =  0  
+ a0_a0_a4_p4_em2  =  0  
+ b0_b0_p1_p4_em2  =  0  
+ a0_b0_p1_p4_em2  =  0  
+ b0_a0_p1_p4_em2  =  0  
+ a0_a0_p1_p4_em2  =  0  
+ b0_b0_p2_p4_em2  =  0  
+ a0_b0_p2_p4_em2  =  0  
+ b0_a0_p2_p4_em2  =  0  
+ a0_a0_p2_p4_em2  =  0  
+ b0_b0_p3_p4_em2  =  0  
+ a0_b0_p3_p4_em2  =  0  
+ b0_a0_p3_p4_em2  =  0  
+ a0_a0_p3_p4_em2  =  0  
+ b0_b0_p4_p4_em2  =  0  
+ a0_b0_p4_p4_em2  =  0  
+ b0_a0_p4_p4_em2  =  0  
+ a0_a0_p4_p4_em2  =  0  
}
endsection pmos90b_10hv_dfrt

section rpoly0_10hv_dfrt
include "soachecks_top.scs" section=rpoly0_10hv_soa
if (enable_esdsoa == 1) {
arpoly0_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly0_It2" targetT=0.0 device1="zrpoly0_10hv" current_probe1="ibody" formulae_cond1="I(d)/(w*np) > 3.10e-3 for duration > 0.0ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=(w*np*3.10e-3)
arpoly0_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly0_Vdwell_maxV" targetT=0.0 formulae_cond1="absV(d-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly0_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly0_Vswell_maxV" targetT=0.0 formulae_cond1="absV(s-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly0_10hv_dfrt

section rpoly0_10hv_dfrt_simple
include "soachecks_top.scs" section=rpoly0_10hv_simple_soa
if (enable_esdsoa == 1) {
arpoly0_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly0_It2" targetT=0.0 device1="rrpoly0_10hvd" current_probe1="i" device2="ccdrpoly0_10hv" current_probe2="i" formulae_cond1="I(d)/(w*np) > 3.10e-3 for duration > 0.0ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=(w*np*3.10e-3)
arpoly0_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly0_Vdwell_maxV" targetT=0.0 formulae_cond1="abs(V(d-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly0_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly0_Vswell_maxV" targetT=0.0 formulae_cond1="abs(V(s-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly0_10hv_dfrt_simple

section rpoly_10hv_dfrt
include "soachecks_top.scs" section=rpoly_10hv_soa
if (enable_esdsoa == 1) {
arpoly_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly_It2" targetT=0.0 device1="zrpoly_10hv" current_probe1="ibody" formulae_cond1="I(d)/(w*np) > 1.0e-3 for duration > 0.0ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=(w*np*1.0e-3)
arpoly_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly_Vdwell_maxV" targetT=0.0 formulae_cond1="absV(d-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly_Vswell_maxV" targetT=0.0 formulae_cond1="absV(s-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly_10hv_dfrt

section rpoly_10hv_dfrt_simple
include "soachecks_top.scs" section=rpoly_10hv_simple_soa
if (enable_esdsoa == 1) {
arpoly_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly_It2" targetT=0.0 device1="rrpoly_10hvd" current_probe1="i" device2="ccdrpoly_10hv" current_probe2="i" formulae_cond1="I(d)/(w*np) > 1.0e-3 for duration > 0.0ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=(w*np*1.0e-3)
arpoly_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly_Vdwell_maxV" targetT=0.0 formulae_cond1="abs(V(d-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly_Vswell_maxV" targetT=0.0 formulae_cond1="abs(V(s-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly_10hv_dfrt_simple

section rhvpw_10hv_dfrt
include "soachecks_top.scs" section=rhvpw_10hv_soa
if (enable_esdsoa == 1) {
arhvpw_10hv_esdchk_1 (nw s) monitor2t enable=soa rule="esd_rhvpw_Vnws_maxV" targetT=0.0 formulae_cond1="V(nw-to-s) > 36.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=36.3
arhvpw_10hv_esdchk_2 (nw d) monitor2t enable=soa rule="esd_rhvpw_Vnwd_maxV" targetT=0.0 formulae_cond1="V(nw-to-d) > 36.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=36.3
arhvpw_10hv_esdchk_3 (nw sub) monitor2t enable=soa rule="esd_rhvpw_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arhvpw_10hv_esdchk_4 (sub nw) monitor2t enable=soa rule="esd_rhvpw_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rhvpw_10hv_dfrt

section rphv_10hv_dfrt
include "soachecks_top.scs" section=rphv_10hv_soa
if (enable_esdsoa == 1) {
arphv_10hv_esdchk_1 (nw s) monitor2t enable=soa rule="esd_rphv_Vnws_maxV" targetT=0.0 formulae_cond1="V(nw-to-s) > 36.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=36.3
arphv_10hv_esdchk_2 (nw d) monitor2t enable=soa rule="esd_rphv_Vnwd_maxV" targetT=0.0 formulae_cond1="V(nw-to-d) > 36.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=36.3
arphv_10hv_esdchk_3 (nw sub) monitor2t enable=soa rule="esd_rphv_Vnwsub_maxV" targetT=0.0 formulae_cond1="V(nw-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arphv_10hv_esdchk_4 (sub nw) monitor2t enable=soa rule="esd_rphv_Vsubnw_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-nw) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rphv_10hv_dfrt

section antifuse_t_10hv_dfrt
endsection antifuse_t_10hv_dfrt

section antifuse_10hv_dfrt
if (enable_esdsoa == 1) {
aantifuse_10hv_esdchk_1 (wr s) monitor2t enable=soa rule="esd_antifuse_Vwrs_maxV" targetT=0.0 formulae_cond1="absV(wr-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
aantifuse_10hv_esdchk_2 (s sub) monitor2t enable=soa rule="esd_antifuse_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
aantifuse_10hv_esdchk_3 (sub s) monitor2t enable=soa rule="esd_antifuse_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection antifuse_10hv_dfrt

section rpoly_1meg_10hv_dfrt
include "soachecks_top.scs" section=rpoly_1meg_10hv_soa
if (enable_esdsoa == 1) {
arpoly_1meg_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly_1meg_It2" targetT=100 device1="zrpoly_1meg_10hv" current_probe1="ibody" formulae_cond1="I(d) > 5.49e-3 for duration > 100ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.49e-3
arpoly_1meg_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly_1meg_Vdwell_maxV" targetT=0.0 formulae_cond1="absV(d-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly_1meg_Vswell_maxV" targetT=0.0 formulae_cond1="absV(s-to-well) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_4 (well sub) monitor2t enable=soa rule="esd_rpoly_1meg_Vwellsub_maxV" targetT=0.0 formulae_cond1="V(well-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_5 (sub well) monitor2t enable=soa rule="esd_rpoly_1meg_Vsubwell_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly_1meg_10hv_dfrt

section rpoly_1meg_10hv_dfrt_simple
include "soachecks_top.scs" section=rpoly_1meg_10hv_simple_soa
if (enable_esdsoa == 1) {
arpoly_1meg_10hv_esdchk_1 (d 0) monitor2t enable=soa rule="esd_rpoly_1meg_It2" targetT=100 device1="rrpoly_1meg_10hvd" current_probe1="i" device2="ccdrpoly_1meg_10hv" current_probe2="i" formulae_cond1="I(d) > 5.49e-3 for duration > 100ns" monitorType_cond1=2 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.49e-3
arpoly_1meg_10hv_esdchk_2 (d well) monitor2t enable=soa rule="esd_rpoly_1meg_Vdwell_maxV" targetT=0.0 formulae_cond1="abs(V(d-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_3 (s well) monitor2t enable=soa rule="esd_rpoly_1meg_Vswell_maxV" targetT=0.0 formulae_cond1="abs(V(s-to-well)) > 200 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_4 (well sub) monitor2t enable=soa rule="esd_rpoly_1meg_Vwellsub_maxV" targetT=0.0 formulae_cond1="V(well-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
arpoly_1meg_10hv_esdchk_5 (sub well) monitor2t enable=soa rule="esd_rpoly_1meg_Vsubwell_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-well) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection rpoly_1meg_10hv_dfrt_simple

section rm1_10hv_dfrt
include "soachecks_top.scs" section=rm1_10hv_soa
endsection rm1_10hv_dfrt

section rm2_10hv_dfrt
include "soachecks_top.scs" section=rm2_10hv_soa
endsection rm2_10hv_dfrt

section rm3_10hv_dfrt
include "soachecks_top.scs" section=rm3_10hv_soa
endsection rm3_10hv_dfrt

section rm4_10hv_dfrt
include "soachecks_top.scs" section=rm4_10hv_soa
endsection rm4_10hv_dfrt

section rulm_10hv_dfrt
include "soachecks_top.scs" section=rulm_10hv_soa
endsection rulm_10hv_dfrt

section ralcap_10hv_dfrt
include "soachecks_top.scs" section=ralcap_10hv_soa
endsection ralcap_10hv_dfrt

section dz5b_10hv_dfrt
include "soachecks_top.scs" section=dz5b_10hv_soa
if (enable_esdsoa == 1) {
adz5b_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dz5b_Vnp_maxV" targetT=0.0 formulae_cond1="V(n-to-p) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0
adz5b_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dz5b_Vpn_maxV" targetT=0.0 formulae_cond1="V(p-to-n) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
adz5b_10hv_esdchk_3 (n sub) monitor2t enable=soa rule="esd_dz5b_Vnsub_maxV" targetT=0.0 formulae_cond1="V(n-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
adz5b_10hv_esdchk_4 (sub p) monitor2t enable=soa rule="esd_dz5b_Vsubp_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-p) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection dz5b_10hv_dfrt

section npn_b_10hv_dfrt
include "soachecks_top.scs" section=npn_b_10hv_soa
if (enable_esdsoa == 1) {
anpn_b_10hv_esdchk_1 (c b) monitor2t enable=soa rule="esd_npn_b_Vcb_maxV" targetT=0.0 formulae_cond1="V(c-to-b) > 60.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=60.4
anpn_b_10hv_esdchk_2 (e b) monitor2t enable=soa rule="esd_npn_b_Veb_maxV" targetT=0.0 formulae_cond1="V(e-to-b) > 17.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=17.4
anpn_b_10hv_esdchk_3 (c e) monitor2t enable=soa rule="esd_npn_b_Vce_maxV" targetT=0.0 formulae_cond1="V(c-to-e) > 29.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=29.3
anpn_b_10hv_esdchk_4 (c sub) monitor2t enable=soa rule="esd_npn_b_Vcsub_maxV" targetT=0.0 formulae_cond1="V(c-to-sub) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
anpn_b_10hv_esdchk_5 (sub e) monitor2t enable=soa rule="esd_npn_b_Vsube_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-e) > 200 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection npn_b_10hv_dfrt

section dpldd_10hv_dfrt
include "soachecks_top.scs" section=dpldd_10hv_soa
if (enable_esdsoa == 1) {
adpldd_10hv_esdchk_1 (n p) monitor2t enable=soa rule="esd_dpldd_Vnp_maxV" targetT=0.0 formulae_cond1="cond1:voltage:n|p:gt:10.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
adpldd_10hv_esdchk_2 (p n) monitor2t enable=soa rule="esd_dpldd_Vpn_maxV" targetT=0.0 formulae_cond1="cond1:voltage:p|n:gt:4.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0
}
endsection dpldd_10hv_dfrt

section nmos120_10hv_dfrt
include "soachecks_top.scs" section=nmos120_10hv_soa
if (enable_esdsoa == 1) {
anmos120_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=1 enable=soa rule="esd_nmos120_Vt1=165p5_Vgs0p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-0.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-165.5):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=2 enable=soa rule="esd_nmos120_Vt1>165p5_Vgs0p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-0.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:165.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=165.5
anmos120_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=3 enable=soa rule="esd_nmos120_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:0.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="cond2:voltage:g|s:lt:0.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(5.0*(V(g)-V(s)-0.0))-165.5):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=4 enable=soa rule="esd_nmos120_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:0.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="cond2:voltage:g|s:lt:0.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(5.0*(V(g)-V(s)-0.0)):gt:165.5" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=165.5
anmos120_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=5 enable=soa rule="esd_nmos120_Vt1=163p0_Vgs0p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-0.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-163.0):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=6 enable=soa rule="esd_nmos120_Vt1>163p0_Vgs0p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-0.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:163.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=163.0
anmos120_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=7 enable=soa rule="esd_nmos120_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:0.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="cond2:voltage:g|s:lt:1.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-163.0):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=8 enable=soa rule="esd_nmos120_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:0.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="cond2:voltage:g|s:lt:1.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5)):gt:163.0" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=163.0
anmos120_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=9 enable=soa rule="esd_nmos120_Vt1=163p0_Vgs1p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-1.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-163.0):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=10 enable=soa rule="esd_nmos120_Vt1>163p0_Vgs1p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-1.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:163.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=163.0
anmos120_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=11 enable=soa rule="esd_nmos120_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:1.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="cond2:voltage:g|s:lt:1.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0))-163.0):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=12 enable=soa rule="esd_nmos120_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:1.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="cond2:voltage:g|s:lt:1.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0)):gt:163.0" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=163.0
anmos120_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=13 enable=soa rule="esd_nmos120_Vt1=163p0_Vgs1p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-1.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-163.0):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=14 enable=soa rule="esd_nmos120_Vt1>163p0_Vgs1p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-1.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:163.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=163.0
anmos120_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=15 enable=soa rule="esd_nmos120_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:1.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="cond2:voltage:g|s:lt:2.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(4.8*(V(g)-V(s)-1.5))-163.0):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=16 enable=soa rule="esd_nmos120_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:1.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="cond2:voltage:g|s:lt:2.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(4.8*(V(g)-V(s)-1.5)):gt:163.0" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=163.0
anmos120_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=17 enable=soa rule="esd_nmos120_Vt1=158p2_Vgs2p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-2.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-158.2):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=18 enable=soa rule="esd_nmos120_Vt1>158p2_Vgs2p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-2.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:158.2" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=158.2
anmos120_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=19 enable=soa rule="esd_nmos120_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:2.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="cond2:voltage:g|s:lt:3.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(2.7*(V(g)-V(s)-2.5))-158.2):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=20 enable=soa rule="esd_nmos120_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:2.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="cond2:voltage:g|s:lt:3.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(2.7*(V(g)-V(s)-2.5)):gt:158.2" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=158.2
anmos120_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=21 enable=soa rule="esd_nmos120_Vt1=155p5_Vgs3p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-3.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-155.5):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=22 enable=soa rule="esd_nmos120_Vt1>155p5_Vgs3p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-3.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:155.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=155.5
anmos120_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=23 enable=soa rule="esd_nmos120_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:3.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="cond2:voltage:g|s:lt:4.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(1.4*(V(g)-V(s)-3.5))-155.5):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=24 enable=soa rule="esd_nmos120_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:3.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="cond2:voltage:g|s:lt:4.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(1.4*(V(g)-V(s)-3.5)):gt:155.5" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=155.5
anmos120_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=25 enable=soa rule="esd_nmos120_Vt1=154p1_Vgs4p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-4.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-154.1):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=26 enable=soa rule="esd_nmos120_Vt1>154p1_Vgs4p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-4.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:154.1" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=154.1
anmos120_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=27 enable=soa rule="esd_nmos120_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:4.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="cond2:voltage:g|s:lt:5.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="cond3:specialVoltage:abs(V(d)-V(s)+(-0.3*(V(g)-V(s)-4.5))-154.1):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos120_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=28 enable=soa rule="esd_nmos120_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:4.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="cond2:voltage:g|s:lt:5.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="cond3:specialVoltage:V(d)-V(s)+(-0.3*(V(g)-V(s)-4.5)):gt:154.1" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=154.1
anmos120_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=29 enable=soa rule="esd_nmos120_Vt1=154p4_Vgs5p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-5.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-154.4):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=30 enable=soa rule="esd_nmos120_Vt1>154p4_Vgs5p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(g)-V(s)-5.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:voltage:d|s:gt:154.4" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=154.4
anmos120_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos120_10hv ruleNum=31 enable=soa rule="esd_nmos120_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:5.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="cond2:specialVoltage:abs(V(d)-V(s)-154.4):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos120_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nmos120_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="cond1:voltage:g|s:gt:5.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="cond2:voltage:d|s:gt:154.4" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=154.4
anmos120_10hv_esdchk_33 (g b) monitor2t enable=soa rule="esd_nmos120_Vgb_BVox" targetT=0.0 formulae_cond1="cond1:absvoltage:g|b:gt:16.7" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos120_10hv_esdchk_34 (g s) monitor2t enable=soa rule="esd_nmos120_Vgs_BVox" targetT=0.0 formulae_cond1="cond1:absvoltage:g|s:gt:16.7" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos120_10hv_esdchk_35 (g d) monitor2t enable=soa rule="esd_nmos120_Vgd_BVox" targetT=0.0 formulae_cond1="cond1:absvoltage:g|d:gt:165.5" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=165.5
anmos120_10hv_esdchk_36 (s b) monitor2t enable=soa rule="esd_nmos120_Vsb_Vt1" targetT=0.0 formulae_cond1="cond1:voltage:s|b:gt:9.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos120_10hv_esdchk_37 (d b) monitor2t enable=soa rule="esd_nmos120_Vdb_Vt1" targetT=0.0 formulae_cond1="cond1:voltage:d|b:gt:165.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=165.5
anmos120_10hv_esdchk_38 (d sub) monitor2t enable=soa rule="esd_nmos120_Vdsub_maxV" targetT=0.0 formulae_cond1="cond1:voltage:d|sub:gt:200.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos120_10hv_esdchk_39 (sub b) monitor2t enable=soa rule="esd_nmos120_Vsubb_maxNegV" targetT=0.0 formulae_cond1="cond1:voltage:sub|b:gt:200.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos120_10hv_esdchk_40 (b d) monitor2t enable=soa rule="esd_nmos120_Vbd_Vt1" targetT=0.0 formulae_cond1="cond1:voltage:b|d:gt:5.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection nmos120_10hv_dfrt

section pld120_10hv_dfrt
include "soachecks_top.scs" section=pld120_10hv_soa
if (enable_esdsoa == 1) {
apld120_10hv_esdchk_1 (d g s sub) monitor_esd_pld120_10hv ruleNum=1 enable=soa rule="esd_pld120_Vt1=142p3_Vgs0p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-0.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-142.3):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_2 (d g s sub) monitor_esd_pld120_10hv ruleNum=2 enable=soa rule="esd_pld120_Vt1>142p3_Vgs0p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-0.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:142.3" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=142.3
apld120_10hv_esdchk_3 (d g s sub) monitor_esd_pld120_10hv ruleNum=3 enable=soa rule="esd_pld120_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:0.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="cond2:voltage:s|g:lt:0.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-142.3):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_4 (d g s sub) monitor_esd_pld120_10hv ruleNum=4 enable=soa rule="esd_pld120_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:0.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="cond2:voltage:s|g:lt:0.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))):gt:142.3" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=142.3
apld120_10hv_esdchk_5 (d g s sub) monitor_esd_pld120_10hv ruleNum=5 enable=soa rule="esd_pld120_Vt1=142p3_Vgs0p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-0.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-142.3):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_6 (d g s sub) monitor_esd_pld120_10hv ruleNum=6 enable=soa rule="esd_pld120_Vt1>142p3_Vgs0p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-0.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:142.3" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=142.3
apld120_10hv_esdchk_7 (d g s sub) monitor_esd_pld120_10hv ruleNum=7 enable=soa rule="esd_pld120_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:0.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="cond2:voltage:s|g:lt:1.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(9.6*(V(s)-V(g)-0.5))-142.3):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_8 (d g s sub) monitor_esd_pld120_10hv ruleNum=8 enable=soa rule="esd_pld120_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:0.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="cond2:voltage:s|g:lt:1.0" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(9.6*(V(s)-V(g)-0.5))):gt:142.3" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=142.3
apld120_10hv_esdchk_9 (d g s sub) monitor_esd_pld120_10hv ruleNum=9 enable=soa rule="esd_pld120_Vt1=137p5_Vgs1p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-1.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-137.5):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_10 (d g s sub) monitor_esd_pld120_10hv ruleNum=10 enable=soa rule="esd_pld120_Vt1>137p5_Vgs1p0" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-1.0):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:137.5" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=137.5
apld120_10hv_esdchk_11 (d g s sub) monitor_esd_pld120_10hv ruleNum=11 enable=soa rule="esd_pld120_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:1.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="cond2:voltage:s|g:lt:1.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(4.0*(V(s)-V(g)-1.0))-137.5):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_12 (d g s sub) monitor_esd_pld120_10hv ruleNum=12 enable=soa rule="esd_pld120_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:1.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="cond2:voltage:s|g:lt:1.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(4.0*(V(s)-V(g)-1.0))):gt:137.5" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=137.5
apld120_10hv_esdchk_13 (d g s sub) monitor_esd_pld120_10hv ruleNum=13 enable=soa rule="esd_pld120_Vt1=135p5_Vgs1p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-1.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-135.5):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_14 (d g s sub) monitor_esd_pld120_10hv ruleNum=14 enable=soa rule="esd_pld120_Vt1>135p5_Vgs1p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-1.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:135.5" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=135.5
apld120_10hv_esdchk_15 (d g s sub) monitor_esd_pld120_10hv ruleNum=15 enable=soa rule="esd_pld120_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:1.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="cond2:voltage:s|g:lt:2.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.5))-135.5):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_16 (d g s sub) monitor_esd_pld120_10hv ruleNum=16 enable=soa rule="esd_pld120_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:1.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="cond2:voltage:s|g:lt:2.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.5))):gt:135.5" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=135.5
apld120_10hv_esdchk_17 (d g s sub) monitor_esd_pld120_10hv ruleNum=17 enable=soa rule="esd_pld120_Vt1=135p5_Vgs2p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-2.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-135.5):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_18 (d g s sub) monitor_esd_pld120_10hv ruleNum=18 enable=soa rule="esd_pld120_Vt1>135p5_Vgs2p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-2.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:135.5" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=135.5
apld120_10hv_esdchk_19 (d g s sub) monitor_esd_pld120_10hv ruleNum=19 enable=soa rule="esd_pld120_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:2.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="cond2:voltage:s|g:lt:3.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(1.1*(V(s)-V(g)-2.5))-135.5):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_20 (d g s sub) monitor_esd_pld120_10hv ruleNum=20 enable=soa rule="esd_pld120_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:2.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="cond2:voltage:s|g:lt:3.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(1.1*(V(s)-V(g)-2.5))):gt:135.5" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=135.5
apld120_10hv_esdchk_21 (d g s sub) monitor_esd_pld120_10hv ruleNum=21 enable=soa rule="esd_pld120_Vt1=134p4_Vgs3p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-3.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-134.4):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_22 (d g s sub) monitor_esd_pld120_10hv ruleNum=22 enable=soa rule="esd_pld120_Vt1>134p4_Vgs3p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-3.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:134.4" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=134.4
apld120_10hv_esdchk_23 (d g s sub) monitor_esd_pld120_10hv ruleNum=23 enable=soa rule="esd_pld120_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:3.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="cond2:voltage:s|g:lt:4.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(9.4*(V(s)-V(g)-3.5))-134.4):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_24 (d g s sub) monitor_esd_pld120_10hv ruleNum=24 enable=soa rule="esd_pld120_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:3.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="cond2:voltage:s|g:lt:4.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(9.4*(V(s)-V(g)-3.5))):gt:134.4" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=134.4
apld120_10hv_esdchk_25 (d g s sub) monitor_esd_pld120_10hv ruleNum=25 enable=soa rule="esd_pld120_Vt1=125p0_Vgs4p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-4.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-125.0):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_26 (d g s sub) monitor_esd_pld120_10hv ruleNum=26 enable=soa rule="esd_pld120_Vt1>125p0_Vgs4p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-4.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:125.0" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=125.0
apld120_10hv_esdchk_27 (d g s sub) monitor_esd_pld120_10hv ruleNum=27 enable=soa rule="esd_pld120_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:4.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="cond2:voltage:s|g:lt:5.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(0.2*(V(s)-V(g)-4.5))-125.0):lt:1e-9" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld120_10hv_esdchk_28 (d g s sub) monitor_esd_pld120_10hv ruleNum=28 enable=soa rule="esd_pld120_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:4.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="cond2:voltage:s|g:lt:5.5" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="cond3:specialVoltage:abs(V(s)-V(d)+(0.2*(V(s)-V(g)-4.5))):gt:125.0" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=125.0
apld120_10hv_esdchk_29 (d g s sub) monitor_esd_pld120_10hv ruleNum=29 enable=soa rule="esd_pld120_Vt1=124p8_Vgs5p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-5.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-124.8):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_30 (d g s sub) monitor_esd_pld120_10hv ruleNum=30 enable=soa rule="esd_pld120_Vt1>124p8_Vgs5p5" targetT=0.0 formulae_cond1="cond1:specialVoltage:abs(V(s)-V(g)-5.5):lt:1e-9" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="cond2:absvoltage:s|d:gt:124.8" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.8
apld120_10hv_esdchk_31 (d g s sub) monitor_esd_pld120_10hv ruleNum=31 enable=soa rule="esd_pld120_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:5.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="cond2:specialVoltage:abs(V(s)-V(d)-124.8):lt:1e-9" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld120_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pld120_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="cond1:voltage:s|g:gt:5.5" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="cond2:absvoltage:s|d:gt:124.8" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.8
apld120_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_pld120_Vgs_BVox" targetT=0.0 formulae_cond1="cond1:absvoltage:g|s:gt:16.7" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld120_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_pld120_Vgd_BVox" targetT=0.0 formulae_cond1="cond1:absvoltage:g|d:gt:142.3" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=142.3
apld120_10hv_esdchk_35 (s sub) monitor2t enable=soa rule="esd_pld120_Vssub_maxV" targetT=0.0 formulae_cond1="cond1:voltage:s|sub:gt:200.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld120_10hv_esdchk_36 (sub d) monitor2t enable=soa rule="esd_pld120_Vsubd_maxNegV" targetT=0.0 formulae_cond1="cond1:voltage:sub|d:gt:200.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld120_10hv_esdchk_37 (d s) monitor2t enable=soa rule="esd_pld120_Vds_Vt1" targetT=0.0 formulae_cond1="cond1:voltage:d|s:gt:5.0" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection pld120_10hv_dfrt

section cfr120_10hv_dfrt
include "soachecks_top.scs" section=cfr120_10hv_soa
if (enable_esdsoa == 1) {
acfr120_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr120_Vtb_maxV" targetT=0.0 formulae_cond1="cond1:absvoltage:t|b:gt:200.0" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr120_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr120_Vtwellsub_maxV" targetT=0.0 formulae_cond1="cond1:voltage:t|well:gt:200" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr120_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr120_Vbwell_maxV" targetT=0.0 formulae_cond1="cond1:voltage:b|well:gt:200" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr120_10hv_dfrt

section cfr120_m1m2m3_10hv_dfrt
include "soachecks_top.scs" section=cfr120_10hv_soa
if (enable_esdsoa == 1) {
acfr120_m1m2m3_10hv_esdchk_1 (t b) monitor2t enable=soa rule="esd_cfr120_m1m2m3_Vtb_maxV" targetT=0.0 formulae_cond1="cond1:absvoltage:t|b:gt:200.0" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
acfr120_m1m2m3_10hv_esdchk_2 (t well) monitor2t enable=soa rule="esd_cfr120_m1m2m3_Vtwellsub_maxV" targetT=0.0 formulae_cond1="cond1:voltage:t|well:gt:200" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
acfr120_m1m2m3_10hv_esdchk_3 (b well) monitor2t enable=soa rule="esd_cfr120_m1m2m3_Vbwell_maxV" targetT=0.0 formulae_cond1="cond1:voltage:b|well:gt:200" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200
}
endsection cfr120_m1m2m3_10hv_dfrt
