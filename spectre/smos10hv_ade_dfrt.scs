////////////////////////////////////////
// design for reliability tools model control file for smos10hv
// Developed by : circuit CAE
// Created on   : 08/04/2025 
// by           : nxg09819 
// NXP Internal Use Only  
//
// Version update:
// version    time          comment
// v17.1:     04/08/2025    1, Soa rules updated based on v3.17ER_06122025 provided by Betsy.
//                          2, Tempco of diode fwd limits changes to 0.0006 from 0.006
//                          3, Add fwd limit on V(b,d) for MOS
//                          4, Updated parcheck2.va file, then rpoly, rpoly0, rpoly_1meg have severity results in SOA violations.
// v17  :     10/08/2024    1, soa rules updated based on v3.17b provided by Betsy.
//                          2, SUB related rules changed from -40, 100 to  -70, 120.
//                          3, some devices Vsd changed from 1.2v to 5.5v.
// v16.1:     01/24/2024    1, 30V, 60V, 115V and 165V VMS SOA models are added.
// v16  :     09/15/2023    1, DC and ESD SOA model for nmos120, pld120, cfr120 and cfr120_m1m2m3 are added. Other rules are updates.
//			    2, In DC SOA, mosfet V(g,d), V(d,s), V(s,b) rules are updated.
//			    3, In DC SOA, V(well,t) and V(wll,b) rules are added for cfr devices.
// v15.1:     07/15/2023    1, DC SOA model for Dpldd is added. A SOA model stakeholder is added for nmos120, pld120, cfr120 and cfr120_m1m2m3.
// v15  :     05/09/2023    1, No change from v14.2_oldSOAMethod. ESD SOA and aging model are the newest. SOA model is the 
//                             original SOA model, new multi-level SOA model is not used in this version.
// v14.2_oldSOAMethod:
//            03/29/2023    1, SOA and ESD SOA models are reversed to v14p1_agingFix. Aging model is keeping the same as v14.1.
//			    2, soachecks_top.scs is kept and not used. The diode V(sub) and drsf90b V(p,n) SOA models are fixed.
// v14.2:     02/16/2023    1, Two issues in SOA model are fixed.
// v14.1:     11/04/2022    1, SOA rules were refined. SOA models were translated to new SOA method.
//			    2, PrestoPlus aging lite function is controlled by swagecheck, default is 0, closed.
// v14p1_agingFix:     
//            08/01/2022    1, Prestoplus aging .va model updated. The outputted unit is changed from mV to Volt, Pct to 1.
// v14p1_bcc18:   
//            07/11/2022    1, SOA rules are were updated to fit BCC18 100V project request.
// v14.0:     05/10/2022    1, SOA and ESD SOA rules were updated. Mainly is the pld65 model added.
// v13.1:     11/30/2021    1, prestoplus aging models were added.
// v13.0:     09/15/2021    1, SOA and ESD SOA rules were updated.
// v12.1.1:   04/14/2021    1, rule esd_dz5b_Vpn_maxV is updated to fix a bug on pin connection.
// v12.1:     01/15/2021    1, pld90b, pmos90b, npn, npn_iso aging model are added.
//			    2, SOA rules are updated.
// ams3.12:   11/24/2020    1, off state HCI model is updated for nld10.
// ams3.12ea3:10/10/2020    1, SOA and ESD SOA rules are updated.
// ams3.12eng:05/19/2020    1, PBTI model has issue to get stress voltage. Original stress voltage is Vg-Vsub. It should be Vg-Vsource for PLD devices, and Vg-Vbody for HV mosfet.
//            04/20/2020    1, pmos_ana added PBTI model. Using the DGO BTI model and close the NBTI part. NBTI part keeps the original version.
// ams3.11:   12/12/2019    1, BTI model for p-type DGO devices: PMOS5, PLD5, PMOS10, PLD10,PLD10b, PLD30,PLD30b, PLD45,PLD45b, PMOS45,PMOS45b, PMOSHS45,PMOSHS45b, PLD90,PLD90b, PMOS90,PMOS90b
//			    2, p-type HV device HCI model: pmos45b, pmoshs45b, pmos90b, pld10b, pld30b, pld45b
//			    3, n-type HV device HCI model: NLD10b, NLD90b
//			    4, SOA and ESD SOA rules are updated 
// ams3.10:   05/16/2019    All p-type mosfet ESD SOA rules are updated. 
// ams3.10:   03/07/2019    NLD30B, NLD65B, NMOS45B HCI model are added. PLD30B, PLD45B NBTI and PBTI model are added. New ESDSOA rules are updated. SOA rules are updated. 
// ams3.9:    09/27/2018    NLD45_HE and NLD45_TLP aging model added. several b version device SOA added. ESDSOA several b vesion added and small device rule updates. 
//			    PLD30, PLD45, PMOS45, PMOSHS45 HCI-TDDB SOA flagging are added.
// ams3.8:    06/16/2018    HCI-TDDB SOA added. ESD SOA model updated. 
// ams3.8:    05/02/2018    nmos90b, nld90b, pmos90b, pld90b, drsf45b and drsf90b SOA model added.
// ams3.7:    03/01/2018    SOA and ESD SOA model updated.
// ams3.7:    11/30/2017    HCI model for <=10V devices are updated. HCI model for nld46 and nld45_he are updated.
// ams3.6:    09/10/2017    SOA model rebuilt.
// ams3.5hf3: 08/03/2017    NBTI formula updated.
// ams3.5:    05/04/2017    all larger than 45V devices Vds rules are updated.
// ams3.5:    04/26/2017    nld30 updated. pld10b and pnp_iso added.
// ams3.3:    10/26/2016    nmosll and pmosll ESD SOA added.
// ams3.3:    09/30/2016    nmosll and pmosll added, pmos and pld mosfets terminal changed, rulm one rule added.
// ams3.2:    06/25/2016    rpoly serial and cdp serial devices rule updated;
// ams3.1:    03/28/2015    vms_15 and vms_45 rules are added.
// ams3.1:    11/22/2015    rulm rules are added. duplus, dpplus, dnfet, dpfet, nmos, pmos, rpoly, rpoly_1meg, rhvpw, rphv updated;
// ams3.0:    10/10/2015    nld5_lvt is added. rules for rpoly, rpoly_1meg, rphv updated. rpoly_1meg_simple is added;
// ams2.3:    05/22/2015    1, esd soa model is added. Esd soa veriloga file is included;
//                          2, all special voltages are using special esd soa model.
//                          3, in esd soa model, drsf90 uses special model.
//                          4, soa model is updated based on ams2p3_v1 smoke alarm.
// ams2.1:    07/18/2014    1, soa model method is updated, now support all simulation analysis;
//                          2, soa pin order issue is fixed.
//                          3, relimo support nld5 and pld5. 
// ams2.0:    03/03/2014    Rebuild soa model based on SA file "smos10hv_ams2p0_mica_v0.smoke.txt";
//                  Relimo and ESDSOA are first added.
// ams1.1x:   11/08/2013    Added nld45_he and nld45_he_simple as copies of nld45 and nld45_simple.
// ams1.1:    10/06/2013    For dnfet & dpfet, rules are updated; for rpoly & rpoly0 & rpoly0_1meg, one comment of each is updated;
//                          Add rules for devices with "_std" postfix;
//                          Add "p" terminal for clgo_box_sub_10hv; 
//                          Based on Smoke Alarm file "smos10hv_ams1p1_mica_v3.smoke.txt"
// ams1.0:    04/24/2013    Initial SOA enabled.
//                          Based on Smoke Alarm file "smos10hv_ams1p0_mica_v2.smoke" 

simulator lang=spectre

section base

include "soachecks_top.scs" section=base

parameters relimo_nbti_aging_open_flag    = (0)
parameters relimo_pbti_aging_open_flag    = (0)
parameters relimo_hci_aging_open_flag    = (0)
parameters relimo_pnp_aging_open_flag    = (0)
parameters relimo_bi_aging_flag    = (0)
parameters relimo_op_aging_flag    = (0)
parameters relimo_aging_tstart    = (0)
parameters relimo_aging_time    = (0)
parameters relimo_a_gm_1_hci_nld5_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld5_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld5_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld5_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld5_10hv = (3049.874179)
parameters relimo_a_idsat_2_hci_nld5_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld5_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld5_10hv = (2.76)
parameters relimo_c_1_hci_nld5_10hv = (41.8425)
parameters relimo_c_2_hci_nld5_10hv = (148.45)
parameters relimo_condvd_hci_nld5_10hv = (1.265)
parameters relimo_condvg_hci_nld5_10hv = (1.65)
parameters relimo_intercept_1_hci_nld5_10hv = (0)
parameters relimo_intercept_2_hci_nld5_10hv = (14.58)
parameters relimo_m_1_hci_nld5_10hv = (4)
parameters relimo_m_2_hci_nld5_10hv = (1)
parameters relimo_n_1_hci_nld5_10hv = (0.237324)
parameters relimo_n_2_hci_nld5_10hv = (2.4)
parameters relimo_r_1_hci_nld5_10hv = (3)
parameters relimo_r_2_hci_nld5_10hv = (1)
parameters relimo_ratio2_a_hci_nld5_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld5_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld5_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld5_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld5_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld5_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld5_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld5_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld5_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld5_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld5_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld5_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld5_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld5_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld5_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld5_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld5_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld5_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld5_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld5_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld5_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld5_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld5_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld5_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld5_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld5_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld5_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld5_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld5_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld5_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld5_10hv = (-0.380777361)
parameters relimo_vth_hci_nld5_10hv = (1)
parameters relimo_a_gm_1_hci_nld5_lvt_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld5_lvt_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld5_lvt_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld5_lvt_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld5_lvt_10hv = (3049.874179)
parameters relimo_a_idsat_2_hci_nld5_lvt_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld5_lvt_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld5_lvt_10hv = (2.76)
parameters relimo_c_1_hci_nld5_lvt_10hv = (41.8425)
parameters relimo_c_2_hci_nld5_lvt_10hv = (148.45)
parameters relimo_condvd_hci_nld5_lvt_10hv = (1.265)
parameters relimo_condvg_hci_nld5_lvt_10hv = (1.65)
parameters relimo_intercept_1_hci_nld5_lvt_10hv = (0)
parameters relimo_intercept_2_hci_nld5_lvt_10hv = (14.58)
parameters relimo_m_1_hci_nld5_lvt_10hv = (4)
parameters relimo_m_2_hci_nld5_lvt_10hv = (1)
parameters relimo_n_1_hci_nld5_lvt_10hv = (0.237324)
parameters relimo_n_2_hci_nld5_lvt_10hv = (2.4)
parameters relimo_r_1_hci_nld5_lvt_10hv = (3)
parameters relimo_r_2_hci_nld5_lvt_10hv = (1)
parameters relimo_ratio2_a_hci_nld5_lvt_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld5_lvt_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld5_lvt_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld5_lvt_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld5_lvt_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld5_lvt_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld5_lvt_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld5_lvt_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld5_lvt_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld5_lvt_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld5_lvt_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld5_lvt_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld5_lvt_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld5_lvt_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld5_lvt_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld5_lvt_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld5_lvt_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld5_lvt_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld5_lvt_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld5_lvt_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld5_lvt_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld5_lvt_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld5_lvt_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld5_lvt_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld5_lvt_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld5_lvt_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld5_lvt_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld5_lvt_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld5_lvt_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld5_lvt_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld5_lvt_10hv = (-0.380777361)
parameters relimo_vth_hci_nld5_lvt_10hv = (1)
parameters relimo_a_gm_1_hci_nmos3_zvt_10hv = (1.48)
parameters relimo_a_gm_2_hci_nmos3_zvt_10hv = (2.63)
parameters relimo_a_idlin_1_hci_nmos3_zvt_10hv = (4.23)
parameters relimo_a_idlin_2_hci_nmos3_zvt_10hv = (3.82)
parameters relimo_a_idsat_1_hci_nmos3_zvt_10hv = (1120.640881)
parameters relimo_a_idsat_2_hci_nmos3_zvt_10hv = (0.454)
parameters relimo_a_vth_1_hci_nmos3_zvt_10hv = (1.12)
parameters relimo_a_vth_2_hci_nmos3_zvt_10hv = (1.72)
parameters relimo_c_1_hci_nmos3_zvt_10hv = (23.3097)
parameters relimo_c_2_hci_nmos3_zvt_10hv = (69.502)
parameters relimo_condvd_hci_nmos3_zvt_10hv = (1.265)
parameters relimo_condvg_hci_nmos3_zvt_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos3_zvt_10hv = (0)
parameters relimo_intercept_2_hci_nmos3_zvt_10hv = (12.97)
parameters relimo_m_1_hci_nmos3_zvt_10hv = (4)
parameters relimo_m_2_hci_nmos3_zvt_10hv = (4)
parameters relimo_n_1_hci_nmos3_zvt_10hv = (0.56049)
parameters relimo_n_2_hci_nmos3_zvt_10hv = (7.92)
parameters relimo_r_1_hci_nmos3_zvt_10hv = (3)
parameters relimo_r_2_hci_nmos3_zvt_10hv = (3)
parameters relimo_ratio2_a_hci_nmos3_zvt_10hv = (-0.32966618)
parameters relimo_ratio2_b_hci_nmos3_zvt_10hv = (-1.064971925)
parameters relimo_ratio3_a_hci_nmos3_zvt_10hv = (-0.276545407)
parameters relimo_ratio3_b_hci_nmos3_zvt_10hv = (-0.842508002)
parameters relimo_ratio4_a_hci_nmos3_zvt_10hv = (0.025359856)
parameters relimo_ratio4_b_hci_nmos3_zvt_10hv = (9.698456464)
parameters relimo_ratio5_a_hci_nmos3_zvt_10hv = (-0.013687109)
parameters relimo_ratio5_b_hci_nmos3_zvt_10hv = (0.98632332)
parameters relimo_ratio6_a_hci_nmos3_zvt_10hv = (-0.049012387)
parameters relimo_ratio6_b_hci_nmos3_zvt_10hv = (0.950991372)
parameters relimo_ratio7_a_hci_nmos3_zvt_10hv = (-0.008042015)
parameters relimo_ratio7_b_hci_nmos3_zvt_10hv = (0.991937165)
parameters relimo_ratio8_a_hci_nmos3_zvt_10hv = (-0.732269517)
parameters relimo_ratio8_b_hci_nmos3_zvt_10hv = (-0.547859133)
parameters relimo_ratio9_a_hci_nmos3_zvt_10hv = (-0.010990515)
parameters relimo_ratio9_b_hci_nmos3_zvt_10hv = (-0.010999105)
parameters relimo_ratio10_a_hci_nmos3_zvt_10hv = (-0.044328387)
parameters relimo_ratio10_b_hci_nmos3_zvt_10hv = (-0.044324543)
parameters relimo_ratio11_a_hci_nmos3_zvt_10hv = (-0.016543264)
parameters relimo_ratio11_b_hci_nmos3_zvt_10hv = (-0.006350993)
parameters relimo_ratio12_a_hci_nmos3_zvt_10hv = (0.007245703)
parameters relimo_ratio12_b_hci_nmos3_zvt_10hv = (0.000373926)
parameters relimo_ratio13_a_hci_nmos3_zvt_10hv = (-0.081317513)
parameters relimo_ratio13_b_hci_nmos3_zvt_10hv = (-0.081110297)
parameters relimo_ratio14_a_hci_nmos3_zvt_10hv = (-0.000293685)
parameters relimo_ratio14_b_hci_nmos3_zvt_10hv = (0.005668605)
parameters relimo_ratio15_a_hci_nmos3_zvt_10hv = (-0.291893773)
parameters relimo_ratio15_b_hci_nmos3_zvt_10hv = (0.001661709)
parameters relimo_ratio16_a_hci_nmos3_zvt_10hv = (0.06769253)
parameters relimo_ratio16_b_hci_nmos3_zvt_10hv = (0.159308751)
parameters relimo_ratio_vth2a0_hci_nmos3_zvt_10hv = (0.662258658)
parameters relimo_vth_hci_nmos3_zvt_10hv = (1)
parameters relimo_a_gm_1_hci_nmos5_10hv = (2.16)
parameters relimo_a_gm_2_hci_nmos5_10hv = (3.48)
parameters relimo_a_idlin_1_hci_nmos5_10hv = (2.79)
parameters relimo_a_idlin_2_hci_nmos5_10hv = (4.56)
parameters relimo_a_idsat_1_hci_nmos5_10hv = (93.07454991)
parameters relimo_a_idsat_2_hci_nmos5_10hv = (0.874)
parameters relimo_a_vth_1_hci_nmos5_10hv = (1.245)
parameters relimo_a_vth_2_hci_nmos5_10hv = (1.81)
parameters relimo_c_1_hci_nmos5_10hv = (33.6377)
parameters relimo_c_2_hci_nmos5_10hv = (89.45)
parameters relimo_condvd_hci_nmos5_10hv = (1.265)
parameters relimo_condvg_hci_nmos5_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos5_10hv = (0)
parameters relimo_intercept_2_hci_nmos5_10hv = (7.32)
parameters relimo_m_1_hci_nmos5_10hv = (4)
parameters relimo_m_2_hci_nmos5_10hv = (4)
parameters relimo_n_1_hci_nmos5_10hv = (0.501535)
parameters relimo_n_2_hci_nmos5_10hv = (3.99)
parameters relimo_r_1_hci_nmos5_10hv = (3)
parameters relimo_r_2_hci_nmos5_10hv = (3)
parameters relimo_ratio2_a_hci_nmos5_10hv = (0.042845225)
parameters relimo_ratio2_b_hci_nmos5_10hv = (-0.166271035)
parameters relimo_ratio3_a_hci_nmos5_10hv = (-1.156581233)
parameters relimo_ratio3_b_hci_nmos5_10hv = (-0.104402731)
parameters relimo_ratio4_a_hci_nmos5_10hv = (0.02114419)
parameters relimo_ratio4_b_hci_nmos5_10hv = (1.314501922)
parameters relimo_ratio5_a_hci_nmos5_10hv = (-0.460182076)
parameters relimo_ratio5_b_hci_nmos5_10hv = (0.580093073)
parameters relimo_ratio6_a_hci_nmos5_10hv = (-0.537840453)
parameters relimo_ratio6_b_hci_nmos5_10hv = (0.462242345)
parameters relimo_ratio7_a_hci_nmos5_10hv = (-0.154116301)
parameters relimo_ratio7_b_hci_nmos5_10hv = (0.847722297)
parameters relimo_ratio8_a_hci_nmos5_10hv = (-0.839370985)
parameters relimo_ratio8_b_hci_nmos5_10hv = (-0.145243022)
parameters relimo_ratio9_a_hci_nmos5_10hv = (-0.119306295)
parameters relimo_ratio9_b_hci_nmos5_10hv = (-0.203964434)
parameters relimo_ratio10_a_hci_nmos5_10hv = (-0.348539155)
parameters relimo_ratio10_b_hci_nmos5_10hv = (-0.486822866)
parameters relimo_ratio11_a_hci_nmos5_10hv = (-0.14019801)
parameters relimo_ratio11_b_hci_nmos5_10hv = (-0.13214661)
parameters relimo_ratio12_a_hci_nmos5_10hv = (0.105061826)
parameters relimo_ratio12_b_hci_nmos5_10hv = (0.004226598)
parameters relimo_ratio13_a_hci_nmos5_10hv = (-0.130498696)
parameters relimo_ratio13_b_hci_nmos5_10hv = (-0.130946445)
parameters relimo_ratio14_a_hci_nmos5_10hv = (0.001074588)
parameters relimo_ratio14_b_hci_nmos5_10hv = (-0.001014909)
parameters relimo_ratio15_a_hci_nmos5_10hv = (0.21625078)
parameters relimo_ratio15_b_hci_nmos5_10hv = (-4.66962E-05)
parameters relimo_ratio16_a_hci_nmos5_10hv = (0.014006561)
parameters relimo_ratio16_b_hci_nmos5_10hv = (0.013391609)
parameters relimo_ratio_vth2a0_hci_nmos5_10hv = (-0.092491116)
parameters relimo_vth_hci_nmos5_10hv = (1)
parameters relimo_a_gm_1_hci_nmos10_10hv = (1.68)
parameters relimo_a_gm_2_hci_nmos10_10hv = (1.48)
parameters relimo_a_idlin_1_hci_nmos10_10hv = (1.24)
parameters relimo_a_idlin_2_hci_nmos10_10hv = (3.12)
parameters relimo_a_idsat_1_hci_nmos10_10hv = (20.67033993)
parameters relimo_a_idsat_2_hci_nmos10_10hv = (0.874)
parameters relimo_a_vth_1_hci_nmos10_10hv = (2.56)
parameters relimo_a_vth_2_hci_nmos10_10hv = (1.63)
parameters relimo_c_1_hci_nmos10_10hv = (50.0099)
parameters relimo_c_2_hci_nmos10_10hv = (186.45)
parameters relimo_condvd_hci_nmos10_10hv = (1.265)
parameters relimo_condvg_hci_nmos10_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos10_10hv = (0)
parameters relimo_intercept_2_hci_nmos10_10hv = (17.82)
parameters relimo_m_1_hci_nmos10_10hv = (4)
parameters relimo_m_2_hci_nmos10_10hv = (4)
parameters relimo_n_1_hci_nmos10_10hv = (0.094634)
parameters relimo_n_2_hci_nmos10_10hv = (1.43)
parameters relimo_r_1_hci_nmos10_10hv = (3)
parameters relimo_r_2_hci_nmos10_10hv = (3)
parameters relimo_ratio2_a_hci_nmos10_10hv = (0.035050599)
parameters relimo_ratio2_b_hci_nmos10_10hv = (-0.173464622)
parameters relimo_ratio3_a_hci_nmos10_10hv = (0.960527831)
parameters relimo_ratio3_b_hci_nmos10_10hv = (-0.066603945)
parameters relimo_ratio4_a_hci_nmos10_10hv = (-0.025874487)
parameters relimo_ratio4_b_hci_nmos10_10hv = (1.232557338)
parameters relimo_ratio5_a_hci_nmos10_10hv = (-0.943915695)
parameters relimo_ratio5_b_hci_nmos10_10hv = (0.29966838)
parameters relimo_ratio6_a_hci_nmos10_10hv = (-0.573801993)
parameters relimo_ratio6_b_hci_nmos10_10hv = (0.425868587)
parameters relimo_ratio7_a_hci_nmos10_10hv = (-0.106124048)
parameters relimo_ratio7_b_hci_nmos10_10hv = (0.858507212)
parameters relimo_ratio8_a_hci_nmos10_10hv = (-0.934716711)
parameters relimo_ratio8_b_hci_nmos10_10hv = (-0.126401988)
parameters relimo_ratio9_a_hci_nmos10_10hv = (-0.10154358)
parameters relimo_ratio9_b_hci_nmos10_10hv = (-0.183133809)
parameters relimo_ratio10_a_hci_nmos10_10hv = (-0.353594373)
parameters relimo_ratio10_b_hci_nmos10_10hv = (-0.492548737)
parameters relimo_ratio11_a_hci_nmos10_10hv = (-0.141266636)
parameters relimo_ratio11_b_hci_nmos10_10hv = (-0.122356282)
parameters relimo_ratio12_a_hci_nmos10_10hv = (0.102243048)
parameters relimo_ratio12_b_hci_nmos10_10hv = (0.004479353)
parameters relimo_ratio13_a_hci_nmos10_10hv = (-0.022761957)
parameters relimo_ratio13_b_hci_nmos10_10hv = (-0.0290694)
parameters relimo_ratio14_a_hci_nmos10_10hv = (-0.002304901)
parameters relimo_ratio14_b_hci_nmos10_10hv = (0.001711153)
parameters relimo_ratio15_a_hci_nmos10_10hv = (-0.351077917)
parameters relimo_ratio15_b_hci_nmos10_10hv = (0.001111489)
parameters relimo_ratio16_a_hci_nmos10_10hv = (0.101826664)
parameters relimo_ratio16_b_hci_nmos10_10hv = (0.022261862)
parameters relimo_ratio_vth2a0_hci_nmos10_10hv = (0.077624368)
parameters relimo_vth_hci_nmos10_10hv = (1)
parameters relimo_a_gm_1_hci_nmos_10hv = (1.435)
parameters relimo_a_gm_2_hci_nmos_10hv = (3.385)
parameters relimo_a_idlin_1_hci_nmos_10hv = (2.512)
parameters relimo_a_idlin_2_hci_nmos_10hv = (1.857)
parameters relimo_a_idsat_1_hci_nmos_10hv = (673773.9234)
parameters relimo_a_idsat_2_hci_nmos_10hv = (0.909)
parameters relimo_a_vth_1_hci_nmos_10hv = (1.897)
parameters relimo_a_vth_2_hci_nmos_10hv = (2.384)
parameters relimo_c_1_hci_nmos_10hv = (26.7562)
parameters relimo_c_2_hci_nmos_10hv = (27.45)
parameters relimo_condvd_hci_nmos_10hv = (1.265)
parameters relimo_condvg_hci_nmos_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos_10hv = (0)
parameters relimo_intercept_2_hci_nmos_10hv = (13.42)
parameters relimo_m_1_hci_nmos_10hv = (10)
parameters relimo_m_2_hci_nmos_10hv = (10)
parameters relimo_n_1_hci_nmos_10hv = (0.471141)
parameters relimo_n_2_hci_nmos_10hv = (2.2)
parameters relimo_r_1_hci_nmos_10hv = (3)
parameters relimo_r_2_hci_nmos_10hv = (3)
parameters relimo_ratio2_a_hci_nmos_10hv = (-0.169815006)
parameters relimo_ratio2_b_hci_nmos_10hv = (-1.189406142)
parameters relimo_ratio3_a_hci_nmos_10hv = (-1.859719623)
parameters relimo_ratio3_b_hci_nmos_10hv = (-0.636826787)
parameters relimo_ratio4_a_hci_nmos_10hv = (3.759902405)
parameters relimo_ratio4_b_hci_nmos_10hv = (1.514713175)
parameters relimo_ratio5_a_hci_nmos_10hv = (-0.303972296)
parameters relimo_ratio5_b_hci_nmos_10hv = (0.739078826)
parameters relimo_ratio6_a_hci_nmos_10hv = (-0.184810548)
parameters relimo_ratio6_b_hci_nmos_10hv = (0.814969519)
parameters relimo_ratio7_a_hci_nmos_10hv = (-0.144704789)
parameters relimo_ratio7_b_hci_nmos_10hv = (0.85512371)
parameters relimo_ratio8_a_hci_nmos_10hv = (-0.369152813)
parameters relimo_ratio8_b_hci_nmos_10hv = (-0.08692652)
parameters relimo_ratio9_a_hci_nmos_10hv = (0.088498527)
parameters relimo_ratio9_b_hci_nmos_10hv = (-0.013622635)
parameters relimo_ratio10_a_hci_nmos_10hv = (0.045493167)
parameters relimo_ratio10_b_hci_nmos_10hv = (-0.07514444)
parameters relimo_ratio11_a_hci_nmos_10hv = (0.052431819)
parameters relimo_ratio11_b_hci_nmos_10hv = (-0.037014724)
parameters relimo_ratio12_a_hci_nmos_10hv = (0.103091649)
parameters relimo_ratio12_b_hci_nmos_10hv = (0.000186797)
parameters relimo_ratio13_a_hci_nmos_10hv = (-0.053559232)
parameters relimo_ratio13_b_hci_nmos_10hv = (-0.05208786)
parameters relimo_ratio14_a_hci_nmos_10hv = (0.000312141)
parameters relimo_ratio14_b_hci_nmos_10hv = (-0.002763285)
parameters relimo_ratio15_a_hci_nmos_10hv = (0.007232431)
parameters relimo_ratio15_b_hci_nmos_10hv = (-0.001780202)
parameters relimo_ratio16_a_hci_nmos_10hv = (-0.056178666)
parameters relimo_ratio16_b_hci_nmos_10hv = (0.005911417)
parameters relimo_ratio_vth2a0_hci_nmos_10hv = (-0.279073291)
parameters relimo_vth_hci_nmos_10hv = (1)
parameters relimo_a_gm_1_hci_nmos_ll_10hv = (1.435)
parameters relimo_a_gm_2_hci_nmos_ll_10hv = (3.385)
parameters relimo_a_idlin_1_hci_nmos_ll_10hv = (2.512)
parameters relimo_a_idlin_2_hci_nmos_ll_10hv = (1.857)
parameters relimo_a_idsat_1_hci_nmos_ll_10hv = (673773.9234)
parameters relimo_a_idsat_2_hci_nmos_ll_10hv = (0.909)
parameters relimo_a_vth_1_hci_nmos_ll_10hv = (1.897)
parameters relimo_a_vth_2_hci_nmos_ll_10hv = (2.384)
parameters relimo_c_1_hci_nmos_ll_10hv = (26.7562)
parameters relimo_c_2_hci_nmos_ll_10hv = (27.45)
parameters relimo_condvd_hci_nmos_ll_10hv = (1.265)
parameters relimo_condvg_hci_nmos_ll_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos_ll_10hv = (0)
parameters relimo_intercept_2_hci_nmos_ll_10hv = (13.42)
parameters relimo_m_1_hci_nmos_ll_10hv = (10)
parameters relimo_m_2_hci_nmos_ll_10hv = (10)
parameters relimo_n_1_hci_nmos_ll_10hv = (0.471141)
parameters relimo_n_2_hci_nmos_ll_10hv = (2.2)
parameters relimo_r_1_hci_nmos_ll_10hv = (3)
parameters relimo_r_2_hci_nmos_ll_10hv = (3)
parameters relimo_ratio2_a_hci_nmos_ll_10hv = (-0.169815006)
parameters relimo_ratio2_b_hci_nmos_ll_10hv = (-1.189406142)
parameters relimo_ratio3_a_hci_nmos_ll_10hv = (-1.859719623)
parameters relimo_ratio3_b_hci_nmos_ll_10hv = (-0.636826787)
parameters relimo_ratio4_a_hci_nmos_ll_10hv = (3.759902405)
parameters relimo_ratio4_b_hci_nmos_ll_10hv = (1.514713175)
parameters relimo_ratio5_a_hci_nmos_ll_10hv = (-0.303972296)
parameters relimo_ratio5_b_hci_nmos_ll_10hv = (0.739078826)
parameters relimo_ratio6_a_hci_nmos_ll_10hv = (-0.184810548)
parameters relimo_ratio6_b_hci_nmos_ll_10hv = (0.814969519)
parameters relimo_ratio7_a_hci_nmos_ll_10hv = (-0.144704789)
parameters relimo_ratio7_b_hci_nmos_ll_10hv = (0.85512371)
parameters relimo_ratio8_a_hci_nmos_ll_10hv = (-0.369152813)
parameters relimo_ratio8_b_hci_nmos_ll_10hv = (-0.08692652)
parameters relimo_ratio9_a_hci_nmos_ll_10hv = (0.088498527)
parameters relimo_ratio9_b_hci_nmos_ll_10hv = (-0.013622635)
parameters relimo_ratio10_a_hci_nmos_ll_10hv = (0.045493167)
parameters relimo_ratio10_b_hci_nmos_ll_10hv = (-0.07514444)
parameters relimo_ratio11_a_hci_nmos_ll_10hv = (0.052431819)
parameters relimo_ratio11_b_hci_nmos_ll_10hv = (-0.037014724)
parameters relimo_ratio12_a_hci_nmos_ll_10hv = (0.103091649)
parameters relimo_ratio12_b_hci_nmos_ll_10hv = (0.000186797)
parameters relimo_ratio13_a_hci_nmos_ll_10hv = (-0.053559232)
parameters relimo_ratio13_b_hci_nmos_ll_10hv = (-0.05208786)
parameters relimo_ratio14_a_hci_nmos_ll_10hv = (0.000312141)
parameters relimo_ratio14_b_hci_nmos_ll_10hv = (-0.002763285)
parameters relimo_ratio15_a_hci_nmos_ll_10hv = (0.007232431)
parameters relimo_ratio15_b_hci_nmos_ll_10hv = (-0.001780202)
parameters relimo_ratio16_a_hci_nmos_ll_10hv = (-0.056178666)
parameters relimo_ratio16_b_hci_nmos_ll_10hv = (0.005911417)
parameters relimo_ratio_vth2a0_hci_nmos_ll_10hv = (-0.279073291)
parameters relimo_vth_hci_nmos_ll_10hv = (1)
parameters relimo_a_gm_1_hci_nmos_ana_10hv = (3.545)
parameters relimo_a_gm_2_hci_nmos_ana_10hv = (3.385)
parameters relimo_a_idlin_1_hci_nmos_ana_10hv = (2.845)
parameters relimo_a_idlin_2_hci_nmos_ana_10hv = (1.857)
parameters relimo_a_idsat_1_hci_nmos_ana_10hv = (35479.08284)
parameters relimo_a_idsat_2_hci_nmos_ana_10hv = (0.454)
parameters relimo_a_vth_1_hci_nmos_ana_10hv = (0.789)
parameters relimo_a_vth_2_hci_nmos_ana_10hv = (2.384)
parameters relimo_c_1_hci_nmos_ana_10hv = (38.2734)
parameters relimo_c_2_hci_nmos_ana_10hv = (57.22)
parameters relimo_condvd_hci_nmos_ana_10hv = (1.265)
parameters relimo_condvg_hci_nmos_ana_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos_ana_10hv = (0)
parameters relimo_intercept_2_hci_nmos_ana_10hv = (21.68)
parameters relimo_m_1_hci_nmos_ana_10hv = (4)
parameters relimo_m_2_hci_nmos_ana_10hv = (4)
parameters relimo_n_1_hci_nmos_ana_10hv = (0.378235)
parameters relimo_n_2_hci_nmos_ana_10hv = (2.2)
parameters relimo_r_1_hci_nmos_ana_10hv = (2.14)
parameters relimo_r_2_hci_nmos_ana_10hv = (3)
parameters relimo_ratio2_a_hci_nmos_ana_10hv = (0.104015934)
parameters relimo_ratio2_b_hci_nmos_ana_10hv = (-0.759813265)
parameters relimo_ratio3_a_hci_nmos_ana_10hv = (0.217866904)
parameters relimo_ratio3_b_hci_nmos_ana_10hv = (-0.460927139)
parameters relimo_ratio4_a_hci_nmos_ana_10hv = (4.333354774)
parameters relimo_ratio4_b_hci_nmos_ana_10hv = (3.118917879)
parameters relimo_ratio5_a_hci_nmos_ana_10hv = (-0.17575888)
parameters relimo_ratio5_b_hci_nmos_ana_10hv = (0.833309453)
parameters relimo_ratio6_a_hci_nmos_ana_10hv = (-0.296970197)
parameters relimo_ratio6_b_hci_nmos_ana_10hv = (0.702794477)
parameters relimo_ratio7_a_hci_nmos_ana_10hv = (-0.123337521)
parameters relimo_ratio7_b_hci_nmos_ana_10hv = (0.879482946)
parameters relimo_ratio8_a_hci_nmos_ana_10hv = (-0.121591981)
parameters relimo_ratio8_b_hci_nmos_ana_10hv = (-0.192267215)
parameters relimo_ratio9_a_hci_nmos_ana_10hv = (0.058030912)
parameters relimo_ratio9_b_hci_nmos_ana_10hv = (-0.05918994)
parameters relimo_ratio10_a_hci_nmos_ana_10hv = (-0.034937541)
parameters relimo_ratio10_b_hci_nmos_ana_10hv = (-0.185891792)
parameters relimo_ratio11_a_hci_nmos_ana_10hv = (0.021223441)
parameters relimo_ratio11_b_hci_nmos_ana_10hv = (-0.070507229)
parameters relimo_ratio12_a_hci_nmos_ana_10hv = (0.120441757)
parameters relimo_ratio12_b_hci_nmos_ana_10hv = (0.000679387)
parameters relimo_ratio13_a_hci_nmos_ana_10hv = (-0.102475324)
parameters relimo_ratio13_b_hci_nmos_ana_10hv = (-0.102412163)
parameters relimo_ratio14_a_hci_nmos_ana_10hv = (0.000609998)
parameters relimo_ratio14_b_hci_nmos_ana_10hv = (-0.001692027)
parameters relimo_ratio15_a_hci_nmos_ana_10hv = (-0.008275925)
parameters relimo_ratio15_b_hci_nmos_ana_10hv = (0.001711148)
parameters relimo_ratio16_a_hci_nmos_ana_10hv = (-0.126975616)
parameters relimo_ratio16_b_hci_nmos_ana_10hv = (0.025719579)
parameters relimo_ratio_vth2a0_hci_nmos_ana_10hv = (-0.340383432)
parameters relimo_vth_hci_nmos_ana_10hv = (1)
parameters relimo_a_gm_1_hci_pld5_10hv = (1.45)
parameters relimo_a_gm_2_hci_pld5_10hv = (1.76)
parameters relimo_a_idlin_1_hci_pld5_10hv = (1.69)
parameters relimo_a_idlin_2_hci_pld5_10hv = (2.16)
parameters relimo_a_idsat_1_hci_pld5_10hv = (11403.80942)
parameters relimo_a_idsat_2_hci_pld5_10hv = (0.02)
parameters relimo_a_vth_1_hci_pld5_10hv = (2.46)
parameters relimo_a_vth_2_hci_pld5_10hv = (3.45)
parameters relimo_c_1_hci_pld5_10hv = (44.7704)
parameters relimo_c_2_hci_pld5_10hv = (594.66)
parameters relimo_c_nbti_pld5_10hv = (109.5)
parameters relimo_condvd_hci_pld5_10hv = (1.265)
parameters relimo_condvg_hci_pld5_10hv = (1.65)
parameters relimo_intercept_1_hci_pld5_10hv = (0)
parameters relimo_intercept_2_hci_pld5_10hv = (67.48)
parameters relimo_intercept_nbti_pld5_10hv = (7.82)
parameters relimo_m_1_hci_pld5_10hv = (4)
parameters relimo_m_2_hci_pld5_10hv = (1)
parameters relimo_n_1_hci_pld5_10hv = (0.127351)
parameters relimo_n_2_hci_pld5_10hv = (2.58)
parameters relimo_n_nbti_pld5_10hv = (3.66)
parameters relimo_r_1_hci_pld5_10hv = (3)
parameters relimo_r_2_hci_pld5_10hv = (1)
parameters relimo_ratio2_a_hci_pld5_10hv = (-0.042776305)
parameters relimo_ratio2_b_hci_pld5_10hv = (-0.281630586)
parameters relimo_ratio3_a_hci_pld5_10hv = (-3.145784339)
parameters relimo_ratio3_b_hci_pld5_10hv = (-0.125759585)
parameters relimo_ratio4_a_hci_pld5_10hv = (0.580259916)
parameters relimo_ratio4_b_hci_pld5_10hv = (1.211071174)
parameters relimo_ratio5_a_hci_pld5_10hv = (-0.183390194)
parameters relimo_ratio5_b_hci_pld5_10hv = (0.841200242)
parameters relimo_ratio6_a_hci_pld5_10hv = (-0.133321283)
parameters relimo_ratio6_b_hci_pld5_10hv = (0.866627273)
parameters relimo_ratio7_a_hci_pld5_10hv = (-0.045487512)
parameters relimo_ratio7_b_hci_pld5_10hv = (0.954581536)
parameters relimo_ratio8_a_hci_pld5_10hv = (-0.860600903)
parameters relimo_ratio8_b_hci_pld5_10hv = (-0.134530989)
parameters relimo_ratio9_a_hci_pld5_10hv = (0.086740911)
parameters relimo_ratio9_b_hci_pld5_10hv = (-0.021917218)
parameters relimo_ratio10_a_hci_pld5_10hv = (0.042180742)
parameters relimo_ratio10_b_hci_pld5_10hv = (-0.079644109)
parameters relimo_ratio11_a_hci_pld5_10hv = (0.059846596)
parameters relimo_ratio11_b_hci_pld5_10hv = (-0.018689639)
parameters relimo_ratio12_a_hci_pld5_10hv = (0.10209475)
parameters relimo_ratio12_b_hci_pld5_10hv = (0.000418067)
parameters relimo_ratio13_a_hci_pld5_10hv = (-0.132356361)
parameters relimo_ratio13_b_hci_pld5_10hv = (-0.132364587)
parameters relimo_ratio14_a_hci_pld5_10hv = (-0.001110969)
parameters relimo_ratio14_b_hci_pld5_10hv = (-0.003488177)
parameters relimo_ratio15_a_hci_pld5_10hv = (0.048159665)
parameters relimo_ratio15_b_hci_pld5_10hv = (-0.015635071)
parameters relimo_ratio16_a_hci_pld5_10hv = (-0.022061851)
parameters relimo_ratio16_b_hci_pld5_10hv = (0.015345643)
parameters relimo_ratio_vth2a0_hci_pld5_10hv = (-0.09952625)
parameters relimo_vth_hci_pld5_10hv = (-1)
parameters relimo_a_gm_1_hci_pmos5_10hv = (3.31)
parameters relimo_a_gm_2_hci_pmos5_10hv = (5.38)
parameters relimo_a_idlin_1_hci_pmos5_10hv = (3.51)
parameters relimo_a_idlin_2_hci_pmos5_10hv = (3.86)
parameters relimo_a_idsat_1_hci_pmos5_10hv = (1483365.29161205)
parameters relimo_a_idsat_2_hci_pmos5_10hv = (0.874)
parameters relimo_a_vth_1_hci_pmos5_10hv = (4.53)
parameters relimo_a_vth_2_hci_pmos5_10hv = (3.68)
parameters relimo_c_1_hci_pmos5_10hv = (77.4067)
parameters relimo_c_2_hci_pmos5_10hv = (162.22)
parameters relimo_c_nbti_pmos5_10hv = (109.5)
parameters relimo_condvd_hci_pmos5_10hv = (1.265)
parameters relimo_condvg_hci_pmos5_10hv = (1.65)
parameters relimo_intercept_1_hci_pmos5_10hv = (0)
parameters relimo_intercept_2_hci_pmos5_10hv = (17.12)
parameters relimo_intercept_nbti_pmos5_10hv = (7.82)
parameters relimo_m_1_hci_pmos5_10hv = (4)
parameters relimo_m_2_hci_pmos5_10hv = (4)
parameters relimo_n_1_hci_pmos5_10hv = (0.303194)
parameters relimo_n_2_hci_pmos5_10hv = (3.99)
parameters relimo_n_nbti_pmos5_10hv = (3.66)
parameters relimo_r_1_hci_pmos5_10hv = (3)
parameters relimo_r_2_hci_pmos5_10hv = (3)
parameters relimo_ratio2_a_hci_pmos5_10hv = (-0.057631561)
parameters relimo_ratio2_b_hci_pmos5_10hv = (-0.286615102)
parameters relimo_ratio3_a_hci_pmos5_10hv = (-0.265319354)
parameters relimo_ratio3_b_hci_pmos5_10hv = (-0.26740872)
parameters relimo_ratio4_a_hci_pmos5_10hv = (-1.24536E-05)
parameters relimo_ratio4_b_hci_pmos5_10hv = (0.926927436)
parameters relimo_ratio5_a_hci_pmos5_10hv = (-0.087324629)
parameters relimo_ratio5_b_hci_pmos5_10hv = (0.923512493)
parameters relimo_ratio6_a_hci_pmos5_10hv = (-0.094145456)
parameters relimo_ratio6_b_hci_pmos5_10hv = (0.905859296)
parameters relimo_ratio7_a_hci_pmos5_10hv = (-0.01500616)
parameters relimo_ratio7_b_hci_pmos5_10hv = (0.98487591)
parameters relimo_ratio8_a_hci_pmos5_10hv = (-1.04129996)
parameters relimo_ratio8_b_hci_pmos5_10hv = (-0.399811598)
parameters relimo_ratio9_a_hci_pmos5_10hv = (7.57712E-06)
parameters relimo_ratio9_b_hci_pmos5_10hv = (-0.013700894)
parameters relimo_ratio10_a_hci_pmos5_10hv = (-0.091041342)
parameters relimo_ratio10_b_hci_pmos5_10hv = (-0.091037395)
parameters relimo_ratio11_a_hci_pmos5_10hv = (-0.026226896)
parameters relimo_ratio11_b_hci_pmos5_10hv = (-0.008556719)
parameters relimo_ratio12_a_hci_pmos5_10hv = (0.007867035)
parameters relimo_ratio12_b_hci_pmos5_10hv = (0.002752003)
parameters relimo_ratio13_a_hci_pmos5_10hv = (-0.163519236)
parameters relimo_ratio13_b_hci_pmos5_10hv = (-0.16724426)
parameters relimo_ratio14_a_hci_pmos5_10hv = (0.000133053)
parameters relimo_ratio14_b_hci_pmos5_10hv = (-0.002116477)
parameters relimo_ratio15_a_hci_pmos5_10hv = (-0.029553575)
parameters relimo_ratio15_b_hci_pmos5_10hv = (-0.002788392)
parameters relimo_ratio16_a_hci_pmos5_10hv = (0.001128556)
parameters relimo_ratio16_b_hci_pmos5_10hv = (0.011200098)
parameters relimo_ratio_vth2a0_hci_pmos5_10hv = (-0.167257379)
parameters relimo_vth_hci_pmos5_10hv = (-1)
parameters relimo_a_gm_1_hci_pmos10_10hv = (2.15)
parameters relimo_a_gm_2_hci_pmos10_10hv = (4.38)
parameters relimo_a_idlin_1_hci_pmos10_10hv = (2.79)
parameters relimo_a_idlin_2_hci_pmos10_10hv = (2.76)
parameters relimo_a_idsat_1_hci_pmos10_10hv = (430835.7682)
parameters relimo_a_idsat_2_hci_pmos10_10hv = (0.874)
parameters relimo_a_vth_1_hci_pmos10_10hv = (3.29)
parameters relimo_a_vth_2_hci_pmos10_10hv = (3.69)
parameters relimo_c_1_hci_pmos10_10hv = (216.775)
parameters relimo_c_2_hci_pmos10_10hv = (186.45)
parameters relimo_c_nbti_pmos10_10hv = (110.24)
parameters relimo_condvd_hci_pmos10_10hv = (1.265)
parameters relimo_condvg_hci_pmos10_10hv = (1.65)
parameters relimo_intercept_1_hci_pmos10_10hv = (0)
parameters relimo_intercept_2_hci_pmos10_10hv = (17.82)
parameters relimo_intercept_nbti_pmos10_10hv = (6.82)
parameters relimo_m_1_hci_pmos10_10hv = (4)
parameters relimo_m_2_hci_pmos10_10hv = (4)
parameters relimo_n_1_hci_pmos10_10hv = (0.426436)
parameters relimo_n_2_hci_pmos10_10hv = (1.43)
parameters relimo_n_nbti_pmos10_10hv = (1.74)
parameters relimo_r_1_hci_pmos10_10hv = (3)
parameters relimo_r_2_hci_pmos10_10hv = (3)
parameters relimo_ratio2_a_hci_pmos10_10hv = (0.006610392)
parameters relimo_ratio2_b_hci_pmos10_10hv = (-0.201466289)
parameters relimo_ratio3_a_hci_pmos10_10hv = (-0.233032303)
parameters relimo_ratio3_b_hci_pmos10_10hv = (-0.241386886)
parameters relimo_ratio4_a_hci_pmos10_10hv = (0.001322887)
parameters relimo_ratio4_b_hci_pmos10_10hv = (0.909031173)
parameters relimo_ratio5_a_hci_pmos10_10hv = (-0.263717168)
parameters relimo_ratio5_b_hci_pmos10_10hv = (0.782320155)
parameters relimo_ratio6_a_hci_pmos10_10hv = (-0.426862307)
parameters relimo_ratio6_b_hci_pmos10_10hv = (0.573921716)
parameters relimo_ratio7_a_hci_pmos10_10hv = (-0.101528126)
parameters relimo_ratio7_b_hci_pmos10_10hv = (0.888267061)
parameters relimo_ratio8_a_hci_pmos10_10hv = (-1.03464895)
parameters relimo_ratio8_b_hci_pmos10_10hv = (-0.431675337)
parameters relimo_ratio9_a_hci_pmos10_10hv = (-0.161980446)
parameters relimo_ratio9_b_hci_pmos10_10hv = (-0.15130121)
parameters relimo_ratio10_a_hci_pmos10_10hv = (-0.324954963)
parameters relimo_ratio10_b_hci_pmos10_10hv = (-0.324693347)
parameters relimo_ratio11_a_hci_pmos10_10hv = (-0.147077686)
parameters relimo_ratio11_b_hci_pmos10_10hv = (-0.087992404)
parameters relimo_ratio12_a_hci_pmos10_10hv = (0.101003422)
parameters relimo_ratio12_b_hci_pmos10_10hv = (0.047454982)
parameters relimo_ratio13_a_hci_pmos10_10hv = (-0.22715942)
parameters relimo_ratio13_b_hci_pmos10_10hv = (-0.238209361)
parameters relimo_ratio14_a_hci_pmos10_10hv = (0.004335059)
parameters relimo_ratio14_b_hci_pmos10_10hv = (-0.001877027)
parameters relimo_ratio15_a_hci_pmos10_10hv = (0.159275951)
parameters relimo_ratio15_b_hci_pmos10_10hv = (-0.038220838)
parameters relimo_ratio16_a_hci_pmos10_10hv = (0.07997891)
parameters relimo_ratio16_b_hci_pmos10_10hv = (0.031834846)
parameters relimo_ratio_vth2a0_hci_pmos10_10hv = (-0.190027076)
parameters relimo_vth_hci_pmos10_10hv = (-1)
parameters relimo_a_gm_1_hci_pmos_10hv = (0.97)
parameters relimo_a_gm_2_hci_pmos_10hv = (1.52)
parameters relimo_a_idlin_1_hci_pmos_10hv = (0.93)
parameters relimo_a_idlin_2_hci_pmos_10hv = (1.09)
parameters relimo_a_idsat_1_hci_pmos_10hv = (83069.19491)
parameters relimo_a_idsat_2_hci_pmos_10hv = (0.324)
parameters relimo_a_vth_1_hci_pmos_10hv = (1.62)
parameters relimo_a_vth_2_hci_pmos_10hv = (1.06)
parameters relimo_c_1_hci_pmos_10hv = (27.1836)
parameters relimo_c_2_hci_pmos_10hv = (27.38)
parameters relimo_c_nbti_pmos_10hv = (14.81241225)
parameters relimo_condvd_hci_pmos_10hv = (1.265)
parameters relimo_condvg_hci_pmos_10hv = (1.65)
parameters relimo_intercept_1_hci_pmos_10hv = (0)
parameters relimo_intercept_2_hci_pmos_10hv = (11.82)
parameters relimo_intercept_nbti_pmos_10hv = (0.436785827)
parameters relimo_m_1_hci_pmos_10hv = (10)
parameters relimo_m_2_hci_pmos_10hv = (10)
parameters relimo_n_1_hci_pmos_10hv = (0.558992)
parameters relimo_n_2_hci_pmos_10hv = (1.86)
parameters relimo_n_nbti_pmos_10hv = (3.836150346)
parameters relimo_r_1_hci_pmos_10hv = (3)
parameters relimo_r_2_hci_pmos_10hv = (3)
parameters relimo_ratio2_a_hci_pmos_10hv = (-0.266285276)
parameters relimo_ratio2_b_hci_pmos_10hv = (-1.261094321)
parameters relimo_ratio3_a_hci_pmos_10hv = (-0.599998964)
parameters relimo_ratio3_b_hci_pmos_10hv = (-0.752521352)
parameters relimo_ratio4_a_hci_pmos_10hv = (-0.000549788)
parameters relimo_ratio4_b_hci_pmos_10hv = (1.864195495)
parameters relimo_ratio5_a_hci_pmos_10hv = (0.004530292)
parameters relimo_ratio5_b_hci_pmos_10hv = (1.010726426)
parameters relimo_ratio6_a_hci_pmos_10hv = (-0.119407553)
parameters relimo_ratio6_b_hci_pmos_10hv = (0.880653861)
parameters relimo_ratio7_a_hci_pmos_10hv = (-0.060966854)
parameters relimo_ratio7_b_hci_pmos_10hv = (0.936332129)
parameters relimo_ratio8_a_hci_pmos_10hv = (-0.791731968)
parameters relimo_ratio8_b_hci_pmos_10hv = (-0.172424377)
parameters relimo_ratio9_a_hci_pmos_10hv = (-0.488952409)
parameters relimo_ratio9_b_hci_pmos_10hv = (0.008012624)
parameters relimo_ratio10_a_hci_pmos_10hv = (-0.114224783)
parameters relimo_ratio10_b_hci_pmos_10hv = (-0.114012718)
parameters relimo_ratio11_a_hci_pmos_10hv = (-0.101023213)
parameters relimo_ratio11_b_hci_pmos_10hv = (-0.057287695)
parameters relimo_ratio12_a_hci_pmos_10hv = (0.01094014)
parameters relimo_ratio12_b_hci_pmos_10hv = (0.001630988)
parameters relimo_ratio13_a_hci_pmos_10hv = (-0.258790716)
parameters relimo_ratio13_b_hci_pmos_10hv = (-0.249079914)
parameters relimo_ratio14_a_hci_pmos_10hv = (0.003298466)
parameters relimo_ratio14_b_hci_pmos_10hv = (-0.028420715)
parameters relimo_ratio15_a_hci_pmos_10hv = (0.048941157)
parameters relimo_ratio15_b_hci_pmos_10hv = (-0.043985379)
parameters relimo_ratio16_a_hci_pmos_10hv = (-0.033549322)
parameters relimo_ratio16_b_hci_pmos_10hv = (0.035240313)
parameters relimo_ratio_vth2a0_hci_pmos_10hv = (-1.344700512)
parameters relimo_vth_hci_pmos_10hv = (-1)
parameters relimo_a_gm_1_hci_pmos_ll_10hv = (0.97)
parameters relimo_a_gm_2_hci_pmos_ll_10hv = (1.52)
parameters relimo_a_idlin_1_hci_pmos_ll_10hv = (0.93)
parameters relimo_a_idlin_2_hci_pmos_ll_10hv = (1.09)
parameters relimo_a_idsat_1_hci_pmos_ll_10hv = (83069.19491)
parameters relimo_a_idsat_2_hci_pmos_ll_10hv = (0.324)
parameters relimo_a_vth_1_hci_pmos_ll_10hv = (1.62)
parameters relimo_a_vth_2_hci_pmos_ll_10hv = (1.06)
parameters relimo_c_1_hci_pmos_ll_10hv = (27.1836)
parameters relimo_c_2_hci_pmos_ll_10hv = (27.38)
parameters relimo_c_nbti_pmos_ll_10hv = (37.03)
parameters relimo_condvd_hci_pmos_ll_10hv = (1.265)
parameters relimo_condvg_hci_pmos_ll_10hv = (1.65)
parameters relimo_intercept_1_hci_pmos_ll_10hv = (0)
parameters relimo_intercept_2_hci_pmos_ll_10hv = (11.82)
parameters relimo_intercept_nbti_pmos_ll_10hv = (10.19)
parameters relimo_m_1_hci_pmos_ll_10hv = (10)
parameters relimo_m_2_hci_pmos_ll_10hv = (10)
parameters relimo_n_1_hci_pmos_ll_10hv = (0.558992)
parameters relimo_n_2_hci_pmos_ll_10hv = (1.86)
parameters relimo_n_nbti_pmos_ll_10hv = (3.67)
parameters relimo_r_1_hci_pmos_ll_10hv = (3)
parameters relimo_r_2_hci_pmos_ll_10hv = (3)
parameters relimo_ratio2_a_hci_pmos_ll_10hv = (-0.266285276)
parameters relimo_ratio2_b_hci_pmos_ll_10hv = (-1.261094321)
parameters relimo_ratio3_a_hci_pmos_ll_10hv = (-0.599998964)
parameters relimo_ratio3_b_hci_pmos_ll_10hv = (-0.752521352)
parameters relimo_ratio4_a_hci_pmos_ll_10hv = (-0.000549788)
parameters relimo_ratio4_b_hci_pmos_ll_10hv = (1.864195495)
parameters relimo_ratio5_a_hci_pmos_ll_10hv = (0.004530292)
parameters relimo_ratio5_b_hci_pmos_ll_10hv = (1.010726426)
parameters relimo_ratio6_a_hci_pmos_ll_10hv = (-0.119407553)
parameters relimo_ratio6_b_hci_pmos_ll_10hv = (0.880653861)
parameters relimo_ratio7_a_hci_pmos_ll_10hv = (-0.060966854)
parameters relimo_ratio7_b_hci_pmos_ll_10hv = (0.936332129)
parameters relimo_ratio8_a_hci_pmos_ll_10hv = (-0.791731968)
parameters relimo_ratio8_b_hci_pmos_ll_10hv = (-0.172424377)
parameters relimo_ratio9_a_hci_pmos_ll_10hv = (-0.488952409)
parameters relimo_ratio9_b_hci_pmos_ll_10hv = (0.008012624)
parameters relimo_ratio10_a_hci_pmos_ll_10hv = (-0.114224783)
parameters relimo_ratio10_b_hci_pmos_ll_10hv = (-0.114012718)
parameters relimo_ratio11_a_hci_pmos_ll_10hv = (-0.101023213)
parameters relimo_ratio11_b_hci_pmos_ll_10hv = (-0.057287695)
parameters relimo_ratio12_a_hci_pmos_ll_10hv = (0.01094014)
parameters relimo_ratio12_b_hci_pmos_ll_10hv = (0.001630988)
parameters relimo_ratio13_a_hci_pmos_ll_10hv = (-0.258790716)
parameters relimo_ratio13_b_hci_pmos_ll_10hv = (-0.249079914)
parameters relimo_ratio14_a_hci_pmos_ll_10hv = (0.003298466)
parameters relimo_ratio14_b_hci_pmos_ll_10hv = (-0.028420715)
parameters relimo_ratio15_a_hci_pmos_ll_10hv = (0.048941157)
parameters relimo_ratio15_b_hci_pmos_ll_10hv = (-0.043985379)
parameters relimo_ratio16_a_hci_pmos_ll_10hv = (-0.033549322)
parameters relimo_ratio16_b_hci_pmos_ll_10hv = (0.035240313)
parameters relimo_ratio_vth2a0_hci_pmos_ll_10hv = (-1.344700512)
parameters relimo_vth_hci_pmos_ll_10hv = (-1)
parameters relimo_a_gm_1_hci_pmos_ana_10hv = (1.54)
parameters relimo_a_gm_2_hci_pmos_ana_10hv = (1.98)
parameters relimo_a_idlin_1_hci_pmos_ana_10hv = (1.29)
parameters relimo_a_idlin_2_hci_pmos_ana_10hv = (1.45)
parameters relimo_a_idsat_1_hci_pmos_ana_10hv = (206975.2806)
parameters relimo_a_idsat_2_hci_pmos_ana_10hv = (0.285)
parameters relimo_a_vth_1_hci_pmos_ana_10hv = (2.53)
parameters relimo_a_vth_2_hci_pmos_ana_10hv = (2.27)
parameters relimo_c_1_hci_pmos_ana_10hv = (45.2985)
parameters relimo_c_2_hci_pmos_ana_10hv = (49.12)
parameters relimo_c_nbti_pmos_ana_10hv = (39.23)
parameters relimo_condvd_hci_pmos_ana_10hv = (1.265)
parameters relimo_condvg_hci_pmos_ana_10hv = (1.65)
parameters relimo_intercept_1_hci_pmos_ana_10hv = (0)
parameters relimo_intercept_2_hci_pmos_ana_10hv = (15.26)
parameters relimo_intercept_nbti_pmos_ana_10hv = (6.61)
parameters relimo_m_1_hci_pmos_ana_10hv = (4)
parameters relimo_m_2_hci_pmos_ana_10hv = (4)
parameters relimo_n_1_hci_pmos_ana_10hv = (0.420162)
parameters relimo_n_2_hci_pmos_ana_10hv = (2.2)
parameters relimo_n_nbti_pmos_ana_10hv = (1.22)
parameters relimo_r_1_hci_pmos_ana_10hv = (2.14)
parameters relimo_r_2_hci_pmos_ana_10hv = (3)
parameters relimo_ratio2_a_hci_pmos_ana_10hv = (-0.048004905)
parameters relimo_ratio2_b_hci_pmos_ana_10hv = (-0.871743256)
parameters relimo_ratio3_a_hci_pmos_ana_10hv = (0.021418501)
parameters relimo_ratio3_b_hci_pmos_ana_10hv = (-0.469539713)
parameters relimo_ratio4_a_hci_pmos_ana_10hv = (0.023863255)
parameters relimo_ratio4_b_hci_pmos_ana_10hv = (2.692476804)
parameters relimo_ratio5_a_hci_pmos_ana_10hv = (-0.05773318)
parameters relimo_ratio5_b_hci_pmos_ana_10hv = (0.95327434)
parameters relimo_ratio6_a_hci_pmos_ana_10hv = (-0.196398475)
parameters relimo_ratio6_b_hci_pmos_ana_10hv = (0.803601636)
parameters relimo_ratio7_a_hci_pmos_ana_10hv = (-0.071013522)
parameters relimo_ratio7_b_hci_pmos_ana_10hv = (0.923958012)
parameters relimo_ratio8_a_hci_pmos_ana_10hv = (-0.824817619)
parameters relimo_ratio8_b_hci_pmos_ana_10hv = (-0.244279202)
parameters relimo_ratio9_a_hci_pmos_ana_10hv = (0.065759201)
parameters relimo_ratio9_b_hci_pmos_ana_10hv = (-0.039958673)
parameters relimo_ratio10_a_hci_pmos_ana_10hv = (-0.195771393)
parameters relimo_ratio10_b_hci_pmos_ana_10hv = (-0.195768269)
parameters relimo_ratio11_a_hci_pmos_ana_10hv = (-0.132368731)
parameters relimo_ratio11_b_hci_pmos_ana_10hv = (-0.075051559)
parameters relimo_ratio12_a_hci_pmos_ana_10hv = (0.012799371)
parameters relimo_ratio12_b_hci_pmos_ana_10hv = (0.003802607)
parameters relimo_ratio13_a_hci_pmos_ana_10hv = (-0.16285503)
parameters relimo_ratio13_b_hci_pmos_ana_10hv = (-0.161909836)
parameters relimo_ratio14_a_hci_pmos_ana_10hv = (0.001150027)
parameters relimo_ratio14_b_hci_pmos_ana_10hv = (-0.00488242)
parameters relimo_ratio15_a_hci_pmos_ana_10hv = (-0.107541748)
parameters relimo_ratio15_b_hci_pmos_ana_10hv = (-0.000925483)
parameters relimo_ratio16_a_hci_pmos_ana_10hv = (0.004232257)
parameters relimo_ratio16_b_hci_pmos_ana_10hv = (0.026011937)
parameters relimo_ratio_vth2a0_hci_pmos_ana_10hv = (-0.584264856)
parameters relimo_a_gm_1_hci_nld45_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld45_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld45_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld45_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld45_10hv = (8.433e9)
parameters relimo_a_idsat_2_hci_nld45_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld45_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld45_10hv = (2.76)
parameters relimo_c_1_hci_nld45_10hv = (0.167)
parameters relimo_c_2_hci_nld45_10hv = (148.45)
parameters relimo_condvd_hci_nld45_10hv = (1.265)
parameters relimo_condvg_hci_nld45_10hv = (1.65)
parameters relimo_intercept_1_hci_nld45_10hv = (0)
parameters relimo_intercept_2_hci_nld45_10hv = (14.58)
parameters relimo_m_1_hci_nld45_10hv = (0.068)
parameters relimo_m_2_hci_nld45_10hv = (1)
parameters relimo_n_1_hci_nld45_10hv = (0.235)
parameters relimo_n_2_hci_nld45_10hv = (2.4)
parameters relimo_r_1_hci_nld45_10hv = (3)
parameters relimo_r_2_hci_nld45_10hv = (1)
parameters relimo_e_hci_nld45_10hv = (0.45)
parameters relimo_ratio1_a_hci_nld45_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld45_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld45_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld45_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld45_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld45_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld45_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld45_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld45_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld45_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld45_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld45_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld45_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld45_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld45_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld45_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld45_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld45_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld45_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld45_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld45_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld45_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld45_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld45_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld45_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld45_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld45_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld45_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld45_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld45_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld45_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld45_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld45_10hv = (-0.380777361)
parameters relimo_vth_hci_nld45_10hv = (1)
parameters relimo_a_gm_1_hci_nld45_he_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld45_he_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld45_he_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld45_he_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld45_he_10hv = (12.721e9)
parameters relimo_a_idsat_2_hci_nld45_he_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld45_he_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld45_he_10hv = (2.76)
parameters relimo_c_1_hci_nld45_he_10hv = (0.180)
parameters relimo_c_2_hci_nld45_he_10hv = (148.45)
parameters relimo_condvd_hci_nld45_he_10hv = (1.265)
parameters relimo_condvg_hci_nld45_he_10hv = (1.65)
parameters relimo_intercept_1_hci_nld45_he_10hv = (0)
parameters relimo_intercept_2_hci_nld45_he_10hv = (14.58)
parameters relimo_m_1_hci_nld45_he_10hv = (0.011)
parameters relimo_m_2_hci_nld45_he_10hv = (1)
parameters relimo_n_1_hci_nld45_he_10hv = (0.268)
parameters relimo_n_2_hci_nld45_he_10hv = (2.4)
parameters relimo_r_1_hci_nld45_he_10hv = (3)
parameters relimo_r_2_hci_nld45_he_10hv = (1)
parameters relimo_e_hci_nld45_he_10hv = (0.35)
parameters relimo_ratio1_a_hci_nld45_he_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld45_he_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld45_he_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld45_he_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld45_he_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld45_he_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld45_he_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld45_he_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld45_he_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld45_he_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld45_he_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld45_he_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld45_he_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld45_he_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld45_he_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld45_he_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld45_he_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld45_he_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld45_he_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld45_he_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld45_he_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld45_he_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld45_he_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld45_he_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld45_he_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld45_he_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld45_he_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld45_he_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld45_he_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld45_he_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld45_he_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld45_he_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld45_he_10hv = (-0.380777361)
parameters relimo_vth_hci_nld45_he_10hv = (1)
parameters relimo_a_gm_1_hci_nld45_tlp_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld45_tlp_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld45_tlp_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld45_tlp_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld45_tlp_10hv = (5.48E+13)
parameters relimo_a_idsat_2_hci_nld45_tlp_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld45_tlp_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld45_tlp_10hv = (2.76)
parameters relimo_c_1_hci_nld45_tlp_10hv = (1.32E-01)
parameters relimo_c_2_hci_nld45_tlp_10hv = (148.45)
parameters relimo_condvd_hci_nld45_tlp_10hv = (1.265)
parameters relimo_condvg_hci_nld45_tlp_10hv = (1.65)
parameters relimo_intercept_1_hci_nld45_tlp_10hv = (0)
parameters relimo_intercept_2_hci_nld45_tlp_10hv = (14.58)
parameters relimo_m_1_hci_nld45_tlp_10hv = (0.0514)
parameters relimo_m_2_hci_nld45_tlp_10hv = (1)
parameters relimo_n_1_hci_nld45_tlp_10hv = (0.267)
parameters relimo_n_2_hci_nld45_tlp_10hv = (2.4)
parameters relimo_r_1_hci_nld45_tlp_10hv = (3)
parameters relimo_r_2_hci_nld45_tlp_10hv = (1)
parameters relimo_e_hci_nld45_tlp_10hv = (0.315)
parameters relimo_ratio1_a_hci_nld45_tlp_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld45_tlp_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld45_tlp_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld45_tlp_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld45_tlp_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld45_tlp_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld45_tlp_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld45_tlp_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld45_tlp_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld45_tlp_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld45_tlp_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld45_tlp_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld45_tlp_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld45_tlp_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld45_tlp_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld45_tlp_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld45_tlp_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld45_tlp_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld45_tlp_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld45_tlp_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld45_tlp_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld45_tlp_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld45_tlp_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld45_tlp_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld45_tlp_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld45_tlp_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld45_tlp_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld45_tlp_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld45_tlp_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld45_tlp_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld45_tlp_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld45_tlp_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld45_tlp_10hv = (-0.380777361)
parameters relimo_vth_hci_nld45_tlp_10hv = (1)

parameters relimo_a_gm_1_hci_nld30_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld30_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld30_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld30_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld30_10hv = (895624650685.476)
parameters relimo_a_idsat_2_hci_nld30_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld30_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld30_10hv = (2.76)
parameters relimo_c_1_hci_nld30_10hv = (0.184818174800417)
parameters relimo_c_2_hci_nld30_10hv = (148.45)
parameters relimo_condvd_hci_nld30_10hv = (1.265)
parameters relimo_condvg_hci_nld30_10hv = (1.65)
parameters relimo_intercept_1_hci_nld30_10hv = (0)
parameters relimo_intercept_2_hci_nld30_10hv = (14.58)
parameters relimo_m_1_hci_nld30_10hv = (0.01515)
parameters relimo_m_2_hci_nld30_10hv = (1)
parameters relimo_n_1_hci_nld30_10hv = (0.30)
parameters relimo_n_2_hci_nld30_10hv = (2.4)
parameters relimo_r_1_hci_nld30_10hv = (3)
parameters relimo_r_2_hci_nld30_10hv = (1)
parameters relimo_e_hci_nld30_10hv = (0.389)
parameters relimo_ratio1_a_hci_nld30_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld30_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld30_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld30_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld30_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld30_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld30_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld30_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld30_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld30_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld30_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld30_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld30_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld30_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld30_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld30_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld30_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld30_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld30_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld30_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld30_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld30_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld30_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld30_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld30_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld30_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld30_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld30_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld30_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld30_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld30_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld30_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld30_10hv = (-0.380777361)
parameters relimo_vth_hci_nld30_10hv = (1)


parameters relimo_a_gm_1_hci_nld10_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld10_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld10_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld10_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld10_10hv = (6.37e3)
parameters relimo_a_idsat_2_hci_nld10_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld10_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld10_10hv = (2.76)
parameters relimo_c_1_hci_nld10_10hv = (0.421407216040941)
parameters relimo_c_2_hci_nld10_10hv = (148.45)
parameters relimo_condvd_hci_nld10_10hv = (1.265)
parameters relimo_condvg_hci_nld10_10hv = (1.65)
parameters relimo_intercept_1_hci_nld10_10hv = (0)
parameters relimo_intercept_2_hci_nld10_10hv = (14.58)
parameters relimo_m_1_hci_nld10_10hv = (0.04)
parameters relimo_m_2_hci_nld10_10hv = (1)
parameters relimo_n_1_hci_nld10_10hv = (1)




parameters relimo_n_2_hci_nld10_10hv = (2.4)
parameters relimo_r_1_hci_nld10_10hv = (3)
parameters relimo_r_2_hci_nld10_10hv = (1)
parameters relimo_e_hci_nld10_10hv = (0.276719557414881)


parameters relimo_ratio1_a_hci_nld10_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld10_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld10_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld10_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld10_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld10_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld10_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld10_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld10_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld10_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld10_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld10_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld10_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld10_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld10_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld10_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld10_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld10_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld10_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld10_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld10_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld10_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld10_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld10_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld10_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld10_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld10_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld10_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld10_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld10_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld10_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld10_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld10_10hv = (-0.380777361)
parameters relimo_vth_hci_nld10_10hv = (1)


parameters relimo_a_gm_1_hci_nld65_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld65_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld65_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld65_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld65_10hv = (1.75e13)
parameters relimo_a_idsat_2_hci_nld65_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld65_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld65_10hv = (2.76)
parameters relimo_c_1_hci_nld65_10hv = (0.0685)
parameters relimo_c_2_hci_nld65_10hv = (148.45)
parameters relimo_condvd_hci_nld65_10hv = (1.265)
parameters relimo_condvg_hci_nld65_10hv = (1.65)
parameters relimo_intercept_1_hci_nld65_10hv = (0)
parameters relimo_intercept_2_hci_nld65_10hv = (14.58)
parameters relimo_m_1_hci_nld65_10hv = (0.0765)
parameters relimo_m_2_hci_nld65_10hv = (1)
parameters relimo_n_1_hci_nld65_10hv = (0.274)
parameters relimo_n_2_hci_nld65_10hv = (2.4)
parameters relimo_r_1_hci_nld65_10hv = (3)
parameters relimo_r_2_hci_nld65_10hv = (1)
parameters relimo_e_hci_nld65_10hv = (0.29)
parameters relimo_ratio1_a_hci_nld65_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld65_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld65_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld65_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld65_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld65_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld65_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld65_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld65_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld65_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld65_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld65_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld65_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld65_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld65_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld65_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld65_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld65_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld65_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld65_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld65_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld65_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld65_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld65_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld65_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld65_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld65_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld65_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld65_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld65_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld65_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld65_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld65_10hv = (-0.380777361)
parameters relimo_vth_hci_nld65_10hv = (1)


parameters relimo_a_gm_1_hci_nld90b_10hv = (0.89)
parameters relimo_a_gm_2_hci_nld90b_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nld90b_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nld90b_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nld90b_10hv = (232712096579392)
parameters relimo_a_idsat_2_hci_nld90b_10hv = (0.574)
parameters relimo_a_vth_1_hci_nld90b_10hv = (1.75)
parameters relimo_a_vth_2_hci_nld90b_10hv = (2.76)
parameters relimo_c_1_hci_nld90b_10hv = (0.0339278926578963)
parameters relimo_c_2_hci_nld90b_10hv = (148.45)
parameters relimo_condvd_hci_nld90b_10hv = (1.265)
parameters relimo_condvg_hci_nld90b_10hv = (1.65)
parameters relimo_intercept_1_hci_nld90b_10hv = (0)
parameters relimo_intercept_2_hci_nld90b_10hv = (14.58)
parameters relimo_m_1_hci_nld90b_10hv = (0.09)
parameters relimo_m_2_hci_nld90b_10hv = (1)
parameters relimo_n_1_hci_nld90b_10hv = (0.297226457465398)
parameters relimo_n_2_hci_nld90b_10hv = (2.4)
parameters relimo_r_1_hci_nld90b_10hv = (3)
parameters relimo_r_2_hci_nld90b_10hv = (1)
parameters relimo_e_hci_nld90b_10hv = (0.141211647869229)
parameters relimo_ratio1_a_hci_nld90b_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nld90b_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nld90b_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nld90b_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nld90b_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nld90b_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nld90b_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nld90b_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nld90b_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nld90b_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nld90b_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nld90b_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nld90b_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nld90b_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nld90b_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nld90b_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nld90b_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nld90b_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nld90b_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nld90b_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nld90b_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nld90b_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nld90b_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nld90b_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nld90b_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nld90b_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nld90b_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nld90b_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nld90b_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nld90b_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nld90b_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nld90b_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nld90b_10hv = (-0.380777361)
parameters relimo_vth_hci_nld90b_10hv = (1)




parameters relimo_a_gm_1_hci_nmos45_10hv = (0.89)
parameters relimo_a_gm_2_hci_nmos45_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nmos45_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nmos45_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nmos45_10hv = (2.54e17)
parameters relimo_a_idsat_2_hci_nmos45_10hv = (0.574)
parameters relimo_a_vth_1_hci_nmos45_10hv = (1.75)
parameters relimo_a_vth_2_hci_nmos45_10hv = (2.76)
parameters relimo_c_1_hci_nmos45_10hv = (0.108)
parameters relimo_c_2_hci_nmos45_10hv = (148.45)
parameters relimo_condvd_hci_nmos45_10hv = (1.265)
parameters relimo_condvg_hci_nmos45_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos45_10hv = (0)
parameters relimo_intercept_2_hci_nmos45_10hv = (14.58)
parameters relimo_m_1_hci_nmos45_10hv = (0.138)
parameters relimo_m_2_hci_nmos45_10hv = (1)
parameters relimo_n_1_hci_nmos45_10hv = (0.246)
parameters relimo_n_2_hci_nmos45_10hv = (2.4)
parameters relimo_r_1_hci_nmos45_10hv = (3)
parameters relimo_r_2_hci_nmos45_10hv = (1)
parameters relimo_e_hci_nmos45_10hv = (0.145)
parameters relimo_ratio1_a_hci_nmos45_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nmos45_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nmos45_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nmos45_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nmos45_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nmos45_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nmos45_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nmos45_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nmos45_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nmos45_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nmos45_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nmos45_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nmos45_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nmos45_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nmos45_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nmos45_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nmos45_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nmos45_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nmos45_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nmos45_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nmos45_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nmos45_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nmos45_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nmos45_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nmos45_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nmos45_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nmos45_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nmos45_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nmos45_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nmos45_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nmos45_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nmos45_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nmos45_10hv = (-0.380777361)
parameters relimo_vth_hci_nmos45_10hv = (1)

parameters relimo_a_gm_1_hci_nmos90b_10hv = (0.89)
parameters relimo_a_gm_2_hci_nmos90b_10hv = (1.45)
parameters relimo_a_idlin_1_hci_nmos90b_10hv = (1.92)
parameters relimo_a_idlin_2_hci_nmos90b_10hv = (1.69)
parameters relimo_a_idsat_1_hci_nmos90b_10hv = (67919637945271600)
parameters relimo_a_idsat_2_hci_nmos90b_10hv = (0.574)
parameters relimo_a_vth_1_hci_nmos90b_10hv = (1.75)
parameters relimo_a_vth_2_hci_nmos90b_10hv = (2.76)
parameters relimo_c_1_hci_nmos90b_10hv = (0.0357333894582358)
parameters relimo_c_2_hci_nmos90b_10hv = (148.45)
parameters relimo_condvd_hci_nmos90b_10hv = (1.265)
parameters relimo_condvg_hci_nmos90b_10hv = (1.65)
parameters relimo_intercept_1_hci_nmos90b_10hv = (0)
parameters relimo_intercept_2_hci_nmos90b_10hv = (14.58)
parameters relimo_m_1_hci_nmos90b_10hv = (0.03)
parameters relimo_m_2_hci_nmos90b_10hv = (1)
parameters relimo_n_1_hci_nmos90b_10hv = (0.262002596568212)
parameters relimo_n_2_hci_nmos90b_10hv = (2.4)
parameters relimo_r_1_hci_nmos90b_10hv = (3)
parameters relimo_r_2_hci_nmos90b_10hv = (1)
parameters relimo_e_hci_nmos90b_10hv = (0.0980398580767862)
parameters relimo_ratio1_a_hci_nmos90b_10hv = (0.163151796)
parameters relimo_ratio1_b_hci_nmos90b_10hv = (-0.461262665)
parameters relimo_ratio2_a_hci_nmos90b_10hv = (0.285782436)
parameters relimo_ratio2_b_hci_nmos90b_10hv = (-0.13793475)
parameters relimo_ratio3_a_hci_nmos90b_10hv = (0.618501058)
parameters relimo_ratio3_b_hci_nmos90b_10hv = (-0.045965089)
parameters relimo_ratio4_a_hci_nmos90b_10hv = (0.180621441)
parameters relimo_ratio4_b_hci_nmos90b_10hv = (0.556493011)
parameters relimo_ratio5_a_hci_nmos90b_10hv = (-0.275411289)
parameters relimo_ratio5_b_hci_nmos90b_10hv = (0.734889943)
parameters relimo_ratio6_a_hci_nmos90b_10hv = (-0.380297184)
parameters relimo_ratio6_b_hci_nmos90b_10hv = (0.620074377)
parameters relimo_ratio7_a_hci_nmos90b_10hv = (-0.101190418)
parameters relimo_ratio7_b_hci_nmos90b_10hv = (0.88270337)
parameters relimo_ratio8_a_hci_nmos90b_10hv = (0.077434837)
parameters relimo_ratio8_b_hci_nmos90b_10hv = (-0.051532481)
parameters relimo_ratio9_a_hci_nmos90b_10hv = (0.055006633)
parameters relimo_ratio9_b_hci_nmos90b_10hv = (-0.022242084)
parameters relimo_ratio10_a_hci_nmos90b_10hv = (-0.183896069)
parameters relimo_ratio10_b_hci_nmos90b_10hv = (-0.293958185)
parameters relimo_ratio11_a_hci_nmos90b_10hv = (-0.077725631)
parameters relimo_ratio11_b_hci_nmos90b_10hv = (-0.038680446)
parameters relimo_ratio12_a_hci_nmos90b_10hv = (0.176343712)
parameters relimo_ratio12_b_hci_nmos90b_10hv = (5.85907E-07)
parameters relimo_ratio13_a_hci_nmos90b_10hv = (-0.20955361)
parameters relimo_ratio13_b_hci_nmos90b_10hv = (-0.209453023)
parameters relimo_ratio14_a_hci_nmos90b_10hv = (-0.020440779)
parameters relimo_ratio14_b_hci_nmos90b_10hv = (-0.032832279)
parameters relimo_ratio15_a_hci_nmos90b_10hv = (-0.03553424)
parameters relimo_ratio15_b_hci_nmos90b_10hv = (-0.040469633)
parameters relimo_ratio16_a_hci_nmos90b_10hv = (-0.554556676)
parameters relimo_ratio16_b_hci_nmos90b_10hv = (0.004819256)
parameters relimo_ratio_vth2a0_hci_nmos90b_10hv = (-0.380777361)
parameters relimo_vth_hci_nmos90b_10hv = (1)



parameters relimo_vth_hci_pmos_ana_10hv = (-1)
parameters relimo_c_nbti_lgo = (14.81241225)
parameters relimo_intercept_nbti_lgo = (0.436785827)
parameters relimo_n_nbti_lgo = (3.836150346)
parameters relimo_c_nbti_ana = (14.08852281)
parameters relimo_intercept_nbti_ana = (0.071002556)
parameters relimo_n_nbti_ana = (3.33746066)
parameters relimo_c_nbti_dgo = (15.29489977)
parameters relimo_intercept_nbti_dgo = (7.51167E-09)
parameters relimo_n_nbti_dgo = (3.203865143)
parameters relimo_ratio20_a_bti_pmos_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos_10hv = (0)
parameters relimo_ratio20_a_bti_pmos_ll_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos_ll_10hv = (0)
parameters relimo_ratio20_a_bti_pmos_ana_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos_ana_10hv = (0)
parameters relimo_ratio20_a_bti_pmos5_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos5_10hv = (0)
parameters relimo_ratio20_a_bti_pld5_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld5_10hv = (0)
parameters relimo_ratio20_a_bti_pmos10_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos10_10hv = (0)
parameters relimo_ratio20_a_bti_pld10_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld10_10hv = (0)
parameters relimo_ratio20_a_bti_pld10b_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld10b_10hv = (0)
parameters relimo_ratio20_a_bti_pld30_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld30_10hv = (0)
parameters relimo_ratio20_a_bti_pmos45_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos45_10hv = (0)
parameters relimo_ratio20_a_bti_pmoshs45_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmoshs45_10hv = (0)
parameters relimo_ratio20_a_bti_pld45_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld45_10hv = (0)
parameters relimo_ratio20_a_bti_pmos90_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos90_10hv = (0)
parameters relimo_ratio20_a_bti_pmos90b_10hv = (1.0)
parameters relimo_ratio20_b_bti_pmos90b_10hv = (0)
parameters relimo_ratio20_a_bti_pld90_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld90_10hv = (0)
parameters relimo_ratio20_a_bti_pld90b_10hv = (1.0)
parameters relimo_ratio20_b_bti_pld90b_10hv = (0)

//
// general prestoplus parameters
//
parameters
+ presto_infinity     = 3.40282e+38
+ presto_active       = 1
+ presto_nbti_active  = 1
+ presto_pbti_active  = 1
+ presto_hci_active   = 1
+ presto_offstate_active   = 1
+ presto_hvgs_active  = 1
+ presto_rvbe_active  = 1
+ presto_tstart       = 0
+ presto_tstop        = presto_infinity
+ presto_tage         = 1*365*24*3600
+ presto_mode         = 0  // dummy param needed for compatibility with presto
+ presto_vthRatio     = 0.001    //unit changed from mV to V.
+ presto_idRatio      = 0.01     //unit changed from % to 1. 

//
// prestoplus flagging criteria
//
parameters
+ presto_tempcrit_bti = -273.0
+ presto_vtshiftcrit  = 0.001
+ presto_ishiftcrit   = 0.001
+ presto_dvthmax      = 7000.0

// Common GO1 NBTI Parameters			
parameters
+ presto_nbti_go1_k = 0.00008617
+ presto_nbti_go1_a = 0.805797511667723**(1.0/0.260678)/3600.0*presto_vthRatio**(1.0/0.260678)
+ presto_nbti_go1_fstat = 1.0
+ presto_nbti_go1_n = 0.260678
+ presto_nbti_go1_m = 3.86127/0.260678
+ presto_nbti_go1_vgexp = 0
+ presto_nbti_go1_ea = 0
+ presto_nbti_go1_lpow = 0
+ presto_nbti_go1_wpow = 0
+ presto_nbti_go1_vbxexp = 0
+ presto_nbti_go1_lexp = 0

// Common GO1_ana NBTI Parameters			
parameters
+ presto_nbti_go1_ana_k = 0.00008617
+ presto_nbti_go1_ana_a = 0.452697788245507**(1.0/0.299629)/3600.0*presto_vthRatio**(1.0/0.299629)
+ presto_nbti_go1_ana_fstat = 1.0
+ presto_nbti_go1_ana_n = 0.299629
+ presto_nbti_go1_ana_m = 4.22133/0.299629
+ presto_nbti_go1_ana_vgexp = 0
+ presto_nbti_go1_ana_ea = 0
+ presto_nbti_go1_ana_lpow = 0
+ presto_nbti_go1_ana_wpow = 0
+ presto_nbti_go1_ana_vbxexp = 0
+ presto_nbti_go1_ana_lexp = 0

// Common GO2 NBTI Parameters			
parameters
+ presto_nbti_go2_k = 0.00008617
+ presto_nbti_go2_a = 1.0/0.0000243*presto_vthRatio**(1.0/0.201)
+ presto_nbti_go2_fstat = 0.0159
+ presto_nbti_go2_n = 0.201
+ presto_nbti_go2_m = 13.9
+ presto_nbti_go2_vgexp = 0
+ presto_nbti_go2_ea = 0.916
+ presto_nbti_go2_lpow = 0
+ presto_nbti_go2_wpow = 0
+ presto_nbti_go2_vbxexp = 0
+ presto_nbti_go2_lexp = 0

// Common GO1_ana PBTI Parameters			
parameters
+ presto_pbti_go1_ana_k = 0.00008617
+ presto_pbti_go1_ana_a = 1.0/2.70E-08*presto_vthRatio**(1.0/0.55)
+ presto_pbti_go1_ana_fstat = 0.0693
+ presto_pbti_go1_ana_n = 0.55
+ presto_pbti_go1_ana_m = 10.9
+ presto_pbti_go1_ana_vgexp = 0
+ presto_pbti_go1_ana_ea = 1.08
+ presto_pbti_go1_ana_lpow = 0
+ presto_pbti_go1_ana_wpow = 0
+ presto_pbti_go1_ana_vbxexp = 0
+ presto_pbti_go1_ana_lexp = 0

// Common GO2 PBTI Parameters			
parameters
+ presto_pbti_go2_k = 0.00008617
+ presto_pbti_go2_a = 1.0/0.000162*presto_vthRatio**(1.0/0.442)
+ presto_pbti_go2_fstat = 0.0084
+ presto_pbti_go2_n = 0.442
+ presto_pbti_go2_m = 11.9
+ presto_pbti_go2_vgexp = 0
+ presto_pbti_go2_ea = 1.33
+ presto_pbti_go2_lpow = 0
+ presto_pbti_go2_wpow = 0
+ presto_pbti_go2_vbxexp = 0
+ presto_pbti_go2_lexp = 0

// Common pmos5 HCI Parameters			
parameters
+ presto_hci_pmos5_avth = 0		
+ presto_hci_pmos5_bvth = 0		
+ presto_hci_pmos5_n_vth = 0		
+ presto_hci_pmos5_ai = 0		
+ presto_hci_pmos5_bi = 1483365.29161205/100.0/3600.0**0.303194		
+ presto_hci_pmos5_gammai = 1		
+ presto_hci_pmos5_n_i = 0.303194		
+ presto_hci_pmos5_alphamve = 0		
+ presto_hci_pmos5_fstatmve = 1		
+ presto_hci_pmos5_vdpowmve = 0		
+ presto_hci_pmos5_vgpowmve = 0		
+ presto_hci_pmos5_vdexpmve = 0		
+ presto_hci_pmos5_eamve = 0		
+ presto_hci_pmos5_lexpmve = 0		
+ presto_hci_pmos5_lpowmve = 0		
+ presto_hci_pmos5_wpowmve = 0		
+ presto_hci_pmos5_vbsexpmve = 0		
+ presto_hci_pmos5_vc1mve = 0		
+ presto_hci_pmos5_vc2mve = 0		
+ presto_hci_pmos5_alphahe = 1		
+ presto_hci_pmos5_fstathe = 1
+ presto_hci_pmos5_vdpowhe = 0		
+ presto_hci_pmos5_vgpowhe = 0		
+ presto_hci_pmos5_vdexphe = 77.4067/0.303194		
+ presto_hci_pmos5_eahe = 0		
+ presto_hci_pmos5_lexphe = 0		
+ presto_hci_pmos5_lpowhe = 0		
+ presto_hci_pmos5_wpowhe = 0		
+ presto_hci_pmos5_vbsexphe = 0		
+ presto_hci_pmos5_vc1he = 0		
+ presto_hci_pmos5_vc2he = 0		

// Common nmos5 HCI Parameters			
parameters
+ presto_hci_nmos5_avth = 0		
+ presto_hci_nmos5_bvth = 0		
+ presto_hci_nmos5_n_vth = 0		
+ presto_hci_nmos5_ai = 0		
+ presto_hci_nmos5_bi = 93.074549912905/100.0/3600.0**0.501535		
+ presto_hci_nmos5_gammai = 1		
+ presto_hci_nmos5_n_i = 0.501535		
+ presto_hci_nmos5_alphamve = 0		
+ presto_hci_nmos5_fstatmve = 1		
+ presto_hci_nmos5_vdpowmve = 0		
+ presto_hci_nmos5_vgpowmve = 0		
+ presto_hci_nmos5_vdexpmve = 0		
+ presto_hci_nmos5_eamve = 0		
+ presto_hci_nmos5_lexpmve = 0		
+ presto_hci_nmos5_lpowmve = 0		
+ presto_hci_nmos5_wpowmve = 0		
+ presto_hci_nmos5_vbsexpmve = 0		
+ presto_hci_nmos5_vc1mve = 0		
+ presto_hci_nmos5_vc2mve = 0		
+ presto_hci_nmos5_alphahe = 1		
+ presto_hci_nmos5_fstathe = 1
+ presto_hci_nmos5_vdpowhe = 0		
+ presto_hci_nmos5_vgpowhe = 0		
+ presto_hci_nmos5_vdexphe = 33.6377/0.501535		
+ presto_hci_nmos5_eahe = 0		
+ presto_hci_nmos5_lexphe = 0		
+ presto_hci_nmos5_lpowhe = 0		
+ presto_hci_nmos5_wpowhe = 0		
+ presto_hci_nmos5_vbsexphe = 0		
+ presto_hci_nmos5_vc1he = 0		
+ presto_hci_nmos5_vc2he = 0		

// Common pld5 HCI Parameters			
parameters 
+ presto_hci_pld5_avth = 0		
+ presto_hci_pld5_bvth = 0		
+ presto_hci_pld5_n_vth = 0		
+ presto_hci_pld5_ai = 0		
+ presto_hci_pld5_bi = 11403.8094167954/100.0/3600.0**0.127351		
+ presto_hci_pld5_gammai = 1		
+ presto_hci_pld5_n_i = 0.127351		
+ presto_hci_pld5_alphamve = 0		
+ presto_hci_pld5_fstatmve = 1		
+ presto_hci_pld5_vdpowmve = 0		
+ presto_hci_pld5_vgpowmve = 0		
+ presto_hci_pld5_vdexpmve = 0		
+ presto_hci_pld5_eamve = 0		
+ presto_hci_pld5_lexpmve = 0		
+ presto_hci_pld5_lpowmve = 0		
+ presto_hci_pld5_wpowmve = 0		
+ presto_hci_pld5_vbsexpmve = 0		
+ presto_hci_pld5_vc1mve = 0		
+ presto_hci_pld5_vc2mve = 0		
+ presto_hci_pld5_alphahe = 1		
+ presto_hci_pld5_fstathe = 1
+ presto_hci_pld5_vdpowhe = 0		
+ presto_hci_pld5_vgpowhe = 0		
+ presto_hci_pld5_vdexphe = 44.7704/0.127351		
+ presto_hci_pld5_eahe = 0		
+ presto_hci_pld5_lexphe = 0		
+ presto_hci_pld5_lpowhe = 0		
+ presto_hci_pld5_wpowhe = 0		
+ presto_hci_pld5_vbsexphe = 0		
+ presto_hci_pld5_vc1he = 0		
+ presto_hci_pld5_vc2he = 0		

// Common nld5 HCI Parameters			
parameters  
+ presto_hci_nld5_avth = 0		
+ presto_hci_nld5_bvth = 0		
+ presto_hci_nld5_n_vth = 0		
+ presto_hci_nld5_ai = 0		
+ presto_hci_nld5_bi = 3049.87417914345/100.0/3600.0**0.237324		
+ presto_hci_nld5_gammai = 1		
+ presto_hci_nld5_n_i = 0.237324		
+ presto_hci_nld5_alphamve = 0		
+ presto_hci_nld5_fstatmve = 1		
+ presto_hci_nld5_vdpowmve = 0		
+ presto_hci_nld5_vgpowmve = 0		
+ presto_hci_nld5_vdexpmve = 0		
+ presto_hci_nld5_eamve = 0		
+ presto_hci_nld5_lexpmve = 0		
+ presto_hci_nld5_lpowmve = 0		
+ presto_hci_nld5_wpowmve = 0		
+ presto_hci_nld5_vbsexpmve = 0		
+ presto_hci_nld5_vc1mve = 0		
+ presto_hci_nld5_vc2mve = 0		
+ presto_hci_nld5_alphahe = 1		
+ presto_hci_nld5_fstathe = 1
+ presto_hci_nld5_vdpowhe = 0		
+ presto_hci_nld5_vgpowhe = 0		
+ presto_hci_nld5_vdexphe = 41.8425/0.237324		
+ presto_hci_nld5_eahe = 0		
+ presto_hci_nld5_lexphe = 0		
+ presto_hci_nld5_lpowhe = 0		
+ presto_hci_nld5_wpowhe = 0		
+ presto_hci_nld5_vbsexphe = 0		
+ presto_hci_nld5_vc1he = 0		
+ presto_hci_nld5_vc2he = 0		

// Common pmos10 HCI Parameters			
parameters   
+ presto_hci_pmos10_avth = 0		
+ presto_hci_pmos10_bvth = 0		
+ presto_hci_pmos10_n_vth = 0		
+ presto_hci_pmos10_ai = 0		
+ presto_hci_pmos10_bi = 430835.768173937/100.0/3600.0**0.426436		
+ presto_hci_pmos10_gammai = 1		
+ presto_hci_pmos10_n_i = 0.426436		
+ presto_hci_pmos10_alphamve = 0		
+ presto_hci_pmos10_fstatmve = 1		
+ presto_hci_pmos10_vdpowmve = 0		
+ presto_hci_pmos10_vgpowmve = 0		
+ presto_hci_pmos10_vdexpmve = 0		
+ presto_hci_pmos10_eamve = 0		
+ presto_hci_pmos10_lexpmve = 0		
+ presto_hci_pmos10_lpowmve = 0		
+ presto_hci_pmos10_wpowmve = 0		
+ presto_hci_pmos10_vbsexpmve = 0		
+ presto_hci_pmos10_vc1mve = 0		
+ presto_hci_pmos10_vc2mve = 0		
+ presto_hci_pmos10_alphahe = 1		
+ presto_hci_pmos10_fstathe = 1
+ presto_hci_pmos10_vdpowhe = 0		
+ presto_hci_pmos10_vgpowhe = 0		
+ presto_hci_pmos10_vdexphe = 216.775/0.426436		
+ presto_hci_pmos10_eahe = 0		
+ presto_hci_pmos10_lexphe = 0		
+ presto_hci_pmos10_lpowhe = 0		
+ presto_hci_pmos10_wpowhe = 0		
+ presto_hci_pmos10_vbsexphe = 0		
+ presto_hci_pmos10_vc1he = 0		
+ presto_hci_pmos10_vc2he = 0		

// Common nmos10 HCI Parameters			
parameters    
+ presto_hci_nmos10_avth = 0		
+ presto_hci_nmos10_bvth = 0		
+ presto_hci_nmos10_n_vth = 0		
+ presto_hci_nmos10_ai = 0		
+ presto_hci_nmos10_bi = 20.6703399347971/100.0/3600.0**0.094634		
+ presto_hci_nmos10_gammai = 1		
+ presto_hci_nmos10_n_i = 0.094634		
+ presto_hci_nmos10_alphamve = 0		
+ presto_hci_nmos10_fstatmve = 1		
+ presto_hci_nmos10_vdpowmve = 0		
+ presto_hci_nmos10_vgpowmve = 0		
+ presto_hci_nmos10_vdexpmve = 0		
+ presto_hci_nmos10_eamve = 0		
+ presto_hci_nmos10_lexpmve = 0		
+ presto_hci_nmos10_lpowmve = 0		
+ presto_hci_nmos10_wpowmve = 0		
+ presto_hci_nmos10_vbsexpmve = 0		
+ presto_hci_nmos10_vc1mve = 0		
+ presto_hci_nmos10_vc2mve = 0		
+ presto_hci_nmos10_alphahe = 1		
+ presto_hci_nmos10_fstathe = 1
+ presto_hci_nmos10_vdpowhe = 0		
+ presto_hci_nmos10_vgpowhe = 0		
+ presto_hci_nmos10_vdexphe = 50.0099/0.094634		
+ presto_hci_nmos10_eahe = 0		
+ presto_hci_nmos10_lexphe = 0		
+ presto_hci_nmos10_lpowhe = 0		
+ presto_hci_nmos10_wpowhe = 0		
+ presto_hci_nmos10_vbsexphe = 0		
+ presto_hci_nmos10_vc1he = 0		
+ presto_hci_nmos10_vc2he = 0		

// Common pmos HCI Parameters			
parameters     
+ presto_hci_pmos_avth = 0		
+ presto_hci_pmos_bvth = 0		
+ presto_hci_pmos_n_vth = 0		
+ presto_hci_pmos_ai = 0		
+ presto_hci_pmos_bi = 83069.1949085317/100.0/3600.0**0.558992		
+ presto_hci_pmos_gammai = 1		
+ presto_hci_pmos_n_i = 0.558992		
+ presto_hci_pmos_alphamve = 0		
+ presto_hci_pmos_fstatmve = 1		
+ presto_hci_pmos_vdpowmve = 0		
+ presto_hci_pmos_vgpowmve = 0		
+ presto_hci_pmos_vdexpmve = 0		
+ presto_hci_pmos_eamve = 0		
+ presto_hci_pmos_lexpmve = 0		
+ presto_hci_pmos_lpowmve = 0		
+ presto_hci_pmos_wpowmve = 0		
+ presto_hci_pmos_vbsexpmve = 0		
+ presto_hci_pmos_vc1mve = 0		
+ presto_hci_pmos_vc2mve = 0		
+ presto_hci_pmos_alphahe = 1		
+ presto_hci_pmos_fstathe = 1
+ presto_hci_pmos_vdpowhe = 0		
+ presto_hci_pmos_vgpowhe = 0		
+ presto_hci_pmos_vdexphe = 27.1836/0.558992		
+ presto_hci_pmos_eahe = 0		
+ presto_hci_pmos_lexphe = 0		
+ presto_hci_pmos_lpowhe = 0		
+ presto_hci_pmos_wpowhe = 0		
+ presto_hci_pmos_vbsexphe = 0		
+ presto_hci_pmos_vc1he = 0		
+ presto_hci_pmos_vc2he = 0		

// Common nmos HCI Parameters			
parameters      
+ presto_hci_nmos_avth = 0		
+ presto_hci_nmos_bvth = 0		
+ presto_hci_nmos_n_vth = 0		
+ presto_hci_nmos_ai = 0		
+ presto_hci_nmos_bi = 673773.92341488/100.0/3600.0**0.471141		
+ presto_hci_nmos_gammai = 1		
+ presto_hci_nmos_n_i = 0.471141		
+ presto_hci_nmos_alphamve = 0		
+ presto_hci_nmos_fstatmve = 1		
+ presto_hci_nmos_vdpowmve = 0		
+ presto_hci_nmos_vgpowmve = 0		
+ presto_hci_nmos_vdexpmve = 0		
+ presto_hci_nmos_eamve = 0		
+ presto_hci_nmos_lexpmve = 0		
+ presto_hci_nmos_lpowmve = 0		
+ presto_hci_nmos_wpowmve = 0		
+ presto_hci_nmos_vbsexpmve = 0		
+ presto_hci_nmos_vc1mve = 0		
+ presto_hci_nmos_vc2mve = 0		
+ presto_hci_nmos_alphahe = 1		
+ presto_hci_nmos_fstathe = 1
+ presto_hci_nmos_vdpowhe = 0		
+ presto_hci_nmos_vgpowhe = 0		
+ presto_hci_nmos_vdexphe = 26.7562/0.471141		
+ presto_hci_nmos_eahe = 0		
+ presto_hci_nmos_lexphe = 0		
+ presto_hci_nmos_lpowhe = 0		
+ presto_hci_nmos_wpowhe = 0		
+ presto_hci_nmos_vbsexphe = 0		
+ presto_hci_nmos_vc1he = 0		
+ presto_hci_nmos_vc2he = 0		

// Common pmos_ana HCI Parameters			
parameters     
+ presto_hci_pmos_ana_avth = 0		
+ presto_hci_pmos_ana_bvth = 0		
+ presto_hci_pmos_ana_n_vth = 0		
+ presto_hci_pmos_ana_ai = 0		
+ presto_hci_pmos_ana_bi = 206975.280598122/100.0/3600.0**0.420162		
+ presto_hci_pmos_ana_gammai = 1		
+ presto_hci_pmos_ana_n_i = 0.420162		
+ presto_hci_pmos_ana_alphamve = 0		
+ presto_hci_pmos_ana_fstatmve = 1		
+ presto_hci_pmos_ana_vdpowmve = 0		
+ presto_hci_pmos_ana_vgpowmve = 0		
+ presto_hci_pmos_ana_vdexpmve = 0		
+ presto_hci_pmos_ana_eamve = 0		
+ presto_hci_pmos_ana_lexpmve = 0		
+ presto_hci_pmos_ana_lpowmve = 0		
+ presto_hci_pmos_ana_wpowmve = 0		
+ presto_hci_pmos_ana_vbsexpmve = 0		
+ presto_hci_pmos_ana_vc1mve = 0		
+ presto_hci_pmos_ana_vc2mve = 0		
+ presto_hci_pmos_ana_alphahe = 1		
+ presto_hci_pmos_ana_fstathe = 1
+ presto_hci_pmos_ana_vdpowhe = 0		
+ presto_hci_pmos_ana_vgpowhe = 0		
+ presto_hci_pmos_ana_vdexphe = 45.2985/0.420162		
+ presto_hci_pmos_ana_eahe = 0		
+ presto_hci_pmos_ana_lexphe = 0		
+ presto_hci_pmos_ana_lpowhe = 0		
+ presto_hci_pmos_ana_wpowhe = 0		
+ presto_hci_pmos_ana_vbsexphe = 0		
+ presto_hci_pmos_ana_vc1he = 0		
+ presto_hci_pmos_ana_vc2he = 0		

// Common nmos_ana HCI Parameters			
parameters     
+ presto_hci_nmos_ana_avth = 0		
+ presto_hci_nmos_ana_bvth = 0		
+ presto_hci_nmos_ana_n_vth = 0		
+ presto_hci_nmos_ana_ai = 0		
+ presto_hci_nmos_ana_bi = 35479.0828449911/100.0/3600.0**0.378235		
+ presto_hci_nmos_ana_gammai = 1		
+ presto_hci_nmos_ana_n_i = 0.378235		
+ presto_hci_nmos_ana_alphamve = 0		
+ presto_hci_nmos_ana_fstatmve = 1		
+ presto_hci_nmos_ana_vdpowmve = 0		
+ presto_hci_nmos_ana_vgpowmve = 0		
+ presto_hci_nmos_ana_vdexpmve = 0		
+ presto_hci_nmos_ana_eamve = 0		
+ presto_hci_nmos_ana_lexpmve = 0		
+ presto_hci_nmos_ana_lpowmve = 0		
+ presto_hci_nmos_ana_wpowmve = 0		
+ presto_hci_nmos_ana_vbsexpmve = 0		
+ presto_hci_nmos_ana_vc1mve = 0		
+ presto_hci_nmos_ana_vc2mve = 0		
+ presto_hci_nmos_ana_alphahe = 1		
+ presto_hci_nmos_ana_fstathe = 1
+ presto_hci_nmos_ana_vdpowhe = 0		
+ presto_hci_nmos_ana_vgpowhe = 0		
+ presto_hci_nmos_ana_vdexphe = 38.2734/0.378235		
+ presto_hci_nmos_ana_eahe = 0		
+ presto_hci_nmos_ana_lexphe = 0		
+ presto_hci_nmos_ana_lpowhe = 0		
+ presto_hci_nmos_ana_wpowhe = 0		
+ presto_hci_nmos_ana_vbsexphe = 0		
+ presto_hci_nmos_ana_vc1he = 0		
+ presto_hci_nmos_ana_vc2he = 0		

// Common nmos3_zvt HCI Parameters			
parameters      
+ presto_hci_nmos3_zvt_avth = 0		
+ presto_hci_nmos3_zvt_bvth = 0		
+ presto_hci_nmos3_zvt_n_vth = 0		
+ presto_hci_nmos3_zvt_ai = 0		
+ presto_hci_nmos3_zvt_bi = 1120.64088119998/100.0/3600.0**0.56049		
+ presto_hci_nmos3_zvt_gammai = 1		
+ presto_hci_nmos3_zvt_n_i = 0.56049		
+ presto_hci_nmos3_zvt_alphamve = 0		
+ presto_hci_nmos3_zvt_fstatmve = 1		
+ presto_hci_nmos3_zvt_vdpowmve = 0		
+ presto_hci_nmos3_zvt_vgpowmve = 0		
+ presto_hci_nmos3_zvt_vdexpmve = 0		
+ presto_hci_nmos3_zvt_eamve = 0		
+ presto_hci_nmos3_zvt_lexpmve = 0		
+ presto_hci_nmos3_zvt_lpowmve = 0		
+ presto_hci_nmos3_zvt_wpowmve = 0		
+ presto_hci_nmos3_zvt_vbsexpmve = 0		
+ presto_hci_nmos3_zvt_vc1mve = 0		
+ presto_hci_nmos3_zvt_vc2mve = 0		
+ presto_hci_nmos3_zvt_alphahe = 1		
+ presto_hci_nmos3_zvt_fstathe = 1
+ presto_hci_nmos3_zvt_vdpowhe = 0		
+ presto_hci_nmos3_zvt_vgpowhe = 0		
+ presto_hci_nmos3_zvt_vdexphe = 23.3097/0.56049		
+ presto_hci_nmos3_zvt_eahe = 0		
+ presto_hci_nmos3_zvt_lexphe = 0		
+ presto_hci_nmos3_zvt_lpowhe = 0		
+ presto_hci_nmos3_zvt_wpowhe = 0		
+ presto_hci_nmos3_zvt_vbsexphe = 0		
+ presto_hci_nmos3_zvt_vc1he = 0		
+ presto_hci_nmos3_zvt_vc2he = 0		




endsection base



section soa_report_header_dfrt
if (enable_soa == 1 || enable_esdsoa == 1) {
soa_report_header soa_report_header
}
endsection soa_report_header_dfrt

section vms_15_10hv_dfrt
include "soachecks_top.scs" section=vms_15_10hv_soa
endsection vms_15_10hv_dfrt

section vms_30_10hv_dfrt
include "soachecks_top.scs" section=vms_30_10hv_soa
endsection vms_30_10hv_dfrt

section vms_45_10hv_dfrt
include "soachecks_top.scs" section=vms_45_10hv_soa
endsection vms_45_10hv_dfrt

section vms_60_10hv_dfrt
include "soachecks_top.scs" section=vms_60_10hv_soa
endsection vms_60_10hv_dfrt

section vms_105_10hv_dfrt
include "soachecks_top.scs" section=vms_105_10hv_soa
endsection vms_105_10hv_dfrt

section vms_115_10hv_dfrt
include "soachecks_top.scs" section=vms_115_10hv_soa
endsection vms_115_10hv_dfrt

section vms_165_10hv_dfrt
include "soachecks_top.scs" section=vms_165_10hv_soa
endsection vms_165_10hv_dfrt

section nld65_10hv_dfrt
include "soachecks_top.scs" section=nld65b_10hv_soa
if (enable_esdsoa == 1) {
anld65_10hv_esdchk_1 (d g s sub) monitor_esd_nld65_10hv ruleNum=1 enable=soa rule="esd_nld65_Vt1=82p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_2 (d g s sub) monitor_esd_nld65_10hv ruleNum=2 enable=soa rule="esd_nld65_Vt1>82p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 82.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=82.4
anld65_10hv_esdchk_3 (d g s sub) monitor_esd_nld65_10hv ruleNum=3 enable=soa rule="esd_nld65_=Vt1_Vgs_0p0_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65_10hv_esdchk_4 (d g s sub) monitor_esd_nld65_10hv ruleNum=4 enable=soa rule="esd_nld65_>Vt1_Vgs_0p0_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 82.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=82.4
anld65_10hv_esdchk_5 (d g s sub) monitor_esd_nld65_10hv ruleNum=5 enable=soa rule="esd_nld65_Vt1=82p4_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_6 (d g s sub) monitor_esd_nld65_10hv ruleNum=6 enable=soa rule="esd_nld65_Vt1>82p4_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 82.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=82.4
anld65_10hv_esdchk_7 (d g s sub) monitor_esd_nld65_10hv ruleNum=7 enable=soa rule="esd_nld65_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(1.5*(V(g)-V(s)-4.5))-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65_10hv_esdchk_8 (d g s sub) monitor_esd_nld65_10hv ruleNum=8 enable=soa rule="esd_nld65_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(1.5*(V(g)-V(s)-4.5))) > 82.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=82.4
anld65_10hv_esdchk_9 (d g s sub) monitor_esd_nld65_10hv ruleNum=9 enable=soa rule="esd_nld65_Vt1=80p9_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-80.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_10 (d g s sub) monitor_esd_nld65_10hv ruleNum=10 enable=soa rule="esd_nld65_Vt1>80p9_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 80.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=80.9
anld65_10hv_esdchk_11 (d g s sub) monitor_esd_nld65_10hv ruleNum=11 enable=soa rule="esd_nld65_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-5.5))-80.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65_10hv_esdchk_12 (d g s sub) monitor_esd_nld65_10hv ruleNum=12 enable=soa rule="esd_nld65_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-5.5))) > 80.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=80.9
anld65_10hv_esdchk_13 (d g s sub) monitor_esd_nld65_10hv ruleNum=13 enable=soa rule="esd_nld65_Vt1=80p7_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-80.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_14 (d g s sub) monitor_esd_nld65_10hv ruleNum=14 enable=soa rule="esd_nld65_Vt1>80p7_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 80.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=80.7
anld65_10hv_esdchk_15 (d g s sub) monitor_esd_nld65_10hv ruleNum=15 enable=soa rule="esd_nld65_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(2.1*(V(g)-V(s)-6.0))-80.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65_10hv_esdchk_16 (d g s sub) monitor_esd_nld65_10hv ruleNum=16 enable=soa rule="esd_nld65_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(2.1*(V(g)-V(s)-6.0))) > 80.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=80.7
anld65_10hv_esdchk_17 (d g s sub) monitor_esd_nld65_10hv ruleNum=17 enable=soa rule="esd_nld65_Vt1=78p6_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-78.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_18 (d g s sub) monitor_esd_nld65_10hv ruleNum=18 enable=soa rule="esd_nld65_Vt1>78p6_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 78.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.6
anld65_10hv_esdchk_19 (d g s sub) monitor_esd_nld65_10hv ruleNum=19 enable=soa rule="esd_nld65_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-78.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65_10hv_esdchk_20 (g s d s) monitor4t enable=soa rule="esd_nld65_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 78.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.6
anld65_10hv_esdchk_21 (g s) monitor2t enable=soa rule="esd_nld65_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld65_10hv_esdchk_22 (g d) monitor2t enable=soa rule="esd_nld65_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 82.4 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=82.4
anld65_10hv_esdchk_23 (d sub) monitor2t enable=soa rule="esd_nld65_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld65_10hv_esdchk_24 (sub s) monitor2t enable=soa rule="esd_nld65_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld65_10hv_esdchk_25 (s d) monitor2t enable=soa rule="esd_nld65_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nld65_10hv_dfrt

section nld65b_10hv_dfrt
include "soachecks_top.scs" section=nld65b_10hv_soa
if (enable_relimo == 1) {
anld65b_10hv_hci3 (d g s sub) relimo_aging_hci_nld65b w=w*ng relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1.25 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld65_10hv relimo_probe_name=amost relimo_a_gm=relimo_a_gm_1_hci_nld65_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld65_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld65_10hv relimo_a_vth=relimo_a_vth_1_hci_nld65_10hv relimo_c=relimo_c_1_hci_nld65_10hv relimo_condvd=relimo_condvd_hci_nld65_10hv relimo_condvg=relimo_condvg_hci_nld65_10hv relimo_intercept=relimo_intercept_1_hci_nld65_10hv relimo_m=relimo_m_1_hci_nld65_10hv relimo_n=relimo_n_1_hci_nld65_10hv relimo_r=relimo_r_1_hci_nld65_10hv relimo_e=relimo_e_hci_nld65_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld65_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld65_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld65_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld65_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld65_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld65_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld65_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld65_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld65_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld65_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld65_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld65_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld65_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld65_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld65_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld65_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld65_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld65_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld65_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld65_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld65_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld65_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld65_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld65_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld65_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld65_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld65_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld65_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld65_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld65_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld65_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld65_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld65_10hv relimo_vth=relimo_vth_hci_nld65_10hv
anld65b_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld65_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld65b_10hv_esdchk_1 (d g s sub) monitor_esd_nld65b_10hv ruleNum=1 enable=soa rule="esd_nld65b_Vt1=82p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_2 (d g s sub) monitor_esd_nld65b_10hv ruleNum=2 enable=soa rule="esd_nld65b_Vt1>82p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 82.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=82.4
anld65b_10hv_esdchk_3 (d g s sub) monitor_esd_nld65b_10hv ruleNum=3 enable=soa rule="esd_nld65b_=Vt1_Vgs_0p0_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65b_10hv_esdchk_4 (d g s sub) monitor_esd_nld65b_10hv ruleNum=4 enable=soa rule="esd_nld65b_>Vt1_Vgs_0p0_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 82.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=82.4
anld65b_10hv_esdchk_5 (d g s sub) monitor_esd_nld65b_10hv ruleNum=5 enable=soa rule="esd_nld65b_Vt1=82p4_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_6 (d g s sub) monitor_esd_nld65b_10hv ruleNum=6 enable=soa rule="esd_nld65b_Vt1>82p4_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 82.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=82.4
anld65b_10hv_esdchk_7 (d g s sub) monitor_esd_nld65b_10hv ruleNum=7 enable=soa rule="esd_nld65b_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(1.5*(V(g)-V(s)-4.5))-82.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65b_10hv_esdchk_8 (d g s sub) monitor_esd_nld65b_10hv ruleNum=8 enable=soa rule="esd_nld65b_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(1.5*(V(g)-V(s)-4.5))) > 82.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=82.4
anld65b_10hv_esdchk_9 (d g s sub) monitor_esd_nld65b_10hv ruleNum=9 enable=soa rule="esd_nld65b_Vt1=80p9_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-80.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_10 (d g s sub) monitor_esd_nld65b_10hv ruleNum=10 enable=soa rule="esd_nld65b_Vt1>80p9_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 80.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=80.9
anld65b_10hv_esdchk_11 (d g s sub) monitor_esd_nld65b_10hv ruleNum=11 enable=soa rule="esd_nld65b_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-5.5))-80.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65b_10hv_esdchk_12 (d g s sub) monitor_esd_nld65b_10hv ruleNum=12 enable=soa rule="esd_nld65b_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-5.5))) > 80.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=80.9
anld65b_10hv_esdchk_13 (d g s sub) monitor_esd_nld65b_10hv ruleNum=13 enable=soa rule="esd_nld65b_Vt1=80p7_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-80.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_14 (d g s sub) monitor_esd_nld65b_10hv ruleNum=14 enable=soa rule="esd_nld65b_Vt1>80p7_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 80.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=80.7
anld65b_10hv_esdchk_15 (d g s sub) monitor_esd_nld65b_10hv ruleNum=15 enable=soa rule="esd_nld65b_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(2.1*(V(g)-V(s)-6.0))-80.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld65b_10hv_esdchk_16 (d g s sub) monitor_esd_nld65b_10hv ruleNum=16 enable=soa rule="esd_nld65b_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(2.1*(V(g)-V(s)-6.0))) > 80.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=80.7
anld65b_10hv_esdchk_17 (d g s sub) monitor_esd_nld65b_10hv ruleNum=17 enable=soa rule="esd_nld65b_Vt1=78p6_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-78.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_18 (d g s sub) monitor_esd_nld65b_10hv ruleNum=18 enable=soa rule="esd_nld65b_Vt1>78p6_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 78.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.6
anld65b_10hv_esdchk_19 (d g s sub) monitor_esd_nld65b_10hv ruleNum=19 enable=soa rule="esd_nld65b_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-78.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld65b_10hv_esdchk_20 (g s d s) monitor4t enable=soa rule="esd_nld65b_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 78.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.6
anld65b_10hv_esdchk_21 (g s) monitor2t enable=soa rule="esd_nld65b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld65b_10hv_esdchk_22 (g d) monitor2t enable=soa rule="esd_nld65b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 82.4 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=82.4
anld65b_10hv_esdchk_23 (d sub) monitor2t enable=soa rule="esd_nld65b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld65b_10hv_esdchk_24 (sub s) monitor2t enable=soa rule="esd_nld65b_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld65b_10hv_esdchk_25 (s d) monitor2t enable=soa rule="esd_nld65b_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "amost"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00368
+ hcia1           = 0.767*presto_idRatio
+ hcia2           = 0.643*presto_idRatio
+ hcic1           = 1350
+ hcilambdael0    = 3.94e-7
+ hcialpha1       = 7.51e-13
+ hcibeta1        = 0.993
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.274
+ offfstattau1    = 0.0765
+ offalpha1       = 1.75E+13
+ offbeta1legacy  = 0.0685
+ offea1          = 0.29
+ hvgsfstat       = 0.0696         // High Vgs HCI part
+ hvgsa           = 305*presto_vthRatio
+ hvgsn           = 0.459
+ hvgsalpha       = 9.49E27
+ hvgsbeta        = 0.854
+ hvgsgamma       = 20.9
+ hvgsdelta       = 10.1
+ hvgsepsilon     = 0
+ hvgsea          = 0.701
+ hvgsrth         = 0.00283
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 12500 
+ a0_b0_b0_a1_em1 = -1.76 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = 740 
+ a0_b0_a1_a1_em1 = -3.88 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 3540 
+ a0_b0_a2_a1_em1 = -6.25 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -5450 
+ a0_b0_a3_a1_em1 = 6.53 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -2.01 
+ a0_b0_p1_a1_em1 = 0.00665 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.89 
+ a0_b0_p2_a1_em1 = -0.00137 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 4.93 
+ a0_b0_p3_a1_em1 = -0.00502 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 9610 
+ a0_b0_b0_a2_em1 = -11.6 
+ b0_a0_b0_a2_em1 = 10.1 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -1830 
+ a0_b0_a1_a2_em1 = 5.24 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 823 
+ a0_b0_a2_a2_em1 = 1.05 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -1660 
+ a0_b0_a3_a2_em1 = -1.95 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -0.29 
+ a0_b0_p1_a2_em1 = -0.00378 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 2.36 
+ a0_b0_p2_a2_em1 = -0.00521 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 2.17 
+ a0_b0_p3_a2_em1 = -0.0021 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 156 
+ a0_b0_b0_a3_em1 = 24.4 
+ b0_a0_b0_a3_em1 = 25 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 1690 
+ a0_b0_a1_a3_em1 = -1.69 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 0.33 
+ a0_b0_a2_a3_em1 = 0.302 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -4020 
+ a0_b0_a3_a3_em1 = 0.0695 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = -0.413 
+ a0_b0_p1_a3_em1 = -0.00101 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.16 
+ a0_b0_p2_a3_em1 = -0.00153 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.88 
+ a0_b0_p3_a3_em1 = -0.0035 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3.1 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 1690 
+ a0_b0_b0_a4_em1 = 1.24 
+ b0_a0_b0_a4_em1 = 0.583 
+ a0_a0_b0_a4_em1 = 0.0392 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -111 
+ a0_b0_a1_a4_em1 = 0.778 
+ b0_a0_a1_a4_em1 = 0.587 
+ a0_a0_a1_a4_em1 = 0.0311 
+ b0_b0_a2_a4_em1 = -1830 
+ a0_b0_a2_a4_em1 = 3.04 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0.0019 
+ b0_b0_a3_a4_em1 = -205 
+ a0_b0_a3_a4_em1 = 8.19 
+ b0_a0_a3_a4_em1 = 0.00514 
+ a0_a0_a3_a4_em1 = -0.0249 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = -5.6 
+ a0_b0_p1_a4_em1 = 0.0109 
+ b0_a0_p1_a4_em1 = 0.055 
+ a0_a0_p1_a4_em1 = -5.47E-05 
+ b0_b0_p2_a4_em1 = 2.32 
+ a0_b0_p2_a4_em1 = -0.00363 
+ b0_a0_p2_a4_em1 = -0.0314 
+ a0_a0_p2_a4_em1 = 8.40E-05 
+ b0_b0_p3_a4_em1 = 1.67 
+ a0_b0_p3_a4_em1 = 0.00271 
+ b0_a0_p3_a4_em1 = -0.00569 
+ a0_a0_p3_a4_em1 = 3.25E-05 
+ b0_b0_p4_a4_em1 = 4.77 
+ a0_b0_p4_a4_em1 = -0.00147 
+ b0_a0_p4_a4_em1 = 0.00822 
+ a0_a0_p4_a4_em1 = -1.44E-05 
+ b0_b0_b0_p1_em1 = 1.67 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.524 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 3.49 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 11.6 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -1 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.48 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 3.27 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 3.81 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 20.5 
+ a0_b0_b0_p2_em1 = 0.0101 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 2.86 
+ a0_b0_a1_p2_em1 = -0.00763 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = -7 
+ a0_b0_a2_p2_em1 = 0.0136 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 3.64 
+ a0_b0_a3_p2_em1 = 0.0153 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 0.975 
+ a0_b0_p2_p2_em1 = 0.00158 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 3.07 
+ a0_b0_p3_p2_em1 = -0.000216 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 4.49 
+ a0_b0_p4_p2_em1 = -0.00132 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 35.1 
+ a0_b0_b0_p3_em1 = 0.00167 
+ b0_a0_b0_p3_em1 = 0.1 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = -3.61 
+ a0_b0_a1_p3_em1 = -0.00246 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0.567 
+ a0_b0_a2_p3_em1 = 0.0088 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -7.07 
+ a0_b0_a3_p3_em1 = 0.0274 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 5.27 
+ a0_b0_p1_p3_em1 = -0.00953 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 3.94 
+ a0_b0_p2_p3_em1 = -0.00176 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 7.09 
+ a0_b0_p3_p3_em1 = -0.0154 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 4.01 
+ a0_b0_p4_p3_em1 = 0.000286 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 39 
+ a0_b0_b0_p4_em1 = -0.00378 
+ b0_a0_b0_p4_em1 = 0.136 
+ a0_a0_b0_p4_em1 = -4.67E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 4.95 
+ a0_b0_a1_p4_em1 = -0.0139 
+ b0_a0_a1_p4_em1 = -0.0295 
+ a0_a0_a1_p4_em1 = 4.85E-05 
+ b0_b0_a2_p4_em1 = 4.77 
+ a0_b0_a2_p4_em1 = -0.0203 
+ b0_a0_a2_p4_em1 = -0.0575 
+ a0_a0_a2_p4_em1 = 0.000154 
+ b0_b0_a3_p4_em1 = 9.25 
+ a0_b0_a3_p4_em1 = 0.0477 
+ b0_a0_a3_p4_em1 = 0.161 
+ a0_a0_a3_p4_em1 = -0.000342 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 1.07 
+ a0_b0_p1_p4_em1 = -0.00175 
+ b0_a0_p1_p4_em1 = -0.00381 
+ a0_a0_p1_p4_em1 = -6.05E-06 
+ b0_b0_p2_p4_em1 = -0.68 
+ a0_b0_p2_p4_em1 = 0.00784 
+ b0_a0_p2_p4_em1 = 0.00449 
+ a0_a0_p2_p4_em1 = -4.46E-05 
+ b0_b0_p3_p4_em1 = 3.2 
+ a0_b0_p3_p4_em1 = -0.00137 
+ b0_a0_p3_p4_em1 = -0.00153 
+ a0_a0_p3_p4_em1 = 4.00E-06 
+ b0_b0_p4_p4_em1 = 3.38 
+ a0_b0_p4_p4_em1 = -0.000311 
+ b0_a0_p4_p4_em1 = -0.00355 
+ a0_a0_p4_p4_em1 = 1.40E-05 
}
endsection nld65b_10hv_dfrt

section nld90_10hv_dfrt
include "soachecks_top.scs" section=nld90b_10hv_soa
if (enable_esdsoa == 1) {
anld90_10hv_esdchk_1 (d g s sub) monitor_esd_nld90_10hv ruleNum=1 enable=soa rule="esd_nld90_Vt1=115p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-115.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_2 (d g s sub) monitor_esd_nld90_10hv ruleNum=2 enable=soa rule="esd_nld90_Vt1>115p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 115.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=115.0
anld90_10hv_esdchk_3 (d g s sub) monitor_esd_nld90_10hv ruleNum=3 enable=soa rule="esd_nld90_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-5.2*(V(g)-V(s)-0.0))-115.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_4 (d g s sub) monitor_esd_nld90_10hv ruleNum=4 enable=soa rule="esd_nld90_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-5.2*(V(g)-V(s)-0.0))) > 115.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=115.0
anld90_10hv_esdchk_5 (d g s sub) monitor_esd_nld90_10hv ruleNum=5 enable=soa rule="esd_nld90_Vt1=117p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-117.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_6 (d g s sub) monitor_esd_nld90_10hv ruleNum=6 enable=soa rule="esd_nld90_Vt1>117p6_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 117.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=117.6
anld90_10hv_esdchk_7 (d g s sub) monitor_esd_nld90_10hv ruleNum=7 enable=soa rule="esd_nld90_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-3.0*(V(g)-V(s)-0.5))-117.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_8 (d g s sub) monitor_esd_nld90_10hv ruleNum=8 enable=soa rule="esd_nld90_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-3.0*(V(g)-V(s)-0.5))) > 117.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=117.6
anld90_10hv_esdchk_9 (d g s sub) monitor_esd_nld90_10hv ruleNum=9 enable=soa rule="esd_nld90_Vt1=119p1_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-119.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_10 (d g s sub) monitor_esd_nld90_10hv ruleNum=10 enable=soa rule="esd_nld90_Vt1>119p1_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 119.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=119.1
anld90_10hv_esdchk_11 (d g s sub) monitor_esd_nld90_10hv ruleNum=11 enable=soa rule="esd_nld90_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(-9.4*(V(g)-V(s)-1.0))-119.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_12 (d g s sub) monitor_esd_nld90_10hv ruleNum=12 enable=soa rule="esd_nld90_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(-9.4*(V(g)-V(s)-1.0))) > 119.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=119.1
anld90_10hv_esdchk_13 (d g s sub) monitor_esd_nld90_10hv ruleNum=13 enable=soa rule="esd_nld90_Vt1=123p8_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_14 (d g s sub) monitor_esd_nld90_10hv ruleNum=14 enable=soa rule="esd_nld90_Vt1>123p8_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8
anld90_10hv_esdchk_15 (d g s sub) monitor_esd_nld90_10hv ruleNum=15 enable=soa rule="esd_nld90_=Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(6.4*(V(g)-V(s)-1.5))-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_16 (d g s sub) monitor_esd_nld90_10hv ruleNum=16 enable=soa rule="esd_nld90_>Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(6.4*(V(g)-V(s)-1.5))) > 123.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=123.8
anld90_10hv_esdchk_17 (d g s sub) monitor_esd_nld90_10hv ruleNum=17 enable=soa rule="esd_nld90_Vt1=120p6_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-120.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_18 (d g s sub) monitor_esd_nld90_10hv ruleNum=18 enable=soa rule="esd_nld90_Vt1>120p6_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 120.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=120.6
anld90_10hv_esdchk_19 (d g s sub) monitor_esd_nld90_10hv ruleNum=19 enable=soa rule="esd_nld90_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-2.0))-120.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_20 (d g s sub) monitor_esd_nld90_10hv ruleNum=20 enable=soa rule="esd_nld90_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-2.0))) > 120.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=120.6
anld90_10hv_esdchk_21 (d g s sub) monitor_esd_nld90_10hv ruleNum=21 enable=soa rule="esd_nld90_Vt1=118p4_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-118.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_22 (d g s sub) monitor_esd_nld90_10hv ruleNum=22 enable=soa rule="esd_nld90_Vt1>118p4_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 118.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=118.4
anld90_10hv_esdchk_23 (d g s sub) monitor_esd_nld90_10hv ruleNum=23 enable=soa rule="esd_nld90_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(0.5*(V(g)-V(s)-3.0))-118.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_24 (d g s sub) monitor_esd_nld90_10hv ruleNum=24 enable=soa rule="esd_nld90_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(0.5*(V(g)-V(s)-3.0))) > 118.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=118.4
anld90_10hv_esdchk_25 (d g s sub) monitor_esd_nld90_10hv ruleNum=25 enable=soa rule="esd_nld90_Vt1=117p9_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-117.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_26 (d g s sub) monitor_esd_nld90_10hv ruleNum=26 enable=soa rule="esd_nld90_Vt1>117p9_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 117.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=117.9
anld90_10hv_esdchk_27 (d g s sub) monitor_esd_nld90_10hv ruleNum=27 enable=soa rule="esd_nld90_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-4.0))-117.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_28 (d g s sub) monitor_esd_nld90_10hv ruleNum=28 enable=soa rule="esd_nld90_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-4.0))) > 117.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=117.9
anld90_10hv_esdchk_29 (d g s sub) monitor_esd_nld90_10hv ruleNum=29 enable=soa rule="esd_nld90_Vt1=117p9_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-117.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_30 (d g s sub) monitor_esd_nld90_10hv ruleNum=30 enable=soa rule="esd_nld90_Vt1>117p9_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 117.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=117.9
anld90_10hv_esdchk_31 (d g s sub) monitor_esd_nld90_10hv ruleNum=31 enable=soa rule="esd_nld90_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(0.8*(V(g)-V(s)-5.0))-117.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_32 (d g s sub) monitor_esd_nld90_10hv ruleNum=32 enable=soa rule="esd_nld90_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(0.8*(V(g)-V(s)-5.0))) > 117.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=117.9
anld90_10hv_esdchk_33 (d g s sub) monitor_esd_nld90_10hv ruleNum=33 enable=soa rule="esd_nld90_Vt1=117p1_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-117.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_34 (d g s sub) monitor_esd_nld90_10hv ruleNum=34 enable=soa rule="esd_nld90_Vt1>117p1_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 117.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=117.1
anld90_10hv_esdchk_35 (d g s sub) monitor_esd_nld90_10hv ruleNum=35 enable=soa rule="esd_nld90_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(0.3*(V(g)-V(s)-6.0))-117.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld90_10hv_esdchk_36 (d g s sub) monitor_esd_nld90_10hv ruleNum=36 enable=soa rule="esd_nld90_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(0.3*(V(g)-V(s)-6.0))) > 117.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=117.1
anld90_10hv_esdchk_37 (d g s sub) monitor_esd_nld90_10hv ruleNum=37 enable=soa rule="esd_nld90_Vt1=116p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-116.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_38 (d g s sub) monitor_esd_nld90_10hv ruleNum=38 enable=soa rule="esd_nld90_Vt1>116p8_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 116.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.8
anld90_10hv_esdchk_39 (d g s sub) monitor_esd_nld90_10hv ruleNum=39 enable=soa rule="esd_nld90_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-116.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90_10hv_esdchk_40 (g s d s) monitor4t enable=soa rule="esd_nld90_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 116.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.8
anld90_10hv_esdchk_41 (g s) monitor2t enable=soa rule="esd_nld90_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld90_10hv_esdchk_42 (g d) monitor2t enable=soa rule="esd_nld90_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 115.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=115.0
anld90_10hv_esdchk_43 (d sub) monitor2t enable=soa rule="esd_nld90_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld90_10hv_esdchk_44 (sub s) monitor2t enable=soa rule="esd_nld90_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld90_10hv_esdchk_45 (s d) monitor2t enable=soa rule="esd_nld90_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nld90_10hv_dfrt

section nld90b_10hv_dfrt
include "soachecks_top.scs" section=nld90b_10hv_soa
if (enable_relimo == 1) {
anld90b_10hv_hv_hci (d g s sub) relimo_aging_hv_hci_nld90b w=w*ng relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_ratio21_a=0.74 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld90b_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld90b_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld90b_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld90b_10hv relimo_a_vth=relimo_a_vth_1_hci_nld90b_10hv relimo_c=relimo_c_1_hci_nld90b_10hv relimo_condvd=relimo_condvd_hci_nld90b_10hv relimo_condvg=relimo_condvg_hci_nld90b_10hv relimo_intercept=relimo_intercept_1_hci_nld90b_10hv relimo_m=relimo_m_1_hci_nld90b_10hv relimo_n=relimo_n_1_hci_nld90b_10hv relimo_r=relimo_r_1_hci_nld90b_10hv relimo_e=relimo_e_hci_nld90b_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld90b_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld90b_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld90b_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld90b_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld90b_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld90b_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld90b_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld90b_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld90b_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld90b_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld90b_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld90b_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld90b_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld90b_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld90b_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld90b_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld90b_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld90b_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld90b_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld90b_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld90b_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld90b_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld90b_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld90b_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld90b_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld90b_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld90b_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld90b_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld90b_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld90b_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld90b_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld90b_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld90b_10hv relimo_vth=relimo_vth_hci_nld90b_10hv
anld90b_10hv_pbti_dummy relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld90b_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld90b_10hv_esdchk_1 (d g s sub) monitor_esd_nld90b_10hv ruleNum=1 enable=soa rule="esd_nld90b_Vt1=120p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-120.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90b_10hv_esdchk_2 (d g s sub) monitor_esd_nld90b_10hv ruleNum=2 enable=soa rule="esd_nld90b_Vt1>120p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 120.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=120.0
anld90b_10hv_esdchk_3 (d g s sub) monitor_esd_nld90b_10hv ruleNum=3 enable=soa rule="esd_nld90b_=Vt1_Vgs_0p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="(abs(V(d)-V(s)-120.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld90b_10hv_esdchk_4 (g s d s) monitor4t enable=soa rule="esd_nld90b_>Vt1_Vgs_0p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(d-to-s) > 120.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=120.0
anld90b_10hv_esdchk_5 (g s) monitor2t enable=soa rule="esd_nld90b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld90b_10hv_esdchk_6 (g d) monitor2t enable=soa rule="esd_nld90b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 120.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=120.0
anld90b_10hv_esdchk_7 (d sub) monitor2t enable=soa rule="esd_nld90b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld90b_10hv_esdchk_8 (sub s) monitor2t enable=soa rule="esd_nld90b_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld90b_10hv_esdchk_9 (s d) monitor2t enable=soa rule="esd_nld90b_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.0029
+ hcia1           = 0.456*presto_idRatio
+ hcia2           = 0.298*presto_idRatio
+ hcic1           = 904
+ hcilambdael0    = 3.96e-7
+ hcialpha1       = 3.31e-14
+ hcibeta1        = 1.24
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.297226457465398
+ offfstattau1    = 0.09
+ offalpha1       = 232712096579392
+ offbeta1legacy  = 0.0339278926578963
+ offea1          = 0.141211647869229
+ hvgsfstat       = 0.017609         // High Vgs HCI part
+ hvgsa           = 328.9*presto_vthRatio
+ hvgsn           = 0.40
+ hvgsalpha       = 9.96E23
+ hvgsbeta        = 8.0E-8
+ hvgsgamma       = 18.83
+ hvgsdelta       = 8.37
+ hvgsepsilon     = 0
+ hvgsea          = 0.81
+ hvgsrth         = 0.002684
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 12400 
+ a0_b0_b0_a1_em1 = -0.155 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -378 
+ a0_b0_a1_a1_em1 = -0.618 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 5390 
+ a0_b0_a2_a1_em1 = -7.39 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -1760 
+ a0_b0_a3_a1_em1 = 3.16 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -0.823 
+ a0_b0_p1_a1_em1 = 0.000291 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.97 
+ a0_b0_p2_a1_em1 = 0.000044 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 4.49 
+ a0_b0_p3_a1_em1 = -0.00267 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.5 
+ a0_b0_p4_a1_em1 = 0 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 8000 
+ a0_b0_b0_a2_em1 = 0 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 1200 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 0 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = -4000 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = 0 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.5 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 1.7 
+ a0_b0_p2_a2_em1 = 0 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 3.5 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 500 
+ a0_b0_b0_a3_em1 = 0 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 0 
+ a0_b0_a1_a3_em1 = 0 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 0 
+ a0_b0_a2_a3_em1 = 0 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = 0 
+ a0_b0_a3_a3_em1 = 0 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 0 
+ a0_b0_p2_a3_em1 = 0 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 0 
+ a0_b0_p3_a3_em1 = 0 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 0 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 238 
+ a0_b0_b0_a4_em1 = 2.17 
+ b0_a0_b0_a4_em1 = 30.3 
+ a0_a0_b0_a4_em1 = -0.0447 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 0 
+ a0_b0_a1_a4_em1 = 0 
+ b0_a0_a1_a4_em1 = 0 
+ a0_a0_a1_a4_em1 = 0 
+ b0_b0_a2_a4_em1 = 0 
+ a0_b0_a2_a4_em1 = 0 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0 
+ b0_b0_a3_a4_em1 = 0 
+ a0_b0_a3_a4_em1 = 0 
+ b0_a0_a3_a4_em1 = 0 
+ a0_a0_a3_a4_em1 = 0 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0 
+ a0_b0_p1_a4_em1 = 0 
+ b0_a0_p1_a4_em1 = 0 
+ a0_a0_p1_a4_em1 = 0 
+ b0_b0_p2_a4_em1 = 0 
+ a0_b0_p2_a4_em1 = 0 
+ b0_a0_p2_a4_em1 = 0 
+ a0_a0_p2_a4_em1 = 0 
+ b0_b0_p3_a4_em1 = 0 
+ a0_b0_p3_a4_em1 = 0 
+ b0_a0_p3_a4_em1 = 0 
+ a0_a0_p3_a4_em1 = 0 
+ b0_b0_p4_a4_em1 = 0 
+ a0_b0_p4_a4_em1 = 0 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = 2.75 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.1 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 4.5 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 6 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 0.5 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.74 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 3.5 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4.04 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 24.7 
+ a0_b0_b0_p2_em1 = -0.000697 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0.518 
+ a0_b0_a1_p2_em1 = 0.00176 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = -10.4 
+ a0_b0_a2_p2_em1 = 0.0123 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 1.97 
+ a0_b0_a3_p2_em1 = -0.00556 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 2.12 
+ a0_b0_p2_p2_em1 = -0.000524 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.5 
+ a0_b0_p3_p2_em1 = 0.000633 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 1.24 
+ a0_b0_p4_p2_em1 = 0.0027 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 33 
+ a0_b0_b0_p3_em1 = 0 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0 
+ a0_b0_a1_p3_em1 = 0 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0 
+ a0_b0_a2_p3_em1 = 0 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0 
+ a0_b0_a3_p3_em1 = 0 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0 
+ a0_b0_p1_p3_em1 = 0 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 0 
+ a0_b0_p2_p3_em1 = 0 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 0 
+ a0_b0_p3_p3_em1 = 0 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 0 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = -20.6 
+ a0_b0_b0_p4_em1 = 0.123 
+ b0_a0_b0_p4_em1 = 0.807 
+ a0_a0_b0_p4_em1 = -0.00258 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 0 
+ a0_b0_a1_p4_em1 = 0 
+ b0_a0_a1_p4_em1 = 0 
+ a0_a0_a1_p4_em1 = 0 
+ b0_b0_a2_p4_em1 = 0 
+ a0_b0_a2_p4_em1 = 0 
+ b0_a0_a2_p4_em1 = 0 
+ a0_a0_a2_p4_em1 = 0 
+ b0_b0_a3_p4_em1 = 0 
+ a0_b0_a3_p4_em1 = 0 
+ b0_a0_a3_p4_em1 = 0 
+ a0_a0_a3_p4_em1 = 0 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0 
+ a0_b0_p1_p4_em1 = 0 
+ b0_a0_p1_p4_em1 = 0 
+ a0_a0_p1_p4_em1 = 0 
+ b0_b0_p2_p4_em1 = 0 
+ a0_b0_p2_p4_em1 = 0 
+ b0_a0_p2_p4_em1 = 0 
+ a0_a0_p2_p4_em1 = 0 
+ b0_b0_p3_p4_em1 = 0 
+ a0_b0_p3_p4_em1 = 0 
+ b0_a0_p3_p4_em1 = 0 
+ a0_a0_p3_p4_em1 = 0 
+ b0_b0_p4_p4_em1 = 0 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0 
}
endsection nld90b_10hv_dfrt

section nld100_10hv_dfrt
include "soachecks_top.scs" section=nld100_10hv_soa
if (enable_esdsoa == 1) {
anld100_10hv_esdchk_1 (d g s sub) monitor_esd_nld100_10hv ruleNum=1 enable=soa rule="esd_nld100_Vt1=133p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_2 (d g s sub) monitor_esd_nld100_10hv ruleNum=2 enable=soa rule="esd_nld100_Vt1>133p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_3 (d g s sub) monitor_esd_nld100_10hv ruleNum=3 enable=soa rule="esd_nld100_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_4 (d g s sub) monitor_esd_nld100_10hv ruleNum=4 enable=soa rule="esd_nld100_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_5 (d g s sub) monitor_esd_nld100_10hv ruleNum=5 enable=soa rule="esd_nld100_Vt1=133p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_6 (d g s sub) monitor_esd_nld100_10hv ruleNum=6 enable=soa rule="esd_nld100_Vt1>133p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_7 (d g s sub) monitor_esd_nld100_10hv ruleNum=7 enable=soa rule="esd_nld100_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_8 (d g s sub) monitor_esd_nld100_10hv ruleNum=8 enable=soa rule="esd_nld100_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_9 (d g s sub) monitor_esd_nld100_10hv ruleNum=9 enable=soa rule="esd_nld100_Vt1=133p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_10 (d g s sub) monitor_esd_nld100_10hv ruleNum=10 enable=soa rule="esd_nld100_Vt1>133p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_11 (d g s sub) monitor_esd_nld100_10hv ruleNum=11 enable=soa rule="esd_nld100_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_12 (d g s sub) monitor_esd_nld100_10hv ruleNum=12 enable=soa rule="esd_nld100_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_13 (d g s sub) monitor_esd_nld100_10hv ruleNum=13 enable=soa rule="esd_nld100_Vt1=133p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_14 (d g s sub) monitor_esd_nld100_10hv ruleNum=14 enable=soa rule="esd_nld100_Vt1>133p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_15 (d g s sub) monitor_esd_nld100_10hv ruleNum=15 enable=soa rule="esd_nld100_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.5))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_16 (d g s sub) monitor_esd_nld100_10hv ruleNum=16 enable=soa rule="esd_nld100_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.5))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_17 (d g s sub) monitor_esd_nld100_10hv ruleNum=17 enable=soa rule="esd_nld100_Vt1=133p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_18 (d g s sub) monitor_esd_nld100_10hv ruleNum=18 enable=soa rule="esd_nld100_Vt1>133p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_19 (d g s sub) monitor_esd_nld100_10hv ruleNum=19 enable=soa rule="esd_nld100_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.5))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_20 (d g s sub) monitor_esd_nld100_10hv ruleNum=20 enable=soa rule="esd_nld100_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.5))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_21 (d g s sub) monitor_esd_nld100_10hv ruleNum=21 enable=soa rule="esd_nld100_Vt1=133p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_22 (d g s sub) monitor_esd_nld100_10hv ruleNum=22 enable=soa rule="esd_nld100_Vt1>133p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0
anld100_10hv_esdchk_23 (d g s sub) monitor_esd_nld100_10hv ruleNum=23 enable=soa rule="esd_nld100_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-3.5))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_24 (d g s sub) monitor_esd_nld100_10hv ruleNum=24 enable=soa rule="esd_nld100_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-3.5))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0
anld100_10hv_esdchk_25 (d g s sub) monitor_esd_nld100_10hv ruleNum=25 enable=soa rule="esd_nld100_Vt1=132p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-132.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_26 (d g s sub) monitor_esd_nld100_10hv ruleNum=26 enable=soa rule="esd_nld100_Vt1>132p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 132.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=132.0
anld100_10hv_esdchk_27 (d g s sub) monitor_esd_nld100_10hv ruleNum=27 enable=soa rule="esd_nld100_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(3.0*(V(g)-V(s)-4.5))-132.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld100_10hv_esdchk_28 (d g s sub) monitor_esd_nld100_10hv ruleNum=28 enable=soa rule="esd_nld100_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(3.0*(V(g)-V(s)-4.5))) > 132.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=132.0
anld100_10hv_esdchk_29 (d g s sub) monitor_esd_nld100_10hv ruleNum=29 enable=soa rule="esd_nld100_Vt1=129p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-129.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_30 (d g s sub) monitor_esd_nld100_10hv ruleNum=30 enable=soa rule="esd_nld100_Vt1>129p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 129.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=129.0
anld100_10hv_esdchk_31 (d g s sub) monitor_esd_nld100_10hv ruleNum=31 enable=soa rule="esd_nld100_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(d)-V(s)-129.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld100_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nld100_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(d-to-s) > 129.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=129.0
anld100_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_nld100_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld100_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_nld100_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 138.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=138.0
anld100_10hv_esdchk_35 (d sub) monitor2t enable=soa rule="esd_nld100_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld100_10hv_esdchk_36 (sub s) monitor2t enable=soa rule="esd_nld100_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld100_10hv_esdchk_37 (s d) monitor2t enable=soa rule="esd_nld100_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nld100_10hv_dfrt

section pld65_10hv_dfrt
include "soachecks_top.scs" section=pld65_10hv_soa
if (enable_esdsoa == 1) {
apld65_10hv_esdchk_1 (d g s sub) monitor_esd_pld65_10hv ruleNum=1 enable=soa rule="esd_pld65_Vt1=91p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-91.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_2 (d g s sub) monitor_esd_pld65_10hv ruleNum=2 enable=soa rule="esd_pld65_Vt1>91p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 91.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=91.1
apld65_10hv_esdchk_3 (d g s sub) monitor_esd_pld65_10hv ruleNum=3 enable=soa rule="esd_pld65_=Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-91.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_4 (d g s sub) monitor_esd_pld65_10hv ruleNum=4 enable=soa rule="esd_pld65_>Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 91.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=91.1
apld65_10hv_esdchk_5 (d g s sub) monitor_esd_pld65_10hv ruleNum=5 enable=soa rule="esd_pld65_Vt1=91p1_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-91.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_6 (d g s sub) monitor_esd_pld65_10hv ruleNum=6 enable=soa rule="esd_pld65_Vt1>91p1_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 91.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=91.1
apld65_10hv_esdchk_7 (d g s sub) monitor_esd_pld65_10hv ruleNum=7 enable=soa rule="esd_pld65_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(1.4*(V(s)-V(g)-1.0))-91.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_8 (d g s sub) monitor_esd_pld65_10hv ruleNum=8 enable=soa rule="esd_pld65_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(1.4*(V(s)-V(g)-1.0)))) > 91.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=91.1
apld65_10hv_esdchk_9 (d g s sub) monitor_esd_pld65_10hv ruleNum=9 enable=soa rule="esd_pld65_Vt1=90p4_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-90.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_10 (d g s sub) monitor_esd_pld65_10hv ruleNum=10 enable=soa rule="esd_pld65_Vt1>90p4_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 90.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=90.4
apld65_10hv_esdchk_11 (d g s sub) monitor_esd_pld65_10hv ruleNum=11 enable=soa rule="esd_pld65_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-1.5))-90.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_12 (d g s sub) monitor_esd_pld65_10hv ruleNum=12 enable=soa rule="esd_pld65_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-1.5)))) > 90.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=90.4
apld65_10hv_esdchk_13 (d g s sub) monitor_esd_pld65_10hv ruleNum=13 enable=soa rule="esd_pld65_Vt1=89p9_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-89.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_14 (d g s sub) monitor_esd_pld65_10hv ruleNum=14 enable=soa rule="esd_pld65_Vt1>89p9_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 89.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=89.9
apld65_10hv_esdchk_15 (d g s sub) monitor_esd_pld65_10hv ruleNum=15 enable=soa rule="esd_pld65_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-2.5))-89.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_16 (d g s sub) monitor_esd_pld65_10hv ruleNum=16 enable=soa rule="esd_pld65_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-2.5)))) > 89.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=89.9
apld65_10hv_esdchk_17 (d g s sub) monitor_esd_pld65_10hv ruleNum=17 enable=soa rule="esd_pld65_Vt1=89p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-89.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_18 (d g s sub) monitor_esd_pld65_10hv ruleNum=18 enable=soa rule="esd_pld65_Vt1>89p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 89.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=89.7
apld65_10hv_esdchk_19 (d g s sub) monitor_esd_pld65_10hv ruleNum=19 enable=soa rule="esd_pld65_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(1.4*(V(s)-V(g)-3.5))-89.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_20 (d g s sub) monitor_esd_pld65_10hv ruleNum=20 enable=soa rule="esd_pld65_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(1.4*(V(s)-V(g)-3.5)))) > 89.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=89.7
apld65_10hv_esdchk_21 (d g s sub) monitor_esd_pld65_10hv ruleNum=21 enable=soa rule="esd_pld65_Vt1=88p3_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-88.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_22 (d g s sub) monitor_esd_pld65_10hv ruleNum=22 enable=soa rule="esd_pld65_Vt1>88p3_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 88.3 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=88.3
apld65_10hv_esdchk_23 (d g s sub) monitor_esd_pld65_10hv ruleNum=23 enable=soa rule="esd_pld65_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-4.5))-88.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld65_10hv_esdchk_24 (d g s sub) monitor_esd_pld65_10hv ruleNum=24 enable=soa rule="esd_pld65_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-4.5)))) > 88.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=88.3
apld65_10hv_esdchk_25 (d g s sub) monitor_esd_pld65_10hv ruleNum=25 enable=soa rule="esd_pld65_Vt1=86p5_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-86.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_26 (d g s sub) monitor_esd_pld65_10hv ruleNum=26 enable=soa rule="esd_pld65_Vt1>86p5_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 86.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=86.5
apld65_10hv_esdchk_27 (d g s sub) monitor_esd_pld65_10hv ruleNum=27 enable=soa rule="esd_pld65_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(s)-V(d)-86.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld65_10hv_esdchk_28 (s g s d) monitor4t enable=soa rule="esd_pld65_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="absV(s-to-d) > 86.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=86.5
apld65_10hv_esdchk_29 (g s) monitor2t enable=soa rule="esd_pld65_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld65_10hv_esdchk_30 (g d) monitor2t enable=soa rule="esd_pld65_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 91.1 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=91.1
apld65_10hv_esdchk_31 (s sub) monitor2t enable=soa rule="esd_pld65_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld65_10hv_esdchk_32 (sub d) monitor2t enable=soa rule="esd_pld65_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld65_10hv_esdchk_33 (d s) monitor2t enable=soa rule="esd_pld65b_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection pld65_10hv_dfrt

section pld90_10hv_dfrt
include "soachecks_top.scs" section=pld90_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=relimo_ratio20_a_bti_pld90_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pld90_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apld90_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld90_10hv_esdchk_1 (d g s sub) monitor_esd_pld90_10hv ruleNum=1 enable=soa rule="esd_pld90_Vt1=114p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-114.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_2 (d g s sub) monitor_esd_pld90_10hv ruleNum=2 enable=soa rule="esd_pld90_Vt1>114p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 114.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=114.2
apld90_10hv_esdchk_3 (d g s sub) monitor_esd_pld90_10hv ruleNum=3 enable=soa rule="esd_pld90_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.8*(V(s)-V(g)-0.0))-114.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_4 (d g s sub) monitor_esd_pld90_10hv ruleNum=4 enable=soa rule="esd_pld90_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.8*(V(s)-V(g)-0.0)))) > 114.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=114.2
apld90_10hv_esdchk_5 (d g s sub) monitor_esd_pld90_10hv ruleNum=5 enable=soa rule="esd_pld90_Vt1=113p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-113.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_6 (d g s sub) monitor_esd_pld90_10hv ruleNum=6 enable=soa rule="esd_pld90_Vt1>113p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 113.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=113.0
apld90_10hv_esdchk_7 (d g s sub) monitor_esd_pld90_10hv ruleNum=7 enable=soa rule="esd_pld90_=Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-1.5))-113.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_8 (d g s sub) monitor_esd_pld90_10hv ruleNum=8 enable=soa rule="esd_pld90_>Vt1_Vgs_1p5_2p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-1.5)))) > 113.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=113.0
apld90_10hv_esdchk_9 (d g s sub) monitor_esd_pld90_10hv ruleNum=9 enable=soa rule="esd_pld90_Vt1=111p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-111.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_10 (d g s sub) monitor_esd_pld90_10hv ruleNum=10 enable=soa rule="esd_pld90_Vt1>111p0_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 111.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=111.0
apld90_10hv_esdchk_11 (d g s sub) monitor_esd_pld90_10hv ruleNum=11 enable=soa rule="esd_pld90_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(2.4*(V(s)-V(g)-2.0))-111.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_12 (d g s sub) monitor_esd_pld90_10hv ruleNum=12 enable=soa rule="esd_pld90_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(2.4*(V(s)-V(g)-2.0)))) > 111.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=111.0
apld90_10hv_esdchk_13 (d g s sub) monitor_esd_pld90_10hv ruleNum=13 enable=soa rule="esd_pld90_Vt1=108p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-108.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_14 (d g s sub) monitor_esd_pld90_10hv ruleNum=14 enable=soa rule="esd_pld90_Vt1>108p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 108.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=108.6
apld90_10hv_esdchk_15 (d g s sub) monitor_esd_pld90_10hv ruleNum=15 enable=soa rule="esd_pld90_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(4.8*(V(s)-V(g)-3.0))-108.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_16 (d g s sub) monitor_esd_pld90_10hv ruleNum=16 enable=soa rule="esd_pld90_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(4.8*(V(s)-V(g)-3.0)))) > 108.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=108.6
apld90_10hv_esdchk_17 (d g s sub) monitor_esd_pld90_10hv ruleNum=17 enable=soa rule="esd_pld90_Vt1=103p8_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-103.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_18 (d g s sub) monitor_esd_pld90_10hv ruleNum=18 enable=soa rule="esd_pld90_Vt1>103p8_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 103.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=103.8
apld90_10hv_esdchk_19 (d g s sub) monitor_esd_pld90_10hv ruleNum=19 enable=soa rule="esd_pld90_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(3.3*(V(s)-V(g)-4.0))-103.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_20 (d g s sub) monitor_esd_pld90_10hv ruleNum=20 enable=soa rule="esd_pld90_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(3.3*(V(s)-V(g)-4.0)))) > 103.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=103.8
apld90_10hv_esdchk_21 (d g s sub) monitor_esd_pld90_10hv ruleNum=21 enable=soa rule="esd_pld90_Vt1=100p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-100.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_22 (d g s sub) monitor_esd_pld90_10hv ruleNum=22 enable=soa rule="esd_pld90_Vt1>100p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 100.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=100.5
apld90_10hv_esdchk_23 (d g s sub) monitor_esd_pld90_10hv ruleNum=23 enable=soa rule="esd_pld90_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-5.0))-100.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_24 (d g s sub) monitor_esd_pld90_10hv ruleNum=24 enable=soa rule="esd_pld90_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-5.0)))) > 100.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=100.5
apld90_10hv_esdchk_25 (d g s sub) monitor_esd_pld90_10hv ruleNum=25 enable=soa rule="esd_pld90_Vt1=100p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-100.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_26 (d g s sub) monitor_esd_pld90_10hv ruleNum=26 enable=soa rule="esd_pld90_Vt1>100p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 100.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=100.5
apld90_10hv_esdchk_27 (d g s sub) monitor_esd_pld90_10hv ruleNum=27 enable=soa rule="esd_pld90_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-6.0))-100.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90_10hv_esdchk_28 (d g s sub) monitor_esd_pld90_10hv ruleNum=28 enable=soa rule="esd_pld90_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-6.0)))) > 100.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=100.5
apld90_10hv_esdchk_29 (d g s sub) monitor_esd_pld90_10hv ruleNum=29 enable=soa rule="esd_pld90_Vt1=96p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-96.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_30 (d g s sub) monitor_esd_pld90_10hv ruleNum=30 enable=soa rule="esd_pld90_Vt1>96p5_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 96.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=96.5
apld90_10hv_esdchk_31 (d g s sub) monitor_esd_pld90_10hv ruleNum=31 enable=soa rule="esd_pld90_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-96.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pld90_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 96.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=96.5
apld90_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_pld90_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld90_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_pld90_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 114.2 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=114.2
apld90_10hv_esdchk_35 (s sub) monitor2t enable=soa rule="esd_pld90_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld90_10hv_esdchk_36 (sub d) monitor2t enable=soa rule="esd_pld90_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld90_10hv_esdchk_37 (d s) monitor2t enable=soa rule="esd_pld90_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pld90_10hv_dfrt

section pld90b_10hv_dfrt
include "soachecks_top.scs" section=pld90b_10hv_soa
if (enable_relimo == 1) {
apld90b_hci (d g s sub) relimo_aging_hci_pld90b w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apld90b_bti (d g s s) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apld90b_10hv_esdchk_1 (d g s sub) monitor_esd_pld90b_10hv ruleNum=1 enable=soa rule="esd_pld90b_Vt1=124p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_2 (d g s sub) monitor_esd_pld90b_10hv ruleNum=2 enable=soa rule="esd_pld90b_Vt1>124p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apld90b_10hv_esdchk_3 (d g s sub) monitor_esd_pld90b_10hv ruleNum=3 enable=soa rule="esd_pld90b_=Vt1_Vgs_0p0_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90b_10hv_esdchk_4 (d g s sub) monitor_esd_pld90b_10hv ruleNum=4 enable=soa rule="esd_pld90b_>Vt1_Vgs_0p0_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 124.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=124.0
apld90b_10hv_esdchk_5 (d g s sub) monitor_esd_pld90b_10hv ruleNum=5 enable=soa rule="esd_pld90b_Vt1=124p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_6 (d g s sub) monitor_esd_pld90b_10hv ruleNum=6 enable=soa rule="esd_pld90b_Vt1>124p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apld90b_10hv_esdchk_7 (d g s sub) monitor_esd_pld90b_10hv ruleNum=7 enable=soa rule="esd_pld90b_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(3.0*(V(s)-V(g)-2.5))-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90b_10hv_esdchk_8 (d g s sub) monitor_esd_pld90b_10hv ruleNum=8 enable=soa rule="esd_pld90b_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(3.0*(V(s)-V(g)-2.5)))) > 124.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=124.0
apld90b_10hv_esdchk_9 (d g s sub) monitor_esd_pld90b_10hv ruleNum=9 enable=soa rule="esd_pld90b_Vt1=121p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-121.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_10 (d g s sub) monitor_esd_pld90b_10hv ruleNum=10 enable=soa rule="esd_pld90b_Vt1>121p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 121.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=121.0
apld90b_10hv_esdchk_11 (d g s sub) monitor_esd_pld90b_10hv ruleNum=11 enable=soa rule="esd_pld90b_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-3.5))-121.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90b_10hv_esdchk_12 (d g s sub) monitor_esd_pld90b_10hv ruleNum=12 enable=soa rule="esd_pld90b_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-3.5)))) > 121.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=121.0
apld90b_10hv_esdchk_13 (d g s sub) monitor_esd_pld90b_10hv ruleNum=13 enable=soa rule="esd_pld90b_Vt1=121p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-121.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_14 (d g s sub) monitor_esd_pld90b_10hv ruleNum=14 enable=soa rule="esd_pld90b_Vt1>121p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 121.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=121.0
apld90b_10hv_esdchk_15 (d g s sub) monitor_esd_pld90b_10hv ruleNum=15 enable=soa rule="esd_pld90b_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(6.0*(V(s)-V(g)-4.5))-121.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld90b_10hv_esdchk_16 (d g s sub) monitor_esd_pld90b_10hv ruleNum=16 enable=soa rule="esd_pld90b_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(6.0*(V(s)-V(g)-4.5)))) > 121.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=121.0
apld90b_10hv_esdchk_17 (d g s sub) monitor_esd_pld90b_10hv ruleNum=17 enable=soa rule="esd_pld90b_Vt1=115p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-115.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_18 (d g s sub) monitor_esd_pld90b_10hv ruleNum=18 enable=soa rule="esd_pld90b_Vt1>115p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 115.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=115.0
apld90b_10hv_esdchk_19 (d g s sub) monitor_esd_pld90b_10hv ruleNum=19 enable=soa rule="esd_pld90b_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(s)-V(d)-115.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld90b_10hv_esdchk_20 (s g s d) monitor4t enable=soa rule="esd_pld90b_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="absV(s-to-d) > 115.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=115.0
apld90b_10hv_esdchk_21 (g s) monitor2t enable=soa rule="esd_pld90b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld90b_10hv_esdchk_22 (g d) monitor2t enable=soa rule="esd_pld90b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 124.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=124.0
apld90b_10hv_esdchk_23 (s sub) monitor2t enable=soa rule="esd_pld90b_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld90b_10hv_esdchk_24 (sub d) monitor2t enable=soa rule="esd_pld90b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld90b_10hv_esdchk_25 (d s) monitor2t enable=soa rule="esd_pld90b_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s s) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s s) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "amost"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 2.4272*presto_idRatio
+ hcia2           = 1.35E-07*presto_idRatio
+ hcic1           = 2.42E+09
+ hcib1           = 7.16E-05*presto_idRatio
+ hcin            = 3
+ hcialpha1       = 39.8
+ hcibeta1        = 0.99
+ hcilambdah0     = 2.22E-06
+ hcialpha2       = 2.52E-42
+ hcibeta2        = 0.844
+ hcilambdael0    = 3.38E-07
+ hcifstattau1    = 0.0119
+ hcifstattau2    = 0.00213
+ hcifstattau12   = 115
+ hcifstattau21   = 115
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.4
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 0.82*presto_idRatio    	    //Off state HCI part
+ offn1           = 1.34
+ offa2           = 3.46*presto_idRatio
+ offn2           = 0.396
+ offalpha1       = 0.00443
+ offbeta1        = 0.09
+ offea1          = 0.99
+ offalpha2       = 1.16E+06
+ offbeta2        = 0.155
+ offea2          = 0.339
+ offfstattau1    = 0.00987
+ offfstattau2    = 0.0215
+ offfstattau12   = 47.4
+ offfstattau21   = 47.4
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.5*presto_idRatio
+ hvgsa           = 1000*presto_vthRatio    	   // High Vgs HCI part
+ hvgsn           = 0.20
+ hvgsalpha       = 8.50E+15
+ hvgsbeta        = 7.42E-09
+ hvgsgamma       = 13.9
+ hvgsdelta       = 4.34
+ hvgsepsilon     = 0
+ hvgsea          = 1.18
+ hvgsrth         = 0.0135
+ hvgsfstat       = 0.0538  	
+ b0_b0_b0_b0_em1 = 0
+ a0_b0_b0_b0_em1 = 0
+ b0_a0_b0_b0_em1 = 0
+ a0_a0_b0_b0_em1 = 0
+ b0_b0_a0_b0_em1 = 0
+ a0_b0_a0_b0_em1 = 0
+ b0_a0_a0_b0_em1 = 0
+ a0_a0_a0_b0_em1 = 0
+ b0_b0_a1_b0_em1 = 0
+ a0_b0_a1_b0_em1 = 0
+ b0_a0_a1_b0_em1 = 0
+ a0_a0_a1_b0_em1 = 0
+ b0_b0_a2_b0_em1 = 0
+ a0_b0_a2_b0_em1 = 0
+ b0_a0_a2_b0_em1 = 0
+ a0_a0_a2_b0_em1 = 0
+ b0_b0_a3_b0_em1 = 0
+ a0_b0_a3_b0_em1 = 0
+ b0_a0_a3_b0_em1 = 0
+ a0_a0_a3_b0_em1 = 0
+ b0_b0_a4_b0_em1 = 0
+ a0_b0_a4_b0_em1 = 0
+ b0_a0_a4_b0_em1 = 0
+ a0_a0_a4_b0_em1 = 0
+ b0_b0_p1_b0_em1 = 0
+ a0_b0_p1_b0_em1 = 0
+ b0_a0_p1_b0_em1 = 0
+ a0_a0_p1_b0_em1 = 0
+ b0_b0_p2_b0_em1 = 0
+ a0_b0_p2_b0_em1 = 0
+ b0_a0_p2_b0_em1 = 0
+ a0_a0_p2_b0_em1 = 0
+ b0_b0_p3_b0_em1 = 0
+ a0_b0_p3_b0_em1 = 0
+ b0_a0_p3_b0_em1 = 0
+ a0_a0_p3_b0_em1 = 0
+ b0_b0_p4_b0_em1 = 0
+ a0_b0_p4_b0_em1 = 0
+ b0_a0_p4_b0_em1 = 0
+ a0_a0_p4_b0_em1 = 0
+ b0_b0_b0_a0_em1 = 0
+ a0_b0_b0_a0_em1 = 0
+ b0_a0_b0_a0_em1 = 0
+ a0_a0_b0_a0_em1 = 0
+ b0_b0_a0_a0_em1 = 0
+ a0_b0_a0_a0_em1 = 0
+ b0_a0_a0_a0_em1 = 0
+ a0_a0_a0_a0_em1 = 0
+ b0_b0_a1_a0_em1 = 0
+ a0_b0_a1_a0_em1 = 0
+ b0_a0_a1_a0_em1 = 0
+ a0_a0_a1_a0_em1 = 0
+ b0_b0_a2_a0_em1 = 0
+ a0_b0_a2_a0_em1 = 0
+ b0_a0_a2_a0_em1 = 0
+ a0_a0_a2_a0_em1 = 0
+ b0_b0_a3_a0_em1 = 0
+ a0_b0_a3_a0_em1 = 0
+ b0_a0_a3_a0_em1 = 0
+ a0_a0_a3_a0_em1 = 0
+ b0_b0_a4_a0_em1 = 0
+ a0_b0_a4_a0_em1 = 0
+ b0_a0_a4_a0_em1 = 0
+ a0_a0_a4_a0_em1 = 0
+ b0_b0_p1_a0_em1 = 0
+ a0_b0_p1_a0_em1 = 0
+ b0_a0_p1_a0_em1 = 0
+ a0_a0_p1_a0_em1 = 0
+ b0_b0_p2_a0_em1 = 0
+ a0_b0_p2_a0_em1 = 0
+ b0_a0_p2_a0_em1 = 0
+ a0_a0_p2_a0_em1 = 0
+ b0_b0_p3_a0_em1 = 0
+ a0_b0_p3_a0_em1 = 0
+ b0_a0_p3_a0_em1 = 0
+ a0_a0_p3_a0_em1 = 0
+ b0_b0_p4_a0_em1 = 0
+ a0_b0_p4_a0_em1 = 0
+ b0_a0_p4_a0_em1 = 0
+ a0_a0_p4_a0_em1 = 0
+ b0_b0_b0_a1_em1 = 7430
+ a0_b0_b0_a1_em1 = -0.68
+ b0_a0_b0_a1_em1 = 0
+ a0_a0_b0_a1_em1 = 0
+ b0_b0_a0_a1_em1 = 0
+ a0_b0_a0_a1_em1 = 0
+ b0_a0_a0_a1_em1 = 0
+ a0_a0_a0_a1_em1 = 0
+ b0_b0_a1_a1_em1 = 1300
+ a0_b0_a1_a1_em1 = -1.19
+ b0_a0_a1_a1_em1 = 0
+ a0_a0_a1_a1_em1 = 0
+ b0_b0_a2_a1_em1 = 38.2
+ a0_b0_a2_a1_em1 = -0.161
+ b0_a0_a2_a1_em1 = 0
+ a0_a0_a2_a1_em1 = 0
+ b0_b0_a3_a1_em1 = -127
+ a0_b0_a3_a1_em1 = -0.577
+ b0_a0_a3_a1_em1 = 0
+ a0_a0_a3_a1_em1 = 0
+ b0_b0_a4_a1_em1 = 0
+ a0_b0_a4_a1_em1 = 0
+ b0_a0_a4_a1_em1 = 0
+ a0_a0_a4_a1_em1 = 0
+ b0_b0_p1_a1_em1 = 2.49
+ a0_b0_p1_a1_em1 = -0.000392
+ b0_a0_p1_a1_em1 = 0
+ a0_a0_p1_a1_em1 = 0
+ b0_b0_p2_a1_em1 = 2.83
+ a0_b0_p2_a1_em1 = 0.000997
+ b0_a0_p2_a1_em1 = 0
+ a0_a0_p2_a1_em1 = 0
+ b0_b0_p3_a1_em1 = 3.54
+ a0_b0_p3_a1_em1 = 0.00365
+ b0_a0_p3_a1_em1 = 0
+ a0_a0_p3_a1_em1 = 0
+ b0_b0_p4_a1_em1 = 6
+ a0_b0_p4_a1_em1 = 0
+ b0_a0_p4_a1_em1 = 0
+ a0_a0_p4_a1_em1 = 0
+ b0_b0_b0_a2_em1 = 2310
+ a0_b0_b0_a2_em1 = 0.251
+ b0_a0_b0_a2_em1 = 0
+ a0_a0_b0_a2_em1 = 0
+ b0_b0_a0_a2_em1 = 0
+ a0_b0_a0_a2_em1 = 0
+ b0_a0_a0_a2_em1 = 0
+ a0_a0_a0_a2_em1 = 0
+ b0_b0_a1_a2_em1 = 2770
+ a0_b0_a1_a2_em1 = -8.95
+ b0_a0_a1_a2_em1 = 0
+ a0_a0_a1_a2_em1 = 0
+ b0_b0_a2_a2_em1 = 1770
+ a0_b0_a2_a2_em1 = -2.52
+ b0_a0_a2_a2_em1 = 0
+ a0_a0_a2_a2_em1 = 0
+ b0_b0_a3_a2_em1 = -854
+ a0_b0_a3_a2_em1 = 1.39
+ b0_a0_a3_a2_em1 = 0
+ a0_a0_a3_a2_em1 = 0
+ b0_b0_a4_a2_em1 = 0
+ a0_b0_a4_a2_em1 = 0
+ b0_a0_a4_a2_em1 = 0
+ a0_a0_a4_a2_em1 = 0
+ b0_b0_p1_a2_em1 = 2.15
+ a0_b0_p1_a2_em1 = -0.00274
+ b0_a0_p1_a2_em1 = 0
+ a0_a0_p1_a2_em1 = 0
+ b0_b0_p2_a2_em1 = 2.16
+ a0_b0_p2_a2_em1 = -0.00262
+ b0_a0_p2_a2_em1 = 0
+ a0_a0_p2_a2_em1 = 0
+ b0_b0_p3_a2_em1 = 1.96
+ a0_b0_p3_a2_em1 = 0.000631
+ b0_a0_p3_a2_em1 = 0
+ a0_a0_p3_a2_em1 = 0
+ b0_b0_p4_a2_em1 = 3
+ a0_b0_p4_a2_em1 = 0
+ b0_a0_p4_a2_em1 = 0
+ a0_a0_p4_a2_em1 = 0
+ b0_b0_b0_a3_em1 = 630
+ a0_b0_b0_a3_em1 = 0.563
+ b0_a0_b0_a3_em1 = -0.0182
+ a0_a0_b0_a3_em1 = -0.0132
+ b0_b0_a0_a3_em1 = 0
+ a0_b0_a0_a3_em1 = 0
+ b0_a0_a0_a3_em1 = 0
+ a0_a0_a0_a3_em1 = 0
+ b0_b0_a1_a3_em1 = 42.9
+ a0_b0_a1_a3_em1 = 0.0964
+ b0_a0_a1_a3_em1 = 0.37
+ a0_a0_a1_a3_em1 = 0.000772
+ b0_b0_a2_a3_em1 = -708
+ a0_b0_a2_a3_em1 = 1.47
+ b0_a0_a2_a3_em1 = -0.105
+ a0_a0_a2_a3_em1 = 0.00183
+ b0_b0_a3_a3_em1 = -126
+ a0_b0_a3_a3_em1 = 1.42
+ b0_a0_a3_a3_em1 = -0.000318
+ a0_a0_a3_a3_em1 = -0.074
+ b0_b0_a4_a3_em1 = 0
+ a0_b0_a4_a3_em1 = 0
+ b0_a0_a4_a3_em1 = 0
+ a0_a0_a4_a3_em1 = 0
+ b0_b0_p1_a3_em1 = -6.04
+ a0_b0_p1_a3_em1 = 0.00519
+ b0_a0_p1_a3_em1 = 0.745
+ a0_a0_p1_a3_em1 = -0.00171
+ b0_b0_p2_a3_em1 = 1.27
+ a0_b0_p2_a3_em1 = -0.00255
+ b0_a0_p2_a3_em1 = 0.017
+ a0_a0_p2_a3_em1 = -0.0000571
+ b0_b0_p3_a3_em1 = 1.33
+ a0_b0_p3_a3_em1 = 0.00543
+ b0_a0_p3_a3_em1 = -0.000000215
+ a0_a0_p3_a3_em1 = -0.0000475
+ b0_b0_p4_a3_em1 = 6
+ a0_b0_p4_a3_em1 = 0
+ b0_a0_p4_a3_em1 = 0
+ a0_a0_p4_a3_em1 = 0
+ b0_b0_b0_a4_em1 = 1410
+ a0_b0_b0_a4_em1 = -0.0711
+ b0_a0_b0_a4_em1 = -0.275
+ a0_a0_b0_a4_em1 = -0.0234
+ b0_b0_a0_a4_em1 = 0
+ a0_b0_a0_a4_em1 = 0
+ b0_a0_a0_a4_em1 = 0
+ a0_a0_a0_a4_em1 = 0
+ b0_b0_a1_a4_em1 = -1300
+ a0_b0_a1_a4_em1 = 4.97
+ b0_a0_a1_a4_em1 = 0.00286
+ a0_a0_a1_a4_em1 = 0.0454
+ b0_b0_a2_a4_em1 = 92.4
+ a0_b0_a2_a4_em1 = -0.224
+ b0_a0_a2_a4_em1 = 0
+ a0_a0_a2_a4_em1 = -0.0576
+ b0_b0_a3_a4_em1 = 528
+ a0_b0_a3_a4_em1 = -1.58
+ b0_a0_a3_a4_em1 = -0.0000649
+ a0_a0_a3_a4_em1 = -0.0171
+ b0_b0_a4_a4_em1 = 0
+ a0_b0_a4_a4_em1 = 0
+ b0_a0_a4_a4_em1 = 0
+ a0_a0_a4_a4_em1 = 0
+ b0_b0_p1_a4_em1 = 0.52
+ a0_b0_p1_a4_em1 = 0.011
+ b0_a0_p1_a4_em1 = -0.0401
+ a0_a0_p1_a4_em1 = 0.0002
+ b0_b0_p2_a4_em1 = 2.78
+ a0_b0_p2_a4_em1 = 0.00136
+ b0_a0_p2_a4_em1 = 0.000269
+ a0_a0_p2_a4_em1 = 0.00000646
+ b0_b0_p3_a4_em1 = -3.15
+ a0_b0_p3_a4_em1 = 0.0104
+ b0_a0_p3_a4_em1 = -0.000159
+ a0_a0_p3_a4_em1 = -0.000844
+ b0_b0_p4_a4_em1 = 6
+ a0_b0_p4_a4_em1 = 0
+ b0_a0_p4_a4_em1 = 0
+ a0_a0_p4_a4_em1 = 0
+ b0_b0_b0_p1_em1 = 0.0172
+ a0_b0_b0_p1_em1 = 0
+ b0_a0_b0_p1_em1 = 0
+ a0_a0_b0_p1_em1 = 0
+ b0_b0_a0_p1_em1 = 0
+ a0_b0_a0_p1_em1 = 0
+ b0_a0_a0_p1_em1 = 0
+ a0_a0_a0_p1_em1 = 0
+ b0_b0_a1_p1_em1 = 3.35
+ a0_b0_a1_p1_em1 = 0
+ b0_a0_a1_p1_em1 = 0
+ a0_a0_a1_p1_em1 = 0
+ b0_b0_a2_p1_em1 = 7.56
+ a0_b0_a2_p1_em1 = 0
+ b0_a0_a2_p1_em1 = 0
+ a0_a0_a2_p1_em1 = 0
+ b0_b0_a3_p1_em1 = 2.84
+ a0_b0_a3_p1_em1 = 0
+ b0_a0_a3_p1_em1 = 0
+ a0_a0_a3_p1_em1 = 0
+ b0_b0_a4_p1_em1 = 0
+ a0_b0_a4_p1_em1 = 0
+ b0_a0_a4_p1_em1 = 0
+ a0_a0_a4_p1_em1 = 0
+ b0_b0_p1_p1_em1 = 1.05
+ a0_b0_p1_p1_em1 = 0
+ b0_a0_p1_p1_em1 = 0
+ a0_a0_p1_p1_em1 = 0
+ b0_b0_p2_p1_em1 = 2.43
+ a0_b0_p2_p1_em1 = 0
+ b0_a0_p2_p1_em1 = 0
+ a0_a0_p2_p1_em1 = 0
+ b0_b0_p3_p1_em1 = 3.52
+ a0_b0_p3_p1_em1 = 0
+ b0_a0_p3_p1_em1 = 0
+ a0_a0_p3_p1_em1 = 0
+ b0_b0_p4_p1_em1 = 6.02
+ a0_b0_p4_p1_em1 = 0
+ b0_a0_p4_p1_em1 = 0
+ a0_a0_p4_p1_em1 = 0
+ b0_b0_b0_p2_em1 = 26.1
+ a0_b0_b0_p2_em1 = 0.00513
+ b0_a0_b0_p2_em1 = 0
+ a0_a0_b0_p2_em1 = 0
+ b0_b0_a0_p2_em1 = 0
+ a0_b0_a0_p2_em1 = 0
+ b0_a0_a0_p2_em1 = 0
+ a0_a0_a0_p2_em1 = 0
+ b0_b0_a1_p2_em1 = -0.292
+ a0_b0_a1_p2_em1 = -0.00197
+ b0_a0_a1_p2_em1 = 0
+ a0_a0_a1_p2_em1 = 0
+ b0_b0_a2_p2_em1 = -5.9
+ a0_b0_a2_p2_em1 = 0.0021
+ b0_a0_a2_p2_em1 = 0
+ a0_a0_a2_p2_em1 = 0
+ b0_b0_a3_p2_em1 = 0.67
+ a0_b0_a3_p2_em1 = 0.00212
+ b0_a0_a3_p2_em1 = 0
+ a0_a0_a3_p2_em1 = 0
+ b0_b0_a4_p2_em1 = 0
+ a0_b0_a4_p2_em1 = 0
+ b0_a0_a4_p2_em1 = 0
+ a0_a0_a4_p2_em1 = 0
+ b0_b0_p1_p2_em1 = -1
+ a0_b0_p1_p2_em1 = 0
+ b0_a0_p1_p2_em1 = 0
+ a0_a0_p1_p2_em1 = 0
+ b0_b0_p2_p2_em1 = 2.22
+ a0_b0_p2_p2_em1 = -0.00193
+ b0_a0_p2_p2_em1 = 0
+ a0_a0_p2_p2_em1 = 0
+ b0_b0_p3_p2_em1 = 2.54
+ a0_b0_p3_p2_em1 = -0.000599
+ b0_a0_p3_p2_em1 = 0
+ a0_a0_p3_p2_em1 = 0
+ b0_b0_p4_p2_em1 = 6.39
+ a0_b0_p4_p2_em1 = -0.00437
+ b0_a0_p4_p2_em1 = 0
+ a0_a0_p4_p2_em1 = 0
+ b0_b0_b0_p3_em1 = 40.2
+ a0_b0_b0_p3_em1 = -0.0483
+ b0_a0_b0_p3_em1 = -0.184
+ a0_a0_b0_p3_em1 = 0.000818
+ b0_b0_a0_p3_em1 = 0
+ a0_b0_a0_p3_em1 = 0
+ b0_a0_a0_p3_em1 = 0
+ a0_a0_a0_p3_em1 = 0
+ b0_b0_a1_p3_em1 = 1.67
+ a0_b0_a1_p3_em1 = 0.0258
+ b0_a0_a1_p3_em1 = 0.00679
+ a0_a0_a1_p3_em1 = -0.000444
+ b0_b0_a2_p3_em1 = 10.2
+ a0_b0_a2_p3_em1 = -0.0141
+ b0_a0_a2_p3_em1 = 0.0154
+ a0_a0_a2_p3_em1 = -0.0000581
+ b0_b0_a3_p3_em1 = 5.77
+ a0_b0_a3_p3_em1 = 0.00601
+ b0_a0_a3_p3_em1 = 0.00000839
+ a0_a0_a3_p3_em1 = 0.00196
+ b0_b0_a4_p3_em1 = 0
+ a0_b0_a4_p3_em1 = 0
+ b0_a0_a4_p3_em1 = 0
+ a0_a0_a4_p3_em1 = 0
+ b0_b0_p1_p3_em1 = 1.66
+ a0_b0_p1_p3_em1 = -0.00156
+ b0_a0_p1_p3_em1 = 0.0453
+ a0_a0_p1_p3_em1 = -0.000109
+ b0_b0_p2_p3_em1 = -0.0507
+ a0_b0_p2_p3_em1 = 0.00423
+ b0_a0_p2_p3_em1 = 0.0552
+ a0_a0_p2_p3_em1 = -0.000127
+ b0_b0_p3_p3_em1 = 1.35
+ a0_b0_p3_p3_em1 = 0.00294
+ b0_a0_p3_p3_em1 = -0.000000325
+ a0_a0_p3_p3_em1 = -0.0000753
+ b0_b0_p4_p3_em1 = 6
+ a0_b0_p4_p3_em1 = 0
+ b0_a0_p4_p3_em1 = 0
+ a0_a0_p4_p3_em1 = 0
+ b0_b0_b0_p4_em1 = 66.1
+ a0_b0_b0_p4_em1 = -0.0778
+ b0_a0_b0_p4_em1 = 1.22
+ a0_a0_b0_p4_em1 = -0.0066
+ b0_b0_a0_p4_em1 = 0
+ a0_b0_a0_p4_em1 = 0
+ b0_a0_a0_p4_em1 = 0
+ a0_a0_a0_p4_em1 = 0
+ b0_b0_a1_p4_em1 = 151
+ a0_b0_a1_p4_em1 = 0.0117
+ b0_a0_a1_p4_em1 = -0.0000495
+ a0_a0_a1_p4_em1 = -0.0081
+ b0_b0_a2_p4_em1 = -19.8
+ a0_b0_a2_p4_em1 = 0.126
+ b0_a0_a2_p4_em1 = -0.604
+ a0_a0_a2_p4_em1 = 0.00275
+ b0_b0_a3_p4_em1 = 34.1
+ a0_b0_a3_p4_em1 = -0.0721
+ b0_a0_a3_p4_em1 = -0.000035
+ a0_a0_a3_p4_em1 = -0.00816
+ b0_b0_a4_p4_em1 = 0
+ a0_b0_a4_p4_em1 = 0
+ b0_a0_a4_p4_em1 = 0
+ a0_a0_a4_p4_em1 = 0
+ b0_b0_p1_p4_em1 = 0.819
+ a0_b0_p1_p4_em1 = -0.00126
+ b0_a0_p1_p4_em1 = -0.00372
+ a0_a0_p1_p4_em1 = 0.000061
+ b0_b0_p2_p4_em1 = 1.09
+ a0_b0_p2_p4_em1 = -0.00225
+ b0_a0_p2_p4_em1 = 0.00253
+ a0_a0_p2_p4_em1 = 0.0000383
+ b0_b0_p3_p4_em1 = 2.97
+ a0_b0_p3_p4_em1 = 0.0019
+ b0_a0_p3_p4_em1 = -0.0000000692
+ a0_a0_p3_p4_em1 = -0.0000165
+ b0_b0_p4_p4_em1 = 3
+ a0_b0_p4_p4_em1 = 0.00477
+ b0_a0_p4_p4_em1 = 0
+ a0_a0_p4_p4_em1 = 0
+ b0_b0_b0_b0_em2 = 0
+ a0_b0_b0_b0_em2 = 0
+ b0_a0_b0_b0_em2 = 0
+ a0_a0_b0_b0_em2 = 0
+ b0_b0_a0_b0_em2 = 0
+ a0_b0_a0_b0_em2 = 0
+ b0_a0_a0_b0_em2 = 0
+ a0_a0_a0_b0_em2 = 0
+ b0_b0_a1_b0_em2 = 0
+ a0_b0_a1_b0_em2 = 0
+ b0_a0_a1_b0_em2 = 0
+ a0_a0_a1_b0_em2 = 0
+ b0_b0_a2_b0_em2 = 0
+ a0_b0_a2_b0_em2 = 0
+ b0_a0_a2_b0_em2 = 0
+ a0_a0_a2_b0_em2 = 0
+ b0_b0_a3_b0_em2 = 0
+ a0_b0_a3_b0_em2 = 0
+ b0_a0_a3_b0_em2 = 0
+ a0_a0_a3_b0_em2 = 0
+ b0_b0_a4_b0_em2 = 0
+ a0_b0_a4_b0_em2 = 0
+ b0_a0_a4_b0_em2 = 0
+ a0_a0_a4_b0_em2 = 0
+ b0_b0_p1_b0_em2 = 0
+ a0_b0_p1_b0_em2 = 0
+ b0_a0_p1_b0_em2 = 0
+ a0_a0_p1_b0_em2 = 0
+ b0_b0_p2_b0_em2 = 0
+ a0_b0_p2_b0_em2 = 0
+ b0_a0_p2_b0_em2 = 0
+ a0_a0_p2_b0_em2 = 0
+ b0_b0_p3_b0_em2 = 0
+ a0_b0_p3_b0_em2 = 0
+ b0_a0_p3_b0_em2 = 0
+ a0_a0_p3_b0_em2 = 0
+ b0_b0_p4_b0_em2 = 0
+ a0_b0_p4_b0_em2 = 0
+ b0_a0_p4_b0_em2 = 0
+ a0_a0_p4_b0_em2 = 0
+ b0_b0_b0_a0_em2 = 0
+ a0_b0_b0_a0_em2 = 0
+ b0_a0_b0_a0_em2 = 0
+ a0_a0_b0_a0_em2 = 0
+ b0_b0_a0_a0_em2 = 0
+ a0_b0_a0_a0_em2 = 0
+ b0_a0_a0_a0_em2 = 0
+ a0_a0_a0_a0_em2 = 0
+ b0_b0_a1_a0_em2 = 0
+ a0_b0_a1_a0_em2 = 0
+ b0_a0_a1_a0_em2 = 0
+ a0_a0_a1_a0_em2 = 0
+ b0_b0_a2_a0_em2 = 0
+ a0_b0_a2_a0_em2 = 0
+ b0_a0_a2_a0_em2 = 0
+ a0_a0_a2_a0_em2 = 0
+ b0_b0_a3_a0_em2 = 0
+ a0_b0_a3_a0_em2 = 0
+ b0_a0_a3_a0_em2 = 0
+ a0_a0_a3_a0_em2 = 0
+ b0_b0_a4_a0_em2 = 0
+ a0_b0_a4_a0_em2 = 0
+ b0_a0_a4_a0_em2 = 0
+ a0_a0_a4_a0_em2 = 0
+ b0_b0_p1_a0_em2 = 0
+ a0_b0_p1_a0_em2 = 0
+ b0_a0_p1_a0_em2 = 0
+ a0_a0_p1_a0_em2 = 0
+ b0_b0_p2_a0_em2 = 0
+ a0_b0_p2_a0_em2 = 0
+ b0_a0_p2_a0_em2 = 0
+ a0_a0_p2_a0_em2 = 0
+ b0_b0_p3_a0_em2 = 0
+ a0_b0_p3_a0_em2 = 0
+ b0_a0_p3_a0_em2 = 0
+ a0_a0_p3_a0_em2 = 0
+ b0_b0_p4_a0_em2 = 0
+ a0_b0_p4_a0_em2 = 0
+ b0_a0_p4_a0_em2 = 0
+ a0_a0_p4_a0_em2 = 0
+ b0_b0_b0_a1_em2 = 9000
+ a0_b0_b0_a1_em2 = 0
+ b0_a0_b0_a1_em2 = 0
+ a0_a0_b0_a1_em2 = 0
+ b0_b0_a0_a1_em2 = 0
+ a0_b0_a0_a1_em2 = 0
+ b0_a0_a0_a1_em2 = 0
+ a0_a0_a0_a1_em2 = 0
+ b0_b0_a1_a1_em2 = 0
+ a0_b0_a1_a1_em2 = 0
+ b0_a0_a1_a1_em2 = 0
+ a0_a0_a1_a1_em2 = 0
+ b0_b0_a2_a1_em2 = 0
+ a0_b0_a2_a1_em2 = 0
+ b0_a0_a2_a1_em2 = 0
+ a0_a0_a2_a1_em2 = 0
+ b0_b0_a3_a1_em2 = 0
+ a0_b0_a3_a1_em2 = 0
+ b0_a0_a3_a1_em2 = 0
+ a0_a0_a3_a1_em2 = 0
+ b0_b0_a4_a1_em2 = 0
+ a0_b0_a4_a1_em2 = 0
+ b0_a0_a4_a1_em2 = 0
+ a0_a0_a4_a1_em2 = 0
+ b0_b0_p1_a1_em2 = 0
+ a0_b0_p1_a1_em2 = 0
+ b0_a0_p1_a1_em2 = 0
+ a0_a0_p1_a1_em2 = 0
+ b0_b0_p2_a1_em2 = 1
+ a0_b0_p2_a1_em2 = 0
+ b0_a0_p2_a1_em2 = 0
+ a0_a0_p2_a1_em2 = 0
+ b0_b0_p3_a1_em2 = 2
+ a0_b0_p3_a1_em2 = 0
+ b0_a0_p3_a1_em2 = 0
+ a0_a0_p3_a1_em2 = 0
+ b0_b0_p4_a1_em2 = 3
+ a0_b0_p4_a1_em2 = 0
+ b0_a0_p4_a1_em2 = 0
+ a0_a0_p4_a1_em2 = 0
+ b0_b0_b0_a2_em2 = 1430
+ a0_b0_b0_a2_em2 = 0.866
+ b0_a0_b0_a2_em2 = 0
+ a0_a0_b0_a2_em2 = 0
+ b0_b0_a0_a2_em2 = 0
+ a0_b0_a0_a2_em2 = 0
+ b0_a0_a0_a2_em2 = 0
+ a0_a0_a0_a2_em2 = 0
+ b0_b0_a1_a2_em2 = -2120
+ a0_b0_a1_a2_em2 = 9.54
+ b0_a0_a1_a2_em2 = 0
+ a0_a0_a1_a2_em2 = 0
+ b0_b0_a2_a2_em2 = 70.3
+ a0_b0_a2_a2_em2 = -0.4
+ b0_a0_a2_a2_em2 = 0
+ a0_a0_a2_a2_em2 = 0
+ b0_b0_a3_a2_em2 = 504
+ a0_b0_a3_a2_em2 = -1.79
+ b0_a0_a3_a2_em2 = 0
+ a0_a0_a3_a2_em2 = 0
+ b0_b0_a4_a2_em2 = 0
+ a0_b0_a4_a2_em2 = 0
+ b0_a0_a4_a2_em2 = 0
+ a0_a0_a4_a2_em2 = 0
+ b0_b0_p1_a2_em2 = 1.19
+ a0_b0_p1_a2_em2 = -0.00148
+ b0_a0_p1_a2_em2 = 0
+ a0_a0_p1_a2_em2 = 0
+ b0_b0_p2_a2_em2 = 1.53
+ a0_b0_p2_a2_em2 = -0.00202
+ b0_a0_p2_a2_em2 = 0
+ a0_a0_p2_a2_em2 = 0
+ b0_b0_p3_a2_em2 = 0.305
+ a0_b0_p3_a2_em2 = 0.00481
+ b0_a0_p3_a2_em2 = 0
+ a0_a0_p3_a2_em2 = 0
+ b0_b0_p4_a2_em2 = 4
+ a0_b0_p4_a2_em2 = 0
+ b0_a0_p4_a2_em2 = 0
+ a0_a0_p4_a2_em2 = 0
+ b0_b0_b0_a3_em2 = 537
+ a0_b0_b0_a3_em2 = -0.235
+ b0_a0_b0_a3_em2 = 0.038
+ a0_a0_b0_a3_em2 = -0.00214
+ b0_b0_a0_a3_em2 = 0
+ a0_b0_a0_a3_em2 = 0
+ b0_a0_a0_a3_em2 = 0
+ a0_a0_a0_a3_em2 = 0
+ b0_b0_a1_a3_em2 = -88.3
+ a0_b0_a1_a3_em2 = 0.724
+ b0_a0_a1_a3_em2 = -0.103
+ a0_a0_a1_a3_em2 = 0.00541
+ b0_b0_a2_a3_em2 = -1160
+ a0_b0_a2_a3_em2 = 2.05
+ b0_a0_a2_a3_em2 = -0.00851
+ a0_a0_a2_a3_em2 = -0.00145
+ b0_b0_a3_a3_em2 = -33.3
+ a0_b0_a3_a3_em2 = 0.271
+ b0_a0_a3_a3_em2 = -0.0202
+ a0_a0_a3_a3_em2 = 0.000247
+ b0_b0_a4_a3_em2 = 0
+ a0_b0_a4_a3_em2 = 0
+ b0_a0_a4_a3_em2 = 0
+ a0_a0_a4_a3_em2 = 0
+ b0_b0_p1_a3_em2 = -0.915
+ a0_b0_p1_a3_em2 = 0.00467
+ b0_a0_p1_a3_em2 = 0.00878
+ a0_a0_p1_a3_em2 = -0.00000394
+ b0_b0_p2_a3_em2 = 1.18
+ a0_b0_p2_a3_em2 = 0.000194
+ b0_a0_p2_a3_em2 = -0.00279
+ a0_a0_p2_a3_em2 = 0.0000103
+ b0_b0_p3_a3_em2 = -0.0447
+ a0_b0_p3_a3_em2 = 0.00703
+ b0_a0_p3_a3_em2 = -0.0186
+ a0_a0_p3_a3_em2 = 0.0000811
+ b0_b0_p4_a3_em2 = 4.13
+ a0_b0_p4_a3_em2 = -0.00258
+ b0_a0_p4_a3_em2 = -0.22
+ a0_a0_p4_a3_em2 = 0.000708
+ b0_b0_b0_a4_em2 = 480
+ a0_b0_b0_a4_em2 = -0.524
+ b0_a0_b0_a4_em2 = -0.207
+ a0_a0_b0_a4_em2 = -0.0309
+ b0_b0_a0_a4_em2 = 0
+ a0_b0_a0_a4_em2 = 0
+ b0_a0_a0_a4_em2 = 0
+ a0_a0_a0_a4_em2 = 0
+ b0_b0_a1_a4_em2 = -637
+ a0_b0_a1_a4_em2 = 3.04
+ b0_a0_a1_a4_em2 = -0.0223
+ a0_a0_a1_a4_em2 = 0.0337
+ b0_b0_a2_a4_em2 = -2550
+ a0_b0_a2_a4_em2 = 3.48
+ b0_a0_a2_a4_em2 = 0
+ a0_a0_a2_a4_em2 = -0.027
+ b0_b0_a3_a4_em2 = 1160
+ a0_b0_a3_a4_em2 = -1.78
+ b0_a0_a3_a4_em2 = 0.00387
+ a0_a0_a3_a4_em2 = 0.00674
+ b0_b0_a4_a4_em2 = 0
+ a0_b0_a4_a4_em2 = 0
+ b0_a0_a4_a4_em2 = 0
+ a0_a0_a4_a4_em2 = 0
+ b0_b0_p1_a4_em2 = 1.74
+ a0_b0_p1_a4_em2 = 0.00164
+ b0_a0_p1_a4_em2 = -0.0374
+ a0_a0_p1_a4_em2 = 0.000111
+ b0_b0_p2_a4_em2 = 3.75
+ a0_b0_p2_a4_em2 = -0.00306
+ b0_a0_p2_a4_em2 = -0.00795
+ a0_a0_p2_a4_em2 = -0.000000485
+ b0_b0_p3_a4_em2 = 3.11
+ a0_b0_p3_a4_em2 = -0.000749
+ b0_a0_p3_a4_em2 = 0.0000461
+ a0_a0_p3_a4_em2 = -0.0000185
+ b0_b0_p4_a4_em2 = 0.759
+ a0_b0_p4_a4_em2 = 0.0123
+ b0_a0_p4_a4_em2 = 0.0000000329
+ a0_a0_p4_a4_em2 = 0.00000864
+ b0_b0_b0_p1_em2 = 1.73
+ a0_b0_b0_p1_em2 = 0
+ b0_a0_b0_p1_em2 = 0
+ a0_a0_b0_p1_em2 = 0
+ b0_b0_a0_p1_em2 = 0
+ a0_b0_a0_p1_em2 = 0
+ b0_a0_a0_p1_em2 = 0
+ a0_a0_a0_p1_em2 = 0
+ b0_b0_a1_p1_em2 = 1.77
+ a0_b0_a1_p1_em2 = 0
+ b0_a0_a1_p1_em2 = 0
+ a0_a0_a1_p1_em2 = 0
+ b0_b0_a2_p1_em2 = 0.348
+ a0_b0_a2_p1_em2 = 0
+ b0_a0_a2_p1_em2 = 0
+ a0_a0_a2_p1_em2 = 0
+ b0_b0_a3_p1_em2 = -2.42
+ a0_b0_a3_p1_em2 = 0
+ b0_a0_a3_p1_em2 = 0
+ a0_a0_a3_p1_em2 = 0
+ b0_b0_a4_p1_em2 = 0
+ a0_b0_a4_p1_em2 = 0
+ b0_a0_a4_p1_em2 = 0
+ a0_a0_a4_p1_em2 = 0
+ b0_b0_p1_p1_em2 = -0.19
+ a0_b0_p1_p1_em2 = 0
+ b0_a0_p1_p1_em2 = 0
+ a0_a0_p1_p1_em2 = 0
+ b0_b0_p2_p1_em2 = 2.57
+ a0_b0_p2_p1_em2 = 0
+ b0_a0_p2_p1_em2 = 0
+ a0_a0_p2_p1_em2 = 0
+ b0_b0_p3_p1_em2 = 3.7
+ a0_b0_p3_p1_em2 = 0
+ b0_a0_p3_p1_em2 = 0
+ a0_a0_p3_p1_em2 = 0
+ b0_b0_p4_p1_em2 = 4.01
+ a0_b0_p4_p1_em2 = 0
+ b0_a0_p4_p1_em2 = 0
+ a0_a0_p4_p1_em2 = 0
+ b0_b0_b0_p2_em2 = 25.6
+ a0_b0_b0_p2_em2 = -0.0179
+ b0_a0_b0_p2_em2 = 0
+ a0_a0_b0_p2_em2 = 0
+ b0_b0_a0_p2_em2 = 0
+ a0_b0_a0_p2_em2 = 0
+ b0_a0_a0_p2_em2 = 0
+ a0_a0_a0_p2_em2 = 0
+ b0_b0_a1_p2_em2 = 5.64
+ a0_b0_a1_p2_em2 = -0.00965
+ b0_a0_a1_p2_em2 = 0
+ a0_a0_a1_p2_em2 = 0
+ b0_b0_a2_p2_em2 = 0.123
+ a0_b0_a2_p2_em2 = 0.00165
+ b0_a0_a2_p2_em2 = 0
+ a0_a0_a2_p2_em2 = 0
+ b0_b0_a3_p2_em2 = -3.13
+ a0_b0_a3_p2_em2 = 0.00506
+ b0_a0_a3_p2_em2 = 0
+ a0_a0_a3_p2_em2 = 0
+ b0_b0_a4_p2_em2 = 0
+ a0_b0_a4_p2_em2 = 0
+ b0_a0_a4_p2_em2 = 0
+ a0_a0_a4_p2_em2 = 0
+ b0_b0_p1_p2_em2 = -1
+ a0_b0_p1_p2_em2 = 0
+ b0_a0_p1_p2_em2 = 0
+ a0_a0_p1_p2_em2 = 0
+ b0_b0_p2_p2_em2 = -2.26
+ a0_b0_p2_p2_em2 = 0.00269
+ b0_a0_p2_p2_em2 = 0
+ a0_a0_p2_p2_em2 = 0
+ b0_b0_p3_p2_em2 = 2.97
+ a0_b0_p3_p2_em2 = -0.00342
+ b0_a0_p3_p2_em2 = 0
+ a0_a0_p3_p2_em2 = 0
+ b0_b0_p4_p2_em2 = 3.32
+ a0_b0_p4_p2_em2 = 0.00428
+ b0_a0_p4_p2_em2 = 0
+ a0_a0_p4_p2_em2 = 0
+ b0_b0_b0_p3_em2 = 33.9
+ a0_b0_b0_p3_em2 = 0.01
+ b0_a0_b0_p3_em2 = 0.0328
+ a0_a0_b0_p3_em2 = 0.0000813
+ b0_b0_a0_p3_em2 = 0
+ a0_b0_a0_p3_em2 = 0
+ b0_a0_a0_p3_em2 = 0
+ a0_a0_a0_p3_em2 = 0
+ b0_b0_a1_p3_em2 = -25
+ a0_b0_a1_p3_em2 = 0.0215
+ b0_a0_a1_p3_em2 = -0.00738
+ a0_a0_a1_p3_em2 = -0.000502
+ b0_b0_a2_p3_em2 = -0.46
+ a0_b0_a2_p3_em2 = 0.00244
+ b0_a0_a2_p3_em2 = 0.0125
+ a0_a0_a2_p3_em2 = -0.0000764
+ b0_b0_a3_p3_em2 = 4.67
+ a0_b0_a3_p3_em2 = 0.00495
+ b0_a0_a3_p3_em2 = 0.192
+ a0_a0_a3_p3_em2 = -0.000535
+ b0_b0_a4_p3_em2 = 0
+ a0_b0_a4_p3_em2 = 0
+ b0_a0_a4_p3_em2 = 0
+ a0_a0_a4_p3_em2 = 0
+ b0_b0_p1_p3_em2 = -0.487
+ a0_b0_p1_p3_em2 = -0.0178
+ b0_a0_p1_p3_em2 = 0.00611
+ a0_a0_p1_p3_em2 = -0.000196
+ b0_b0_p2_p3_em2 = -0.521
+ a0_b0_p2_p3_em2 = -0.017
+ b0_a0_p2_p3_em2 = 0.0238
+ a0_a0_p2_p3_em2 = -0.000258
+ b0_b0_p3_p3_em2 = 2.77
+ a0_b0_p3_p3_em2 = -0.00237
+ b0_a0_p3_p3_em2 = -0.0168
+ a0_a0_p3_p3_em2 = 0.0000351
+ b0_b0_p4_p3_em2 = 2.17
+ a0_b0_p4_p3_em2 = 0.00141
+ b0_a0_p4_p3_em2 = -0.00412
+ a0_a0_p4_p3_em2 = 0.0000129
+ b0_b0_b0_p4_em2 = 65
+ a0_b0_b0_p4_em2 = -0.0397
+ b0_a0_b0_p4_em2 = -0.0786
+ a0_a0_b0_p4_em2 = -0.00077
+ b0_b0_a0_p4_em2 = 0
+ a0_b0_a0_p4_em2 = 0
+ b0_a0_a0_p4_em2 = 0
+ a0_a0_a0_p4_em2 = 0
+ b0_b0_a1_p4_em2 = 5.02
+ a0_b0_a1_p4_em2 = 0.0115
+ b0_a0_a1_p4_em2 = -0.169
+ a0_a0_a1_p4_em2 = 0.000602
+ b0_b0_a2_p4_em2 = 4.99
+ a0_b0_a2_p4_em2 = 0.056
+ b0_a0_a2_p4_em2 = 0.458
+ a0_a0_a2_p4_em2 = -0.000233
+ b0_b0_a3_p4_em2 = 4.98
+ a0_b0_a3_p4_em2 = -0.028
+ b0_a0_a3_p4_em2 = -0.0837
+ a0_a0_a3_p4_em2 = 0.0000251
+ b0_b0_a4_p4_em2 = 0
+ a0_b0_a4_p4_em2 = 0
+ b0_a0_a4_p4_em2 = 0
+ a0_a0_a4_p4_em2 = 0
+ b0_b0_p1_p4_em2 = 0.0848
+ a0_b0_p1_p4_em2 = -0.000334
+ b0_a0_p1_p4_em2 = -0.0295
+ a0_a0_p1_p4_em2 = 0.0000458
+ b0_b0_p2_p4_em2 = 2.47
+ a0_b0_p2_p4_em2 = 0.000867
+ b0_a0_p2_p4_em2 = -0.0184
+ a0_a0_p2_p4_em2 = 0.0000544
+ b0_b0_p3_p4_em2 = 3.4
+ a0_b0_p3_p4_em2 = -0.000333
+ b0_a0_p3_p4_em2 = -0.00504
+ a0_a0_p3_p4_em2 = 0.00000277
+ b0_b0_p4_p4_em2 = 4.56
+ a0_b0_p4_p4_em2 = 0.0000987
+ b0_a0_p4_p4_em2 = 0.0172
+ a0_a0_p4_p4_em2 = -0.0000625
}
endsection pld90b_10hv_dfrt

section pld100_10hv_dfrt
include "soachecks_top.scs" section=pld100_10hv_soa
if (enable_esdsoa == 1) {
apld100_10hv_esdchk_1 (d g s sub) monitor_esd_pld100_10hv ruleNum=1 enable=soa rule="esd_pld100_Vt1=127p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-127.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_2 (d g s sub) monitor_esd_pld100_10hv ruleNum=2 enable=soa rule="esd_pld100_Vt1>127p0_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 127.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=127.0
apld100_10hv_esdchk_3 (d g s sub) monitor_esd_pld100_10hv ruleNum=3 enable=soa rule="esd_pld100_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-0.0))-127.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_4 (d g s sub) monitor_esd_pld100_10hv ruleNum=4 enable=soa rule="esd_pld100_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-0.0)))) > 127.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=127.0
apld100_10hv_esdchk_5 (d g s sub) monitor_esd_pld100_10hv ruleNum=5 enable=soa rule="esd_pld100_Vt1=126p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-126.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_6 (d g s sub) monitor_esd_pld100_10hv ruleNum=6 enable=soa rule="esd_pld100_Vt1>126p0_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 126.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=126.0
apld100_10hv_esdchk_7 (d g s sub) monitor_esd_pld100_10hv ruleNum=7 enable=soa rule="esd_pld100_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-0.5))-126.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_8 (d g s sub) monitor_esd_pld100_10hv ruleNum=8 enable=soa rule="esd_pld100_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-0.5)))) > 126.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=126.0
apld100_10hv_esdchk_9 (d g s sub) monitor_esd_pld100_10hv ruleNum=9 enable=soa rule="esd_pld100_Vt1=124p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_10 (d g s sub) monitor_esd_pld100_10hv ruleNum=10 enable=soa rule="esd_pld100_Vt1>124p0_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apld100_10hv_esdchk_11 (d g s sub) monitor_esd_pld100_10hv ruleNum=11 enable=soa rule="esd_pld100_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.0))-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_12 (d g s sub) monitor_esd_pld100_10hv ruleNum=12 enable=soa rule="esd_pld100_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.0)))) > 124.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=124.0
apld100_10hv_esdchk_13 (d g s sub) monitor_esd_pld100_10hv ruleNum=13 enable=soa rule="esd_pld100_Vt1=124p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_14 (d g s sub) monitor_esd_pld100_10hv ruleNum=14 enable=soa rule="esd_pld100_Vt1>124p0_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 124.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=124.0
apld100_10hv_esdchk_15 (d g s sub) monitor_esd_pld100_10hv ruleNum=15 enable=soa rule="esd_pld100_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-1.5))-124.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_16 (d g s sub) monitor_esd_pld100_10hv ruleNum=16 enable=soa rule="esd_pld100_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-1.5)))) > 124.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=124.0
apld100_10hv_esdchk_17 (d g s sub) monitor_esd_pld100_10hv ruleNum=17 enable=soa rule="esd_pld100_Vt1=123p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-123.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_18 (d g s sub) monitor_esd_pld100_10hv ruleNum=18 enable=soa rule="esd_pld100_Vt1>123p0_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 123.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.0
apld100_10hv_esdchk_19 (d g s sub) monitor_esd_pld100_10hv ruleNum=19 enable=soa rule="esd_pld100_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-2.5))-123.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_20 (d g s sub) monitor_esd_pld100_10hv ruleNum=20 enable=soa rule="esd_pld100_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(4.0*(V(s)-V(g)-2.5)))) > 123.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=123.0
apld100_10hv_esdchk_21 (d g s sub) monitor_esd_pld100_10hv ruleNum=21 enable=soa rule="esd_pld100_Vt1=119p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-119.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_22 (d g s sub) monitor_esd_pld100_10hv ruleNum=22 enable=soa rule="esd_pld100_Vt1>119p0_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 119.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=119.0
apld100_10hv_esdchk_23 (d g s sub) monitor_esd_pld100_10hv ruleNum=23 enable=soa rule="esd_pld100_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(3.0*(V(s)-V(g)-3.5))-119.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_24 (d g s sub) monitor_esd_pld100_10hv ruleNum=24 enable=soa rule="esd_pld100_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(3.0*(V(s)-V(g)-3.5)))) > 119.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=119.0
apld100_10hv_esdchk_25 (d g s sub) monitor_esd_pld100_10hv ruleNum=25 enable=soa rule="esd_pld100_Vt1=116p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-116.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_26 (d g s sub) monitor_esd_pld100_10hv ruleNum=26 enable=soa rule="esd_pld100_Vt1>116p0_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 116.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.0
apld100_10hv_esdchk_27 (d g s sub) monitor_esd_pld100_10hv ruleNum=27 enable=soa rule="esd_pld100_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-4.5))-116.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apld100_10hv_esdchk_28 (d g s sub) monitor_esd_pld100_10hv ruleNum=28 enable=soa rule="esd_pld100_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-4.5)))) > 116.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=116.0
apld100_10hv_esdchk_29 (d g s sub) monitor_esd_pld100_10hv ruleNum=29 enable=soa rule="esd_pld100_Vt1=116p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-116.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_30 (d g s sub) monitor_esd_pld100_10hv ruleNum=30 enable=soa rule="esd_pld100_Vt1>116p0_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 116.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.0
apld100_10hv_esdchk_31 (d g s sub) monitor_esd_pld100_10hv ruleNum=31 enable=soa rule="esd_pld100_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(s)-V(d)-116.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apld100_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pld100_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="absV(s-to-d) > 116.0 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=116.0
apld100_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_pld100_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apld100_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_pld100_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 127.0 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=127.0
apld100_10hv_esdchk_35 (s sub) monitor2t enable=soa rule="esd_pld100_Vssub_maxV" targetT=0.0 formulae_cond1="V(s-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld100_10hv_esdchk_36 (sub d) monitor2t enable=soa rule="esd_pld100_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apld100_10hv_esdchk_37 (d s) monitor2t enable=soa rule="esd_pld100_Vds_Vt1" targetT=0.0 formulae_cond1="V(d-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
endsection pld100_10hv_dfrt

section nld45_tlp_10hv_dfrt
include "soachecks_top.scs" section=nld45b_tlp_10hv_soa
if (enable_relimo == 1) {
anld45_tlp_10hv_hci3 (d g s sub) relimo_aging_hci_nld45_tlp w=w*ng relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1.6 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_tlp_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_tlp_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_tlp_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_tlp_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_tlp_10hv relimo_c=relimo_c_1_hci_nld45_tlp_10hv relimo_condvd=relimo_condvd_hci_nld45_tlp_10hv relimo_condvg=relimo_condvg_hci_nld45_tlp_10hv relimo_intercept=relimo_intercept_1_hci_nld45_tlp_10hv relimo_m=relimo_m_1_hci_nld45_tlp_10hv relimo_n=relimo_n_1_hci_nld45_tlp_10hv relimo_r=relimo_r_1_hci_nld45_tlp_10hv relimo_e=relimo_e_hci_nld45_tlp_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_tlp_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_tlp_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_tlp_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_tlp_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_tlp_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_tlp_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_tlp_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_tlp_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_tlp_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_tlp_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_tlp_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_tlp_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_tlp_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_tlp_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_tlp_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_tlp_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_tlp_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_tlp_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_tlp_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_tlp_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_tlp_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_tlp_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_tlp_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_tlp_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_tlp_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_tlp_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_tlp_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_tlp_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_tlp_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_tlp_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_tlp_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_tlp_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_tlp_10hv relimo_vth=relimo_vth_hci_nld45_tlp_10hv
anld45_tlp_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_tlp_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld45_tlp_10hv_esdchk_1 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=1 enable=soa rule="esd_nld45_tlp_Vt1=69p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_2 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=2 enable=soa rule="esd_nld45_tlp_Vt1>69p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.8
anld45_tlp_10hv_esdchk_3 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=3 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_tlp_10hv_esdchk_4 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=4 enable=soa rule="esd_nld45_tlp_>Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 69.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.8
anld45_tlp_10hv_esdchk_5 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=5 enable=soa rule="esd_nld45_tlp_Vt1=69p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_6 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=6 enable=soa rule="esd_nld45_tlp_Vt1>69p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.8
anld45_tlp_10hv_esdchk_7 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=7 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_tlp_10hv_esdchk_8 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=8 enable=soa rule="esd_nld45_tlp_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))) > 69.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.8
anld45_tlp_10hv_esdchk_9 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=9 enable=soa rule="esd_nld45_tlp_Vt1=69p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_10 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=10 enable=soa rule="esd_nld45_tlp_Vt1>69p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.2
anld45_tlp_10hv_esdchk_11 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=11 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(3.5*(V(g)-V(s)-4.5))-69.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_tlp_10hv_esdchk_12 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=12 enable=soa rule="esd_nld45_tlp_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(3.5*(V(g)-V(s)-4.5))) > 69.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.2
anld45_tlp_10hv_esdchk_13 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=13 enable=soa rule="esd_nld45_tlp_Vt1=65p7_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-65.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_14 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=14 enable=soa rule="esd_nld45_tlp_Vt1>65p7_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 65.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=65.7
anld45_tlp_10hv_esdchk_15 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=15 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))-65.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_tlp_10hv_esdchk_16 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=16 enable=soa rule="esd_nld45_tlp_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))) > 65.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=65.7
anld45_tlp_10hv_esdchk_17 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=17 enable=soa rule="esd_nld45_tlp_Vt1=64p6_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-64.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_18 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=18 enable=soa rule="esd_nld45_tlp_Vt1>64p6_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 64.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.6
anld45_tlp_10hv_esdchk_19 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=19 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(3.4*(V(g)-V(s)-6.0))-64.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45_tlp_10hv_esdchk_20 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=20 enable=soa rule="esd_nld45_tlp_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(3.4*(V(g)-V(s)-6.0))) > 64.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=64.6
anld45_tlp_10hv_esdchk_21 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=21 enable=soa rule="esd_nld45_tlp_Vt1=61p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_22 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=22 enable=soa rule="esd_nld45_tlp_Vt1>61p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.2
anld45_tlp_10hv_esdchk_23 (d g s sub) monitor_esd_nld45_tlp_10hv ruleNum=23 enable=soa rule="esd_nld45_tlp_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45_tlp_10hv_esdchk_24 (g s d s) monitor4t enable=soa rule="esd_nld45_tlp_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 61.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.2
anld45_tlp_10hv_esdchk_25 (g s) monitor2t enable=soa rule="esd_nld45_tlp_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45_tlp_10hv_esdchk_26 (g d) monitor2t enable=soa rule="esd_nld45_tlp_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 69.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=69.8
anld45_tlp_10hv_esdchk_27 (d sub) monitor2t enable=soa rule="esd_nld45_tlp_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_tlp_10hv_esdchk_28 (sub s) monitor2t enable=soa rule="esd_nld45_tlp_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45_tlp_10hv_esdchk_29 (s d) monitor2t enable=soa rule="esd_nld45_tlp_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00254
+ hcia1           = 0.698*presto_idRatio
+ hcia2           = 1.38*presto_idRatio
+ hcic1           = 8.38E5
+ hcilambdael0    = 6.14e-7
+ hcialpha1       = 5.27e-13
+ hcibeta1        = 1.07
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.267
+ offfstattau1    = 0.0514
+ offalpha1       = 5.48E+13
+ offbeta1legacy  = 0.132
+ offea1          = 0.315
+ hvgsfstat       = 0.0146         // High Vgs HCI part
+ hvgsa           = 351*presto_vthRatio
+ hvgsn           = 0.419
+ hvgsalpha       = 7.44E19
+ hvgsbeta        = 4.68E-8
+ hvgsgamma       = 17.9
+ hvgsdelta       = 7.62
+ hvgsepsilon     = 0
+ hvgsea          = 0.81
+ hvgsrth         = 0.00571
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 17400 
+ a0_b0_b0_a1_em1 = -3.27 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -1400 
+ a0_b0_a1_a1_em1 = 0.27 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 12000 
+ a0_b0_a2_a1_em1 = 26.4 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -2320 
+ a0_b0_a3_a1_em1 = -7.53 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -2.71 
+ a0_b0_p1_a1_em1 = -7.37E-06 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.03 
+ a0_b0_p2_a1_em1 = 0.000163 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 1.36 
+ a0_b0_p3_a1_em1 = 0.000102 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 5200 
+ a0_b0_b0_a2_em1 = 0 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 0 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 0 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = 0 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 1 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 2 
+ a0_b0_p2_a2_em1 = 0 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 3 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 2480 
+ a0_b0_b0_a3_em1 = 0.502 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 634 
+ a0_b0_a1_a3_em1 = -17.6 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 25500 
+ a0_b0_a2_a3_em1 = -33.6 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -672 
+ a0_b0_a3_a3_em1 = -0.973 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.598 
+ a0_b0_p1_a3_em1 = 0.000857 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.28 
+ a0_b0_p2_a3_em1 = 8.13E-05 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.26 
+ a0_b0_p3_a3_em1 = 0.000714 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 5.83 
+ a0_b0_p4_a3_em1 = -0.00405 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 1040 
+ a0_b0_b0_a4_em1 = -0.0325 
+ b0_a0_b0_a4_em1 = 12.7 
+ a0_a0_b0_a4_em1 = -0.0121 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 5270 
+ a0_b0_a1_a4_em1 = -12.4 
+ b0_a0_a1_a4_em1 = 0.556 
+ a0_a0_a1_a4_em1 = 0.286 
+ b0_b0_a2_a4_em1 = -303 
+ a0_b0_a2_a4_em1 = 1.36 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.00683 
+ b0_b0_a3_a4_em1 = 6350 
+ a0_b0_a3_a4_em1 = -6.57 
+ b0_a0_a3_a4_em1 = 17.6 
+ a0_a0_a3_a4_em1 = -0.0552 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0.545 
+ a0_b0_p1_a4_em1 = 1.09E-03 
+ b0_a0_p1_a4_em1 = 0.00483 
+ a0_a0_p1_a4_em1 = -2.32E-05 
+ b0_b0_p2_a4_em1 = 0.994 
+ a0_b0_p2_a4_em1 = 0.000526 
+ b0_a0_p2_a4_em1 = 6.02E-05 
+ a0_a0_p2_a4_em1 = -1.86E-05 
+ b0_b0_p3_a4_em1 = 3.16 
+ a0_b0_p3_a4_em1 = 1.19E-05 
+ b0_a0_p3_a4_em1 = 0.000843 
+ a0_a0_p3_a4_em1 = 3.55E-06 
+ b0_b0_p4_a4_em1 = 4.7 
+ a0_b0_p4_a4_em1 = -0.000241 
+ b0_a0_p4_a4_em1 = -0.00231 
+ a0_a0_p4_a4_em1 = 1.02E-05 
+ b0_b0_b0_p1_em1 = -4.68 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 17.2 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -0.159 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 1.41 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 1.08 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.43 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.01 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 2.3 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 6.78 
+ a0_b0_b0_p2_em1 = 0.00226 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 1.27 
+ a0_b0_a1_p2_em1 = -0.000307 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0.285 
+ a0_b0_a2_p2_em1 = -0.13 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 6.22 
+ a0_b0_a3_p2_em1 = -0.0235 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.36 
+ a0_b0_p2_p2_em1 = 5.54E-05 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 1.4 
+ a0_b0_p3_p2_em1 = 0 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 2 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 15.9 
+ a0_b0_b0_p3_em1 = 0.00466 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 3.95 
+ a0_b0_a1_p3_em1 = 0.0218 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = -9.77 
+ a0_b0_a2_p3_em1 = -0.0391 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -4.21 
+ a0_b0_a3_p3_em1 = -0.00335 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0.761 
+ a0_b0_p1_p3_em1 = 0.00122 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.1 
+ a0_b0_p2_p3_em1 = 1.16E-05 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 2.82 
+ a0_b0_p3_p3_em1 = -0.000961 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 3.16 
+ a0_b0_p4_p3_em1 = 0.00349 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 28.4 
+ a0_b0_b0_p4_em1 = 0.0078 
+ b0_a0_b0_p4_em1 = 0.27 
+ a0_a0_b0_p4_em1 = -0.000461 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 4.74 
+ a0_b0_a1_p4_em1 = -0.0104 
+ b0_a0_a1_p4_em1 = -0.0955 
+ a0_a0_a1_p4_em1 = 0.000172 
+ b0_b0_a2_p4_em1 = -30.8 
+ a0_b0_a2_p4_em1 = 0.0767 
+ b0_a0_a2_p4_em1 = 0.452 
+ a0_a0_a2_p4_em1 = -0.00128 
+ b0_b0_a3_p4_em1 = 91.8 
+ a0_b0_a3_p4_em1 = 0.0253 
+ b0_a0_a3_p4_em1 = 1.83 
+ a0_a0_a3_p4_em1 = -0.00492 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0.867 
+ a0_b0_p1_p4_em1 = -0.00466 
+ b0_a0_p1_p4_em1 = -0.196 
+ a0_a0_p1_p4_em1 = 0.000438 
+ b0_b0_p2_p4_em1 = 1.71 
+ a0_b0_p2_p4_em1 = -0.000729 
+ b0_a0_p2_p4_em1 = -0.0515 
+ a0_a0_p2_p4_em1 = 0.000102 
+ b0_b0_p3_p4_em1 = 2.95 
+ a0_b0_p3_p4_em1 = -9.66E-05 
+ b0_a0_p3_p4_em1 = 0.00906 
+ a0_a0_p3_p4_em1 = -2.63E-05 
+ b0_b0_p4_p4_em1 = 3.49 
+ a0_b0_p4_p4_em1 = -0.00113 
+ b0_a0_p4_p4_em1 = 0.00189 
+ a0_a0_p4_p4_em1 = -4.62E-06 
}
endsection nld45_tlp_10hv_dfrt

section nld45b_tlp_10hv_dfrt
include "soachecks_top.scs" section=nld45b_tlp_10hv_soa
if (enable_relimo == 1) {
anld45_tlp_10hv_hci3 (d g s sub) relimo_aging_hci_nld45b_tlp w=w*ng relimo_ratio20_a=1.0 relimo_ratio20_b=0 relimo_ratio21_a=1.6 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_tlp_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_tlp_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_tlp_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_tlp_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_tlp_10hv relimo_c=relimo_c_1_hci_nld45_tlp_10hv relimo_condvd=relimo_condvd_hci_nld45_tlp_10hv relimo_condvg=relimo_condvg_hci_nld45_tlp_10hv relimo_intercept=relimo_intercept_1_hci_nld45_tlp_10hv relimo_m=relimo_m_1_hci_nld45_tlp_10hv relimo_n=relimo_n_1_hci_nld45_tlp_10hv relimo_r=relimo_r_1_hci_nld45_tlp_10hv relimo_e=relimo_e_hci_nld45_tlp_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_tlp_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_tlp_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_tlp_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_tlp_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_tlp_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_tlp_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_tlp_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_tlp_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_tlp_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_tlp_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_tlp_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_tlp_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_tlp_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_tlp_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_tlp_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_tlp_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_tlp_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_tlp_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_tlp_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_tlp_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_tlp_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_tlp_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_tlp_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_tlp_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_tlp_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_tlp_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_tlp_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_tlp_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_tlp_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_tlp_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_tlp_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_tlp_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_tlp_10hv relimo_vth=relimo_vth_hci_nld45_tlp_10hv
anld45_tlp_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_tlp_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld45b_tlp_10hv_esdchk_1 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=1 enable=soa rule="esd_nld45b_tlp_Vt1=69p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_2 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=2 enable=soa rule="esd_nld45b_tlp_Vt1>69p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.8
anld45b_tlp_10hv_esdchk_3 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=3 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_tlp_10hv_esdchk_4 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=4 enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 69.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.8
anld45b_tlp_10hv_esdchk_5 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=5 enable=soa rule="esd_nld45b_tlp_Vt1=69p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_6 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=6 enable=soa rule="esd_nld45b_tlp_Vt1>69p8_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.8
anld45b_tlp_10hv_esdchk_7 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=7 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_tlp_10hv_esdchk_8 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=8 enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-3.5))) > 69.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.8
anld45b_tlp_10hv_esdchk_9 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=9 enable=soa rule="esd_nld45b_tlp_Vt1=69p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_10 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=10 enable=soa rule="esd_nld45b_tlp_Vt1>69p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.2
anld45b_tlp_10hv_esdchk_11 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=11 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(3.5*(V(g)-V(s)-4.5))-69.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_tlp_10hv_esdchk_12 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=12 enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(3.5*(V(g)-V(s)-4.5))) > 69.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.2
anld45b_tlp_10hv_esdchk_13 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=13 enable=soa rule="esd_nld45b_tlp_Vt1=65p7_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-65.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_14 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=14 enable=soa rule="esd_nld45b_tlp_Vt1>65p7_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 65.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=65.7
anld45b_tlp_10hv_esdchk_15 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=15 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))-65.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_tlp_10hv_esdchk_16 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=16 enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs_5p5_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))) > 65.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=65.7
anld45b_tlp_10hv_esdchk_17 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=17 enable=soa rule="esd_nld45b_tlp_Vt1=64p6_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-64.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_18 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=18 enable=soa rule="esd_nld45b_tlp_Vt1>64p6_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 64.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.6
anld45b_tlp_10hv_esdchk_19 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=19 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(3.4*(V(g)-V(s)-6.0))-64.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld45b_tlp_10hv_esdchk_20 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=20 enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(3.4*(V(g)-V(s)-6.0))) > 64.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=64.6
anld45b_tlp_10hv_esdchk_21 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=21 enable=soa rule="esd_nld45b_tlp_Vt1=61p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_22 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=22 enable=soa rule="esd_nld45b_tlp_Vt1>61p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.2
anld45b_tlp_10hv_esdchk_23 (d g s sub) monitor_esd_nld45b_tlp_10hv ruleNum=23 enable=soa rule="esd_nld45b_tlp_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld45b_tlp_10hv_esdchk_24 (g s d s) monitor4t enable=soa rule="esd_nld45b_tlp_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 61.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.2
anld45b_tlp_10hv_esdchk_25 (g s) monitor2t enable=soa rule="esd_nld45b_tlp_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld45b_tlp_10hv_esdchk_26 (g d) monitor2t enable=soa rule="esd_nld45b_tlp_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 69.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=69.8
anld45b_tlp_10hv_esdchk_27 (d sub) monitor2t enable=soa rule="esd_nld45b_tlp_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_tlp_10hv_esdchk_28 (sub s) monitor2t enable=soa rule="esd_nld45b_tlp_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld45b_tlp_10hv_esdchk_29 (s d) monitor2t enable=soa rule="esd_nld45b_tlp_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00254
+ hcia1           = 0.698*presto_idRatio
+ hcia2           = 1.38*presto_idRatio
+ hcic1           = 8.38E5
+ hcilambdael0    = 6.14e-7
+ hcialpha1       = 5.27e-13
+ hcibeta1        = 1.07
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.267
+ offfstattau1    = 0.0514
+ offalpha1       = 5.48E+13
+ offbeta1legacy  = 0.132
+ offea1          = 0.315
+ hvgsfstat       = 0.0146         // High Vgs HCI part
+ hvgsa           = 351*presto_vthRatio
+ hvgsn           = 0.419
+ hvgsalpha       = 7.44E19
+ hvgsbeta        = 4.68E-8
+ hvgsgamma       = 17.9
+ hvgsdelta       = 7.62
+ hvgsepsilon     = 0
+ hvgsea          = 0.81
+ hvgsrth         = 0.00571
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 17400 
+ a0_b0_b0_a1_em1 = -3.27 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -1400 
+ a0_b0_a1_a1_em1 = 0.27 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 12000 
+ a0_b0_a2_a1_em1 = 26.4 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -2320 
+ a0_b0_a3_a1_em1 = -7.53 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -2.71 
+ a0_b0_p1_a1_em1 = -7.37E-06 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.03 
+ a0_b0_p2_a1_em1 = 0.000163 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 1.36 
+ a0_b0_p3_a1_em1 = 0.000102 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 5200 
+ a0_b0_b0_a2_em1 = 0 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 0 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 0 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = 0 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 1 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 2 
+ a0_b0_p2_a2_em1 = 0 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 3 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 2480 
+ a0_b0_b0_a3_em1 = 0.502 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 634 
+ a0_b0_a1_a3_em1 = -17.6 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = 25500 
+ a0_b0_a2_a3_em1 = -33.6 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -672 
+ a0_b0_a3_a3_em1 = -0.973 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.598 
+ a0_b0_p1_a3_em1 = 0.000857 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.28 
+ a0_b0_p2_a3_em1 = 8.13E-05 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 1.26 
+ a0_b0_p3_a3_em1 = 0.000714 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 5.83 
+ a0_b0_p4_a3_em1 = -0.00405 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 1040 
+ a0_b0_b0_a4_em1 = -0.0325 
+ b0_a0_b0_a4_em1 = 12.7 
+ a0_a0_b0_a4_em1 = -0.0121 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 5270 
+ a0_b0_a1_a4_em1 = -12.4 
+ b0_a0_a1_a4_em1 = 0.556 
+ a0_a0_a1_a4_em1 = 0.286 
+ b0_b0_a2_a4_em1 = -303 
+ a0_b0_a2_a4_em1 = 1.36 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.00683 
+ b0_b0_a3_a4_em1 = 6350 
+ a0_b0_a3_a4_em1 = -6.57 
+ b0_a0_a3_a4_em1 = 17.6 
+ a0_a0_a3_a4_em1 = -0.0552 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 0.545 
+ a0_b0_p1_a4_em1 = 1.09E-03 
+ b0_a0_p1_a4_em1 = 0.00483 
+ a0_a0_p1_a4_em1 = -2.32E-05 
+ b0_b0_p2_a4_em1 = 0.994 
+ a0_b0_p2_a4_em1 = 0.000526 
+ b0_a0_p2_a4_em1 = 6.02E-05 
+ a0_a0_p2_a4_em1 = -1.86E-05 
+ b0_b0_p3_a4_em1 = 3.16 
+ a0_b0_p3_a4_em1 = 1.19E-05 
+ b0_a0_p3_a4_em1 = 0.000843 
+ a0_a0_p3_a4_em1 = 3.55E-06 
+ b0_b0_p4_a4_em1 = 4.7 
+ a0_b0_p4_a4_em1 = -0.000241 
+ b0_a0_p4_a4_em1 = -0.00231 
+ a0_a0_p4_a4_em1 = 1.02E-05 
+ b0_b0_b0_p1_em1 = -4.68 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 17.2 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -0.159 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 1.41 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 1.08 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.43 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.01 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 2.3 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 6.78 
+ a0_b0_b0_p2_em1 = 0.00226 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 1.27 
+ a0_b0_a1_p2_em1 = -0.000307 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0.285 
+ a0_b0_a2_p2_em1 = -0.13 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 6.22 
+ a0_b0_a3_p2_em1 = -0.0235 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.36 
+ a0_b0_p2_p2_em1 = 5.54E-05 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 1.4 
+ a0_b0_p3_p2_em1 = 0 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 2 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 15.9 
+ a0_b0_b0_p3_em1 = 0.00466 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 3.95 
+ a0_b0_a1_p3_em1 = 0.0218 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = -9.77 
+ a0_b0_a2_p3_em1 = -0.0391 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -4.21 
+ a0_b0_a3_p3_em1 = -0.00335 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0.761 
+ a0_b0_p1_p3_em1 = 0.00122 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.1 
+ a0_b0_p2_p3_em1 = 1.16E-05 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 2.82 
+ a0_b0_p3_p3_em1 = -0.000961 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 3.16 
+ a0_b0_p4_p3_em1 = 0.00349 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 28.4 
+ a0_b0_b0_p4_em1 = 0.0078 
+ b0_a0_b0_p4_em1 = 0.27 
+ a0_a0_b0_p4_em1 = -0.000461 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 4.74 
+ a0_b0_a1_p4_em1 = -0.0104 
+ b0_a0_a1_p4_em1 = -0.0955 
+ a0_a0_a1_p4_em1 = 0.000172 
+ b0_b0_a2_p4_em1 = -30.8 
+ a0_b0_a2_p4_em1 = 0.0767 
+ b0_a0_a2_p4_em1 = 0.452 
+ a0_a0_a2_p4_em1 = -0.00128 
+ b0_b0_a3_p4_em1 = 91.8 
+ a0_b0_a3_p4_em1 = 0.0253 
+ b0_a0_a3_p4_em1 = 1.83 
+ a0_a0_a3_p4_em1 = -0.00492 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0.867 
+ a0_b0_p1_p4_em1 = -0.00466 
+ b0_a0_p1_p4_em1 = -0.196 
+ a0_a0_p1_p4_em1 = 0.000438 
+ b0_b0_p2_p4_em1 = 1.71 
+ a0_b0_p2_p4_em1 = -0.000729 
+ b0_a0_p2_p4_em1 = -0.0515 
+ a0_a0_p2_p4_em1 = 0.000102 
+ b0_b0_p3_p4_em1 = 2.95 
+ a0_b0_p3_p4_em1 = -9.66E-05 
+ b0_a0_p3_p4_em1 = 0.00906 
+ a0_a0_p3_p4_em1 = -2.63E-05 
+ b0_b0_p4_p4_em1 = 3.49 
+ a0_b0_p4_p4_em1 = -0.00113 
+ b0_a0_p4_p4_em1 = 0.00189 
+ a0_a0_p4_p4_em1 = -4.62E-06 
}
endsection nld45b_tlp_10hv_dfrt

section nld10_10hv_dfrt
include "soachecks_top.scs" section=nld10_10hv_soa
if (enable_relimo == 1) {
anld10_10hv_hci_hv (d g s sub) relimo_aging_hv_hci_nld10 w=w*ng relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_ratio21_a=1/9.8537  relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld10_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld10_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld10_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld10_10hv relimo_a_vth=relimo_a_vth_1_hci_nld10_10hv relimo_c=relimo_c_1_hci_nld10_10hv relimo_condvd=relimo_condvd_hci_nld10_10hv relimo_condvg=relimo_condvg_hci_nld10_10hv relimo_intercept=relimo_intercept_1_hci_nld10_10hv relimo_m=relimo_m_1_hci_nld10_10hv relimo_n=relimo_n_1_hci_nld10_10hv relimo_r=relimo_r_1_hci_nld10_10hv relimo_e=relimo_e_hci_nld10_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld10_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld10_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld10_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld10_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld10_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld10_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld10_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld10_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld10_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld10_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld10_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld10_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld10_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld10_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld10_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld10_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld10_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld10_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld10_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld10_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld10_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld10_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld10_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld10_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld10_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld10_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld10_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld10_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld10_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld10_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld10_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld10_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld10_10hv relimo_vth=relimo_vth_hci_nld10_10hv
anld10_10hv_pbti_dummy relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld10_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld10_10hv_esdchk_1 (d g s sub) monitor_esd_nld10_10hv ruleNum=1 enable=soa rule="esd_nld10_Vt1=22p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-22.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_2 (d g s sub) monitor_esd_nld10_10hv ruleNum=2 enable=soa rule="esd_nld10_Vt1>22p9_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 22.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=22.9
anld10_10hv_esdchk_3 (d g s sub) monitor_esd_nld10_10hv ruleNum=3 enable=soa rule="esd_nld10_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-0.0))-22.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld10_10hv_esdchk_4 (d g s sub) monitor_esd_nld10_10hv ruleNum=4 enable=soa rule="esd_nld10_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-0.0))) > 22.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=22.9
anld10_10hv_esdchk_5 (d g s sub) monitor_esd_nld10_10hv ruleNum=5 enable=soa rule="esd_nld10_Vt1=22p4_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-22.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_6 (d g s sub) monitor_esd_nld10_10hv ruleNum=6 enable=soa rule="esd_nld10_Vt1>22p4_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 22.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=22.4
anld10_10hv_esdchk_7 (d g s sub) monitor_esd_nld10_10hv ruleNum=7 enable=soa rule="esd_nld10_=Vt1_Vgs_0p5_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))-22.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld10_10hv_esdchk_8 (d g s sub) monitor_esd_nld10_10hv ruleNum=8 enable=soa rule="esd_nld10_>Vt1_Vgs_0p5_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-0.5))) > 22.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=22.4
anld10_10hv_esdchk_9 (d g s sub) monitor_esd_nld10_10hv ruleNum=9 enable=soa rule="esd_nld10_Vt1=21p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-21.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_10 (d g s sub) monitor_esd_nld10_10hv ruleNum=10 enable=soa rule="esd_nld10_Vt1>21p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 21.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=21.7
anld10_10hv_esdchk_11 (d g s sub) monitor_esd_nld10_10hv ruleNum=11 enable=soa rule="esd_nld10_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(0.9*(V(g)-V(s)-5.0))-21.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld10_10hv_esdchk_12 (d g s sub) monitor_esd_nld10_10hv ruleNum=12 enable=soa rule="esd_nld10_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(0.9*(V(g)-V(s)-5.0))) > 21.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=21.7
anld10_10hv_esdchk_13 (d g s sub) monitor_esd_nld10_10hv ruleNum=13 enable=soa rule="esd_nld10_Vt1=20p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-20.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_14 (d g s sub) monitor_esd_nld10_10hv ruleNum=14 enable=soa rule="esd_nld10_Vt1>20p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 20.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=20.8
anld10_10hv_esdchk_15 (d g s sub) monitor_esd_nld10_10hv ruleNum=15 enable=soa rule="esd_nld10_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(0.7*(V(g)-V(s)-6.0))-20.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld10_10hv_esdchk_16 (d g s sub) monitor_esd_nld10_10hv ruleNum=16 enable=soa rule="esd_nld10_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(0.7*(V(g)-V(s)-6.0))) > 20.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=20.8
anld10_10hv_esdchk_17 (d g s sub) monitor_esd_nld10_10hv ruleNum=17 enable=soa rule="esd_nld10_Vt1=20p1_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-20.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_18 (d g s sub) monitor_esd_nld10_10hv ruleNum=18 enable=soa rule="esd_nld10_Vt1>20p1_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 20.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=20.1
anld10_10hv_esdchk_19 (d g s sub) monitor_esd_nld10_10hv ruleNum=19 enable=soa rule="esd_nld10_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-20.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld10_10hv_esdchk_20 (g s d s) monitor4t enable=soa rule="esd_nld10_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 20.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=20.1
anld10_10hv_esdchk_21 (g s) monitor2t enable=soa rule="esd_nld10_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld10_10hv_esdchk_22 (g d) monitor2t enable=soa rule="esd_nld10_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 22.9 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=22.9
anld10_10hv_esdchk_23 (d sub) monitor2t enable=soa rule="esd_nld10_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld10_10hv_esdchk_24 (sub s) monitor2t enable=soa rule="esd_nld10_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld10_10hv_esdchk_25 (s d) monitor2t enable=soa rule="esd_nld10_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.01
+ hcia1           = 0.369*presto_idRatio
+ hcia2           = 1.15*presto_idRatio
+ hcic1           = 102
+ hcilambdael0    = 9.02e-7
+ hcialpha1       = 1.42e-6
+ hcibeta1        = 1.59
+ offnmosmodelswitch = 1            //Off state HCI part
+ offa1           = 8.14807*presto_idRatio             
+ offn1           = 0.59
+ offn2           = 0.50
+ offfstattau1    = 0.04
+ offalpha1       = 6.37E+3
+ offbeta1legacy  = 0.421
+ offea1          = 0.277
+ hvgsfstat       = 0.02            // High Vgs HCI part
+ hvgsa           = 497*presto_vthRatio
+ hvgsn           = 0.49
+ hvgsalpha       = 3.36E11
+ hvgsbeta        = 5.27E-5
+ hvgsgamma       = 10.80
+ hvgsdelta       = 5.61
+ hvgsepsilon     = 0
+ hvgsea          = 0.71
+ hvgsrth         = 0.00912
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 9280 
+ a0_b0_b0_a1_em1 = -0.997 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -764 
+ a0_b0_a1_a1_em1 = -4.63 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = 114 
+ a0_b0_a2_a1_em1 = 0.297 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -7.38 
+ a0_b0_a3_a1_em1 = 5.62 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.312 
+ a0_b0_p1_a1_em1 = 0.000259 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 2.13 
+ a0_b0_p2_a1_em1 = -0.00128 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.7 
+ a0_b0_p3_a1_em1 = 0.00154 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 5 
+ a0_b0_p4_a1_em1 = 0 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 23000 
+ a0_b0_b0_a2_em1 = 10 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = -0.0002 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 9000 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = -12000 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = 0 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.2 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 1.5 
+ a0_b0_p2_a2_em1 = -0.0002 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 2.5 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3.5 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 25000 
+ a0_b0_b0_a3_em1 = 4 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 20000 
+ a0_b0_a1_a3_em1 = 0 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -20000 
+ a0_b0_a2_a3_em1 = 0 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = 0 
+ a0_b0_a3_a3_em1 = 0 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 1 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 2 
+ a0_b0_p2_a3_em1 = 0 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 3 
+ a0_b0_p3_a3_em1 = 0 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 4 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 25200 
+ a0_b0_b0_a4_em1 = 1.2 
+ b0_a0_b0_a4_em1 = -0.518 
+ a0_a0_b0_a4_em1 = 0.00131 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 5640 
+ a0_b0_a1_a4_em1 = 3.84 
+ b0_a0_a1_a4_em1 = 0.55 
+ a0_a0_a1_a4_em1 = 0.00386 
+ b0_b0_a2_a4_em1 = -3610 
+ a0_b0_a2_a4_em1 = -0.156 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = 0.0005 
+ b0_b0_a3_a4_em1 = -6290 
+ a0_b0_a3_a4_em1 = -0.173 
+ b0_a0_a3_a4_em1 = 0.443 
+ a0_a0_a3_a4_em1 = 0.00313 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 1.6 
+ a0_b0_p1_a4_em1 = -0.000709 
+ b0_a0_p1_a4_em1 = -0.0000472 
+ a0_a0_p1_a4_em1 = 0.000000327 
+ b0_b0_p2_a4_em1 = 2.61 
+ a0_b0_p2_a4_em1 = -0.00147 
+ b0_a0_p2_a4_em1 = -0.000182 
+ a0_a0_p2_a4_em1 = 0.000000197 
+ b0_b0_p3_a4_em1 = 2.89 
+ a0_b0_p3_a4_em1 = 0.00348 
+ b0_a0_p3_a4_em1 = 0.00261 
+ a0_a0_p3_a4_em1 = -0.00000617 
+ b0_b0_p4_a4_em1 = 5.37 
+ a0_b0_p4_a4_em1 = -0.000432 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = -7.4 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 2 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 0.01 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -1.1 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 1.34 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 2.1 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 3.57 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4.4 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 3.52 
+ a0_b0_b0_p2_em1 = 0.00158 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 1.7 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 1.44 
+ a0_b0_a1_p2_em1 = -0.00128 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0.521 
+ a0_b0_a2_p2_em1 = -0.00173 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -0.2 
+ a0_b0_a3_p2_em1 = 0.0000282 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 1.22 
+ a0_b0_p2_p2_em1 = 0.000915 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 3.86 
+ a0_b0_p3_p2_em1 = -0.00302 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 8.78 
+ a0_b0_p4_p2_em1 = -0.00821 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 72.6 
+ a0_b0_b0_p3_em1 = -0.287 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0.3 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 1.08 
+ a0_b0_a1_p3_em1 = -0.00000609 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0.782 
+ a0_b0_a2_p3_em1 = -0.00348 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -4.05 
+ a0_b0_a3_p3_em1 = 0.007 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 86.8 
+ a0_b0_p1_p3_em1 = -0.369 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.31 
+ a0_b0_p2_p3_em1 = 0.0000997 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 3.52 
+ a0_b0_p3_p3_em1 = 0.000709 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 3.65 
+ a0_b0_p4_p3_em1 = 0.00278 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 6.89 
+ a0_b0_b0_p4_em1 = 0.000237 
+ b0_a0_b0_p4_em1 = -0.000637 
+ a0_a0_b0_p4_em1 = 0.00000132 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 0 
+ a0_b0_a1_p4_em1 = 0 
+ b0_a0_a1_p4_em1 = 0 
+ a0_a0_a1_p4_em1 = 0 
+ b0_b0_a2_p4_em1 = 0 
+ a0_b0_a2_p4_em1 = 0 
+ b0_a0_a2_p4_em1 = 0 
+ a0_a0_a2_p4_em1 = 0 
+ b0_b0_a3_p4_em1 = 0 
+ a0_b0_a3_p4_em1 = 0 
+ b0_a0_a3_p4_em1 = 0 
+ a0_a0_a3_p4_em1 = 0 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0 
+ a0_b0_p1_p4_em1 = 0 
+ b0_a0_p1_p4_em1 = 0 
+ a0_a0_p1_p4_em1 = 0 
+ b0_b0_p2_p4_em1 = 0 
+ a0_b0_p2_p4_em1 = 0 
+ b0_a0_p2_p4_em1 = 0 
+ a0_a0_p2_p4_em1 = 0 
+ b0_b0_p3_p4_em1 = 0 
+ a0_b0_p3_p4_em1 = 0 
+ b0_a0_p3_p4_em1 = 0 
+ a0_a0_p3_p4_em1 = 0 
+ b0_b0_p4_p4_em1 = 0 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0 
}
endsection nld10_10hv_dfrt

section nld30_10hv_dfrt
include "soachecks_top.scs" section=nld30b_10hv_soa
if (enable_esdsoa == 1) {
anld30_10hv_esdchk_1 (d g s sub) monitor_esd_nld30_10hv ruleNum=1 enable=soa rule="esd_nld30_Vt1=49p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_2 (d g s sub) monitor_esd_nld30_10hv ruleNum=2 enable=soa rule="esd_nld30_Vt1>49p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.8
anld30_10hv_esdchk_3 (d g s sub) monitor_esd_nld30_10hv ruleNum=3 enable=soa rule="esd_nld30_=Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))-49.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_4 (d g s sub) monitor_esd_nld30_10hv ruleNum=4 enable=soa rule="esd_nld30_>Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))) > 49.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.8
anld30_10hv_esdchk_5 (d g s sub) monitor_esd_nld30_10hv ruleNum=5 enable=soa rule="esd_nld30_Vt1=49p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_6 (d g s sub) monitor_esd_nld30_10hv ruleNum=6 enable=soa rule="esd_nld30_Vt1>49p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.2
anld30_10hv_esdchk_7 (d g s sub) monitor_esd_nld30_10hv ruleNum=7 enable=soa rule="esd_nld30_=Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(2.0*(V(g)-V(s)-1.0))-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_8 (d g s sub) monitor_esd_nld30_10hv ruleNum=8 enable=soa rule="esd_nld30_>Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(2.0*(V(g)-V(s)-1.0))) > 49.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.2
anld30_10hv_esdchk_9 (d g s sub) monitor_esd_nld30_10hv ruleNum=9 enable=soa rule="esd_nld30_Vt1=47p2_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-47.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_10 (d g s sub) monitor_esd_nld30_10hv ruleNum=10 enable=soa rule="esd_nld30_Vt1>47p2_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 47.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.2
anld30_10hv_esdchk_11 (d g s sub) monitor_esd_nld30_10hv ruleNum=11 enable=soa rule="esd_nld30_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(3.6*(V(g)-V(s)-2.0))-47.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_12 (d g s sub) monitor_esd_nld30_10hv ruleNum=12 enable=soa rule="esd_nld30_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(3.6*(V(g)-V(s)-2.0))) > 47.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=47.2
anld30_10hv_esdchk_13 (d g s sub) monitor_esd_nld30_10hv ruleNum=13 enable=soa rule="esd_nld30_Vt1=43p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-43.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_14 (d g s sub) monitor_esd_nld30_10hv ruleNum=14 enable=soa rule="esd_nld30_Vt1>43p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 43.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=43.6
anld30_10hv_esdchk_15 (d g s sub) monitor_esd_nld30_10hv ruleNum=15 enable=soa rule="esd_nld30_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-3.0))-43.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_16 (d g s sub) monitor_esd_nld30_10hv ruleNum=16 enable=soa rule="esd_nld30_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-3.0))) > 43.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=43.6
anld30_10hv_esdchk_17 (d g s sub) monitor_esd_nld30_10hv ruleNum=17 enable=soa rule="esd_nld30_Vt1=42p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_18 (d g s sub) monitor_esd_nld30_10hv ruleNum=18 enable=soa rule="esd_nld30_Vt1>42p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 42.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.4
anld30_10hv_esdchk_19 (d g s sub) monitor_esd_nld30_10hv ruleNum=19 enable=soa rule="esd_nld30_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(6.7*(V(g)-V(s)-4.0))-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_20 (d g s sub) monitor_esd_nld30_10hv ruleNum=20 enable=soa rule="esd_nld30_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(6.7*(V(g)-V(s)-4.0))) > 42.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=42.4
anld30_10hv_esdchk_21 (d g s sub) monitor_esd_nld30_10hv ruleNum=21 enable=soa rule="esd_nld30_Vt1=35p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-35.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_22 (d g s sub) monitor_esd_nld30_10hv ruleNum=22 enable=soa rule="esd_nld30_Vt1>35p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 35.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=35.7
anld30_10hv_esdchk_23 (d g s sub) monitor_esd_nld30_10hv ruleNum=23 enable=soa rule="esd_nld30_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(2.9*(V(g)-V(s)-5.0))-35.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_24 (d g s sub) monitor_esd_nld30_10hv ruleNum=24 enable=soa rule="esd_nld30_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(2.9*(V(g)-V(s)-5.0))) > 35.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=35.7
anld30_10hv_esdchk_25 (d g s sub) monitor_esd_nld30_10hv ruleNum=25 enable=soa rule="esd_nld30_Vt1=32p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-32.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_26 (d g s sub) monitor_esd_nld30_10hv ruleNum=26 enable=soa rule="esd_nld30_Vt1>32p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 32.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=32.8
anld30_10hv_esdchk_27 (d g s sub) monitor_esd_nld30_10hv ruleNum=27 enable=soa rule="esd_nld30_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.6*(V(g)-V(s)-6.0))-32.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30_10hv_esdchk_28 (d g s sub) monitor_esd_nld30_10hv ruleNum=28 enable=soa rule="esd_nld30_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.6*(V(g)-V(s)-6.0))) > 32.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=32.8
anld30_10hv_esdchk_29 (d g s sub) monitor_esd_nld30_10hv ruleNum=29 enable=soa rule="esd_nld30_Vt1=26p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-26.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_30 (d g s sub) monitor_esd_nld30_10hv ruleNum=30 enable=soa rule="esd_nld30_Vt1>26p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 26.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=26.2
anld30_10hv_esdchk_31 (d g s sub) monitor_esd_nld30_10hv ruleNum=31 enable=soa rule="esd_nld30_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-26.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nld30_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 26.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=26.2
anld30_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_nld30_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld30_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_nld30_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 49.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=49.8
anld30_10hv_esdchk_35 (d sub) monitor2t enable=soa rule="esd_nld30_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld30_10hv_esdchk_36 (sub s) monitor2t enable=soa rule="esd_nld30_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld30_10hv_esdchk_37 (s d) monitor2t enable=soa rule="esd_nld30_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nld30_10hv_dfrt

section nld30b_10hv_dfrt
include "soachecks_top.scs" section=nld30b_10hv_soa
if (enable_relimo == 1) {
anld30b_10hv_hci3 (d g s sub) relimo_aging_hci_nld30b w=w*ng relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_ratio21_a=0.74 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld30_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld30_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld30_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld30_10hv relimo_a_vth=relimo_a_vth_1_hci_nld30_10hv relimo_c=relimo_c_1_hci_nld30_10hv relimo_condvd=relimo_condvd_hci_nld30_10hv relimo_condvg=relimo_condvg_hci_nld30_10hv relimo_intercept=relimo_intercept_1_hci_nld30_10hv relimo_m=relimo_m_1_hci_nld30_10hv relimo_n=relimo_n_1_hci_nld30_10hv relimo_r=relimo_r_1_hci_nld30_10hv relimo_e=relimo_e_hci_nld30_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld30_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld30_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld30_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld30_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld30_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld30_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld30_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld30_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld30_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld30_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld30_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld30_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld30_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld30_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld30_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld30_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld30_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld30_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld30_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld30_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld30_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld30_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld30_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld30_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld30_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld30_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld30_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld30_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld30_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld30_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld30_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld30_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld30_10hv relimo_vth=relimo_vth_hci_nld30_10hv
anld30b_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld30_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anld30b_10hv_esdchk_1 (d g s sub) monitor_esd_nld30b_10hv ruleNum=1 enable=soa rule="esd_nld30b_Vt1=49p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_2 (d g s sub) monitor_esd_nld30b_10hv ruleNum=2 enable=soa rule="esd_nld30b_Vt1>49p8_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.8
anld30b_10hv_esdchk_3 (d g s sub) monitor_esd_nld30b_10hv ruleNum=3 enable=soa rule="esd_nld30b_=Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))-49.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_4 (d g s sub) monitor_esd_nld30b_10hv ruleNum=4 enable=soa rule="esd_nld30b_>Vt1_Vgs_0p0_1p0" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))) > 49.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.8
anld30b_10hv_esdchk_5 (d g s sub) monitor_esd_nld30b_10hv ruleNum=5 enable=soa rule="esd_nld30b_Vt1=49p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_6 (d g s sub) monitor_esd_nld30b_10hv ruleNum=6 enable=soa rule="esd_nld30b_Vt1>49p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.2
anld30b_10hv_esdchk_7 (d g s sub) monitor_esd_nld30b_10hv ruleNum=7 enable=soa rule="esd_nld30b_=Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(2.0*(V(g)-V(s)-1.0))-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_8 (d g s sub) monitor_esd_nld30b_10hv ruleNum=8 enable=soa rule="esd_nld30b_>Vt1_Vgs_1p0_2p0" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(2.0*(V(g)-V(s)-1.0))) > 49.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.2
anld30b_10hv_esdchk_9 (d g s sub) monitor_esd_nld30b_10hv ruleNum=9 enable=soa rule="esd_nld30b_Vt1=47p2_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-47.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_10 (d g s sub) monitor_esd_nld30b_10hv ruleNum=10 enable=soa rule="esd_nld30b_Vt1>47p2_Vgs2p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 47.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=47.2
anld30b_10hv_esdchk_11 (d g s sub) monitor_esd_nld30b_10hv ruleNum=11 enable=soa rule="esd_nld30b_=Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(3.6*(V(g)-V(s)-2.0))-47.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_12 (d g s sub) monitor_esd_nld30b_10hv ruleNum=12 enable=soa rule="esd_nld30b_>Vt1_Vgs_2p0_3p0" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(3.6*(V(g)-V(s)-2.0))) > 47.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=47.2
anld30b_10hv_esdchk_13 (d g s sub) monitor_esd_nld30b_10hv ruleNum=13 enable=soa rule="esd_nld30b_Vt1=43p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-43.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_14 (d g s sub) monitor_esd_nld30b_10hv ruleNum=14 enable=soa rule="esd_nld30b_Vt1>43p6_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 43.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=43.6
anld30b_10hv_esdchk_15 (d g s sub) monitor_esd_nld30b_10hv ruleNum=15 enable=soa rule="esd_nld30b_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-3.0))-43.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_16 (d g s sub) monitor_esd_nld30b_10hv ruleNum=16 enable=soa rule="esd_nld30b_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-3.0))) > 43.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=43.6
anld30b_10hv_esdchk_17 (d g s sub) monitor_esd_nld30b_10hv ruleNum=17 enable=soa rule="esd_nld30b_Vt1=42p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_18 (d g s sub) monitor_esd_nld30b_10hv ruleNum=18 enable=soa rule="esd_nld30b_Vt1>42p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 42.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.4
anld30b_10hv_esdchk_19 (d g s sub) monitor_esd_nld30b_10hv ruleNum=19 enable=soa rule="esd_nld30b_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(6.7*(V(g)-V(s)-4.0))-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_20 (d g s sub) monitor_esd_nld30b_10hv ruleNum=20 enable=soa rule="esd_nld30b_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(6.7*(V(g)-V(s)-4.0))) > 42.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=42.4
anld30b_10hv_esdchk_21 (d g s sub) monitor_esd_nld30b_10hv ruleNum=21 enable=soa rule="esd_nld30b_Vt1=35p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-35.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_22 (d g s sub) monitor_esd_nld30b_10hv ruleNum=22 enable=soa rule="esd_nld30b_Vt1>35p7_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 35.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=35.7
anld30b_10hv_esdchk_23 (d g s sub) monitor_esd_nld30b_10hv ruleNum=23 enable=soa rule="esd_nld30b_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(2.9*(V(g)-V(s)-5.0))-35.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_24 (d g s sub) monitor_esd_nld30b_10hv ruleNum=24 enable=soa rule="esd_nld30b_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(2.9*(V(g)-V(s)-5.0))) > 35.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=35.7
anld30b_10hv_esdchk_25 (d g s sub) monitor_esd_nld30b_10hv ruleNum=25 enable=soa rule="esd_nld30b_Vt1=32p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-32.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_26 (d g s sub) monitor_esd_nld30b_10hv ruleNum=26 enable=soa rule="esd_nld30b_Vt1>32p8_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 32.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=32.8
anld30b_10hv_esdchk_27 (d g s sub) monitor_esd_nld30b_10hv ruleNum=27 enable=soa rule="esd_nld30b_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.6*(V(g)-V(s)-6.0))-32.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anld30b_10hv_esdchk_28 (d g s sub) monitor_esd_nld30b_10hv ruleNum=28 enable=soa rule="esd_nld30b_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.6*(V(g)-V(s)-6.0))) > 32.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=32.8
anld30b_10hv_esdchk_29 (d g s sub) monitor_esd_nld30b_10hv ruleNum=29 enable=soa rule="esd_nld30b_Vt1=26p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-26.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_30 (d g s sub) monitor_esd_nld30b_10hv ruleNum=30 enable=soa rule="esd_nld30b_Vt1>26p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 26.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=26.2
anld30b_10hv_esdchk_31 (d g s sub) monitor_esd_nld30b_10hv ruleNum=31 enable=soa rule="esd_nld30b_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-26.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anld30b_10hv_esdchk_32 (g s d s) monitor4t enable=soa rule="esd_nld30b_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 26.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=26.2
anld30b_10hv_esdchk_33 (g s) monitor2t enable=soa rule="esd_nld30b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anld30b_10hv_esdchk_34 (g d) monitor2t enable=soa rule="esd_nld30b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 49.8 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=49.8
anld30b_10hv_esdchk_35 (d sub) monitor2t enable=soa rule="esd_nld30b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld30b_10hv_esdchk_36 (sub s) monitor2t enable=soa rule="esd_nld30b_Vsubs_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-s) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anld30b_10hv_esdchk_37 (s d) monitor2t enable=soa rule="esd_nld30b_Vsd_Vt1" targetT=0.0 formulae_cond1="V(s-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mpowermos"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00308
+ hcia1           = 0.835*presto_idRatio
+ hcia2           = 0.982*presto_idRatio
+ hcic1           = 7630
+ hcilambdael0    = 5.96e-7
+ hcialpha1       = 9.36e-11
+ hcibeta1        = 2.03
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.30
+ offfstattau1    = 0.01515
+ offalpha1       = 8.96E+11
+ offbeta1legacy  = 0.18
+ offea1          = 0.389
+ hvgsfstat       = 0.033855         // High Vgs HCI part
+ hvgsa           = 428.10*presto_vthRatio
+ hvgsn           = 0.42
+ hvgsalpha       = 6.87E20
+ hvgsbeta        = 5.40E-5
+ hvgsgamma       = 18.13
+ hvgsdelta       = 9.97
+ hvgsepsilon     = 0
+ hvgsea          = 0.82
+ hvgsrth         = 0.00952
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 14100 
+ a0_b0_b0_a1_em1 = -2.74 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = -0.004 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -2930 
+ a0_b0_a1_a1_em1 = -1.28 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -3670 
+ a0_b0_a2_a1_em1 = -4.21 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -4750 
+ a0_b0_a3_a1_em1 = 2.8 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = 0.815 
+ a0_b0_p1_a1_em1 = 6.05E-04 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 2.05 
+ a0_b0_p2_a1_em1 = 0.000903 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 2.92 
+ a0_b0_p3_a1_em1 = -0.000182 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 3.7 
+ a0_b0_p4_a1_em1 = 0 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 8500 
+ a0_b0_b0_a2_em1 = 0.5 
+ b0_a0_b0_a2_em1 = 3.55 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0.0005 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 933 
+ a0_b0_a1_a2_em1 = 0.0005 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = -3000 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -2000 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -1 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 0.3 
+ a0_b0_p2_a2_em1 = 0.0005 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 1.7 
+ a0_b0_p3_a2_em1 = 5.00E-04 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3.3 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 6000 
+ a0_b0_b0_a3_em1 = 4 
+ b0_a0_b0_a3_em1 = 3.55 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 0 
+ a0_b0_a1_a3_em1 = 0 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -6000 
+ a0_b0_a2_a3_em1 = 0 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = 0 
+ a0_b0_a3_a3_em1 = 0 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = -1 
+ a0_b0_p1_a3_em1 = 0 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.8 
+ a0_b0_p2_a3_em1 = 0.00E+00 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 2.5 
+ a0_b0_p3_a3_em1 = 0 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3.1 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 6000 
+ a0_b0_b0_a4_em1 = 10.7 
+ b0_a0_b0_a4_em1 = -0.0357 
+ a0_a0_b0_a4_em1 = -0.0155 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 0.51 
+ a0_b0_a1_a4_em1 = -0.354 
+ b0_a0_a1_a4_em1 = -0.594 
+ a0_a0_a1_a4_em1 = 0.00315 
+ b0_b0_a2_a4_em1 = -3 
+ a0_b0_a2_a4_em1 = -1.56 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.000627 
+ b0_b0_a3_a4_em1 = 9.16 
+ a0_b0_a3_a4_em1 = 2.71 
+ b0_a0_a3_a4_em1 = 0.408 
+ a0_a0_a3_a4_em1 = -0.0433 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = -15.8 
+ a0_b0_p1_a4_em1 = -2.82E-02 
+ b0_a0_p1_a4_em1 = -0.265 
+ a0_a0_p1_a4_em1 = 1.43E-03 
+ b0_b0_p2_a4_em1 = 1.37 
+ a0_b0_p2_a4_em1 = -0.00684 
+ b0_a0_p2_a4_em1 = 0.0618 
+ a0_a0_p2_a4_em1 = -2.31E-04 
+ b0_b0_p3_a4_em1 = 2.46 
+ a0_b0_p3_a4_em1 = 0.000591 
+ b0_a0_p3_a4_em1 = -0.046 
+ a0_a0_p3_a4_em1 = 1.80E-04 
+ b0_b0_p4_a4_em1 = 3.5 
+ a0_b0_p4_a4_em1 = 0.0073 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0.00E+00 
+ b0_b0_b0_p1_em1 = 3.63 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 1.5 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -2.94 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -9.23 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -0.6 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.47 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 3.7 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 20.5 
+ a0_b0_b0_p2_em1 = 0 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0 
+ a0_b0_a1_p2_em1 = 0 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 0 
+ a0_b0_a2_p2_em1 = 0 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 0 
+ a0_b0_a3_p2_em1 = 0 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = 0 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 0 
+ a0_b0_p2_p2_em1 = 0 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 0 
+ a0_b0_p3_p2_em1 = 0 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 0 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 25.4 
+ a0_b0_b0_p3_em1 = 0.0072 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0 
+ a0_b0_a1_p3_em1 = 0 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 0 
+ a0_b0_a2_p3_em1 = 0 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = 0 
+ a0_b0_a3_p3_em1 = 0 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 0 
+ a0_b0_p1_p3_em1 = 0 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 0 
+ a0_b0_p2_p3_em1 = 0 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 0 
+ a0_b0_p3_p3_em1 = 0 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 0 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 25.8 
+ a0_b0_b0_p4_em1 = 0.0172 
+ b0_a0_b0_p4_em1 = 0.0279 
+ a0_a0_b0_p4_em1 = -2.33E-04 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 0 
+ a0_b0_a1_p4_em1 = 0 
+ b0_a0_a1_p4_em1 = 0 
+ a0_a0_a1_p4_em1 = 0 
+ b0_b0_a2_p4_em1 = 0 
+ a0_b0_a2_p4_em1 = 0 
+ b0_a0_a2_p4_em1 = 0 
+ a0_a0_a2_p4_em1 = 0 
+ b0_b0_a3_p4_em1 = 0 
+ a0_b0_a3_p4_em1 = 0 
+ b0_a0_a3_p4_em1 = 0 
+ a0_a0_a3_p4_em1 = 0 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 0 
+ a0_b0_p1_p4_em1 = 0 
+ b0_a0_p1_p4_em1 = 0 
+ a0_a0_p1_p4_em1 = 0 
+ b0_b0_p2_p4_em1 = 0 
+ a0_b0_p2_p4_em1 = 0 
+ b0_a0_p2_p4_em1 = 0 
+ a0_a0_p2_p4_em1 = 0 
+ b0_b0_p3_p4_em1 = 0 
+ a0_b0_p3_p4_em1 = 0 
+ b0_a0_p3_p4_em1 = 0 
+ a0_a0_p3_p4_em1 = 0 
+ b0_b0_p4_p4_em1 = 0 
+ a0_b0_p4_p4_em1 = 0 
+ b0_a0_p4_p4_em1 = 0 
+ a0_a0_p4_p4_em1 = 0      
}
endsection nld30b_10hv_dfrt

section nld45_10hv_dfrt
include "soachecks_top.scs" section=nld45b_10hv_soa
if (enable_relimo == 1) {
anld45_10hv_hci3 (d g s sub) relimo_aging_hci_nld45 w=w*ng relimo_ratio20_a=0.95 relimo_ratio20_b=0 relimo_ratio21_a=1.705 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nld45_10hv relimo_probe_name=mpowermos relimo_a_gm=relimo_a_gm_1_hci_nld45_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nld45_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nld45_10hv relimo_a_vth=relimo_a_vth_1_hci_nld45_10hv relimo_c=relimo_c_1_hci_nld45_10hv relimo_condvd=relimo_condvd_hci_nld45_10hv relimo_condvg=relimo_condvg_hci_nld45_10hv relimo_intercept=relimo_intercept_1_hci_nld45_10hv relimo_m=relimo_m_1_hci_nld45_10hv relimo_n=relimo_n_1_hci_nld45_10hv relimo_r=relimo_r_1_hci_nld45_10hv relimo_e=relimo_e_hci_nld45_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nld45_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nld45_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nld45_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nld45_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nld45_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nld45_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nld45_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nld45_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nld45_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nld45_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nld45_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nld45_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nld45_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nld45_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nld45_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nld45_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nld45_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nld45_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nld45_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nld45_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nld45_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nld45_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nld45_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nld45_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nld45_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nld45_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nld45_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nld45_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nld45_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nld45_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nld45_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nld45_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nld45_10hv relimo_vth=relimo_vth_hci_nld45_10hv
anld45_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nld45_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
