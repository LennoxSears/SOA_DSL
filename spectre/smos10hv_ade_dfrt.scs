+ vgpowmve  = presto_hci_pmos_vgpowmve
+ vdexpmve  = presto_hci_pmos_vdexpmve
+ eamve     = presto_hci_pmos_eamve
+ lexpmve   = presto_hci_pmos_lexpmve
+ lpowmve   = presto_hci_pmos_lpowmve
+ wpowmve   = presto_hci_pmos_wpowmve
+ vbsexpmve = presto_hci_pmos_vbsexpmve
+ vc1mve    = presto_hci_pmos_vc1mve
+ vc2mve    = presto_hci_pmos_vc2mve
+ alphahe   = presto_hci_pmos_alphahe
+ fstathe   = presto_hci_pmos_fstathe
+ vdpowhe   = presto_hci_pmos_vdpowhe
+ vgpowhe   = presto_hci_pmos_vgpowhe
+ vdexphe   = presto_hci_pmos_vdexphe
+ eahe      = presto_hci_pmos_eahe
+ lexphe    = presto_hci_pmos_lexphe
+ lpowhe    = presto_hci_pmos_lpowhe
+ wpowhe    = presto_hci_pmos_wpowhe
+ vbsexphe  = presto_hci_pmos_vbsexphe
+ vc1he     = presto_hci_pmos_vc1he
+ vc2he     = presto_hci_pmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos_ll_10hv_dfrt

section pmos_ull_10hv_dfrt
include "soachecks_top.scs" section=pmos_ull_10hv_soa
if (enable_relimo == 1) {
apmos_ull_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.14 relimo_ratio20_a=relimo_ratio20_a_bti_pmos_ll_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos_ll_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos_ull_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos_ull_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apmos_lgo_nbti (d g s) relimo_aging_nbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_c=relimo_c_nbti_lgo relimo_intercept=relimo_intercept_nbti_lgo relimo_n=relimo_n_nbti_lgo
}
if (enable_esdsoa == 1) {
apmos_ull_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=1 enable=soa rule="esd_pmos_ull_Vt1=5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ull_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=2 enable=soa rule="esd_pmos_ull_Vt1>5p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
apmos_ull_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=3 enable=soa rule="esd_pmos_ull_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ull_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=4 enable=soa rule="esd_pmos_ull_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
apmos_ull_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=5 enable=soa rule="esd_pmos_ull_Vt1=5p7_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ull_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=6 enable=soa rule="esd_pmos_ull_Vt1>5p7_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 5.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=5.7
apmos_ull_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=7 enable=soa rule="esd_pmos_ull_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.5))-5.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ull_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=8 enable=soa rule="esd_pmos_ull_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.5)))) > 5.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=5.7
apmos_ull_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=9 enable=soa rule="esd_pmos_ull_Vt1=4p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-4.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ull_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=10 enable=soa rule="esd_pmos_ull_Vt1>4p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 4.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.9
apmos_ull_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos_ull_10hv ruleNum=11 enable=soa rule="esd_pmos_ull_=Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="(abs(V(s)-V(d)-4.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ull_10hv_esdchk_12 (s g s d) monitor4t enable=soa rule="esd_pmos_ull_>Vt1_Vgs>1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="absV(s-to-d) > 4.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=4.9
apmos_ull_10hv_esdchk_13 (g b) monitor2t enable=soa rule="esd_pmos_ull_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ull_10hv_esdchk_14 (g s) monitor2t enable=soa rule="esd_pmos_ull_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ull_10hv_esdchk_15 (g d) monitor2t enable=soa rule="esd_pmos_ull_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ull_10hv_esdchk_16 (b s) monitor2t enable=soa rule="esd_pmos_ull_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
apmos_ull_10hv_esdchk_17 (b d) monitor2t enable=soa rule="esd_pmos_ull_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.7
apmos_ull_10hv_esdchk_18 (b sub) monitor2t enable=soa rule="esd_pmos_ull_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ull_10hv_esdchk_19 (sub d) monitor2t enable=soa rule="esd_pmos_ull_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ull_10hv_esdchk_20 (d b) monitor2t enable=soa rule="esd_pmos_ull_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go1_k
+ a         = presto_nbti_go1_a
+ fstat     = presto_nbti_go1_fstat
+ n         = presto_nbti_go1_n
+ m         = presto_nbti_go1_m
+ vgexp     = presto_nbti_go1_vgexp
+ ea        = presto_nbti_go1_ea
+ lpow      = presto_nbti_go1_lpow
+ wpow      = presto_nbti_go1_wpow
+ vbxexp    = presto_nbti_go1_vbxexp
+ lexp      = presto_nbti_go1_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos_avth
+ bvth      = presto_hci_pmos_bvth
+ ai        = presto_hci_pmos_ai
+ bi        = presto_hci_pmos_bi
+ nvth      = presto_hci_pmos_n_vth
+ ni        = presto_hci_pmos_n_i
+ gammai    = presto_hci_pmos_gammai
+ alphamve  = presto_hci_pmos_alphamve
+ fstatmve  = presto_hci_pmos_fstatmve
+ vdpowmve  = presto_hci_pmos_vdpowmve
+ vgpowmve  = presto_hci_pmos_vgpowmve
+ vdexpmve  = presto_hci_pmos_vdexpmve
+ eamve     = presto_hci_pmos_eamve
+ lexpmve   = presto_hci_pmos_lexpmve
+ lpowmve   = presto_hci_pmos_lpowmve
+ wpowmve   = presto_hci_pmos_wpowmve
+ vbsexpmve = presto_hci_pmos_vbsexpmve
+ vc1mve    = presto_hci_pmos_vc1mve
+ vc2mve    = presto_hci_pmos_vc2mve
+ alphahe   = presto_hci_pmos_alphahe
+ fstathe   = presto_hci_pmos_fstathe
+ vdpowhe   = presto_hci_pmos_vdpowhe
+ vgpowhe   = presto_hci_pmos_vgpowhe
+ vdexphe   = presto_hci_pmos_vdexphe
+ eahe      = presto_hci_pmos_eahe
+ lexphe    = presto_hci_pmos_lexphe
+ lpowhe    = presto_hci_pmos_lpowhe
+ wpowhe    = presto_hci_pmos_wpowhe
+ vbsexphe  = presto_hci_pmos_vbsexphe
+ vc1he     = presto_hci_pmos_vc1he
+ vc2he     = presto_hci_pmos_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos_ull_10hv_dfrt

section pmos_ana_10hv_dfrt
include "soachecks_top.scs" section=pmos_ana_10hv_soa
if (enable_relimo == 1) {
apmos_ana_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.1 relimo_ratio20_a=relimo_ratio20_a_bti_pmos_ana_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos_ana_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos_ana_10hv relimo_probe_name=mpmos_ana_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ana_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ana_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ana_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ana_10hv relimo_c=relimo_c_1_hci_pmos_ana_10hv relimo_condvd=relimo_condvd_hci_pmos_ana_10hv relimo_condvg=relimo_condvg_hci_pmos_ana_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ana_10hv relimo_m=relimo_m_1_hci_pmos_ana_10hv relimo_n=relimo_n_1_hci_pmos_ana_10hv relimo_r=relimo_r_1_hci_pmos_ana_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos_ana_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos_ana_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ana_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ana_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ana_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ana_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ana_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ana_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ana_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ana_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ana_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ana_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ana_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ana_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ana_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ana_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ana_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ana_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ana_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ana_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ana_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ana_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ana_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ana_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ana_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ana_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ana_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ana_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ana_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ana_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ana_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ana_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ana_10hv relimo_vth=relimo_vth_hci_pmos_ana_10hv
apmos_ana_nbti (d g s) relimo_aging_nbti relimo_pbti_aging_open_flag=1 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_device_name=pmos_ana_10hv relimo_probe_name=mpmos_ana_10hv_i relimo_c=relimo_c_nbti_ana relimo_intercept=relimo_intercept_nbti_ana relimo_n=relimo_n_nbti_ana
apmos_ana_pbti (d g s b) relimo_aging_bti_pmos_ana relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=0 relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos_ana_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=1 enable=soa rule="esd_pmos_ana_Vt1=6p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-6.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ana_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=2 enable=soa rule="esd_pmos_ana_Vt1>6p6_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 6.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=6.6
apmos_ana_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=3 enable=soa rule="esd_pmos_ana_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-1.4*(V(s)-V(g)-0.0))-6.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ana_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=4 enable=soa rule="esd_pmos_ana_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-1.4*(V(s)-V(g)-0.0)))) > 6.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=6.6
apmos_ana_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=5 enable=soa rule="esd_pmos_ana_Vt1=7p3_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ana_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=6 enable=soa rule="esd_pmos_ana_Vt1>7p3_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 7.3 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.3
apmos_ana_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=7 enable=soa rule="esd_pmos_ana_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-0.5))-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ana_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=8 enable=soa rule="esd_pmos_ana_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-0.5)))) > 7.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=7.3
apmos_ana_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=9 enable=soa rule="esd_pmos_ana_Vt1=7p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-7.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ana_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=10 enable=soa rule="esd_pmos_ana_Vt1>7p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 7.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.2
apmos_ana_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=11 enable=soa rule="esd_pmos_ana_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-1.0))-7.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos_ana_10hv_esdchk_12 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=12 enable=soa rule="esd_pmos_ana_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-1.0)))) > 7.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=7.2
apmos_ana_10hv_esdchk_13 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=13 enable=soa rule="esd_pmos_ana_Vt1=7p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-7.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ana_10hv_esdchk_14 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=14 enable=soa rule="esd_pmos_ana_Vt1>7p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 7.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.1
apmos_ana_10hv_esdchk_15 (d g s b sub) monitor_esd_pmos_ana_10hv ruleNum=15 enable=soa rule="esd_pmos_ana_=Vt1_Vgs>1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="(abs(V(s)-V(d)-7.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos_ana_10hv_esdchk_16 (s g s d) monitor4t enable=soa rule="esd_pmos_ana_>Vt1_Vgs>1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="absV(s-to-d) > 7.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.1
apmos_ana_10hv_esdchk_17 (g b) monitor2t enable=soa rule="esd_pmos_ana_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ana_10hv_esdchk_18 (g s) monitor2t enable=soa rule="esd_pmos_ana_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ana_10hv_esdchk_19 (g d) monitor2t enable=soa rule="esd_pmos_ana_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
apmos_ana_10hv_esdchk_20 (b s) monitor2t enable=soa rule="esd_pmos_ana_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 7.6 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.6
apmos_ana_10hv_esdchk_21 (b d) monitor2t enable=soa rule="esd_pmos_ana_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 6.6 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.6
apmos_ana_10hv_esdchk_22 (b sub) monitor2t enable=soa rule="esd_pmos_ana_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ana_10hv_esdchk_23 (sub d) monitor2t enable=soa rule="esd_pmos_ana_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos_ana_10hv_esdchk_24 (d b) monitor2t enable=soa rule="esd_pmos_ana_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go1_ana_k
+ a         = presto_nbti_go1_ana_a
+ fstat     = presto_nbti_go1_ana_fstat
+ n         = presto_nbti_go1_ana_n
+ m         = presto_nbti_go1_ana_m
+ vgexp     = presto_nbti_go1_ana_vgexp
+ ea        = presto_nbti_go1_ana_ea
+ lpow      = presto_nbti_go1_ana_lpow
+ wpow      = presto_nbti_go1_ana_wpow
+ vbxexp    = presto_nbti_go1_ana_vbxexp
+ lexp      = presto_nbti_go1_ana_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go1_ana_k
+ a         = presto_pbti_go1_ana_a
+ fstat     = presto_pbti_go1_ana_fstat
+ n         = presto_pbti_go1_ana_n
+ m         = presto_pbti_go1_ana_m
+ vgexp     = presto_pbti_go1_ana_vgexp
+ ea        = presto_pbti_go1_ana_ea
+ lpow      = presto_pbti_go1_ana_lpow
+ wpow      = presto_pbti_go1_ana_wpow
+ vbxexp    = presto_pbti_go1_ana_vbxexp
+ lexp      = presto_pbti_go1_ana_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos_ana_avth
+ bvth      = presto_hci_pmos_ana_bvth
+ ai        = presto_hci_pmos_ana_ai
+ bi        = presto_hci_pmos_ana_bi
+ nvth      = presto_hci_pmos_ana_n_vth
+ ni        = presto_hci_pmos_ana_n_i
+ gammai    = presto_hci_pmos_ana_gammai
+ alphamve  = presto_hci_pmos_ana_alphamve
+ fstatmve  = presto_hci_pmos_ana_fstatmve
+ vdpowmve  = presto_hci_pmos_ana_vdpowmve
+ vgpowmve  = presto_hci_pmos_ana_vgpowmve
+ vdexpmve  = presto_hci_pmos_ana_vdexpmve
+ eamve     = presto_hci_pmos_ana_eamve
+ lexpmve   = presto_hci_pmos_ana_lexpmve
+ lpowmve   = presto_hci_pmos_ana_lpowmve
+ wpowmve   = presto_hci_pmos_ana_wpowmve
+ vbsexpmve = presto_hci_pmos_ana_vbsexpmve
+ vc1mve    = presto_hci_pmos_ana_vc1mve
+ vc2mve    = presto_hci_pmos_ana_vc2mve
+ alphahe   = presto_hci_pmos_ana_alphahe
+ fstathe   = presto_hci_pmos_ana_fstathe
+ vdpowhe   = presto_hci_pmos_ana_vdpowhe
+ vgpowhe   = presto_hci_pmos_ana_vgpowhe
+ vdexphe   = presto_hci_pmos_ana_vdexphe
+ eahe      = presto_hci_pmos_ana_eahe
+ lexphe    = presto_hci_pmos_ana_lexphe
+ lpowhe    = presto_hci_pmos_ana_lpowhe
+ wpowhe    = presto_hci_pmos_ana_wpowhe
+ vbsexphe  = presto_hci_pmos_ana_vbsexphe
+ vc1he     = presto_hci_pmos_ana_vc1he
+ vc2he     = presto_hci_pmos_ana_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos_ana_10hv_dfrt

section nmos3_zvt_10hv_dfrt
include "soachecks_top.scs" section=nmos3_zvt_10hv_soa
if (enable_relimo == 1) {
anmos3_zvt_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.15 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos3_zvt_10hv relimo_probe_name=mnmos3_zvt_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos3_zvt_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos3_zvt_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos3_zvt_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos3_zvt_10hv relimo_c=relimo_c_1_hci_nmos3_zvt_10hv relimo_condvd=relimo_condvd_hci_nmos3_zvt_10hv relimo_condvg=relimo_condvg_hci_nmos3_zvt_10hv relimo_intercept=relimo_intercept_1_hci_nmos3_zvt_10hv relimo_m=relimo_m_1_hci_nmos3_zvt_10hv relimo_n=relimo_n_1_hci_nmos3_zvt_10hv relimo_r=relimo_r_1_hci_nmos3_zvt_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos3_zvt_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos3_zvt_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos3_zvt_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos3_zvt_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos3_zvt_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos3_zvt_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos3_zvt_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos3_zvt_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos3_zvt_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos3_zvt_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos3_zvt_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos3_zvt_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos3_zvt_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos3_zvt_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos3_zvt_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos3_zvt_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos3_zvt_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos3_zvt_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos3_zvt_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos3_zvt_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos3_zvt_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos3_zvt_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos3_zvt_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos3_zvt_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos3_zvt_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos3_zvt_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos3_zvt_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos3_zvt_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos3_zvt_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos3_zvt_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos3_zvt_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos3_zvt_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos3_zvt_10hv relimo_vth=relimo_vth_hci_nmos3_zvt_10hv
anmos3_zvt_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos3_zvt_10hv relimo_probe_name=mnmos3_zvt_10hv_i
}
if (enable_esdsoa == 1) {
anmos3_zvt_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=1 enable=soa rule="esd_nmos3_zvt_Vt1=8p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos3_zvt_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=2 enable=soa rule="esd_nmos3_zvt_Vt1>8p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.2
anmos3_zvt_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=3 enable=soa rule="esd_nmos3_zvt_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-8.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
anmos3_zvt_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=4 enable=soa rule="esd_nmos3_zvt_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 8.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=8.2
anmos3_zvt_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=5 enable=soa rule="esd_nmos3_zvt_Vt1=8p2_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos3_zvt_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=6 enable=soa rule="esd_nmos3_zvt_Vt1>8p2_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.2
anmos3_zvt_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos3_zvt_10hv ruleNum=7 enable=soa rule="esd_nmos3_zvt_=Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="(abs(V(d)-V(s)-8.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
anmos3_zvt_10hv_esdchk_8 (g s d s) monitor4t enable=soa rule="esd_nmos3_zvt_>Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(d-to-s) > 8.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.2
anmos3_zvt_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_nmos3_zvt_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos3_zvt_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_nmos3_zvt_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 5.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.3
anmos3_zvt_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_nmos3_zvt_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 8.2 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=8.2
anmos3_zvt_10hv_esdchk_12 (s b) monitor2t enable=soa rule="esd_nmos3_zvt_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos3_zvt_10hv_esdchk_13 (d b) monitor2t enable=soa rule="esd_nmos3_zvt_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 8.2 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=8.2
anmos3_zvt_10hv_esdchk_14 (d sub) monitor2t enable=soa rule="esd_nmos3_zvt_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos3_zvt_10hv_esdchk_15 (sub b) monitor2t enable=soa rule="esd_nmos3_zvt_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos3_zvt_10hv_esdchk_16 (b d) monitor2t enable=soa rule="esd_nmos3_zvt_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos3_zvt_avth
+ bvth      = presto_hci_nmos3_zvt_bvth
+ ai        = presto_hci_nmos3_zvt_ai
+ bi        = presto_hci_nmos3_zvt_bi
+ nvth      = presto_hci_nmos3_zvt_n_vth
+ ni        = presto_hci_nmos3_zvt_n_i
+ gammai    = presto_hci_nmos3_zvt_gammai
+ alphamve  = presto_hci_nmos3_zvt_alphamve
+ fstatmve  = presto_hci_nmos3_zvt_fstatmve
+ vdpowmve  = presto_hci_nmos3_zvt_vdpowmve
+ vgpowmve  = presto_hci_nmos3_zvt_vgpowmve
+ vdexpmve  = presto_hci_nmos3_zvt_vdexpmve
+ eamve     = presto_hci_nmos3_zvt_eamve
+ lexpmve   = presto_hci_nmos3_zvt_lexpmve
+ lpowmve   = presto_hci_nmos3_zvt_lpowmve
+ wpowmve   = presto_hci_nmos3_zvt_wpowmve
+ vbsexpmve = presto_hci_nmos3_zvt_vbsexpmve
+ vc1mve    = presto_hci_nmos3_zvt_vc1mve
+ vc2mve    = presto_hci_nmos3_zvt_vc2mve
+ alphahe   = presto_hci_nmos3_zvt_alphahe
+ fstathe   = presto_hci_nmos3_zvt_fstathe
+ vdpowhe   = presto_hci_nmos3_zvt_vdpowhe
+ vgpowhe   = presto_hci_nmos3_zvt_vgpowhe
+ vdexphe   = presto_hci_nmos3_zvt_vdexphe
+ eahe      = presto_hci_nmos3_zvt_eahe
+ lexphe    = presto_hci_nmos3_zvt_lexphe
+ lpowhe    = presto_hci_nmos3_zvt_lpowhe
+ wpowhe    = presto_hci_nmos3_zvt_wpowhe
+ vbsexphe  = presto_hci_nmos3_zvt_vbsexphe
+ vc1he     = presto_hci_nmos3_zvt_vc1he
+ vc2he     = presto_hci_nmos3_zvt_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos3_zvt_10hv_dfrt

section nsrampg_10hv_dfrt
endsection nsrampg_10hv_dfrt

section nsrampd_10hv_dfrt
endsection nsrampd_10hv_dfrt

section psrampu_10hv_dfrt
endsection psrampu_10hv_dfrt

section nmos5_10hv_dfrt
include "soachecks_top.scs" section=nmos5_10hv_soa
if (enable_relimo == 1) {
anmos5_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.23 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos5_10hv relimo_probe_name=mnmos5_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos5_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos5_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos5_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos5_10hv relimo_c=relimo_c_1_hci_nmos5_10hv relimo_condvd=relimo_condvd_hci_nmos5_10hv relimo_condvg=relimo_condvg_hci_nmos5_10hv relimo_intercept=relimo_intercept_1_hci_nmos5_10hv relimo_m=relimo_m_1_hci_nmos5_10hv relimo_n=relimo_n_1_hci_nmos5_10hv relimo_r=relimo_r_1_hci_nmos5_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos5_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos5_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos5_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos5_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos5_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos5_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos5_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos5_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos5_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos5_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos5_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos5_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos5_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos5_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos5_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos5_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos5_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos5_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos5_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos5_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos5_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos5_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos5_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos5_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos5_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos5_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos5_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos5_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos5_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos5_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos5_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos5_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos5_10hv relimo_vth=relimo_vth_hci_nmos5_10hv
anmos5_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos5_10hv relimo_probe_name=mnmos5_10hv_i
}
if (enable_esdsoa == 1) {
anmos5_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=1 enable=soa rule="esd_nmos5_Vt1=12p6_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-12.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=2 enable=soa rule="esd_nmos5_Vt1>12p6_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 12.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=12.6 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=3 enable=soa rule="esd_nmos5_=Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))-12.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=4 enable=soa rule="esd_nmos5_>Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))) > 12.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=12.6 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=5 enable=soa rule="esd_nmos5_Vt1=12p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-12.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=6 enable=soa rule="esd_nmos5_Vt1>12p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 12.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=12.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=7 enable=soa rule="esd_nmos5_=Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))-12.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=8 enable=soa rule="esd_nmos5_>Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))) > 12.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=12.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=9 enable=soa rule="esd_nmos5_Vt1=12p1_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-12.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=10 enable=soa rule="esd_nmos5_Vt1>12p1_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 12.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=12.1 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=11 enable=soa rule="esd_nmos5_=Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(3.6*(V(g)-V(s)-1.0))-12.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=12 enable=soa rule="esd_nmos5_>Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(3.6*(V(g)-V(s)-1.0))) > 12.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=12.1 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=13 enable=soa rule="esd_nmos5_Vt1=10p3_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=14 enable=soa rule="esd_nmos5_Vt1>10p3_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=15 enable=soa rule="esd_nmos5_=Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))-10.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=16 enable=soa rule="esd_nmos5_>Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))) > 10.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=10.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos5_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=17 enable=soa rule="esd_nmos5_Vt1=10p2_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=18 enable=soa rule="esd_nmos5_Vt1>10p2_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=19 enable=soa rule="esd_nmos5_=Vt1_Vgs>2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="(abs(V(d)-V(s)-10.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_20 (g s d s b s) monitor6t enable=soa rule="esd_nmos5_>Vt1_Vgs>2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(d-to-s) > 10.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos5_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=20 enable=soa rule="esd_nmos5_Vt1=10p2_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-10.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=21 enable=soa rule="esd_nmos5_Vt1>10p2_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 10.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=10.2 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=22 enable=soa rule="esd_nmos5_=Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))-10.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=23 enable=soa rule="esd_nmos5_>Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(2.4*(V(g)-V(s)-0.0))) > 10.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=10.2 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=24 enable=soa rule="esd_nmos5_Vt1=9p0_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-9.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=25 enable=soa rule="esd_nmos5_Vt1>9p0_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 9.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=26 enable=soa rule="esd_nmos5_=Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(1.8*(V(g)-V(s)-0.5))-9.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=27 enable=soa rule="esd_nmos5_>Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(1.8*(V(g)-V(s)-0.5))) > 9.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=9.0 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=28 enable=soa rule="esd_nmos5_Vt1=8p1_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-8.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=29 enable=soa rule="esd_nmos5_Vt1>8p1_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 8.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=8.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=30 enable=soa rule="esd_nmos5_=Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-1.0))-8.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_32 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=31 enable=soa rule="esd_nmos5_>Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-1.0))) > 8.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=8.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=32 enable=soa rule="esd_nmos5_Vt1=7p9_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-7.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=33 enable=soa rule="esd_nmos5_Vt1>7p9_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 7.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=34 enable=soa rule="esd_nmos5_=Vt1_Vgs_1p5_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))-7.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_36 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=35 enable=soa rule="esd_nmos5_>Vt1_Vgs_1p5_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(0.2*(V(g)-V(s)-1.5))) > 7.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=7.9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=36 enable=soa rule="esd_nmos5_Vt1=7p8_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-7.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=37 enable=soa rule="esd_nmos5_Vt1>7p8_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 7.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=38 enable=soa rule="esd_nmos5_=Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(0.5*(V(g)-V(s)-2.0))-7.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_40 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=39 enable=soa rule="esd_nmos5_>Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(0.5*(V(g)-V(s)-2.0))) > 7.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=7.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos5_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=40 enable=soa rule="esd_nmos5_Vt1=7p3_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=41 enable=soa rule="esd_nmos5_Vt1>7p3_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 7.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.3 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos5_10hv ruleNum=42 enable=soa rule="esd_nmos5_=Vt1_Vgs>3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="(abs(V(d)-V(s)-7.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_44 (g s d s b s) monitor6t enable=soa rule="esd_nmos5_>Vt1_Vgs>3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(d-to-s) > 7.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=7.3 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos5_10hv_esdchk_45 (g b) monitor2t enable=soa rule="esd_nmos5_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos5_10hv_esdchk_46 (g s) monitor2t enable=soa rule="esd_nmos5_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos5_10hv_esdchk_47 (g d) monitor2t enable=soa rule="esd_nmos5_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos5_10hv_esdchk_48 (s b) monitor2t enable=soa rule="esd_nmos5_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos5_10hv_esdchk_49 (d b) monitor2t enable=soa rule="esd_nmos5_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 12.6 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=12.6
anmos5_10hv_esdchk_50 (d sub) monitor2t enable=soa rule="esd_nmos5_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos5_10hv_esdchk_51 (sub b) monitor2t enable=soa rule="esd_nmos5_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos5_10hv_esdchk_52 (b d) monitor2t enable=soa rule="esd_nmos5_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos5_avth
+ bvth      = presto_hci_nmos5_bvth
+ ai        = presto_hci_nmos5_ai
+ bi        = presto_hci_nmos5_bi
+ nvth      = presto_hci_nmos5_n_vth
+ ni        = presto_hci_nmos5_n_i
+ gammai    = presto_hci_nmos5_gammai
+ alphamve  = presto_hci_nmos5_alphamve
+ fstatmve  = presto_hci_nmos5_fstatmve
+ vdpowmve  = presto_hci_nmos5_vdpowmve
+ vgpowmve  = presto_hci_nmos5_vgpowmve
+ vdexpmve  = presto_hci_nmos5_vdexpmve
+ eamve     = presto_hci_nmos5_eamve
+ lexpmve   = presto_hci_nmos5_lexpmve
+ lpowmve   = presto_hci_nmos5_lpowmve
+ wpowmve   = presto_hci_nmos5_wpowmve
+ vbsexpmve = presto_hci_nmos5_vbsexpmve
+ vc1mve    = presto_hci_nmos5_vc1mve
+ vc2mve    = presto_hci_nmos5_vc2mve
+ alphahe   = presto_hci_nmos5_alphahe
+ fstathe   = presto_hci_nmos5_fstathe
+ vdpowhe   = presto_hci_nmos5_vdpowhe
+ vgpowhe   = presto_hci_nmos5_vgpowhe
+ vdexphe   = presto_hci_nmos5_vdexphe
+ eahe      = presto_hci_nmos5_eahe
+ lexphe    = presto_hci_nmos5_lexphe
+ lpowhe    = presto_hci_nmos5_lpowhe
+ wpowhe    = presto_hci_nmos5_wpowhe
+ vbsexphe  = presto_hci_nmos5_vbsexphe
+ vc1he     = presto_hci_nmos5_vc1he
+ vc2he     = presto_hci_nmos5_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos5_10hv_dfrt

section pmos5_10hv_dfrt
include "soachecks_top.scs" section=pmos5_10hv_soa
if (enable_relimo == 1) {
apmos5_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.28 relimo_ratio20_a=relimo_ratio20_a_bti_pmos5_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos5_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos5_10hv relimo_probe_name=mpmos5_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos5_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos5_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos5_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos5_10hv relimo_c=relimo_c_1_hci_pmos5_10hv relimo_condvd=relimo_condvd_hci_pmos5_10hv relimo_condvg=relimo_condvg_hci_pmos5_10hv relimo_intercept=relimo_intercept_1_hci_pmos5_10hv relimo_m=relimo_m_1_hci_pmos5_10hv relimo_n=relimo_n_1_hci_pmos5_10hv relimo_r=relimo_r_1_hci_pmos5_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos5_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos5_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos5_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos5_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos5_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos5_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos5_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos5_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos5_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos5_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos5_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos5_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos5_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos5_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos5_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos5_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos5_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos5_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos5_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos5_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos5_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos5_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos5_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos5_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos5_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos5_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos5_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos5_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos5_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos5_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos5_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos5_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos5_10hv relimo_vth=relimo_vth_hci_pmos5_10hv
apmos5_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos5_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=1 enable=soa rule="esd_pmos5_Vt1=9p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-9.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos5_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=2 enable=soa rule="esd_pmos5_Vt1>9p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 9.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.5
apmos5_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=3 enable=soa rule="esd_pmos5_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.6*(V(s)-V(g)-0.0))-9.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos5_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=4 enable=soa rule="esd_pmos5_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(-0.6*(V(s)-V(g)-0.0)))) > 9.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=9.5
apmos5_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=5 enable=soa rule="esd_pmos5_Vt1=9p8_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-9.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos5_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=6 enable=soa rule="esd_pmos5_Vt1>9p8_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 9.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.8
apmos5_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos5_10hv ruleNum=7 enable=soa rule="esd_pmos5_=Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="(abs(V(s)-V(d)-9.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos5_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pmos5_>Vt1_Vgs>0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="absV(s-to-d) > 9.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=9.8
apmos5_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_pmos5_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos5_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_pmos5_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos5_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_pmos5_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos5_10hv_esdchk_12 (b s) monitor2t enable=soa rule="esd_pmos5_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos5_10hv_esdchk_13 (b d) monitor2t enable=soa rule="esd_pmos5_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 9.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.5
apmos5_10hv_esdchk_14 (b sub) monitor2t enable=soa rule="esd_pmos5_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos5_10hv_esdchk_15 (sub d) monitor2t enable=soa rule="esd_pmos5_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos5_10hv_esdchk_16 (d b) monitor2t enable=soa rule="esd_pmos5_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos5_avth
+ bvth      = presto_hci_pmos5_bvth
+ ai        = presto_hci_pmos5_ai
+ bi        = presto_hci_pmos5_bi
+ nvth      = presto_hci_pmos5_n_vth
+ ni        = presto_hci_pmos5_n_i
+ gammai    = presto_hci_pmos5_gammai
+ alphamve  = presto_hci_pmos5_alphamve
+ fstatmve  = presto_hci_pmos5_fstatmve
+ vdpowmve  = presto_hci_pmos5_vdpowmve
+ vgpowmve  = presto_hci_pmos5_vgpowmve
+ vdexpmve  = presto_hci_pmos5_vdexpmve
+ eamve     = presto_hci_pmos5_eamve
+ lexpmve   = presto_hci_pmos5_lexpmve
+ lpowmve   = presto_hci_pmos5_lpowmve
+ wpowmve   = presto_hci_pmos5_wpowmve
+ vbsexpmve = presto_hci_pmos5_vbsexpmve
+ vc1mve    = presto_hci_pmos5_vc1mve
+ vc2mve    = presto_hci_pmos5_vc2mve
+ alphahe   = presto_hci_pmos5_alphahe
+ fstathe   = presto_hci_pmos5_fstathe
+ vdpowhe   = presto_hci_pmos5_vdpowhe
+ vgpowhe   = presto_hci_pmos5_vgpowhe
+ vdexphe   = presto_hci_pmos5_vdexphe
+ eahe      = presto_hci_pmos5_eahe
+ lexphe    = presto_hci_pmos5_lexphe
+ lpowhe    = presto_hci_pmos5_lpowhe
+ wpowhe    = presto_hci_pmos5_wpowhe
+ vbsexphe  = presto_hci_pmos5_vbsexphe
+ vc1he     = presto_hci_pmos5_vc1he
+ vc2he     = presto_hci_pmos5_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos5_10hv_dfrt

section nmos10_10hv_dfrt
include "soachecks_top.scs" section=nmos10_10hv_soa
if (enable_relimo == 1) {
anmos10_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=0.27 relimo_ratio20_a=1 relimo_ratio20_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos10_10hv relimo_probe_name=mnmos10_10hv_i relimo_a_gm=relimo_a_gm_1_hci_nmos10_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos10_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos10_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos10_10hv relimo_c=relimo_c_1_hci_nmos10_10hv relimo_condvd=relimo_condvd_hci_nmos10_10hv relimo_condvg=relimo_condvg_hci_nmos10_10hv relimo_intercept=relimo_intercept_1_hci_nmos10_10hv relimo_m=relimo_m_1_hci_nmos10_10hv relimo_n=relimo_n_1_hci_nmos10_10hv relimo_r=relimo_r_1_hci_nmos10_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos10_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos10_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos10_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos10_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos10_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos10_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos10_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos10_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos10_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos10_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos10_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos10_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos10_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos10_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos10_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos10_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos10_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos10_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos10_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos10_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos10_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos10_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos10_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos10_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos10_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos10_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos10_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos10_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos10_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos10_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos10_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos10_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos10_10hv relimo_vth=relimo_vth_hci_nmos10_10hv
anmos10_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos10_10hv relimo_probe_name=mnmos10_10hv_i
}
if (enable_esdsoa == 1) {
anmos10_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=1 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=2 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=3 enable=soa rule="esd_nmos10_=Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=4 enable=soa rule="esd_nmos10_>Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=5 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=6 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=7 enable=soa rule="esd_nmos10_=Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=8 enable=soa rule="esd_nmos10_>Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=9 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=10 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=11 enable=soa rule="esd_nmos10_=Vt1_Vgs_1p0_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=12 enable=soa rule="esd_nmos10_>Vt1_Vgs_1p0_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-1.0))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=13 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=14 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=15 enable=soa rule="esd_nmos10_=Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.0))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=16 enable=soa rule="esd_nmos10_>Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-2.0))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=17 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=18 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=19 enable=soa rule="esd_nmos10_=Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-3.0))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=20 enable=soa rule="esd_nmos10_>Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-3.0))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=21 enable=soa rule="esd_nmos10_Vt1=24p5_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=22 enable=soa rule="esd_nmos10_Vt1>24p5_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.5 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=23 enable=soa rule="esd_nmos10_=Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-4.0))-24.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=24 enable=soa rule="esd_nmos10_>Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-4.0))) > 24.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.5 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=25 enable=soa rule="esd_nmos10_Vt1=24p1_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-24.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=26 enable=soa rule="esd_nmos10_Vt1>24p1_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 24.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=24.1 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=27 enable=soa rule="esd_nmos10_=Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-5.0))-24.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=28 enable=soa rule="esd_nmos10_>Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-5.0))) > 24.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=24.1 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=29 enable=soa rule="esd_nmos10_Vt1=23p1_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-23.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=30 enable=soa rule="esd_nmos10_Vt1>23p1_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 23.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=23.1 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=31 enable=soa rule="esd_nmos10_=Vt1_Vgs_6p0_7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-6.0))-23.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_32 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=32 enable=soa rule="esd_nmos10_>Vt1_Vgs_6p0_7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-6.0))) > 23.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=23.1 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos10_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=33 enable=soa rule="esd_nmos10_Vt1=21p9_Vgs7p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-21.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=34 enable=soa rule="esd_nmos10_Vt1>21p9_Vgs7p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 21.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=21.9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=35 enable=soa rule="esd_nmos10_=Vt1_Vgs>7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-21.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_36 (g s d s b s) monitor6t enable=soa rule="esd_nmos10_>Vt1_Vgs>7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 21.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=21.9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos10_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=36 enable=soa rule="esd_nmos10_Vt1=18p5_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-18.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=37 enable=soa rule="esd_nmos10_Vt1>18p5_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 18.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=18.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=38 enable=soa rule="esd_nmos10_=Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))-18.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_40 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=39 enable=soa rule="esd_nmos10_>Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-0.0))) > 18.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=18.5 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=40 enable=soa rule="esd_nmos10_Vt1=18p2_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-18.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=41 enable=soa rule="esd_nmos10_Vt1>18p2_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 18.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=18.2 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=42 enable=soa rule="esd_nmos10_=Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(1.0*(V(g)-V(s)-0.5))-18.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_44 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=43 enable=soa rule="esd_nmos10_>Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(1.0*(V(g)-V(s)-0.5))) > 18.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=18.2 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_45 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=44 enable=soa rule="esd_nmos10_Vt1=17p7_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-17.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_46 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=45 enable=soa rule="esd_nmos10_Vt1>17p7_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 17.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=17.7 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_47 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=46 enable=soa rule="esd_nmos10_=Vt1_Vgs_1p0_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(0.9*(V(g)-V(s)-1.0))-17.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_48 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=47 enable=soa rule="esd_nmos10_>Vt1_Vgs_1p0_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(0.9*(V(g)-V(s)-1.0))) > 17.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=17.7 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_49 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=48 enable=soa rule="esd_nmos10_Vt1=16p8_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-16.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_50 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=49 enable=soa rule="esd_nmos10_Vt1>16p8_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 16.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=16.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_51 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=50 enable=soa rule="esd_nmos10_=Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(0.7*(V(g)-V(s)-2.0))-16.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_52 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=51 enable=soa rule="esd_nmos10_>Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(0.7*(V(g)-V(s)-2.0))) > 16.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=16.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_53 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=52 enable=soa rule="esd_nmos10_Vt1=16p1_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-16.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_54 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=53 enable=soa rule="esd_nmos10_Vt1>16p1_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 16.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=16.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_55 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=54 enable=soa rule="esd_nmos10_=Vt1_Vgs_3p0_4p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(1.1*(V(g)-V(s)-3.0))-16.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_56 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=55 enable=soa rule="esd_nmos10_>Vt1_Vgs_3p0_4p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(1.1*(V(g)-V(s)-3.0))) > 16.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=16.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_57 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=56 enable=soa rule="esd_nmos10_Vt1=15p0_Vgs4p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-15.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_58 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=57 enable=soa rule="esd_nmos10_Vt1>15p0_Vgs4p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 15.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=15.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_59 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=58 enable=soa rule="esd_nmos10_=Vt1_Vgs_4p0_5p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-4.0))-15.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_60 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=59 enable=soa rule="esd_nmos10_>Vt1_Vgs_4p0_5p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-4.0))) > 15.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=15.0 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_61 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=60 enable=soa rule="esd_nmos10_Vt1=13p8_Vgs5p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-13.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_62 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=61 enable=soa rule="esd_nmos10_Vt1>13p8_Vgs5p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 13.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=13.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_63 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=62 enable=soa rule="esd_nmos10_=Vt1_Vgs_5p0_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(0.7*(V(g)-V(s)-5.0))-13.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_64 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=63 enable=soa rule="esd_nmos10_>Vt1_Vgs_5p0_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(0.7*(V(g)-V(s)-5.0))) > 13.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=13.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_65 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=64 enable=soa rule="esd_nmos10_Vt1=13p1_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-13.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_66 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=65 enable=soa rule="esd_nmos10_Vt1>13p1_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 13.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=13.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_67 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=66 enable=soa rule="esd_nmos10_=Vt1_Vgs_6p0_7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(0.7*(V(g)-V(s)-6.0))-13.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_68 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=67 enable=soa rule="esd_nmos10_>Vt1_Vgs_6p0_7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(0.7*(V(g)-V(s)-6.0))) > 13.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=13.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos10_10hv_esdchk_69 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=68 enable=soa rule="esd_nmos10_Vt1=12p4_Vgs7p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-12.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_70 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=69 enable=soa rule="esd_nmos10_Vt1>12p4_Vgs7p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 12.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=12.4 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_71 (d g s b sub) monitor_esd_nmos10_10hv ruleNum=70 enable=soa rule="esd_nmos10_=Vt1_Vgs>7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-12.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_72 (g s d s b s) monitor6t enable=soa rule="esd_nmos10_>Vt1_Vgs>7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 12.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=12.4 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos10_10hv_esdchk_73 (g b) monitor2t enable=soa rule="esd_nmos10_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos10_10hv_esdchk_74 (g s) monitor2t enable=soa rule="esd_nmos10_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos10_10hv_esdchk_75 (g d) monitor2t enable=soa rule="esd_nmos10_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 24.5 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=24.5
anmos10_10hv_esdchk_76 (s b) monitor2t enable=soa rule="esd_nmos10_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos10_10hv_esdchk_77 (d b) monitor2t enable=soa rule="esd_nmos10_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 24.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=24.5
anmos10_10hv_esdchk_78 (d sub) monitor2t enable=soa rule="esd_nmos10_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos10_10hv_esdchk_79 (sub b) monitor2t enable=soa rule="esd_nmos10_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos10_10hv_esdchk_80 (b d) monitor2t enable=soa rule="esd_nmos10_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = 1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_nmos10_avth
+ bvth      = presto_hci_nmos10_bvth
+ ai        = presto_hci_nmos10_ai
+ bi        = presto_hci_nmos10_bi
+ nvth      = presto_hci_nmos10_n_vth
+ ni        = presto_hci_nmos10_n_i
+ gammai    = presto_hci_nmos10_gammai
+ alphamve  = presto_hci_nmos10_alphamve
+ fstatmve  = presto_hci_nmos10_fstatmve
+ vdpowmve  = presto_hci_nmos10_vdpowmve
+ vgpowmve  = presto_hci_nmos10_vgpowmve
+ vdexpmve  = presto_hci_nmos10_vdexpmve
+ eamve     = presto_hci_nmos10_eamve
+ lexpmve   = presto_hci_nmos10_lexpmve
+ lpowmve   = presto_hci_nmos10_lpowmve
+ wpowmve   = presto_hci_nmos10_wpowmve
+ vbsexpmve = presto_hci_nmos10_vbsexpmve
+ vc1mve    = presto_hci_nmos10_vc1mve
+ vc2mve    = presto_hci_nmos10_vc2mve
+ alphahe   = presto_hci_nmos10_alphahe
+ fstathe   = presto_hci_nmos10_fstathe
+ vdpowhe   = presto_hci_nmos10_vdpowhe
+ vgpowhe   = presto_hci_nmos10_vgpowhe
+ vdexphe   = presto_hci_nmos10_vdexphe
+ eahe      = presto_hci_nmos10_eahe
+ lexphe    = presto_hci_nmos10_lexphe
+ lpowhe    = presto_hci_nmos10_lpowhe
+ wpowhe    = presto_hci_nmos10_wpowhe
+ vbsexphe  = presto_hci_nmos10_vbsexphe
+ vc1he     = presto_hci_nmos10_vc1he
+ vc2he     = presto_hci_nmos10_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection nmos10_10hv_dfrt

section pmos10_10hv_dfrt
include "soachecks_top.scs" section=pmos10_10hv_soa
if (enable_relimo == 1) {
apmos10_10hv_hci1 (d g s) relimo_aging_hci1 relimo_vgsCutoff=-0.29 relimo_ratio20_a=relimo_ratio20_a_bti_pmos10_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos10_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=pmos10_10hv relimo_probe_name=mpmos10_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos10_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos10_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos10_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos10_10hv relimo_c=relimo_c_1_hci_pmos10_10hv relimo_condvd=relimo_condvd_hci_pmos10_10hv relimo_condvg=relimo_condvg_hci_pmos10_10hv relimo_intercept=relimo_intercept_1_hci_pmos10_10hv relimo_m=relimo_m_1_hci_pmos10_10hv relimo_n=relimo_n_1_hci_pmos10_10hv relimo_r=relimo_r_1_hci_pmos10_10hv relimo_ratio1_a=relimo_ratio1_a_hci_pmos10_10hv relimo_ratio1_b=relimo_ratio1_b_hci_pmos10_10hv relimo_ratio2_a=relimo_ratio2_a_hci_pmos10_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos10_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos10_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos10_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos10_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos10_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos10_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos10_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos10_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos10_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos10_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos10_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos10_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos10_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos10_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos10_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos10_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos10_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos10_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos10_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos10_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos10_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos10_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos10_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos10_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos10_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos10_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos10_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos10_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos10_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos10_10hv relimo_vth=relimo_vth_hci_pmos10_10hv
apmos10_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos10_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=1 enable=soa rule="esd_pmos10_Vt1=20p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-20.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=2 enable=soa rule="esd_pmos10_Vt1>20p7_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 20.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=20.7
apmos10_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=3 enable=soa rule="esd_pmos10_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.0))-20.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos10_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=4 enable=soa rule="esd_pmos10_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-0.0)))) > 20.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=20.7
apmos10_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=5 enable=soa rule="esd_pmos10_Vt1=19p9_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=6 enable=soa rule="esd_pmos10_Vt1>19p9_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.9
apmos10_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=7 enable=soa rule="esd_pmos10_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.5))-19.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos10_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=8 enable=soa rule="esd_pmos10_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.5)))) > 19.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=19.9
apmos10_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=9 enable=soa rule="esd_pmos10_Vt1=19p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=10 enable=soa rule="esd_pmos10_Vt1>19p9_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.9
apmos10_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=11 enable=soa rule="esd_pmos10_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-1.0))-19.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos10_10hv_esdchk_12 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=12 enable=soa rule="esd_pmos10_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(0.2*(V(s)-V(g)-1.0)))) > 19.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=19.9
apmos10_10hv_esdchk_13 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=13 enable=soa rule="esd_pmos10_Vt1=19p8_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_14 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=14 enable=soa rule="esd_pmos10_Vt1>19p8_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.8
apmos10_10hv_esdchk_15 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=15 enable=soa rule="esd_pmos10_=Vt1_Vgs_1p5_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.5))-19.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos10_10hv_esdchk_16 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=16 enable=soa rule="esd_pmos10_>Vt1_Vgs_1p5_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-1.5)))) > 19.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=19.8
apmos10_10hv_esdchk_17 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=17 enable=soa rule="esd_pmos10_Vt1=19p8_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-19.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_18 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=18 enable=soa rule="esd_pmos10_Vt1>19p8_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 19.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.8
apmos10_10hv_esdchk_19 (d g s b sub) monitor_esd_pmos10_10hv ruleNum=19 enable=soa rule="esd_pmos10_=Vt1_Vgs>3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="(abs(V(s)-V(d)-19.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos10_10hv_esdchk_20 (s g s d) monitor4t enable=soa rule="esd_pmos10_>Vt1_Vgs>3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="absV(s-to-d) > 19.8 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=19.8
apmos10_10hv_esdchk_21 (g b) monitor2t enable=soa rule="esd_pmos10_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos10_10hv_esdchk_22 (g s) monitor2t enable=soa rule="esd_pmos10_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos10_10hv_esdchk_23 (g d) monitor2t enable=soa rule="esd_pmos10_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 20.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=20.7
apmos10_10hv_esdchk_24 (b s) monitor2t enable=soa rule="esd_pmos10_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos10_10hv_esdchk_25 (b d) monitor2t enable=soa rule="esd_pmos10_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 20.7 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=20.7
apmos10_10hv_esdchk_26 (b sub) monitor2t enable=soa rule="esd_pmos10_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos10_10hv_esdchk_27 (sub d) monitor2t enable=soa rule="esd_pmos10_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos10_10hv_esdchk_28 (d b) monitor2t enable=soa rule="esd_pmos10_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s b) mhcilite2
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_hci_active
+ avth      = presto_hci_pmos10_avth
+ bvth      = presto_hci_pmos10_bvth
+ ai        = presto_hci_pmos10_ai
+ bi        = presto_hci_pmos10_bi
+ nvth      = presto_hci_pmos10_n_vth
+ ni        = presto_hci_pmos10_n_i
+ gammai    = presto_hci_pmos10_gammai
+ alphamve  = presto_hci_pmos10_alphamve
+ fstatmve  = presto_hci_pmos10_fstatmve
+ vdpowmve  = presto_hci_pmos10_vdpowmve
+ vgpowmve  = presto_hci_pmos10_vgpowmve
+ vdexpmve  = presto_hci_pmos10_vdexpmve
+ eamve     = presto_hci_pmos10_eamve
+ lexpmve   = presto_hci_pmos10_lexpmve
+ lpowmve   = presto_hci_pmos10_lpowmve
+ wpowmve   = presto_hci_pmos10_wpowmve
+ vbsexpmve = presto_hci_pmos10_vbsexpmve
+ vc1mve    = presto_hci_pmos10_vc1mve
+ vc2mve    = presto_hci_pmos10_vc2mve
+ alphahe   = presto_hci_pmos10_alphahe
+ fstathe   = presto_hci_pmos10_fstathe
+ vdpowhe   = presto_hci_pmos10_vdpowhe
+ vgpowhe   = presto_hci_pmos10_vgpowhe
+ vdexphe   = presto_hci_pmos10_vdexphe
+ eahe      = presto_hci_pmos10_eahe
+ lexphe    = presto_hci_pmos10_lexphe
+ lpowhe    = presto_hci_pmos10_lpowhe
+ wpowhe    = presto_hci_pmos10_wpowhe
+ vbsexphe  = presto_hci_pmos10_vbsexphe
+ vc1he     = presto_hci_pmos10_vc1he
+ vc2he     = presto_hci_pmos10_vc2he
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = hcidamage
+ dicrit    = presto_ishiftcrit
+ dvtcrit   = presto_vtshiftcrit
}
endsection pmos10_10hv_dfrt

section nmos45_10hv_dfrt
include "soachecks_top.scs" section=nmos45b_10hv_soa
if (enable_esdsoa == 1) {
anmos45_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=1 enable=soa rule="esd_nmos45_Vt1=76p3_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-76.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=2 enable=soa rule="esd_nmos45_Vt1>76p3_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 76.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=76.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=3 enable=soa rule="esd_nmos45_=Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-76.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=4 enable=soa rule="esd_nmos45_>Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 76.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=76.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=5 enable=soa rule="esd_nmos45_Vt1=76p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-76.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=6 enable=soa rule="esd_nmos45_Vt1>76p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 76.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=76.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=7 enable=soa rule="esd_nmos45_=Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))-76.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=8 enable=soa rule="esd_nmos45_>Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))) > 76.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=76.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=9 enable=soa rule="esd_nmos45_Vt1=76p1_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-76.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=10 enable=soa rule="esd_nmos45_Vt1>76p1_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 76.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=76.1 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=11 enable=soa rule="esd_nmos45_=Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(3.8*(V(g)-V(s)-1.0))-76.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=12 enable=soa rule="esd_nmos45_>Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(3.8*(V(g)-V(s)-1.0))) > 76.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=76.1 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=13 enable=soa rule="esd_nmos45_Vt1=74p2_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-74.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=14 enable=soa rule="esd_nmos45_Vt1>74p2_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 74.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=74.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=15 enable=soa rule="esd_nmos45_=Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(2.4*(V(g)-V(s)-1.5))-74.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=16 enable=soa rule="esd_nmos45_>Vt1_Vgs_1p5_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(2.4*(V(g)-V(s)-1.5))) > 74.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=74.2 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=17 enable=soa rule="esd_nmos45_Vt1=73p0_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-73.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=18 enable=soa rule="esd_nmos45_Vt1>73p0_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 73.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=73.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=19 enable=soa rule="esd_nmos45_=Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(5.2*(V(g)-V(s)-2.0))-73.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=20 enable=soa rule="esd_nmos45_>Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(5.2*(V(g)-V(s)-2.0))) > 73.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=73.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=21 enable=soa rule="esd_nmos45_Vt1=67p8_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-67.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=22 enable=soa rule="esd_nmos45_Vt1>67p8_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 67.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=67.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=23 enable=soa rule="esd_nmos45_=Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(4.6*(V(g)-V(s)-3.0))-67.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=24 enable=soa rule="esd_nmos45_>Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(4.6*(V(g)-V(s)-3.0))) > 67.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=67.8 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=25 enable=soa rule="esd_nmos45_Vt1=63p2_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=26 enable=soa rule="esd_nmos45_Vt1>63p2_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=27 enable=soa rule="esd_nmos45_=Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(6.6*(V(g)-V(s)-4.0))-63.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=28 enable=soa rule="esd_nmos45_>Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(6.6*(V(g)-V(s)-4.0))) > 63.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.2 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=29 enable=soa rule="esd_nmos45_Vt1=56p6_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=30 enable=soa rule="esd_nmos45_Vt1>56p6_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 56.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=56.6 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=31 enable=soa rule="esd_nmos45_=Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(12.0*(V(g)-V(s)-5.0))-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_32 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=32 enable=soa rule="esd_nmos45_>Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(12.0*(V(g)-V(s)-5.0))) > 56.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=56.6 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=33 enable=soa rule="esd_nmos45_Vt1=44p6_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=34 enable=soa rule="esd_nmos45_Vt1>44p6_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 44.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=44.6 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=35 enable=soa rule="esd_nmos45_=Vt1_Vgs_6p0_7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))-44.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_36 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=36 enable=soa rule="esd_nmos45_>Vt1_Vgs_6p0_7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.7*(V(g)-V(s)-6.0))) > 44.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=44.6 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=37 enable=soa rule="esd_nmos45_Vt1=37p9_Vgs7p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-37.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=38 enable=soa rule="esd_nmos45_Vt1>37p9_Vgs7p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 37.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=37.9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=39 enable=soa rule="esd_nmos45_=Vt1_Vgs>7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-37.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_40 (g s d s b s) monitor6t enable=soa rule="esd_nmos45_>Vt1_Vgs>7p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 37.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=37.9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=40 enable=soa rule="esd_nmos45_Vt1=72p0_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-72.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=41 enable=soa rule="esd_nmos45_Vt1>72p0_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 72.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=72.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=42 enable=soa rule="esd_nmos45_=Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-1.0*(V(g)-V(s)-0.0))-72.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_44 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=43 enable=soa rule="esd_nmos45_>Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-1.0*(V(g)-V(s)-0.0))) > 72.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=72.0 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_45 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=44 enable=soa rule="esd_nmos45_Vt1=72p5_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-72.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_46 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=45 enable=soa rule="esd_nmos45_Vt1>72p5_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 72.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=72.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_47 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=46 enable=soa rule="esd_nmos45_=Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))-72.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_48 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=47 enable=soa rule="esd_nmos45_>Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.4*(V(g)-V(s)-0.5))) > 72.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=72.5 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_49 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=48 enable=soa rule="esd_nmos45_Vt1=72p3_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-72.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_50 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=49 enable=soa rule="esd_nmos45_Vt1>72p3_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 72.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=72.3 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_51 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=50 enable=soa rule="esd_nmos45_=Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(24.0*(V(g)-V(s)-1.0))-72.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_52 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=51 enable=soa rule="esd_nmos45_>Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(24.0*(V(g)-V(s)-1.0))) > 72.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=72.3 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_53 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=52 enable=soa rule="esd_nmos45_Vt1=60p3_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-60.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_54 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=53 enable=soa rule="esd_nmos45_Vt1>60p3_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 60.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.3 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_55 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=54 enable=soa rule="esd_nmos45_=Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(-0.7*(V(g)-V(s)-1.5))-60.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_56 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=55 enable=soa rule="esd_nmos45_>Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(-0.7*(V(g)-V(s)-1.5))) > 60.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=60.3 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_57 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=56 enable=soa rule="esd_nmos45_Vt1=61p0_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-61.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_58 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=57 enable=soa rule="esd_nmos45_Vt1>61p0_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 61.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_59 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=58 enable=soa rule="esd_nmos45_=Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(4.4*(V(g)-V(s)-2.5))-61.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_60 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=59 enable=soa rule="esd_nmos45_>Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(4.4*(V(g)-V(s)-2.5))) > 61.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.0 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_61 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=60 enable=soa rule="esd_nmos45_Vt1=56p6_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_62 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=61 enable=soa rule="esd_nmos45_Vt1>56p6_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 56.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=56.6 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_63 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=62 enable=soa rule="esd_nmos45_=Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(7.4*(V(g)-V(s)-3.5))-56.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_64 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=63 enable=soa rule="esd_nmos45_>Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(7.4*(V(g)-V(s)-3.5))) > 56.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=56.6 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_65 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=64 enable=soa rule="esd_nmos45_Vt1=49p2_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_66 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=65 enable=soa rule="esd_nmos45_Vt1>49p2_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.2 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_67 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=66 enable=soa rule="esd_nmos45_=Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(5.7*(V(g)-V(s)-4.5))-49.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_68 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=67 enable=soa rule="esd_nmos45_>Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(5.7*(V(g)-V(s)-4.5))) > 49.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.2 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_69 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=68 enable=soa rule="esd_nmos45_Vt1=43p5_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-43.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_70 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=69 enable=soa rule="esd_nmos45_Vt1>43p5_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 43.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=43.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_71 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=70 enable=soa rule="esd_nmos45_=Vt1_Vgs_5p5_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))-43.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_72 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=71 enable=soa rule="esd_nmos45_>Vt1_Vgs_5p5_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(2.2*(V(g)-V(s)-5.5))) > 43.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=43.5 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_73 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=72 enable=soa rule="esd_nmos45_Vt1=42p4_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_74 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=73 enable=soa rule="esd_nmos45_Vt1>42p4_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 42.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.4 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_75 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=74 enable=soa rule="esd_nmos45_=Vt1_Vgs_6p0_7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(d)-V(s)+(6.4*(V(g)-V(s)-6.0))-42.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_76 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=75 enable=soa rule="esd_nmos45_>Vt1_Vgs_6p0_7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(g-to-s) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(V(d)-V(s)+(6.4*(V(g)-V(s)-6.0))) > 42.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=42.4 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45_10hv_esdchk_77 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=76 enable=soa rule="esd_nmos45_Vt1=36p0_Vgs7p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-36.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_78 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=77 enable=soa rule="esd_nmos45_Vt1>36p0_Vgs7p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 36.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=36.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_79 (d g s b sub) monitor_esd_nmos45_10hv ruleNum=78 enable=soa rule="esd_nmos45_=Vt1_Vgs>7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(d)-V(s)-36.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_80 (g s d s b s) monitor6t enable=soa rule="esd_nmos45_>Vt1_Vgs>7p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="V(d-to-s) > 36.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=36.0 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45_10hv_esdchk_81 (g b) monitor2t enable=soa rule="esd_nmos45_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos45_10hv_esdchk_82 (g s) monitor2t enable=soa rule="esd_nmos45_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos45_10hv_esdchk_83 (g d) monitor2t enable=soa rule="esd_nmos45_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 76.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=76.3
anmos45_10hv_esdchk_84 (s b) monitor2t enable=soa rule="esd_nmos45_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos45_10hv_esdchk_85 (d b) monitor2t enable=soa rule="esd_nmos45_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 76.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=76.3
anmos45_10hv_esdchk_86 (d sub) monitor2t enable=soa rule="esd_nmos45_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos45_10hv_esdchk_87 (sub b) monitor2t enable=soa rule="esd_nmos45_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos45_10hv_esdchk_88 (b d) monitor2t enable=soa rule="esd_nmos45_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
endsection nmos45_10hv_dfrt

section nmos45b_10hv_dfrt
include "soachecks_top.scs" section=nmos45b_10hv_soa
if (enable_relimo == 1) {
anmos45b_10hv_hci3 (d g s sub) relimo_aging_hci_nmos45b w=w*ng relimo_ratio20_a=1.1212 relimo_ratio20_b=0 relimo_ratio21_a=1.5 relimo_ratio21_b=0 relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag relimo_device_name=nmos45_10hv relimo_probe_name=amost relimo_a_gm=relimo_a_gm_1_hci_nmos45_10hv relimo_a_idlin=relimo_a_idlin_1_hci_nmos45_10hv relimo_a_idsat=relimo_a_idsat_1_hci_nmos45_10hv relimo_a_vth=relimo_a_vth_1_hci_nmos45_10hv relimo_c=relimo_c_1_hci_nmos45_10hv relimo_condvd=relimo_condvd_hci_nmos45_10hv relimo_condvg=relimo_condvg_hci_nmos45_10hv relimo_intercept=relimo_intercept_1_hci_nmos45_10hv relimo_m=relimo_m_1_hci_nmos45_10hv relimo_n=relimo_n_1_hci_nmos45_10hv relimo_r=relimo_r_1_hci_nmos45_10hv relimo_e=relimo_e_hci_nmos45_10hv relimo_ratio1_a=relimo_ratio1_a_hci_nmos45_10hv relimo_ratio1_b=relimo_ratio1_b_hci_nmos45_10hv relimo_ratio2_a=relimo_ratio2_a_hci_nmos45_10hv relimo_ratio2_b=relimo_ratio2_b_hci_nmos45_10hv relimo_ratio3_a=relimo_ratio3_a_hci_nmos45_10hv relimo_ratio3_b=relimo_ratio3_b_hci_nmos45_10hv relimo_ratio4_a=relimo_ratio4_a_hci_nmos45_10hv relimo_ratio4_b=relimo_ratio4_b_hci_nmos45_10hv relimo_ratio5_a=relimo_ratio5_a_hci_nmos45_10hv relimo_ratio5_b=relimo_ratio5_b_hci_nmos45_10hv relimo_ratio6_a=relimo_ratio6_a_hci_nmos45_10hv relimo_ratio6_b=relimo_ratio6_b_hci_nmos45_10hv relimo_ratio7_a=relimo_ratio7_a_hci_nmos45_10hv relimo_ratio7_b=relimo_ratio7_b_hci_nmos45_10hv relimo_ratio8_a=relimo_ratio8_a_hci_nmos45_10hv relimo_ratio8_b=relimo_ratio8_b_hci_nmos45_10hv relimo_ratio9_a=relimo_ratio9_a_hci_nmos45_10hv relimo_ratio9_b=relimo_ratio9_b_hci_nmos45_10hv relimo_ratio10_a=relimo_ratio10_a_hci_nmos45_10hv relimo_ratio10_b=relimo_ratio10_b_hci_nmos45_10hv relimo_ratio11_a=relimo_ratio11_a_hci_nmos45_10hv relimo_ratio11_b=relimo_ratio11_b_hci_nmos45_10hv relimo_ratio12_a=relimo_ratio12_a_hci_nmos45_10hv relimo_ratio12_b=relimo_ratio12_b_hci_nmos45_10hv relimo_ratio13_a=relimo_ratio13_a_hci_nmos45_10hv relimo_ratio13_b=relimo_ratio13_b_hci_nmos45_10hv relimo_ratio14_a=relimo_ratio14_a_hci_nmos45_10hv relimo_ratio14_b=relimo_ratio14_b_hci_nmos45_10hv relimo_ratio15_a=relimo_ratio15_a_hci_nmos45_10hv relimo_ratio15_b=relimo_ratio15_b_hci_nmos45_10hv relimo_ratio16_a=relimo_ratio16_a_hci_nmos45_10hv relimo_ratio16_b=relimo_ratio16_b_hci_nmos45_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_nmos45_10hv relimo_vth=relimo_vth_hci_nmos45_10hv
anmos45b_10hv_pbti relimo_aging_pbti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_pbti_aging_open_flag=0 relimo_device_name=nmos45_10hv relimo_probe_name=mpowermos
}
if (enable_esdsoa == 1) {
anmos45b_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=1 enable=soa rule="esd_nmos45b_Vt1=78p3_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=2 enable=soa rule="esd_nmos45b_Vt1>78p3_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 78.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=3 enable=soa rule="esd_nmos45b_=Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=4 enable=soa rule="esd_nmos45b_>Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 78.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=78.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=5 enable=soa rule="esd_nmos45b_Vt1=78p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=6 enable=soa rule="esd_nmos45b_Vt1>78p3_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 78.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=7 enable=soa rule="esd_nmos45b_=Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=8 enable=soa rule="esd_nmos45b_>Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.5))) > 78.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=78.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=9 enable=soa rule="esd_nmos45b_Vt1=78p3_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=10 enable=soa rule="esd_nmos45b_Vt1>78p3_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 78.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=78.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=11 enable=soa rule="esd_nmos45b_=Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(3.4*(V(g)-V(s)-1.0))-78.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=12 enable=soa rule="esd_nmos45b_>Vt1_Vgs_1p0_1p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(3.4*(V(g)-V(s)-1.0))) > 78.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=78.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=13 enable=soa rule="esd_nmos45b_Vt1=76p6_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-76.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=14 enable=soa rule="esd_nmos45b_Vt1>76p6_Vgs1p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 76.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=76.6 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=15 enable=soa rule="esd_nmos45b_=Vt1_Vgs_1p5_2p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(3.4*(V(g)-V(s)-1.5))-76.6)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=16 enable=soa rule="esd_nmos45b_>Vt1_Vgs_1p5_2p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(3.4*(V(g)-V(s)-1.5))) > 76.6 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=76.6 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=17 enable=soa rule="esd_nmos45b_Vt1=73p2_Vgs2p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-73.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=18 enable=soa rule="esd_nmos45b_Vt1>73p2_Vgs2p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 73.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=73.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=19 enable=soa rule="esd_nmos45b_=Vt1_Vgs_2p5_3p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(4.1*(V(g)-V(s)-2.5))-73.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=20 enable=soa rule="esd_nmos45b_>Vt1_Vgs_2p5_3p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(4.1*(V(g)-V(s)-2.5))) > 73.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=73.2 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=21 enable=soa rule="esd_nmos45b_Vt1=69p1_Vgs3p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=22 enable=soa rule="esd_nmos45b_Vt1>69p1_Vgs3p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.1 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=23 enable=soa rule="esd_nmos45b_=Vt1_Vgs_3p5_4p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(5.4*(V(g)-V(s)-3.5))-69.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=24 enable=soa rule="esd_nmos45b_>Vt1_Vgs_3p5_4p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(5.4*(V(g)-V(s)-3.5))) > 69.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.1 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=25 enable=soa rule="esd_nmos45b_Vt1=63p7_Vgs4p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=26 enable=soa rule="esd_nmos45b_Vt1>63p7_Vgs4p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.7 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=27 enable=soa rule="esd_nmos45b_=Vt1_Vgs_4p5_5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(6.5*(V(g)-V(s)-4.5))-63.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=28 enable=soa rule="esd_nmos45b_>Vt1_Vgs_4p5_5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(6.5*(V(g)-V(s)-4.5))) > 63.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.7 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos45b_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=29 enable=soa rule="esd_nmos45b_Vt1=57p2_Vgs5p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-57.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=30 enable=soa rule="esd_nmos45b_Vt1>57p2_Vgs5p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 57.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=57.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=31 enable=soa rule="esd_nmos45b_=Vt1_Vgs>5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(d)-V(s)-57.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_32 (g s d s b s) monitor6t enable=soa rule="esd_nmos45b_>Vt1_Vgs>5p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(d-to-s) > 57.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=57.2 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos45b_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=32 enable=soa rule="esd_nmos45b_Vt1=69p8_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=33 enable=soa rule="esd_nmos45b_Vt1>69p8_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=34 enable=soa rule="esd_nmos45b_=Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(1.4*(V(g)-V(s)-0.0))-69.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_36 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=35 enable=soa rule="esd_nmos45b_>Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(1.4*(V(g)-V(s)-0.0))) > 69.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=36 enable=soa rule="esd_nmos45b_Vt1=69p1_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-69.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=37 enable=soa rule="esd_nmos45b_Vt1>69p1_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 69.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=69.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=38 enable=soa rule="esd_nmos45b_=Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(3.8*(V(g)-V(s)-0.5))-69.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_40 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=39 enable=soa rule="esd_nmos45b_>Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(3.8*(V(g)-V(s)-0.5))) > 69.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=69.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=40 enable=soa rule="esd_nmos45b_Vt1=67p2_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-67.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=41 enable=soa rule="esd_nmos45b_Vt1>67p2_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 67.2 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=67.2 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=42 enable=soa rule="esd_nmos45b_=Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(d)-V(s)+(4.2*(V(g)-V(s)-1.0))-67.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_44 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=43 enable=soa rule="esd_nmos45b_>Vt1_Vgs_1p0_1p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(V(d)-V(s)+(4.2*(V(g)-V(s)-1.0))) > 67.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=67.2 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_45 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=44 enable=soa rule="esd_nmos45b_Vt1=65p1_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-65.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_46 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=45 enable=soa rule="esd_nmos45b_Vt1>65p1_Vgs1p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 65.1 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=65.1 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_47 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=46 enable=soa rule="esd_nmos45b_=Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(d)-V(s)+(1.2*(V(g)-V(s)-1.5))-65.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_48 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=47 enable=soa rule="esd_nmos45b_>Vt1_Vgs_1p5_2p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(g-to-s) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(V(d)-V(s)+(1.2*(V(g)-V(s)-1.5))) > 65.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=65.1 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_49 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=48 enable=soa rule="esd_nmos45b_Vt1=63p9_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-63.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_50 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=49 enable=soa rule="esd_nmos45b_Vt1>63p9_Vgs2p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 63.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_51 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=50 enable=soa rule="esd_nmos45b_=Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(d)-V(s)+(6.2*(V(g)-V(s)-2.5))-63.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_52 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=51 enable=soa rule="esd_nmos45b_>Vt1_Vgs_2p5_3p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(g-to-s) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(V(d)-V(s)+(6.2*(V(g)-V(s)-2.5))) > 63.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_53 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=52 enable=soa rule="esd_nmos45b_Vt1=57p7_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-57.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_54 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=53 enable=soa rule="esd_nmos45b_Vt1>57p7_Vgs3p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 57.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=57.7 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_55 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=54 enable=soa rule="esd_nmos45b_=Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(d)-V(s)+(8.0*(V(g)-V(s)-3.5))-57.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_56 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=55 enable=soa rule="esd_nmos45b_>Vt1_Vgs_3p5_4p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(g-to-s) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(V(d)-V(s)+(8.0*(V(g)-V(s)-3.5))) > 57.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=57.7 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_57 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=56 enable=soa rule="esd_nmos45b_Vt1=49p7_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_58 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=57 enable=soa rule="esd_nmos45b_Vt1>49p7_Vgs4p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 49.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=49.7 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_59 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=58 enable=soa rule="esd_nmos45b_=Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(d)-V(s)+(7.1*(V(g)-V(s)-4.5))-49.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_60 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=59 enable=soa rule="esd_nmos45b_>Vt1_Vgs_4p5_5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(g-to-s) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(V(d)-V(s)+(7.1*(V(g)-V(s)-4.5))) > 49.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=49.7 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos45b_10hv_esdchk_61 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=60 enable=soa rule="esd_nmos45b_Vt1=42p6_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-42.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_62 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=61 enable=soa rule="esd_nmos45b_Vt1>42p6_Vgs5p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 42.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.6 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_63 (d g s b sub) monitor_esd_nmos45b_10hv ruleNum=62 enable=soa rule="esd_nmos45b_=Vt1_Vgs>5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(d)-V(s)-42.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_64 (g s d s b s) monitor6t enable=soa rule="esd_nmos45b_>Vt1_Vgs>5p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="V(d-to-s) > 42.6 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=42.6 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos45b_10hv_esdchk_65 (g b) monitor2t enable=soa rule="esd_nmos45b_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos45b_10hv_esdchk_66 (g s) monitor2t enable=soa rule="esd_nmos45b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
anmos45b_10hv_esdchk_67 (g d) monitor2t enable=soa rule="esd_nmos45b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 78.3 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=78.3
anmos45b_10hv_esdchk_68 (s b) monitor2t enable=soa rule="esd_nmos45b_Vsb_Vt1" targetT=0.0 formulae_cond1="V(s-to-b) > 9.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=9.0
anmos45b_10hv_esdchk_69 (d b) monitor2t enable=soa rule="esd_nmos45b_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 78.3 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=78.3
anmos45b_10hv_esdchk_70 (d sub) monitor2t enable=soa rule="esd_nmos45b_Vdsub_maxV" targetT=0.0 formulae_cond1="V(d-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos45b_10hv_esdchk_71 (sub b) monitor2t enable=soa rule="esd_nmos45b_Vsubb_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-b) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
anmos45b_10hv_esdchk_72 (b d) monitor2t enable=soa rule="esd_nmos45b_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5
}
if (enable_aging == 1) {
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "amost"
+ simprobeparam   = "ide"
+ type            = 1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hcifstattau1    = 0.00382
+ hcia1           = 0.325*presto_idRatio
+ hcia2           = 1.64*presto_idRatio
+ hcic1           = 495
+ hcilambdael0    = 4.71e-7
+ hcialpha1       = 3.94e-11
+ hcibeta1        = 1.59
+ offa1           = 1000*presto_idRatio             //Off state HCI part
+ offn1           = 0.246
+ offfstattau1    = 0.138
+ offalpha1       = 2.54E+17
+ offbeta1legacy  = 0.108
+ offea1          = 0.145
+ hvgsfstat       = 0.0198           // High Vgs HCI part
+ hvgsa           = 1000*presto_vthRatio
+ hvgsn           = 0.362
+ hvgsalpha       = 4.59e29
+ hvgsbeta        = 4.39
+ hvgsgamma       = 10.7
+ hvgsdelta       = 8.2
+ hvgsepsilon     = 0
+ hvgsea          = 0.733
+ hvgsrth         = 0.00624
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 19300 
+ a0_b0_b0_a1_em1 = -6.46 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -2760 
+ a0_b0_a1_a1_em1 = -2.91 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -903 
+ a0_b0_a2_a1_em1 = -6.21 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = 3210 
+ a0_b0_a3_a1_em1 = -2.66 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -0.671 
+ a0_b0_p1_a1_em1 = 0.00438 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 0.996 
+ a0_b0_p2_a1_em1 = -0.0113 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.66 
+ a0_b0_p3_a1_em1 = -0.00286 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 8000 
+ a0_b0_b0_a2_em1 = 0 
+ b0_a0_b0_a2_em1 = 8 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -1000 
+ a0_b0_a1_a2_em1 = 0 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 4000 
+ a0_b0_a2_a2_em1 = 0 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -1000 
+ a0_b0_a3_a2_em1 = 0 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.5 
+ a0_b0_p1_a2_em1 = 0 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 1.3 
+ a0_b0_p2_a2_em1 = 0 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 2.2 
+ a0_b0_p3_a2_em1 = 0 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 3 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 5180 
+ a0_b0_b0_a3_em1 = 0.868 
+ b0_a0_b0_a3_em1 = 23 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 2120 
+ a0_b0_a1_a3_em1 = -3 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -12000 
+ a0_b0_a2_a3_em1 = 14.5 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -4980 
+ a0_b0_a3_a3_em1 = 6.86 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.52 
+ a0_b0_p1_a3_em1 = -0.00333 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 2.27 
+ a0_b0_p2_a3_em1 = -0.00177 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 2.4 
+ a0_b0_p3_a3_em1 = -0.000878 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 11100 
+ a0_b0_b0_a4_em1 = -45.2 
+ b0_a0_b0_a4_em1 = 19.2 
+ a0_a0_b0_a4_em1 = 0.261 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 266 
+ a0_b0_a1_a4_em1 = 0.0606 
+ b0_a0_a1_a4_em1 = 1.64 
+ a0_a0_a1_a4_em1 = -0.000585 
+ b0_b0_a2_a4_em1 = -487 
+ a0_b0_a2_a4_em1 = -0.656 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.0279 
+ b0_b0_a3_a4_em1 = 4640 
+ a0_b0_a3_a4_em1 = -14.8 
+ b0_a0_a3_a4_em1 = -1.58 
+ a0_a0_a3_a4_em1 = -0.192 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 25.2 
+ a0_b0_p1_a4_em1 = -0.158 
+ b0_a0_p1_a4_em1 = -0.0634 
+ a0_a0_p1_a4_em1 = 1.21E-03 
+ b0_b0_p2_a4_em1 = 1.52 
+ a0_b0_p2_a4_em1 = -0.00143 
+ b0_a0_p2_a4_em1 = 0.00124 
+ a0_a0_p2_a4_em1 = 8.71E-06 
+ b0_b0_p3_a4_em1 = 3.45 
+ a0_b0_p3_a4_em1 = -0.00301 
+ b0_a0_p3_a4_em1 = -0.058 
+ a0_a0_p3_a4_em1 = 2.02E-04 
+ b0_b0_p4_a4_em1 = 5.51 
+ a0_b0_p4_a4_em1 = -0.00666 
+ b0_a0_p4_a4_em1 = -0.0565 
+ a0_a0_p4_a4_em1 = 1.71E-04 
+ b0_b0_b0_p1_em1 = 7.64 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 4.46 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = 0.416 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -4.63 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = 1.29 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 3.87 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 4.5 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4.95 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 14.1 
+ a0_b0_b0_p2_em1 = 0.00339 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = -0.968 
+ a0_b0_a1_p2_em1 = -0.000562 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 5.35 
+ a0_b0_a2_p2_em1 = -0.00493 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -2.32 
+ a0_b0_a3_p2_em1 = 0.000692 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 2.44 
+ a0_b0_p2_p2_em1 = -0.00178 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 3.94 
+ a0_b0_p3_p2_em1 = 0.000322 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 5 
+ a0_b0_p4_p2_em1 = 0 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 25 
+ a0_b0_b0_p3_em1 = 0.00403 
+ b0_a0_b0_p3_em1 = 0.025 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = -2.38 
+ a0_b0_a1_p3_em1 = 0.00211 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = -0.0466 
+ a0_b0_a2_p3_em1 = 0.00887 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -0.549 
+ a0_b0_a3_p3_em1 = 0.00339 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 1.29 
+ a0_b0_p1_p3_em1 = -0.00555 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 1.19 
+ a0_b0_p2_p3_em1 = 0.00219 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 2.47 
+ a0_b0_p3_p3_em1 = 0.000299 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 10.6 
+ a0_b0_p4_p3_em1 = -0.0106 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 44.4 
+ a0_b0_b0_p4_em1 = 0.193 
+ b0_a0_b0_p4_em1 = -0.42 
+ a0_a0_b0_p4_em1 = -2.25E-03 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = -6.52 
+ a0_b0_a1_p4_em1 = 0.0035 
+ b0_a0_a1_p4_em1 = 0.0294 
+ a0_a0_a1_p4_em1 = -3.32E-05 
+ b0_b0_a2_p4_em1 = -21.7 
+ a0_b0_a2_p4_em1 = 0.0831 
+ b0_a0_a2_p4_em1 = 0.228 
+ a0_a0_a2_p4_em1 = -0.00112 
+ b0_b0_a3_p4_em1 = 12 
+ a0_b0_a3_p4_em1 = -0.0383 
+ b0_a0_a3_p4_em1 = -0.846 
+ a0_a0_a3_p4_em1 = 0.00382 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 1.83 
+ a0_b0_p1_p4_em1 = -0.0461 
+ b0_a0_p1_p4_em1 = 0.0572 
+ a0_a0_p1_p4_em1 = 4.77E-04 
+ b0_b0_p2_p4_em1 = 0.334 
+ a0_b0_p2_p4_em1 = 0.00275 
+ b0_a0_p2_p4_em1 = 0.0217 
+ a0_a0_p2_p4_em1 = -5.76E-05 
+ b0_b0_p3_p4_em1 = 2.22 
+ a0_b0_p3_p4_em1 = -0.00112 
+ b0_a0_p3_p4_em1 = -0.0193 
+ a0_a0_p3_p4_em1 = 1.10E-04 
+ b0_b0_p4_p4_em1 = 13 
+ a0_b0_p4_p4_em1 = -0.0286 
+ b0_a0_p4_p4_em1 = -0.177 
+ a0_a0_p4_p4_em1 = 5.21E-04 
}
endsection nmos45b_10hv_dfrt

section pmos45_10hv_dfrt
include "soachecks_top.scs" section=pmos45_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=relimo_ratio20_a_bti_pmos45_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmos45_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apmos45_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos45_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=1 enable=soa rule="esd_pmos45_Vt1=63p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-63.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=2 enable=soa rule="esd_pmos45_Vt1>63p2_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 63.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=63.2
apmos45_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=3 enable=soa rule="esd_pmos45_=Vt1_Vgs_0p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(0.1*(V(s)-V(g)-0.0))-63.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=4 enable=soa rule="esd_pmos45_>Vt1_Vgs_0p0_3p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(s)-V(d)+(0.1*(V(s)-V(g)-0.0)))) > 63.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=63.2
apmos45_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=5 enable=soa rule="esd_pmos45_Vt1=62p9_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-62.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=6 enable=soa rule="esd_pmos45_Vt1>62p9_Vgs3p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 62.9 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.9
apmos45_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=7 enable=soa rule="esd_pmos45_=Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-3.0))-62.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=8 enable=soa rule="esd_pmos45_>Vt1_Vgs_3p0_4p0" targetT=0.0 formulae_cond1="V(s-to-g) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(s-to-g) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(s)-V(d)+(0.5*(V(s)-V(g)-3.0)))) > 62.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.9
apmos45_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=9 enable=soa rule="esd_pmos45_Vt1=62p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-62.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=10 enable=soa rule="esd_pmos45_Vt1>62p4_Vgs4p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 62.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.4
apmos45_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=11 enable=soa rule="esd_pmos45_=Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(1.9*(V(s)-V(g)-4.0))-62.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45_10hv_esdchk_12 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=12 enable=soa rule="esd_pmos45_>Vt1_Vgs_4p0_5p0" targetT=0.0 formulae_cond1="V(s-to-g) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(s-to-g) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(s)-V(d)+(1.9*(V(s)-V(g)-4.0)))) > 62.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.4
apmos45_10hv_esdchk_13 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=13 enable=soa rule="esd_pmos45_Vt1=60p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-60.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_14 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=14 enable=soa rule="esd_pmos45_Vt1>60p5_Vgs5p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 60.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=60.5
apmos45_10hv_esdchk_15 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=15 enable=soa rule="esd_pmos45_=Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-5.0))-60.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45_10hv_esdchk_16 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=16 enable=soa rule="esd_pmos45_>Vt1_Vgs_5p0_6p0" targetT=0.0 formulae_cond1="V(s-to-g) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(s-to-g) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(s)-V(d)+(1.0*(V(s)-V(g)-5.0)))) > 60.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=60.5
apmos45_10hv_esdchk_17 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=17 enable=soa rule="esd_pmos45_Vt1=59p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-59.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_18 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=18 enable=soa rule="esd_pmos45_Vt1>59p5_Vgs6p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 59.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.5
apmos45_10hv_esdchk_19 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=19 enable=soa rule="esd_pmos45_=Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(0.3*(V(s)-V(g)-6.0))-59.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45_10hv_esdchk_20 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=20 enable=soa rule="esd_pmos45_>Vt1_Vgs_6p0_7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(s-to-g) < 7.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=7.0 formulae_cond3="(abs(V(s)-V(d)+(0.3*(V(s)-V(g)-6.0)))) > 59.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=59.5
apmos45_10hv_esdchk_21 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=21 enable=soa rule="esd_pmos45_Vt1=59p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-59.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_22 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=22 enable=soa rule="esd_pmos45_Vt1>59p2_Vgs7p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-7.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 59.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.2
apmos45_10hv_esdchk_23 (d g s b sub) monitor_esd_pmos45_10hv ruleNum=23 enable=soa rule="esd_pmos45_=Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="(abs(V(s)-V(d)-59.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45_10hv_esdchk_24 (s g s d) monitor4t enable=soa rule="esd_pmos45_>Vt1_Vgs>7p0" targetT=0.0 formulae_cond1="V(s-to-g) > 7.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=7.0 formulae_cond2="absV(s-to-d) > 59.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.2
apmos45_10hv_esdchk_25 (g b) monitor2t enable=soa rule="esd_pmos45_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos45_10hv_esdchk_26 (g s) monitor2t enable=soa rule="esd_pmos45_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos45_10hv_esdchk_27 (g d) monitor2t enable=soa rule="esd_pmos45_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 63.2 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=63.2
apmos45_10hv_esdchk_28 (b s) monitor2t enable=soa rule="esd_pmos45_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos45_10hv_esdchk_29 (b d) monitor2t enable=soa rule="esd_pmos45_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 63.2 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=63.2
apmos45_10hv_esdchk_30 (b sub) monitor2t enable=soa rule="esd_pmos45_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos45_10hv_esdchk_31 (sub d) monitor2t enable=soa rule="esd_pmos45_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos45_10hv_esdchk_32 (d b) monitor2t enable=soa rule="esd_pmos45_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pmos45_10hv_dfrt

section pmos45b_10hv_dfrt
include "soachecks_top.scs" section=pmos45b_10hv_soa
if (enable_relimo == 1) {
apmos45b_hci (d g s sub) relimo_aging_hci_pmos45b l=l w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apmos45b_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmos45b_10hv_esdchk_1 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=1 enable=soa rule="esd_pmos45b_Vt1=68p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-68.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_2 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=2 enable=soa rule="esd_pmos45b_Vt1>68p4_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 68.4 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=68.4
apmos45b_10hv_esdchk_3 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=3 enable=soa rule="esd_pmos45b_=Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(0.4*(V(s)-V(g)-0.0))-68.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_4 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=4 enable=soa rule="esd_pmos45b_>Vt1_Vgs_0p0_0p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(s)-V(d)+(0.4*(V(s)-V(g)-0.0)))) > 68.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=68.4
apmos45b_10hv_esdchk_5 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=5 enable=soa rule="esd_pmos45b_Vt1=68p2_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-68.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_6 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=6 enable=soa rule="esd_pmos45b_Vt1>68p2_Vgs0p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 68.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=68.2
apmos45b_10hv_esdchk_7 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=7 enable=soa rule="esd_pmos45b_=Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.5))-68.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_8 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=8 enable=soa rule="esd_pmos45b_>Vt1_Vgs_0p5_1p0" targetT=0.0 formulae_cond1="V(s-to-g) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(s-to-g) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.5)))) > 68.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=68.2
apmos45b_10hv_esdchk_9 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=9 enable=soa rule="esd_pmos45b_Vt1=68p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-68.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_10 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=10 enable=soa rule="esd_pmos45b_Vt1>68p2_Vgs1p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 68.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=68.2
apmos45b_10hv_esdchk_11 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=11 enable=soa rule="esd_pmos45b_=Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-1.0))-68.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_12 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=12 enable=soa rule="esd_pmos45b_>Vt1_Vgs_1p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(2.0*(V(s)-V(g)-1.0)))) > 68.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=68.2
apmos45b_10hv_esdchk_13 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=13 enable=soa rule="esd_pmos45b_Vt1=67p2_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-67.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_14 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=14 enable=soa rule="esd_pmos45b_Vt1>67p2_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 67.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=67.2
apmos45b_10hv_esdchk_15 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=15 enable=soa rule="esd_pmos45b_=Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(2.7*(V(s)-V(g)-1.5))-67.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_16 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=16 enable=soa rule="esd_pmos45b_>Vt1_Vgs_1p5_2p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="V(s-to-g) < 2.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.5 formulae_cond3="(abs(V(s)-V(d)+(2.7*(V(s)-V(g)-1.5)))) > 67.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=67.2
apmos45b_10hv_esdchk_17 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=17 enable=soa rule="esd_pmos45b_Vt1=64p5_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-64.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_18 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=18 enable=soa rule="esd_pmos45b_Vt1>64p5_Vgs2p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-2.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 64.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.5
apmos45b_10hv_esdchk_19 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=19 enable=soa rule="esd_pmos45b_=Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-2.5))-64.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_20 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=20 enable=soa rule="esd_pmos45b_>Vt1_Vgs_2p5_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 2.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.5 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(1.8*(V(s)-V(g)-2.5)))) > 64.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=64.5
apmos45b_10hv_esdchk_21 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=21 enable=soa rule="esd_pmos45b_Vt1=62p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-62.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_22 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=22 enable=soa rule="esd_pmos45b_Vt1>62p7_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 62.7 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.7
apmos45b_10hv_esdchk_23 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=23 enable=soa rule="esd_pmos45b_=Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(1.5*(V(s)-V(g)-3.5))-62.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_24 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=24 enable=soa rule="esd_pmos45b_>Vt1_Vgs_3p5_4p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="V(s-to-g) < 4.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.5 formulae_cond3="(abs(V(s)-V(d)+(1.5*(V(s)-V(g)-3.5)))) > 62.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.7
apmos45b_10hv_esdchk_25 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=25 enable=soa rule="esd_pmos45b_Vt1=61p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_26 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=26 enable=soa rule="esd_pmos45b_Vt1>61p2_Vgs4p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-4.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 61.2 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=61.2
apmos45b_10hv_esdchk_27 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=27 enable=soa rule="esd_pmos45b_=Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-4.5))-61.2)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmos45b_10hv_esdchk_28 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=28 enable=soa rule="esd_pmos45b_>Vt1_Vgs_4p5_5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 4.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.5 formulae_cond2="V(s-to-g) < 5.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.5 formulae_cond3="(abs(V(s)-V(d)+(1.6*(V(s)-V(g)-4.5)))) > 61.2 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=61.2
apmos45b_10hv_esdchk_29 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=29 enable=soa rule="esd_pmos45b_Vt1=59p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-59.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_30 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=30 enable=soa rule="esd_pmos45b_Vt1>59p6_Vgs5p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-5.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 59.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.6
apmos45b_10hv_esdchk_31 (d g s b sub) monitor_esd_pmos45b_10hv ruleNum=31 enable=soa rule="esd_pmos45b_=Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="(abs(V(s)-V(d)-59.6)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmos45b_10hv_esdchk_32 (s g s d) monitor4t enable=soa rule="esd_pmos45b_>Vt1_Vgs>5p5" targetT=0.0 formulae_cond1="V(s-to-g) > 5.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.5 formulae_cond2="absV(s-to-d) > 59.6 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=59.6
apmos45b_10hv_esdchk_33 (g b) monitor2t enable=soa rule="esd_pmos45b_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos45b_10hv_esdchk_34 (g s) monitor2t enable=soa rule="esd_pmos45b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmos45b_10hv_esdchk_35 (g d) monitor2t enable=soa rule="esd_pmos45b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 68.4 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=68.4
apmos45b_10hv_esdchk_36 (b s) monitor2t enable=soa rule="esd_pmos45b_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmos45b_10hv_esdchk_37 (b d) monitor2t enable=soa rule="esd_pmos45b_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 68.4 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=68.4
apmos45b_10hv_esdchk_38 (b sub) monitor2t enable=soa rule="esd_pmos45b_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos45b_10hv_esdchk_39 (sub d) monitor2t enable=soa rule="esd_pmos45b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmos45b_10hv_esdchk_40 (d b) monitor2t enable=soa rule="esd_pmos45b_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mamost"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 0.28*presto_idRatio
+ hcia2           = 1.42*presto_idRatio
+ hcic1           = 3870
+ hcib1           = 0.000133*presto_idRatio
+ hcin            = 3
+ hcialpha1       = 5.21E-05
+ hcibeta1        = 0.999
+ hcilambdah0     = 2.23E-06
+ hcialpha2       = 3.76E-29
+ hcibeta2        = 0.5
+ hcilambdael0    = 4.60E-07
+ hcifstattau1    = 0.00718
+ hcifstattau2    = 0.00717
+ hcifstattau12   = 460
+ hcifstattau21   = 460
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.3
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 7.68*presto_idRatio             //Off state HCI part
+ offn1           = 0.213
+ offa2           = 3.75*presto_idRatio
+ offn2           = 0.302
+ offalpha1       = 66.8
+ offbeta1        = 0.0975
+ offea1          = 0.596
+ offalpha2       = 332
+ offbeta2        = 0.144
+ offea2          = 0.394
+ offfstattau1    = 0.0198
+ offfstattau2    = 0.0244
+ offfstattau12   = 14.4
+ offfstattau21   = 14.4
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.5*presto_idRatio
+ hvgsfstat       = 0.0986         // High Vgs HCI part
+ hvgsa           = 1000*presto_vthRatio
+ hvgsn           = 0.234
+ hvgsalpha       = 1.71E32
+ hvgsbeta        = 1.64E-7
+ hvgsgamma       = 21.8
+ hvgsdelta       = 9.08
+ hvgsepsilon     = 0
+ hvgsea          = 0.682
+ hvgsrth         = 0.00799
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 17500 
+ a0_b0_b0_a1_em1 = -6.37 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = 7520 
+ a0_b0_a1_a1_em1 = -3.73 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -2130 
+ a0_b0_a2_a1_em1 = 2.24 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -3030 
+ a0_b0_a3_a1_em1 = 19.1 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -0.0802 
+ a0_b0_p1_a1_em1 = 0.000244 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 1.17 
+ a0_b0_p2_a1_em1 = -0.00075 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.76 
+ a0_b0_p3_a1_em1 = -0.000303 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 5650 
+ a0_b0_b0_a2_em1 = -0.0946 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = -3020 
+ a0_b0_a1_a2_em1 = 43.7 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = -879 
+ a0_b0_a2_a2_em1 = 0.736 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -1120 
+ a0_b0_a3_a2_em1 = -4.61 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = 0 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = 0.286 
+ a0_b0_p1_a2_em1 = 0.000103 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = 0.536 
+ a0_b0_p2_a2_em1 = -0.000153 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 3.97 
+ a0_b0_p3_a2_em1 = -0.000551 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 3360 
+ a0_b0_b0_a3_em1 = 0.181 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = 2920 
+ a0_b0_a1_a3_em1 = -4.55 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -695 
+ a0_b0_a2_a3_em1 = 1.58 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -4790 
+ a0_b0_a3_a3_em1 = 1.6 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.0896 
+ a0_b0_p1_a3_em1 = -1.24E-05 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 0.321 
+ a0_b0_p2_a3_em1 = 0.000648 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 2.96 
+ a0_b0_p3_a3_em1 = -0.000183 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 2210 
+ a0_b0_b0_a4_em1 = -0.595 
+ b0_a0_b0_a4_em1 = -0.651 
+ a0_a0_b0_a4_em1 = 0.00184 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = -130 
+ a0_b0_a1_a4_em1 = -0.632 
+ b0_a0_a1_a4_em1 = 1.74 
+ a0_a0_a1_a4_em1 = -0.00594 
+ b0_b0_a2_a4_em1 = 1770 
+ a0_b0_a2_a4_em1 = 0.153 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.00156 
+ b0_b0_a3_a4_em1 = -22.5 
+ a0_b0_a3_a4_em1 = 0.102 
+ b0_a0_a3_a4_em1 = 0.619 
+ a0_a0_a3_a4_em1 = -0.00158 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = -2.09 
+ a0_b0_p1_a4_em1 = 0.00332 
+ b0_a0_p1_a4_em1 = 0.00392 
+ a0_a0_p1_a4_em1 = -9.15E-06 
+ b0_b0_p2_a4_em1 = -0.0679 
+ a0_b0_p2_a4_em1 = 2.20E-05 
+ b0_a0_p2_a4_em1 = 0.000391 
+ a0_a0_p2_a4_em1 = -1.16E-06 
+ b0_b0_p3_a4_em1 = 0.14 
+ a0_b0_p3_a4_em1 = -0.000166 
+ b0_a0_p3_a4_em1 = -0.00201 
+ a0_a0_p3_a4_em1 = 5.26E-06 
+ b0_b0_p4_a4_em1 = 11.1 
+ a0_b0_p4_a4_em1 = -0.0104 
+ b0_a0_p4_a4_em1 = 0 
+ a0_a0_p4_a4_em1 = 0 
+ b0_b0_b0_p1_em1 = 6.28 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 6.82 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -0.00446 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = 0.817 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -0.037 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 0.532 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.82 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 1.92 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 10.8 
+ a0_b0_b0_p2_em1 = 0.00224 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = 0.764 
+ a0_b0_a1_p2_em1 = -0.00124 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = 2.91 
+ a0_b0_a2_p2_em1 = -0.0485 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = 0.913 
+ a0_b0_a3_p2_em1 = -0.00123 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 2.71 
+ a0_b0_p2_p2_em1 = 0.00025 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 2.89 
+ a0_b0_p3_p2_em1 = 1.35E-06 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 2.97 
+ a0_b0_p4_p2_em1 = 0.00355 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 19.4 
+ a0_b0_b0_p3_em1 = 0.00254 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = 0.0291 
+ a0_b0_a1_p3_em1 = 0.00745 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 1.74 
+ a0_b0_a2_p3_em1 = 0.00387 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -2.39 
+ a0_b0_a3_p3_em1 = 0.00404 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = 3.71 
+ a0_b0_p1_p3_em1 = -0.00218 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 2.17 
+ a0_b0_p2_p3_em1 = -0.00215 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 4.49 
+ a0_b0_p3_p3_em1 = -0.00358 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 3.83 
+ a0_b0_p4_p3_em1 = 0.00402 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 28.9 
+ a0_b0_b0_p4_em1 = 0.0108 
+ b0_a0_b0_p4_em1 = -0.0347 
+ a0_a0_b0_p4_em1 = 8.99E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 1.4 
+ a0_b0_a1_p4_em1 = -0.00475 
+ b0_a0_a1_p4_em1 = 0.0106 
+ a0_a0_a1_p4_em1 = -2.55E-05 
+ b0_b0_a2_p4_em1 = 11.9 
+ a0_b0_a2_p4_em1 = -0.0106 
+ b0_a0_a2_p4_em1 = -0.0271 
+ a0_a0_a2_p4_em1 = 7.81E-05 
+ b0_b0_a3_p4_em1 = -5.27 
+ a0_b0_a3_p4_em1 = 0.00181 
+ b0_a0_a3_p4_em1 = -0.00506 
+ a0_a0_a3_p4_em1 = 1.34E-05 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = -3.23 
+ a0_b0_p1_p4_em1 = 0.00417 
+ b0_a0_p1_p4_em1 = 0.0335 
+ a0_a0_p1_p4_em1 = -9.28E-05 
+ b0_b0_p2_p4_em1 = 2.37 
+ a0_b0_p2_p4_em1 = 0.000953 
+ b0_a0_p2_p4_em1 = 0.000539 
+ a0_a0_p2_p4_em1 = -8.65E-07 
+ b0_b0_p3_p4_em1 = 2.42 
+ a0_b0_p3_p4_em1 = 0.00213 
+ b0_a0_p3_p4_em1 = 0.000306 
+ a0_a0_p3_p4_em1 = -1.09E-06 
+ b0_b0_p4_p4_em1 = 5.19 
+ a0_b0_p4_p4_em1 = -0.000374 
+ b0_a0_p4_p4_em1 = 0.00251 
+ a0_a0_p4_p4_em1 = -6.21E-06 
+ b0_b0_b0_b0_em2 = 0 
+ a0_b0_b0_b0_em2 = 0 
+ b0_a0_b0_b0_em2 = 0 
+ a0_a0_b0_b0_em2 = 0 
+ b0_b0_a0_b0_em2 = 0 
+ a0_b0_a0_b0_em2 = 0 
+ b0_a0_a0_b0_em2 = 0 
+ a0_a0_a0_b0_em2 = 0 
+ b0_b0_a1_b0_em2 = 0 
+ a0_b0_a1_b0_em2 = 0 
+ b0_a0_a1_b0_em2 = 0 
+ a0_a0_a1_b0_em2 = 0 
+ b0_b0_a2_b0_em2 = 0 
+ a0_b0_a2_b0_em2 = 0 
+ b0_a0_a2_b0_em2 = 0 
+ a0_a0_a2_b0_em2 = 0 
+ b0_b0_a3_b0_em2 = 0 
+ a0_b0_a3_b0_em2 = 0 
+ b0_a0_a3_b0_em2 = 0 
+ a0_a0_a3_b0_em2 = 0 
+ b0_b0_a4_b0_em2 = 0 
+ a0_b0_a4_b0_em2 = 0 
+ b0_a0_a4_b0_em2 = 0 
+ a0_a0_a4_b0_em2 = 0 
+ b0_b0_p1_b0_em2 = 0 
+ a0_b0_p1_b0_em2 = 0 
+ b0_a0_p1_b0_em2 = 0 
+ a0_a0_p1_b0_em2 = 0 
+ b0_b0_p2_b0_em2 = 0 
+ a0_b0_p2_b0_em2 = 0 
+ b0_a0_p2_b0_em2 = 0 
+ a0_a0_p2_b0_em2 = 0 
+ b0_b0_p3_b0_em2 = 0 
+ a0_b0_p3_b0_em2 = 0 
+ b0_a0_p3_b0_em2 = 0 
+ a0_a0_p3_b0_em2 = 0 
+ b0_b0_p4_b0_em2 = 0 
+ a0_b0_p4_b0_em2 = 0 
+ b0_a0_p4_b0_em2 = 0 
+ a0_a0_p4_b0_em2 = 0 
+ b0_b0_b0_a0_em2 = 0 
+ a0_b0_b0_a0_em2 = 0 
+ b0_a0_b0_a0_em2 = 0 
+ a0_a0_b0_a0_em2 = 0 
+ b0_b0_a0_a0_em2 = 0 
+ a0_b0_a0_a0_em2 = 0 
+ b0_a0_a0_a0_em2 = 0 
+ a0_a0_a0_a0_em2 = 0 
+ b0_b0_a1_a0_em2 = 0 
+ a0_b0_a1_a0_em2 = 0 
+ b0_a0_a1_a0_em2 = 0 
+ a0_a0_a1_a0_em2 = 0 
+ b0_b0_a2_a0_em2 = 0 
+ a0_b0_a2_a0_em2 = 0 
+ b0_a0_a2_a0_em2 = 0 
+ a0_a0_a2_a0_em2 = 0 
+ b0_b0_a3_a0_em2 = 0 
+ a0_b0_a3_a0_em2 = 0 
+ b0_a0_a3_a0_em2 = 0 
+ a0_a0_a3_a0_em2 = 0 
+ b0_b0_a4_a0_em2 = 0 
+ a0_b0_a4_a0_em2 = 0 
+ b0_a0_a4_a0_em2 = 0 
+ a0_a0_a4_a0_em2 = 0 
+ b0_b0_p1_a0_em2 = 0 
+ a0_b0_p1_a0_em2 = 0 
+ b0_a0_p1_a0_em2 = 0 
+ a0_a0_p1_a0_em2 = 0 
+ b0_b0_p2_a0_em2 = 0 
+ a0_b0_p2_a0_em2 = 0 
+ b0_a0_p2_a0_em2 = 0 
+ a0_a0_p2_a0_em2 = 0 
+ b0_b0_p3_a0_em2 = 0 
+ a0_b0_p3_a0_em2 = 0 
+ b0_a0_p3_a0_em2 = 0 
+ a0_a0_p3_a0_em2 = 0 
+ b0_b0_p4_a0_em2 = 0 
+ a0_b0_p4_a0_em2 = 0 
+ b0_a0_p4_a0_em2 = 0 
+ a0_a0_p4_a0_em2 = 0 
+ b0_b0_b0_a1_em2 = 12700 
+ a0_b0_b0_a1_em2 = -10.7 
+ b0_a0_b0_a1_em2 = 0 
+ a0_a0_b0_a1_em2 = 0 
+ b0_b0_a0_a1_em2 = 0 
+ a0_b0_a0_a1_em2 = 0 
+ b0_a0_a0_a1_em2 = 0 
+ a0_a0_a0_a1_em2 = 0 
+ b0_b0_a1_a1_em2 = -1750 
+ a0_b0_a1_a1_em2 = 0.442 
+ b0_a0_a1_a1_em2 = 0 
+ a0_a0_a1_a1_em2 = 0 
+ b0_b0_a2_a1_em2 = 3830 
+ a0_b0_a2_a1_em2 = -4.95 
+ b0_a0_a2_a1_em2 = 0 
+ a0_a0_a2_a1_em2 = 0 
+ b0_b0_a3_a1_em2 = -5270 
+ a0_b0_a3_a1_em2 = 6.23 
+ b0_a0_a3_a1_em2 = 0 
+ a0_a0_a3_a1_em2 = 0 
+ b0_b0_a4_a1_em2 = 0 
+ a0_b0_a4_a1_em2 = 0 
+ b0_a0_a4_a1_em2 = 0 
+ a0_a0_a4_a1_em2 = 0 
+ b0_b0_p1_a1_em2 = -2.05 
+ a0_b0_p1_a1_em2 = 0.00798 
+ b0_a0_p1_a1_em2 = 0 
+ a0_a0_p1_a1_em2 = 0 
+ b0_b0_p2_a1_em2 = 0.845 
+ a0_b0_p2_a1_em2 = 0.00205 
+ b0_a0_p2_a1_em2 = 0 
+ a0_a0_p2_a1_em2 = 0 
+ b0_b0_p3_a1_em2 = 3.31 
+ a0_b0_p3_a1_em2 = -0.000216 
+ b0_a0_p3_a1_em2 = 0 
+ a0_a0_p3_a1_em2 = 0 
+ b0_b0_p4_a1_em2 = 5 
+ a0_b0_p4_a1_em2 = 0 
+ b0_a0_p4_a1_em2 = 0 
+ a0_a0_p4_a1_em2 = 0 
+ b0_b0_b0_a2_em2 = 4410 
+ a0_b0_b0_a2_em2 = 6.2 
+ b0_a0_b0_a2_em2 = 0 
+ a0_a0_b0_a2_em2 = 0 
+ b0_b0_a0_a2_em2 = 0 
+ a0_b0_a0_a2_em2 = 0 
+ b0_a0_a0_a2_em2 = 0 
+ a0_a0_a0_a2_em2 = 0 
+ b0_b0_a1_a2_em2 = -107 
+ a0_b0_a1_a2_em2 = 0.023 
+ b0_a0_a1_a2_em2 = 0 
+ a0_a0_a1_a2_em2 = 0 
+ b0_b0_a2_a2_em2 = -3.74 
+ a0_b0_a2_a2_em2 = 0.00353 
+ b0_a0_a2_a2_em2 = 0 
+ a0_a0_a2_a2_em2 = 0 
+ b0_b0_a3_a2_em2 = 2.19 
+ a0_b0_a3_a2_em2 = -0.00231 
+ b0_a0_a3_a2_em2 = 0 
+ a0_a0_a3_a2_em2 = 0 
+ b0_b0_a4_a2_em2 = 0 
+ a0_b0_a4_a2_em2 = 0 
+ b0_a0_a4_a2_em2 = 0 
+ a0_a0_a4_a2_em2 = 0 
+ b0_b0_p1_a2_em2 = 1.13 
+ a0_b0_p1_a2_em2 = 0.0276 
+ b0_a0_p1_a2_em2 = 0 
+ a0_a0_p1_a2_em2 = 0 
+ b0_b0_p2_a2_em2 = 2.01 
+ a0_b0_p2_a2_em2 = -0.0214 
+ b0_a0_p2_a2_em2 = 0 
+ a0_a0_p2_a2_em2 = 0 
+ b0_b0_p3_a2_em2 = 3 
+ a0_b0_p3_a2_em2 = 0 
+ b0_a0_p3_a2_em2 = 0 
+ a0_a0_p3_a2_em2 = 0 
+ b0_b0_p4_a2_em2 = 5 
+ a0_b0_p4_a2_em2 = 0 
+ b0_a0_p4_a2_em2 = 0 
+ a0_a0_p4_a2_em2 = 0 
+ b0_b0_b0_a3_em2 = 2600 
+ a0_b0_b0_a3_em2 = 1.85 
+ b0_a0_b0_a3_em2 = 0 
+ a0_a0_b0_a3_em2 = 0 
+ b0_b0_a0_a3_em2 = 0 
+ a0_b0_a0_a3_em2 = 0 
+ b0_a0_a0_a3_em2 = 0 
+ a0_a0_a0_a3_em2 = 0 
+ b0_b0_a1_a3_em2 = 5760 
+ a0_b0_a1_a3_em2 = -10.4 
+ b0_a0_a1_a3_em2 = 0 
+ a0_a0_a1_a3_em2 = 0 
+ b0_b0_a2_a3_em2 = -488 
+ a0_b0_a2_a3_em2 = 1.6 
+ b0_a0_a2_a3_em2 = 0 
+ a0_a0_a2_a3_em2 = 0 
+ b0_b0_a3_a3_em2 = -3740 
+ a0_b0_a3_a3_em2 = 5.84 
+ b0_a0_a3_a3_em2 = 0 
+ a0_a0_a3_a3_em2 = 0 
+ b0_b0_a4_a3_em2 = 0 
+ a0_b0_a4_a3_em2 = 0 
+ b0_a0_a4_a3_em2 = 0 
+ a0_a0_a4_a3_em2 = 0 
+ b0_b0_p1_a3_em2 = 0.222 
+ a0_b0_p1_a3_em2 = 0.00232 
+ b0_a0_p1_a3_em2 = 0 
+ a0_a0_p1_a3_em2 = 0 
+ b0_b0_p2_a3_em2 = -0.0694 
+ a0_b0_p2_a3_em2 = 0.00467 
+ b0_a0_p2_a3_em2 = 0 
+ a0_a0_p2_a3_em2 = 0 
+ b0_b0_p3_a3_em2 = 6.79 
+ a0_b0_p3_a3_em2 = -0.00521 
+ b0_a0_p3_a3_em2 = 0 
+ a0_a0_p3_a3_em2 = 0 
+ b0_b0_p4_a3_em2 = 6 
+ a0_b0_p4_a3_em2 = 0 
+ b0_a0_p4_a3_em2 = 0 
+ a0_a0_p4_a3_em2 = 0 
+ b0_b0_b0_a4_em2 = 1890 
+ a0_b0_b0_a4_em2 = 1.26 
+ b0_a0_b0_a4_em2 = 0.0113 
+ a0_a0_b0_a4_em2 = 0.00637 
+ b0_b0_a0_a4_em2 = 0 
+ a0_b0_a0_a4_em2 = 0 
+ b0_a0_a0_a4_em2 = 0 
+ a0_a0_a0_a4_em2 = 0 
+ b0_b0_a1_a4_em2 = 1350 
+ a0_b0_a1_a4_em2 = -5.49 
+ b0_a0_a1_a4_em2 = -0.0285 
+ a0_a0_a1_a4_em2 = -0.0088 
+ b0_b0_a2_a4_em2 = -2820 
+ a0_b0_a2_a4_em2 = 10 
+ b0_a0_a2_a4_em2 = 0 
+ a0_a0_a2_a4_em2 = -0.0146 
+ b0_b0_a3_a4_em2 = 510 
+ a0_b0_a3_a4_em2 = -0.542 
+ b0_a0_a3_a4_em2 = 0.017 
+ a0_a0_a3_a4_em2 = 0.000791 
+ b0_b0_a4_a4_em2 = 0 
+ a0_b0_a4_a4_em2 = 0 
+ b0_a0_a4_a4_em2 = 0 
+ a0_a0_a4_a4_em2 = 0 
+ b0_b0_p1_a4_em2 = -0.778 
+ a0_b0_p1_a4_em2 = 0.00281 
+ b0_a0_p1_a4_em2 = 0.00153 
+ a0_a0_p1_a4_em2 = -3.44E-06 
+ b0_b0_p2_a4_em2 = 1.84 
+ a0_b0_p2_a4_em2 = -0.00109 
+ b0_a0_p2_a4_em2 = 0.00274 
+ a0_a0_p2_a4_em2 = -6.44E-06 
+ b0_b0_p3_a4_em2 = 2.78 
+ a0_b0_p3_a4_em2 = -0.00266 
+ b0_a0_p3_a4_em2 = 0.00388 
+ a0_a0_p3_a4_em2 = -9.07E-06 
+ b0_b0_p4_a4_em2 = 1.77 
+ a0_b0_p4_a4_em2 = 0.00658 
+ b0_a0_p4_a4_em2 = 0.0127 
+ a0_a0_p4_a4_em2 = -4.66E-05 
+ b0_b0_b0_p1_em2 = 5.22 
+ a0_b0_b0_p1_em2 = 0 
+ b0_a0_b0_p1_em2 = 0 
+ a0_a0_b0_p1_em2 = 0 
+ b0_b0_a0_p1_em2 = 0 
+ a0_b0_a0_p1_em2 = 0 
+ b0_a0_a0_p1_em2 = 0 
+ a0_a0_a0_p1_em2 = 0 
+ b0_b0_a1_p1_em2 = 0.000244 
+ a0_b0_a1_p1_em2 = 0 
+ b0_a0_a1_p1_em2 = 0 
+ a0_a0_a1_p1_em2 = 0 
+ b0_b0_a2_p1_em2 = 3.02 
+ a0_b0_a2_p1_em2 = 0 
+ b0_a0_a2_p1_em2 = 0 
+ a0_a0_a2_p1_em2 = 0 
+ b0_b0_a3_p1_em2 = -2.66 
+ a0_b0_a3_p1_em2 = 0 
+ b0_a0_a3_p1_em2 = 0 
+ a0_a0_a3_p1_em2 = 0 
+ b0_b0_a4_p1_em2 = 0 
+ a0_b0_a4_p1_em2 = 0 
+ b0_a0_a4_p1_em2 = 0 
+ a0_a0_a4_p1_em2 = 0 
+ b0_b0_p1_p1_em2 = 0.798 
+ a0_b0_p1_p1_em2 = 0 
+ b0_a0_p1_p1_em2 = 0 
+ a0_a0_p1_p1_em2 = 0 
+ b0_b0_p2_p1_em2 = 1.28 
+ a0_b0_p2_p1_em2 = 0 
+ b0_a0_p2_p1_em2 = 0 
+ a0_a0_p2_p1_em2 = 0 
+ b0_b0_p3_p1_em2 = 3.29 
+ a0_b0_p3_p1_em2 = 0 
+ b0_a0_p3_p1_em2 = 0 
+ a0_a0_p3_p1_em2 = 0 
+ b0_b0_p4_p1_em2 = 5.4 
+ a0_b0_p4_p1_em2 = 0 
+ b0_a0_p4_p1_em2 = 0 
+ a0_a0_p4_p1_em2 = 0 
+ b0_b0_b0_p2_em2 = 18 
+ a0_b0_b0_p2_em2 = 0 
+ b0_a0_b0_p2_em2 = 0 
+ a0_a0_b0_p2_em2 = 0 
+ b0_b0_a0_p2_em2 = 0 
+ a0_b0_a0_p2_em2 = 0 
+ b0_a0_a0_p2_em2 = 0 
+ a0_a0_a0_p2_em2 = 0 
+ b0_b0_a1_p2_em2 = 0 
+ a0_b0_a1_p2_em2 = 0 
+ b0_a0_a1_p2_em2 = 0 
+ a0_a0_a1_p2_em2 = 0 
+ b0_b0_a2_p2_em2 = 0 
+ a0_b0_a2_p2_em2 = 0 
+ b0_a0_a2_p2_em2 = 0 
+ a0_a0_a2_p2_em2 = 0 
+ b0_b0_a3_p2_em2 = 0 
+ a0_b0_a3_p2_em2 = 0 
+ b0_a0_a3_p2_em2 = 0 
+ a0_a0_a3_p2_em2 = 0 
+ b0_b0_a4_p2_em2 = 0 
+ a0_b0_a4_p2_em2 = 0 
+ b0_a0_a4_p2_em2 = 0 
+ a0_a0_a4_p2_em2 = 0 
+ b0_b0_p1_p2_em2 = 0 
+ a0_b0_p1_p2_em2 = 0 
+ b0_a0_p1_p2_em2 = 0 
+ a0_a0_p1_p2_em2 = 0 
+ b0_b0_p2_p2_em2 = 2 
+ a0_b0_p2_p2_em2 = 0 
+ b0_a0_p2_p2_em2 = 0 
+ a0_a0_p2_p2_em2 = 0 
+ b0_b0_p3_p2_em2 = 3 
+ a0_b0_p3_p2_em2 = 0 
+ b0_a0_p3_p2_em2 = 0 
+ a0_a0_p3_p2_em2 = 0 
+ b0_b0_p4_p2_em2 = 4 
+ a0_b0_p4_p2_em2 = 0 
+ b0_a0_p4_p2_em2 = 0 
+ a0_a0_p4_p2_em2 = 0 
+ b0_b0_b0_p3_em2 = 19.8 
+ a0_b0_b0_p3_em2 = 0.00692 
+ b0_a0_b0_p3_em2 = 0 
+ a0_a0_b0_p3_em2 = 0 
+ b0_b0_a0_p3_em2 = 0 
+ a0_b0_a0_p3_em2 = 0 
+ b0_a0_a0_p3_em2 = 0 
+ a0_a0_a0_p3_em2 = 0 
+ b0_b0_a1_p3_em2 = -11.5 
+ a0_b0_a1_p3_em2 = 0.0295 
+ b0_a0_a1_p3_em2 = 0 
+ a0_a0_a1_p3_em2 = 0 
+ b0_b0_a2_p3_em2 = -4 
+ a0_b0_a2_p3_em2 = 0.0109 
+ b0_a0_a2_p3_em2 = 0 
+ a0_a0_a2_p3_em2 = 0 
+ b0_b0_a3_p3_em2 = 3.56 
+ a0_b0_a3_p3_em2 = -0.016 
+ b0_a0_a3_p3_em2 = 0 
+ a0_a0_a3_p3_em2 = 0 
+ b0_b0_a4_p3_em2 = 0 
+ a0_b0_a4_p3_em2 = 0 
+ b0_a0_a4_p3_em2 = 0 
+ a0_a0_a4_p3_em2 = 0 
+ b0_b0_p1_p3_em2 = -2.62 
+ a0_b0_p1_p3_em2 = 0.0113 
+ b0_a0_p1_p3_em2 = 0 
+ a0_a0_p1_p3_em2 = 0 
+ b0_b0_p2_p3_em2 = -3.84 
+ a0_b0_p2_p3_em2 = 0.013 
+ b0_a0_p2_p3_em2 = 0 
+ a0_a0_p2_p3_em2 = 0 
+ b0_b0_p3_p3_em2 = 2.21 
+ a0_b0_p3_p3_em2 = 0.00228 
+ b0_a0_p3_p3_em2 = 0 
+ a0_a0_p3_p3_em2 = 0 
+ b0_b0_p4_p3_em2 = 5.14 
+ a0_b0_p4_p3_em2 = -0.00163 
+ b0_a0_p4_p3_em2 = 0 
+ a0_a0_p4_p3_em2 = 0 
+ b0_b0_b0_p4_em2 = 39.6 
+ a0_b0_b0_p4_em2 = -0.00211 
+ b0_a0_b0_p4_em2 = 0.0279 
+ a0_a0_b0_p4_em2 = -9.48E-05 
+ b0_b0_a0_p4_em2 = 0 
+ a0_b0_a0_p4_em2 = 0 
+ b0_a0_a0_p4_em2 = 0 
+ a0_a0_a0_p4_em2 = 0 
+ b0_b0_a1_p4_em2 = -2.46 
+ a0_b0_a1_p4_em2 = 0.00453 
+ b0_a0_a1_p4_em2 = -0.0465 
+ a0_a0_a1_p4_em2 = 0.000104 
+ b0_b0_a2_p4_em2 = -0.108 
+ a0_b0_a2_p4_em2 = -0.0101 
+ b0_a0_a2_p4_em2 = -0.107 
+ a0_a0_a2_p4_em2 = 0.000262 
+ b0_b0_a3_p4_em2 = -1.11 
+ a0_b0_a3_p4_em2 = -0.00392 
+ b0_a0_a3_p4_em2 = 0.0167 
+ a0_a0_a3_p4_em2 = -4.83E-05 
+ b0_b0_a4_p4_em2 = 0 
+ a0_b0_a4_p4_em2 = 0 
+ b0_a0_a4_p4_em2 = 0 
+ a0_a0_a4_p4_em2 = 0 
+ b0_b0_p1_p4_em2 = 4.76 
+ a0_b0_p1_p4_em2 = -0.0074 
+ b0_a0_p1_p4_em2 = -0.0176 
+ a0_a0_p1_p4_em2 = 4.86E-05 
+ b0_b0_p2_p4_em2 = -2.99 
+ a0_b0_p2_p4_em2 = 0.0103 
+ b0_a0_p2_p4_em2 = 0.0428 
+ a0_a0_p2_p4_em2 = -9.86E-05 
+ b0_b0_p3_p4_em2 = 1.58 
+ a0_b0_p3_p4_em2 = 0.00157 
+ b0_a0_p3_p4_em2 = 0.00454 
+ a0_a0_p3_p4_em2 = -8.88E-06 
+ b0_b0_p4_p4_em2 = 5.31 
+ a0_b0_p4_p4_em2 = -0.00228 
+ b0_a0_p4_p4_em2 = 0.0237 
+ a0_a0_p4_p4_em2 = -6.33E-05 
}
endsection pmos45b_10hv_dfrt

section pmoshs45_10hv_dfrt
include "soachecks_top.scs" section=pmoshs45_10hv_soa
if (enable_relimo == 1) {
apmos_ll_10hv_hci1 (d g s) relimo_aging_hci1 relimo_ratio20_a=relimo_ratio20_a_bti_pmoshs45_10hv relimo_ratio20_b=relimo_ratio20_b_bti_pmoshs45_10hv relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=0 relimo_device_name=pmos_ll_10hv relimo_probe_name=mpmos_ll_10hv_i relimo_a_gm=relimo_a_gm_1_hci_pmos_ll_10hv relimo_a_idlin=relimo_a_idlin_1_hci_pmos_ll_10hv relimo_a_idsat=relimo_a_idsat_1_hci_pmos_ll_10hv relimo_a_vth=relimo_a_vth_1_hci_pmos_ll_10hv relimo_c=relimo_c_1_hci_pmos_ll_10hv relimo_condvd=relimo_condvd_hci_pmos_ll_10hv relimo_condvg=relimo_condvg_hci_pmos_ll_10hv relimo_intercept=relimo_intercept_1_hci_pmos_ll_10hv relimo_m=relimo_m_1_hci_pmos_ll_10hv relimo_n=relimo_n_1_hci_pmos_ll_10hv relimo_r=relimo_r_1_hci_pmos_ll_10hv relimo_ratio1_a=1.0 relimo_ratio1_b=0 relimo_ratio2_a=relimo_ratio2_a_hci_pmos_ll_10hv relimo_ratio2_b=relimo_ratio2_b_hci_pmos_ll_10hv relimo_ratio3_a=relimo_ratio3_a_hci_pmos_ll_10hv relimo_ratio3_b=relimo_ratio3_b_hci_pmos_ll_10hv relimo_ratio4_a=relimo_ratio4_a_hci_pmos_ll_10hv relimo_ratio4_b=relimo_ratio4_b_hci_pmos_ll_10hv relimo_ratio5_a=relimo_ratio5_a_hci_pmos_ll_10hv relimo_ratio5_b=relimo_ratio5_b_hci_pmos_ll_10hv relimo_ratio6_a=relimo_ratio6_a_hci_pmos_ll_10hv relimo_ratio6_b=relimo_ratio6_b_hci_pmos_ll_10hv relimo_ratio7_a=relimo_ratio7_a_hci_pmos_ll_10hv relimo_ratio7_b=relimo_ratio7_b_hci_pmos_ll_10hv relimo_ratio8_a=relimo_ratio8_a_hci_pmos_ll_10hv relimo_ratio8_b=relimo_ratio8_b_hci_pmos_ll_10hv relimo_ratio9_a=relimo_ratio9_a_hci_pmos_ll_10hv relimo_ratio9_b=relimo_ratio9_b_hci_pmos_ll_10hv relimo_ratio10_a=relimo_ratio10_a_hci_pmos_ll_10hv relimo_ratio10_b=relimo_ratio10_b_hci_pmos_ll_10hv relimo_ratio11_a=relimo_ratio11_a_hci_pmos_ll_10hv relimo_ratio11_b=relimo_ratio11_b_hci_pmos_ll_10hv relimo_ratio12_a=relimo_ratio12_a_hci_pmos_ll_10hv relimo_ratio12_b=relimo_ratio12_b_hci_pmos_ll_10hv relimo_ratio13_a=relimo_ratio13_a_hci_pmos_ll_10hv relimo_ratio13_b=relimo_ratio13_b_hci_pmos_ll_10hv relimo_ratio14_a=relimo_ratio14_a_hci_pmos_ll_10hv relimo_ratio14_b=relimo_ratio14_b_hci_pmos_ll_10hv relimo_ratio15_a=relimo_ratio15_a_hci_pmos_ll_10hv relimo_ratio15_b=relimo_ratio15_b_hci_pmos_ll_10hv relimo_ratio16_a=relimo_ratio16_a_hci_pmos_ll_10hv relimo_ratio16_b=relimo_ratio16_b_hci_pmos_ll_10hv relimo_ratio_vth2a0=relimo_ratio_vth2a0_hci_pmos_ll_10hv relimo_vth=relimo_vth_hci_pmos_ll_10hv
apmoshs45_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmoshs45_10hv_esdchk_1 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=1 enable=soa rule="esd_pmoshs45_Vt1=64p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-64.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45_10hv_esdchk_2 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=2 enable=soa rule="esd_pmoshs45_Vt1>64p1_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 64.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.1
apmoshs45_10hv_esdchk_3 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=3 enable=soa rule="esd_pmoshs45_=Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0))-64.1)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmoshs45_10hv_esdchk_4 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=4 enable=soa rule="esd_pmoshs45_>Vt1_Vgs_0p0_1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 1.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.5 formulae_cond3="(abs(V(s)-V(d)+(-0.0*(V(s)-V(g)-0.0)))) > 64.1 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=64.1
apmoshs45_10hv_esdchk_5 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=5 enable=soa rule="esd_pmoshs45_Vt1=64p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-64.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45_10hv_esdchk_6 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=6 enable=soa rule="esd_pmoshs45_Vt1>64p1_Vgs1p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-1.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 64.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.1
apmoshs45_10hv_esdchk_7 (d g s b sub) monitor_esd_pmoshs45_10hv ruleNum=7 enable=soa rule="esd_pmoshs45_=Vt1_Vgs>1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="(abs(V(s)-V(d)-64.1)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pmoshs45_>Vt1_Vgs>1p5" targetT=0.0 formulae_cond1="V(s-to-g) > 1.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.5 formulae_cond2="absV(s-to-d) > 64.1 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=64.1
apmoshs45_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_pmoshs45_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmoshs45_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_pmoshs45_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmoshs45_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_pmoshs45_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 64.1 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=64.1
apmoshs45_10hv_esdchk_12 (b s) monitor2t enable=soa rule="esd_pmoshs45_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmoshs45_10hv_esdchk_13 (b d) monitor2t enable=soa rule="esd_pmoshs45_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 64.1 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=64.1
apmoshs45_10hv_esdchk_14 (b sub) monitor2t enable=soa rule="esd_pmoshs45_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmoshs45_10hv_esdchk_15 (sub d) monitor2t enable=soa rule="esd_pmoshs45_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmoshs45_10hv_esdchk_16 (d b) monitor2t enable=soa rule="esd_pmoshs45_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
}
endsection pmoshs45_10hv_dfrt

section pmoshs45b_10hv_dfrt
include "soachecks_top.scs" section=pmoshs45b_10hv_soa
if (enable_relimo == 1) {
apmoshs45b_hci (d g s sub) relimo_aging_hci_pmoshs45b l=l w=w*ng relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_hci_aging_open_flag=relimo_hci_aging_open_flag 
apmoshs45b_bti (d g s b) relimo_aging_bti relimo_bi_aging_flag=relimo_bi_aging_flag relimo_op_aging_flag=relimo_op_aging_flag relimo_aging_tstart=relimo_aging_tstart relimo_aging_time=relimo_aging_time dela_vth_relimo=dela_vth_relimo delr_u0_relimo=delr_u0_relimo delr_rdsw_relimo=delr_rdsw_relimo delr_a0_relimo=delr_a0_relimo relimo_nbti_aging_open_flag=relimo_nbti_aging_open_flag relimo_pbti_aging_open_flag=relimo_pbti_aging_open_flag
}
if (enable_esdsoa == 1) {
apmoshs45b_10hv_esdchk_1 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=1 enable=soa rule="esd_pmoshs45b_Vt1=68p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-68.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45b_10hv_esdchk_2 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=2 enable=soa rule="esd_pmoshs45b_Vt1>68p5_Vgs0p0" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 68.5 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=68.5
apmoshs45b_10hv_esdchk_3 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=3 enable=soa rule="esd_pmoshs45b_=Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-0.0))-68.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9
apmoshs45b_10hv_esdchk_4 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=4 enable=soa rule="esd_pmoshs45b_>Vt1_Vgs_0p0_3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(s-to-g) < 3.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.5 formulae_cond3="(abs(V(s)-V(d)+(0.6*(V(s)-V(g)-0.0)))) > 68.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=68.5
apmoshs45b_10hv_esdchk_5 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=5 enable=soa rule="esd_pmoshs45b_Vt1=66p3_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(s)-V(d)-66.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45b_10hv_esdchk_6 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=6 enable=soa rule="esd_pmoshs45b_Vt1>66p3_Vgs3p5" targetT=0.0 formulae_cond1="(abs(V(s)-V(g)-3.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="absV(s-to-d) > 66.3 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=66.3
apmoshs45b_10hv_esdchk_7 (d g s b sub) monitor_esd_pmoshs45b_10hv ruleNum=7 enable=soa rule="esd_pmoshs45b_=Vt1_Vgs>3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="(abs(V(s)-V(d)-66.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9
apmoshs45b_10hv_esdchk_8 (s g s d) monitor4t enable=soa rule="esd_pmoshs45b_>Vt1_Vgs>3p5" targetT=0.0 formulae_cond1="V(s-to-g) > 3.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.5 formulae_cond2="absV(s-to-d) > 66.3 for duration > 0.0ns" monitorType_cond2=5 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=66.3
apmoshs45b_10hv_esdchk_9 (g b) monitor2t enable=soa rule="esd_pmoshs45b_Vgb_BVox" targetT=0.0 formulae_cond1="absV(g-to-b) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmoshs45b_10hv_esdchk_10 (g s) monitor2t enable=soa rule="esd_pmoshs45b_Vgs_BVox" targetT=0.0 formulae_cond1="absV(g-to-s) > 16.7 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=16.7
apmoshs45b_10hv_esdchk_11 (g d) monitor2t enable=soa rule="esd_pmoshs45b_Vgd_BVox" targetT=0.0 formulae_cond1="absV(g-to-d) > 68.5 for duration > 0.0ns" monitorType_cond1=5 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=68.5
apmoshs45b_10hv_esdchk_12 (b s) monitor2t enable=soa rule="esd_pmoshs45b_Vbs_Vt1" targetT=0.0 formulae_cond1="V(b-to-s) > 10.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=10.0
apmoshs45b_10hv_esdchk_13 (b d) monitor2t enable=soa rule="esd_pmoshs45b_Vbd_Vt1" targetT=0.0 formulae_cond1="V(b-to-d) > 68.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=68.5
apmoshs45b_10hv_esdchk_14 (b sub) monitor2t enable=soa rule="esd_pmoshs45b_Vbsub_maxV" targetT=0.0 formulae_cond1="V(b-to-sub) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmoshs45b_10hv_esdchk_15 (sub d) monitor2t enable=soa rule="esd_pmoshs45b_Vsubd_maxNegV" targetT=0.0 formulae_cond1="V(sub-to-d) > 200.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=200.0
apmoshs45b_10hv_esdchk_16 (d b) monitor2t enable=soa rule="esd_pmoshs45b_Vdb_Vt1" targetT=0.0 formulae_cond1="V(d-to-b) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0
}
if (enable_aging == 1) {
// mos nbti checking
  nbti (d g s b) mnbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_nbti_active
+ k         = presto_nbti_go2_k
+ a         = presto_nbti_go2_a
+ fstat     = presto_nbti_go2_fstat
+ n         = presto_nbti_go2_n
+ m         = presto_nbti_go2_m
+ vgexp     = presto_nbti_go2_vgexp
+ ea        = presto_nbti_go2_ea
+ lpow      = presto_nbti_go2_lpow
+ wpow      = presto_nbti_go2_wpow
+ vbxexp    = presto_nbti_go2_vbxexp
+ lexp      = presto_nbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = nbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos pbti checking
  pbti (d g s b) mpbti4 
+ type      = -1
+ l         = l
+ w         = w
+ active    = presto_active * presto_device_active * presto_pbti_active
+ k         = presto_pbti_go2_k
+ a         = presto_pbti_go2_a
+ fstat     = presto_pbti_go2_fstat
+ n         = presto_pbti_go2_n
+ m         = presto_pbti_go2_m
+ vgexp     = presto_pbti_go2_vgexp
+ ea        = presto_pbti_go2_ea
+ lpow      = presto_pbti_go2_lpow
+ wpow      = presto_pbti_go2_wpow
+ vbxexp    = presto_pbti_go2_vbxexp
+ lexp      = presto_pbti_go2_lexp
+ tstart    = presto_tstart
+ tstop     = presto_tstop
+ swagecheck= 0
+ tage      = presto_tage
+ damage    = pbtidamage
+ tempcrit  = presto_tempcrit_bti
+ dvtcrit   = presto_vtshiftcrit
+ dvthmax   = presto_dvthmax
// mos hci checking
  hci (d g s sub d dtemp) mhcihv5
+ scaling1        = 1e-5
+ scaling2        = 1e-15 
+ hcidamage1      = hcidamage1
+ hcidamage2      = hcidamage2
+ offdamage1      = offdamage1
+ offdamage2      = offdamage2
+ hvgsdamage      = hvgsdamage 
+ hciactive       = presto_hci_active
+ offactive       = presto_offstate_active
+ hvgsactive      = presto_hvgs_active 
+ swagecheck      = 0
+ tage            = presto_tage
+ tstart          = presto_tstart
+ tstop           = presto_tstop
+ active          = presto_active * presto_device_active
+ simprobeactive  = 1
+ simprobedevice  = "mamost"
+ simprobeparam   = "ide"
+ simprobeparamsign = -1
+ type            = -1
+ l               = l*1e-6
+ w               = w*1e-6
+ mult            = ng
+ hciep           = 0.063            //Regular HCI part
+ hciphibel       = 3.2
+ hciphibh        = 4.8
+ hcia1           = 0.328*presto_idRatio
+ hcia2           = 1.87*presto_idRatio
+ hcic1           = 1750
+ hcib1           = 0.00021*presto_idRatio
+ hcin            = 3
+ hcialpha1       = 3.31E-08
+ hcibeta1        = 1.09
+ hcilambdah0     = 9.75E-07
+ hcialpha2       = 1.02E-29
+ hcibeta2        = 1.82
+ hcilambdael0    = 3.57E-07
+ hcifstattau1    = 0.00602
+ hcifstattau2    = 0.00649
+ hcifstattau12   = 444
+ hcifstattau21   = 444
+ hcimexpa        = 1
+ hcideltaa       = 6*presto_idRatio
+ hcimexpb        = 1
+ hcideltab       = 0.4*presto_idRatio
+ hcivgscutoff    = -0.3
+ hcimexpcutoff   = 1
+ hcideltacutoff  = 0.01
+ offa1           = 0.859*presto_idRatio   	 //Off state HCI part
+ offn1           = 1
+ offa2           = 0.692*presto_idRatio
+ offn2           = 0.64
+ offalpha1       = 3.82E+05
+ offbeta1        = 0.191
+ offea1          = 0.388
+ offalpha2       = 2.72E+14
+ offbeta2        = 0.497
+ offea2          = 6.64E-12
+ offfstattau1    = 0.00799
+ offfstattau2    = 0.00178
+ offfstattau12   = 1120
+ offfstattau21   = 1120
+ offmexpa        = 1
+ offdeltaa       = 0.5*presto_idRatio
+ offmexpb        = 1
+ offdeltab       = 0.1*presto_idRatio
+ hvgsa           = 1000*presto_vthRatio    	     // High Vgs HCI part
+ hvgsn           = 0.233
+ hvgsalpha       = 1.89E+33
+ hvgsbeta        = 3.17E-05
+ hvgsgamma       = 22.7
+ hvgsdelta       = 8.94
+ hvgsepsilon     = 0
+ hvgsea          = 0.559
+ hvgsrth         = 0.00295
+ hvgsfstat       = 0.135   	  
+ b0_b0_b0_b0_em1 = 0 
+ a0_b0_b0_b0_em1 = 0 
+ b0_a0_b0_b0_em1 = 0 
+ a0_a0_b0_b0_em1 = 0 
+ b0_b0_a0_b0_em1 = 0 
+ a0_b0_a0_b0_em1 = 0 
+ b0_a0_a0_b0_em1 = 0 
+ a0_a0_a0_b0_em1 = 0 
+ b0_b0_a1_b0_em1 = 0 
+ a0_b0_a1_b0_em1 = 0 
+ b0_a0_a1_b0_em1 = 0 
+ a0_a0_a1_b0_em1 = 0 
+ b0_b0_a2_b0_em1 = 0 
+ a0_b0_a2_b0_em1 = 0 
+ b0_a0_a2_b0_em1 = 0 
+ a0_a0_a2_b0_em1 = 0 
+ b0_b0_a3_b0_em1 = 0 
+ a0_b0_a3_b0_em1 = 0 
+ b0_a0_a3_b0_em1 = 0 
+ a0_a0_a3_b0_em1 = 0 
+ b0_b0_a4_b0_em1 = 0 
+ a0_b0_a4_b0_em1 = 0 
+ b0_a0_a4_b0_em1 = 0 
+ a0_a0_a4_b0_em1 = 0 
+ b0_b0_p1_b0_em1 = 0 
+ a0_b0_p1_b0_em1 = 0 
+ b0_a0_p1_b0_em1 = 0 
+ a0_a0_p1_b0_em1 = 0 
+ b0_b0_p2_b0_em1 = 0 
+ a0_b0_p2_b0_em1 = 0 
+ b0_a0_p2_b0_em1 = 0 
+ a0_a0_p2_b0_em1 = 0 
+ b0_b0_p3_b0_em1 = 0 
+ a0_b0_p3_b0_em1 = 0 
+ b0_a0_p3_b0_em1 = 0 
+ a0_a0_p3_b0_em1 = 0 
+ b0_b0_p4_b0_em1 = 0 
+ a0_b0_p4_b0_em1 = 0 
+ b0_a0_p4_b0_em1 = 0 
+ a0_a0_p4_b0_em1 = 0 
+ b0_b0_b0_a0_em1 = 0 
+ a0_b0_b0_a0_em1 = 0 
+ b0_a0_b0_a0_em1 = 0 
+ a0_a0_b0_a0_em1 = 0 
+ b0_b0_a0_a0_em1 = 0 
+ a0_b0_a0_a0_em1 = 0 
+ b0_a0_a0_a0_em1 = 0 
+ a0_a0_a0_a0_em1 = 0 
+ b0_b0_a1_a0_em1 = 0 
+ a0_b0_a1_a0_em1 = 0 
+ b0_a0_a1_a0_em1 = 0 
+ a0_a0_a1_a0_em1 = 0 
+ b0_b0_a2_a0_em1 = 0 
+ a0_b0_a2_a0_em1 = 0 
+ b0_a0_a2_a0_em1 = 0 
+ a0_a0_a2_a0_em1 = 0 
+ b0_b0_a3_a0_em1 = 0 
+ a0_b0_a3_a0_em1 = 0 
+ b0_a0_a3_a0_em1 = 0 
+ a0_a0_a3_a0_em1 = 0 
+ b0_b0_a4_a0_em1 = 0 
+ a0_b0_a4_a0_em1 = 0 
+ b0_a0_a4_a0_em1 = 0 
+ a0_a0_a4_a0_em1 = 0 
+ b0_b0_p1_a0_em1 = 0 
+ a0_b0_p1_a0_em1 = 0 
+ b0_a0_p1_a0_em1 = 0 
+ a0_a0_p1_a0_em1 = 0 
+ b0_b0_p2_a0_em1 = 0 
+ a0_b0_p2_a0_em1 = 0 
+ b0_a0_p2_a0_em1 = 0 
+ a0_a0_p2_a0_em1 = 0 
+ b0_b0_p3_a0_em1 = 0 
+ a0_b0_p3_a0_em1 = 0 
+ b0_a0_p3_a0_em1 = 0 
+ a0_a0_p3_a0_em1 = 0 
+ b0_b0_p4_a0_em1 = 0 
+ a0_b0_p4_a0_em1 = 0 
+ b0_a0_p4_a0_em1 = 0 
+ a0_a0_p4_a0_em1 = 0 
+ b0_b0_b0_a1_em1 = 81900 
+ a0_b0_b0_a1_em1 = -105 
+ b0_a0_b0_a1_em1 = 0 
+ a0_a0_b0_a1_em1 = 0 
+ b0_b0_a0_a1_em1 = 0 
+ a0_b0_a0_a1_em1 = 0 
+ b0_a0_a0_a1_em1 = 0 
+ a0_a0_a0_a1_em1 = 0 
+ b0_b0_a1_a1_em1 = -847 
+ a0_b0_a1_a1_em1 = 0.00699 
+ b0_a0_a1_a1_em1 = 0 
+ a0_a0_a1_a1_em1 = 0 
+ b0_b0_a2_a1_em1 = -3330 
+ a0_b0_a2_a1_em1 = 2.56 
+ b0_a0_a2_a1_em1 = 0 
+ a0_a0_a2_a1_em1 = 0 
+ b0_b0_a3_a1_em1 = -1480 
+ a0_b0_a3_a1_em1 = -5.49 
+ b0_a0_a3_a1_em1 = 0 
+ a0_a0_a3_a1_em1 = 0 
+ b0_b0_a4_a1_em1 = 0 
+ a0_b0_a4_a1_em1 = 0 
+ b0_a0_a4_a1_em1 = 0 
+ a0_a0_a4_a1_em1 = 0 
+ b0_b0_p1_a1_em1 = -76.1 
+ a0_b0_p1_a1_em1 = 0.12 
+ b0_a0_p1_a1_em1 = 0 
+ a0_a0_p1_a1_em1 = 0 
+ b0_b0_p2_a1_em1 = 2.62 
+ a0_b0_p2_a1_em1 = -0.0026 
+ b0_a0_p2_a1_em1 = 0 
+ a0_a0_p2_a1_em1 = 0 
+ b0_b0_p3_a1_em1 = 3.45 
+ a0_b0_p3_a1_em1 = -0.000367 
+ b0_a0_p3_a1_em1 = 0 
+ a0_a0_p3_a1_em1 = 0 
+ b0_b0_p4_a1_em1 = 4.9 
+ a0_b0_p4_a1_em1 = -0.0017 
+ b0_a0_p4_a1_em1 = 0 
+ a0_a0_p4_a1_em1 = 0 
+ b0_b0_b0_a2_em1 = 7060 
+ a0_b0_b0_a2_em1 = 2.16 
+ b0_a0_b0_a2_em1 = 0 
+ a0_a0_b0_a2_em1 = 0 
+ b0_b0_a0_a2_em1 = 0 
+ a0_b0_a0_a2_em1 = 0 
+ b0_a0_a0_a2_em1 = 0 
+ a0_a0_a0_a2_em1 = 0 
+ b0_b0_a1_a2_em1 = 2400 
+ a0_b0_a1_a2_em1 = -3.25 
+ b0_a0_a1_a2_em1 = 0 
+ a0_a0_a1_a2_em1 = 0 
+ b0_b0_a2_a2_em1 = 332 
+ a0_b0_a2_a2_em1 = -4.87 
+ b0_a0_a2_a2_em1 = 0 
+ a0_a0_a2_a2_em1 = 0 
+ b0_b0_a3_a2_em1 = -1540 
+ a0_b0_a3_a2_em1 = 0.892 
+ b0_a0_a3_a2_em1 = 0 
+ a0_a0_a3_a2_em1 = 0 
+ b0_b0_a4_a2_em1 = -100 
+ a0_b0_a4_a2_em1 = 0 
+ b0_a0_a4_a2_em1 = 0 
+ a0_a0_a4_a2_em1 = 0 
+ b0_b0_p1_a2_em1 = -1.7 
+ a0_b0_p1_a2_em1 = 0.00894 
+ b0_a0_p1_a2_em1 = 0 
+ a0_a0_p1_a2_em1 = 0 
+ b0_b0_p2_a2_em1 = -1.22 
+ a0_b0_p2_a2_em1 = 0.00962 
+ b0_a0_p2_a2_em1 = 0 
+ a0_a0_p2_a2_em1 = 0 
+ b0_b0_p3_a2_em1 = 3.72 
+ a0_b0_p3_a2_em1 = 0.0171 
+ b0_a0_p3_a2_em1 = 0 
+ a0_a0_p3_a2_em1 = 0 
+ b0_b0_p4_a2_em1 = 4.5 
+ a0_b0_p4_a2_em1 = 0 
+ b0_a0_p4_a2_em1 = 0 
+ a0_a0_p4_a2_em1 = 0 
+ b0_b0_b0_a3_em1 = 2770 
+ a0_b0_b0_a3_em1 = 1.24 
+ b0_a0_b0_a3_em1 = 0 
+ a0_a0_b0_a3_em1 = 0 
+ b0_b0_a0_a3_em1 = 0 
+ a0_b0_a0_a3_em1 = 0 
+ b0_a0_a0_a3_em1 = 0 
+ a0_a0_a0_a3_em1 = 0 
+ b0_b0_a1_a3_em1 = -199 
+ a0_b0_a1_a3_em1 = -1.26 
+ b0_a0_a1_a3_em1 = 0 
+ a0_a0_a1_a3_em1 = 0 
+ b0_b0_a2_a3_em1 = -3090 
+ a0_b0_a2_a3_em1 = -0.0858 
+ b0_a0_a2_a3_em1 = 0 
+ a0_a0_a2_a3_em1 = 0 
+ b0_b0_a3_a3_em1 = -452 
+ a0_b0_a3_a3_em1 = 2.1 
+ b0_a0_a3_a3_em1 = 0 
+ a0_a0_a3_a3_em1 = 0 
+ b0_b0_a4_a3_em1 = 0 
+ a0_b0_a4_a3_em1 = 0 
+ b0_a0_a4_a3_em1 = 0 
+ a0_a0_a4_a3_em1 = 0 
+ b0_b0_p1_a3_em1 = 0.86 
+ a0_b0_p1_a3_em1 = -0.00116 
+ b0_a0_p1_a3_em1 = 0 
+ a0_a0_p1_a3_em1 = 0 
+ b0_b0_p2_a3_em1 = 1.34 
+ a0_b0_p2_a3_em1 = 0.000838 
+ b0_a0_p2_a3_em1 = 0 
+ a0_a0_p2_a3_em1 = 0 
+ b0_b0_p3_a3_em1 = 2.25 
+ a0_b0_p3_a3_em1 = 0.000197 
+ b0_a0_p3_a3_em1 = 0 
+ a0_a0_p3_a3_em1 = 0 
+ b0_b0_p4_a3_em1 = 3 
+ a0_b0_p4_a3_em1 = 0 
+ b0_a0_p4_a3_em1 = 0 
+ a0_a0_p4_a3_em1 = 0 
+ b0_b0_b0_a4_em1 = 2050 
+ a0_b0_b0_a4_em1 = -0.0289 
+ b0_a0_b0_a4_em1 = 0.026 
+ a0_a0_b0_a4_em1 = -2.36E-06 
+ b0_b0_a0_a4_em1 = 0 
+ a0_b0_a0_a4_em1 = 0 
+ b0_a0_a0_a4_em1 = 0 
+ a0_a0_a0_a4_em1 = 0 
+ b0_b0_a1_a4_em1 = 3840 
+ a0_b0_a1_a4_em1 = -8.21 
+ b0_a0_a1_a4_em1 = 0.000587 
+ a0_a0_a1_a4_em1 = 8.50E-05 
+ b0_b0_a2_a4_em1 = -1080 
+ a0_b0_a2_a4_em1 = 2 
+ b0_a0_a2_a4_em1 = 0 
+ a0_a0_a2_a4_em1 = -0.000693 
+ b0_b0_a3_a4_em1 = 756 
+ a0_b0_a3_a4_em1 = 0.167 
+ b0_a0_a3_a4_em1 = -0.00087 
+ a0_a0_a3_a4_em1 = -1.86E-05 
+ b0_b0_a4_a4_em1 = 0 
+ a0_b0_a4_a4_em1 = 0 
+ b0_a0_a4_a4_em1 = 0 
+ a0_a0_a4_a4_em1 = 0 
+ b0_b0_p1_a4_em1 = 3.62 
+ a0_b0_p1_a4_em1 = -0.00109 
+ b0_a0_p1_a4_em1 = -0.000502 
+ a0_a0_p1_a4_em1 = 4.02E-06 
+ b0_b0_p2_a4_em1 = 3.97 
+ a0_b0_p2_a4_em1 = -0.00054 
+ b0_a0_p2_a4_em1 = -0.000209 
+ a0_a0_p2_a4_em1 = -2.47E-06 
+ b0_b0_p3_a4_em1 = 3.92 
+ a0_b0_p3_a4_em1 = 0.00193 
+ b0_a0_p3_a4_em1 = 0.000182 
+ a0_a0_p3_a4_em1 = 2.95E-06 
+ b0_b0_p4_a4_em1 = 6 
+ a0_b0_p4_a4_em1 = -6.94E-06 
+ b0_a0_p4_a4_em1 = 0.00197 
+ a0_a0_p4_a4_em1 = -5.04E-06 
+ b0_b0_b0_p1_em1 = 4.51 
+ a0_b0_b0_p1_em1 = 0 
+ b0_a0_b0_p1_em1 = 0 
+ a0_a0_b0_p1_em1 = 0 
+ b0_b0_a0_p1_em1 = 0 
+ a0_b0_a0_p1_em1 = 0 
+ b0_a0_a0_p1_em1 = 0 
+ a0_a0_a0_p1_em1 = 0 
+ b0_b0_a1_p1_em1 = 0.383 
+ a0_b0_a1_p1_em1 = 0 
+ b0_a0_a1_p1_em1 = 0 
+ a0_a0_a1_p1_em1 = 0 
+ b0_b0_a2_p1_em1 = -0.905 
+ a0_b0_a2_p1_em1 = 0 
+ b0_a0_a2_p1_em1 = 0 
+ a0_a0_a2_p1_em1 = 0 
+ b0_b0_a3_p1_em1 = -3.02 
+ a0_b0_a3_p1_em1 = 0 
+ b0_a0_a3_p1_em1 = 0 
+ a0_a0_a3_p1_em1 = 0 
+ b0_b0_a4_p1_em1 = 0 
+ a0_b0_a4_p1_em1 = 0 
+ b0_a0_a4_p1_em1 = 0 
+ a0_a0_a4_p1_em1 = 0 
+ b0_b0_p1_p1_em1 = -1.03 
+ a0_b0_p1_p1_em1 = 0 
+ b0_a0_p1_p1_em1 = 0 
+ a0_a0_p1_p1_em1 = 0 
+ b0_b0_p2_p1_em1 = 1.78 
+ a0_b0_p2_p1_em1 = 0 
+ b0_a0_p2_p1_em1 = 0 
+ a0_a0_p2_p1_em1 = 0 
+ b0_b0_p3_p1_em1 = 2.98 
+ a0_b0_p3_p1_em1 = 0 
+ b0_a0_p3_p1_em1 = 0 
+ a0_a0_p3_p1_em1 = 0 
+ b0_b0_p4_p1_em1 = 4.46 
+ a0_b0_p4_p1_em1 = 0 
+ b0_a0_p4_p1_em1 = 0 
+ a0_a0_p4_p1_em1 = 0 
+ b0_b0_b0_p2_em1 = 13.9 
+ a0_b0_b0_p2_em1 = -0.000133 
+ b0_a0_b0_p2_em1 = 0 
+ a0_a0_b0_p2_em1 = 0 
+ b0_b0_a0_p2_em1 = 0 
+ a0_b0_a0_p2_em1 = 0 
+ b0_a0_a0_p2_em1 = 0 
+ a0_a0_a0_p2_em1 = 0 
+ b0_b0_a1_p2_em1 = -0.5 
+ a0_b0_a1_p2_em1 = 0.002 
+ b0_a0_a1_p2_em1 = 0 
+ a0_a0_a1_p2_em1 = 0 
+ b0_b0_a2_p2_em1 = -7.08 
+ a0_b0_a2_p2_em1 = -0.00387 
+ b0_a0_a2_p2_em1 = 0 
+ a0_a0_a2_p2_em1 = 0 
+ b0_b0_a3_p2_em1 = -7.78 
+ a0_b0_a3_p2_em1 = 0.0575 
+ b0_a0_a3_p2_em1 = 0 
+ a0_a0_a3_p2_em1 = 0 
+ b0_b0_a4_p2_em1 = 0 
+ a0_b0_a4_p2_em1 = 0 
+ b0_a0_a4_p2_em1 = 0 
+ a0_a0_a4_p2_em1 = 0 
+ b0_b0_p1_p2_em1 = -1 
+ a0_b0_p1_p2_em1 = 0 
+ b0_a0_p1_p2_em1 = 0 
+ a0_a0_p1_p2_em1 = 0 
+ b0_b0_p2_p2_em1 = 3.85 
+ a0_b0_p2_p2_em1 = -0.00254 
+ b0_a0_p2_p2_em1 = 0 
+ a0_a0_p2_p2_em1 = 0 
+ b0_b0_p3_p2_em1 = 4.27 
+ a0_b0_p3_p2_em1 = -0.00148 
+ b0_a0_p3_p2_em1 = 0 
+ a0_a0_p3_p2_em1 = 0 
+ b0_b0_p4_p2_em1 = 5.28 
+ a0_b0_p4_p2_em1 = -0.0028 
+ b0_a0_p4_p2_em1 = 0 
+ a0_a0_p4_p2_em1 = 0 
+ b0_b0_b0_p3_em1 = 22 
+ a0_b0_b0_p3_em1 = -0.0328 
+ b0_a0_b0_p3_em1 = 0 
+ a0_a0_b0_p3_em1 = 0 
+ b0_b0_a0_p3_em1 = 0 
+ a0_b0_a0_p3_em1 = 0 
+ b0_a0_a0_p3_em1 = 0 
+ a0_a0_a0_p3_em1 = 0 
+ b0_b0_a1_p3_em1 = -0.17 
+ a0_b0_a1_p3_em1 = 0.00397 
+ b0_a0_a1_p3_em1 = 0 
+ a0_a0_a1_p3_em1 = 0 
+ b0_b0_a2_p3_em1 = 6.91 
+ a0_b0_a2_p3_em1 = -0.0157 
+ b0_a0_a2_p3_em1 = 0 
+ a0_a0_a2_p3_em1 = 0 
+ b0_b0_a3_p3_em1 = -3.66 
+ a0_b0_a3_p3_em1 = 0.00871 
+ b0_a0_a3_p3_em1 = 0 
+ a0_a0_a3_p3_em1 = 0 
+ b0_b0_a4_p3_em1 = 0 
+ a0_b0_a4_p3_em1 = 0 
+ b0_a0_a4_p3_em1 = 0 
+ a0_a0_a4_p3_em1 = 0 
+ b0_b0_p1_p3_em1 = -9.66 
+ a0_b0_p1_p3_em1 = 0.00279 
+ b0_a0_p1_p3_em1 = 0 
+ a0_a0_p1_p3_em1 = 0 
+ b0_b0_p2_p3_em1 = 0.582 
+ a0_b0_p2_p3_em1 = 0.00374 
+ b0_a0_p2_p3_em1 = 0 
+ a0_a0_p2_p3_em1 = 0 
+ b0_b0_p3_p3_em1 = 1.22 
+ a0_b0_p3_p3_em1 = 0.00552 
+ b0_a0_p3_p3_em1 = 0 
+ a0_a0_p3_p3_em1 = 0 
+ b0_b0_p4_p3_em1 = 6 
+ a0_b0_p4_p3_em1 = 0 
+ b0_a0_p4_p3_em1 = 0 
+ a0_a0_p4_p3_em1 = 0 
+ b0_b0_b0_p4_em1 = 31.4 
+ a0_b0_b0_p4_em1 = 0.00765 
+ b0_a0_b0_p4_em1 = -0.00471 
+ a0_a0_b0_p4_em1 = 1.24E-05 
+ b0_b0_a0_p4_em1 = 0 
+ a0_b0_a0_p4_em1 = 0 
+ b0_a0_a0_p4_em1 = 0 
+ a0_a0_a0_p4_em1 = 0 
+ b0_b0_a1_p4_em1 = 12.4 
+ a0_b0_a1_p4_em1 = -0.0237 
+ b0_a0_a1_p4_em1 = 0.000214 
+ a0_a0_a1_p4_em1 = 1.10E-05 
+ b0_b0_a2_p4_em1 = 4.66 
+ a0_b0_a2_p4_em1 = -0.0114 
+ b0_a0_a2_p4_em1 = 0.00673 
+ a0_a0_a2_p4_em1 = -2.21E-05 
+ b0_b0_a3_p4_em1 = 1.52 
+ a0_b0_a3_p4_em1 = -0.000852 
+ b0_a0_a3_p4_em1 = 0.000678 
+ a0_a0_a3_p4_em1 = -6.98E-07 
+ b0_b0_a4_p4_em1 = 0 
+ a0_b0_a4_p4_em1 = 0 
+ b0_a0_a4_p4_em1 = 0 
+ a0_a0_a4_p4_em1 = 0 
+ b0_b0_p1_p4_em1 = 2.39 
+ a0_b0_p1_p4_em1 = -0.00216 
+ b0_a0_p1_p4_em1 = 0.00127 
+ a0_a0_p1_p4_em1 = 1.48E-05 
+ b0_b0_p2_p4_em1 = 2.04 
+ a0_b0_p2_p4_em1 = -0.00371 
+ b0_a0_p2_p4_em1 = 0.00082 
+ a0_a0_p2_p4_em1 = 1.84E-05 
+ b0_b0_p3_p4_em1 = 1.78 
+ a0_b0_p3_p4_em1 = 0.0035 
+ b0_a0_p3_p4_em1 = 0.00618 
+ a0_a0_p3_p4_em1 = -1.84E-05 
+ b0_b0_p4_p4_em1 = 4.43 
+ a0_b0_p4_p4_em1 = 0.00411 
+ b0_a0_p4_p4_em1 = -0.000269 
+ a0_a0_p4_p4_em1 = -1.56E-06 
+ b0_b0_b0_b0_em2 = 0 
+ a0_b0_b0_b0_em2 = 0 
+ b0_a0_b0_b0_em2 = 0 
+ a0_a0_b0_b0_em2 = 0 
+ b0_b0_a0_b0_em2 = 0 
+ a0_b0_a0_b0_em2 = 0 
+ b0_a0_a0_b0_em2 = 0 
+ a0_a0_a0_b0_em2 = 0 
+ b0_b0_a1_b0_em2 = 0 
+ a0_b0_a1_b0_em2 = 0 
+ b0_a0_a1_b0_em2 = 0 
+ a0_a0_a1_b0_em2 = 0 
+ b0_b0_a2_b0_em2 = 0 
+ a0_b0_a2_b0_em2 = 0 
+ b0_a0_a2_b0_em2 = 0 
+ a0_a0_a2_b0_em2 = 0 
+ b0_b0_a3_b0_em2 = 0 
+ a0_b0_a3_b0_em2 = 0 
+ b0_a0_a3_b0_em2 = 0 
+ a0_a0_a3_b0_em2 = 0 
+ b0_b0_a4_b0_em2 = 0 
+ a0_b0_a4_b0_em2 = 0 
+ b0_a0_a4_b0_em2 = 0 
+ a0_a0_a4_b0_em2 = 0 
+ b0_b0_p1_b0_em2 = 0 
+ a0_b0_p1_b0_em2 = 0 
+ b0_a0_p1_b0_em2 = 0 
+ a0_a0_p1_b0_em2 = 0 
+ b0_b0_p2_b0_em2 = 0 
+ a0_b0_p2_b0_em2 = 0 
+ b0_a0_p2_b0_em2 = 0 
+ a0_a0_p2_b0_em2 = 0 
+ b0_b0_p3_b0_em2 = 0 
+ a0_b0_p3_b0_em2 = 0 
+ b0_a0_p3_b0_em2 = 0 
+ a0_a0_p3_b0_em2 = 0 
+ b0_b0_p4_b0_em2 = 0 
+ a0_b0_p4_b0_em2 = 0 
+ b0_a0_p4_b0_em2 = 0 
+ a0_a0_p4_b0_em2 = 0 
+ b0_b0_b0_a0_em2 = 0 
+ a0_b0_b0_a0_em2 = 0 
+ b0_a0_b0_a0_em2 = 0 
+ a0_a0_b0_a0_em2 = 0 
+ b0_b0_a0_a0_em2 = 0 
+ a0_b0_a0_a0_em2 = 0 
+ b0_a0_a0_a0_em2 = 0 
+ a0_a0_a0_a0_em2 = 0 
+ b0_b0_a1_a0_em2 = 0 
+ a0_b0_a1_a0_em2 = 0 
+ b0_a0_a1_a0_em2 = 0 
+ a0_a0_a1_a0_em2 = 0 
+ b0_b0_a2_a0_em2 = 0 
+ a0_b0_a2_a0_em2 = 0 
+ b0_a0_a2_a0_em2 = 0 
+ a0_a0_a2_a0_em2 = 0 
+ b0_b0_a3_a0_em2 = 0 
+ a0_b0_a3_a0_em2 = 0 
+ b0_a0_a3_a0_em2 = 0 
+ a0_a0_a3_a0_em2 = 0 
+ b0_b0_a4_a0_em2 = 0 
+ a0_b0_a4_a0_em2 = 0 
+ b0_a0_a4_a0_em2 = 0 
+ a0_a0_a4_a0_em2 = 0 
+ b0_b0_p1_a0_em2 = 0 
+ a0_b0_p1_a0_em2 = 0 
+ b0_a0_p1_a0_em2 = 0 
+ a0_a0_p1_a0_em2 = 0 
+ b0_b0_p2_a0_em2 = 0 
+ a0_b0_p2_a0_em2 = 0 
+ b0_a0_p2_a0_em2 = 0 
+ a0_a0_p2_a0_em2 = 0 
+ b0_b0_p3_a0_em2 = 0 
+ a0_b0_p3_a0_em2 = 0 
+ b0_a0_p3_a0_em2 = 0 
+ a0_a0_p3_a0_em2 = 0 
+ b0_b0_p4_a0_em2 = 0 
+ a0_b0_p4_a0_em2 = 0 
+ b0_a0_p4_a0_em2 = 0 
+ a0_a0_p4_a0_em2 = 0 
+ b0_b0_b0_a1_em2 = 18000 
+ a0_b0_b0_a1_em2 = -1.13 
+ b0_a0_b0_a1_em2 = 0 
+ a0_a0_b0_a1_em2 = 0 
+ b0_b0_a0_a1_em2 = 0 
+ a0_b0_a0_a1_em2 = 0 
+ b0_a0_a0_a1_em2 = 0 
+ a0_a0_a0_a1_em2 = 0 
+ b0_b0_a1_a1_em2 = -4700 
+ a0_b0_a1_a1_em2 = -3 
+ b0_a0_a1_a1_em2 = 0 
+ a0_a0_a1_a1_em2 = 0 
+ b0_b0_a2_a1_em2 = -4280 
+ a0_b0_a2_a1_em2 = 1.21 
+ b0_a0_a2_a1_em2 = 0 
+ a0_a0_a2_a1_em2 = 0 
+ b0_b0_a3_a1_em2 = -6810 
+ a0_b0_a3_a1_em2 = 13.4 
+ b0_a0_a3_a1_em2 = 0 
+ a0_a0_a3_a1_em2 = 0 
+ b0_b0_a4_a1_em2 = 0 
+ a0_b0_a4_a1_em2 = 0 
+ b0_a0_a4_a1_em2 = 0 
+ a0_a0_a4_a1_em2 = 0 
+ b0_b0_p1_a1_em2 = 1.69 
+ a0_b0_p1_a1_em2 = 9.27E-05 
+ b0_a0_p1_a1_em2 = 0 
+ a0_a0_p1_a1_em2 = 0 
+ b0_b0_p2_a1_em2 = 1.84 
+ a0_b0_p2_a1_em2 = 0.00126 
+ b0_a0_p2_a1_em2 = 0 
+ a0_a0_p2_a1_em2 = 0 
+ b0_b0_p3_a1_em2 = 4.02 
+ a0_b0_p3_a1_em2 = -0.000463 
+ b0_a0_p3_a1_em2 = 0 
+ a0_a0_p3_a1_em2 = 0 
+ b0_b0_p4_a1_em2 = 4 
+ a0_b0_p4_a1_em2 = 0 
+ b0_a0_p4_a1_em2 = 0 
+ a0_a0_p4_a1_em2 = 0 
+ b0_b0_b0_a2_em2 = 7990 
+ a0_b0_b0_a2_em2 = 0.584 
+ b0_a0_b0_a2_em2 = 0 
+ a0_a0_b0_a2_em2 = 0 
+ b0_b0_a0_a2_em2 = 0 
+ a0_b0_a0_a2_em2 = 0 
+ b0_a0_a0_a2_em2 = 0 
+ a0_a0_a0_a2_em2 = 0 
+ b0_b0_a1_a2_em2 = -3650 
+ a0_b0_a1_a2_em2 = 4.54 
+ b0_a0_a1_a2_em2 = 0 
+ a0_a0_a1_a2_em2 = 0 
+ b0_b0_a2_a2_em2 = -1700 
+ a0_b0_a2_a2_em2 = 0.0665 
+ b0_a0_a2_a2_em2 = 0 
+ a0_a0_a2_a2_em2 = 0 
+ b0_b0_a3_a2_em2 = -5880 
+ a0_b0_a3_a2_em2 = 4.1 
+ b0_a0_a3_a2_em2 = 0 
+ a0_a0_a3_a2_em2 = 0 
+ b0_b0_a4_a2_em2 = 0 
+ a0_b0_a4_a2_em2 = 0 
+ b0_a0_a4_a2_em2 = 0 
+ a0_a0_a4_a2_em2 = 0 
+ b0_b0_p1_a2_em2 = 2.39 
+ a0_b0_p1_a2_em2 = -0.000126 
+ b0_a0_p1_a2_em2 = 0 
+ a0_a0_p1_a2_em2 = 0 
+ b0_b0_p2_a2_em2 = 2.09 
+ a0_b0_p2_a2_em2 = 0.00092 
+ b0_a0_p2_a2_em2 = 0 
+ a0_a0_p2_a2_em2 = 0 
+ b0_b0_p3_a2_em2 = 4.25 
+ a0_b0_p3_a2_em2 = -0.000852 
+ b0_a0_p3_a2_em2 = 0 
+ a0_a0_p3_a2_em2 = 0 
+ b0_b0_p4_a2_em2 = 4.5 
+ a0_b0_p4_a2_em2 = 0 
+ b0_a0_p4_a2_em2 = 0 
+ a0_a0_p4_a2_em2 = 0 
+ b0_b0_b0_a3_em2 = 3500 
+ a0_b0_b0_a3_em2 = 78.7 
+ b0_a0_b0_a3_em2 = 0 
+ a0_a0_b0_a3_em2 = 0 
+ b0_b0_a0_a3_em2 = 0 
+ a0_b0_a0_a3_em2 = 0 
+ b0_a0_a0_a3_em2 = 0 
+ a0_a0_a0_a3_em2 = 0 
+ b0_b0_a1_a3_em2 = -158 
+ a0_b0_a1_a3_em2 = 0.000922 
+ b0_a0_a1_a3_em2 = 0 
+ a0_a0_a1_a3_em2 = 0 
+ b0_b0_a2_a3_em2 = -822 
+ a0_b0_a2_a3_em2 = 9.93 
+ b0_a0_a2_a3_em2 = 0 
+ a0_a0_a2_a3_em2 = 0 
+ b0_b0_a3_a3_em2 = -1140 
+ a0_b0_a3_a3_em2 = 1.67 
+ b0_a0_a3_a3_em2 = 0 
+ a0_a0_a3_a3_em2 = 0 
+ b0_b0_a4_a3_em2 = 0 
+ a0_b0_a4_a3_em2 = 0 
+ b0_a0_a4_a3_em2 = 0 
+ a0_a0_a4_a3_em2 = 0 
+ b0_b0_p1_a3_em2 = -3.53 
+ a0_b0_p1_a3_em2 = -0.492 
+ b0_a0_p1_a3_em2 = 0 
+ a0_a0_p1_a3_em2 = 0 
+ b0_b0_p2_a3_em2 = 1.56 
+ a0_b0_p2_a3_em2 = 0.00251 
+ b0_a0_p2_a3_em2 = 0 
+ a0_a0_p2_a3_em2 = 0 
+ b0_b0_p3_a3_em2 = 2.81 
+ a0_b0_p3_a3_em2 = 0.000409 
+ b0_a0_p3_a3_em2 = 0 
+ a0_a0_p3_a3_em2 = 0 
+ b0_b0_p4_a3_em2 = 4.5 
+ a0_b0_p4_a3_em2 = 0 
+ b0_a0_p4_a3_em2 = 0 
+ a0_a0_p4_a3_em2 = 0 
+ b0_b0_b0_a4_em2 = 2010 
+ a0_b0_b0_a4_em2 = -5.5 
+ b0_a0_b0_a4_em2 = -0.235 
+ a0_a0_b0_a4_em2 = -0.0118 
+ b0_b0_a0_a4_em2 = 0 
+ a0_b0_a0_a4_em2 = 0 
+ b0_a0_a0_a4_em2 = 0 
+ a0_a0_a0_a4_em2 = 0 
+ b0_b0_a1_a4_em2 = 4.04 
+ a0_b0_a1_a4_em2 = 1.21 
+ b0_a0_a1_a4_em2 = -2.49 
+ a0_a0_a1_a4_em2 = 0.00788 
+ b0_b0_a2_a4_em2 = 10.9 
+ a0_b0_a2_a4_em2 = 0.521 
+ b0_a0_a2_a4_em2 = 0 
+ a0_a0_a2_a4_em2 = -0.00101 
+ b0_b0_a3_a4_em2 = 3.43 
+ a0_b0_a3_a4_em2 = -0.231 
+ b0_a0_a3_a4_em2 = -3.6 
+ a0_a0_a3_a4_em2 = 0.0121 
+ b0_b0_a4_a4_em2 = 0 
+ a0_b0_a4_a4_em2 = 0 
+ b0_a0_a4_a4_em2 = 0 
+ a0_a0_a4_a4_em2 = 0 
+ b0_b0_p1_a4_em2 = -2.32 
+ a0_b0_p1_a4_em2 = -0.00431 
+ b0_a0_p1_a4_em2 = -0.0392 
+ a0_a0_p1_a4_em2 = 9.04E-05 
+ b0_b0_p2_a4_em2 = 3.2 
+ a0_b0_p2_a4_em2 = -0.00847 
+ b0_a0_p2_a4_em2 = -0.00275 
+ a0_a0_p2_a4_em2 = 1.56E-05 
+ b0_b0_p3_a4_em2 = 2.1 
+ a0_b0_p3_a4_em2 = -0.000961 
+ b0_a0_p3_a4_em2 = 0.00629 
+ a0_a0_p3_a4_em2 = -1.97E-05 
+ b0_b0_p4_a4_em2 = -3.57 
+ a0_b0_p4_a4_em2 = 0.0283 
+ b0_a0_p4_a4_em2 = 0.00711 
+ a0_a0_p4_a4_em2 = -0.000744 
+ b0_b0_b0_p1_em2 = 5.38 
+ a0_b0_b0_p1_em2 = 0 
+ b0_a0_b0_p1_em2 = 0 
+ a0_a0_b0_p1_em2 = 0 
+ b0_b0_a0_p1_em2 = 0 
+ a0_b0_a0_p1_em2 = 0 
+ b0_a0_a0_p1_em2 = 0 
+ a0_a0_a0_p1_em2 = 0 
+ b0_b0_a1_p1_em2 = 0.664 
+ a0_b0_a1_p1_em2 = 0 
+ b0_a0_a1_p1_em2 = 0 
+ a0_a0_a1_p1_em2 = 0 
+ b0_b0_a2_p1_em2 = -1.22 
+ a0_b0_a2_p1_em2 = 0 
+ b0_a0_a2_p1_em2 = 0 
+ a0_a0_a2_p1_em2 = 0 
+ b0_b0_a3_p1_em2 = -2.85 
+ a0_b0_a3_p1_em2 = 0 
+ b0_a0_a3_p1_em2 = 0 
+ a0_a0_a3_p1_em2 = 0 
+ b0_b0_a4_p1_em2 = 0 
+ a0_b0_a4_p1_em2 = 0 
+ b0_a0_a4_p1_em2 = 0 
+ a0_a0_a4_p1_em2 = 0 
+ b0_b0_p1_p1_em2 = -0.00457 
+ a0_b0_p1_p1_em2 = 0 
+ b0_a0_p1_p1_em2 = 0 
+ a0_a0_p1_p1_em2 = 0 
+ b0_b0_p2_p1_em2 = 1.39 
+ a0_b0_p2_p1_em2 = 0 
+ b0_a0_p2_p1_em2 = 0 
+ a0_a0_p2_p1_em2 = 0 
+ b0_b0_p3_p1_em2 = 3.33 
+ a0_b0_p3_p1_em2 = 0 
+ b0_a0_p3_p1_em2 = 0 
+ a0_a0_p3_p1_em2 = 0 
+ b0_b0_p4_p1_em2 = 4.62 
+ a0_b0_p4_p1_em2 = 0 
+ b0_a0_p4_p1_em2 = 0 
+ a0_a0_p4_p1_em2 = 0 
+ b0_b0_b0_p2_em2 = 10.8 
+ a0_b0_b0_p2_em2 = 0.000435 
+ b0_a0_b0_p2_em2 = 0 
+ a0_a0_b0_p2_em2 = 0 
+ b0_b0_a0_p2_em2 = 0 
+ a0_b0_a0_p2_em2 = 0 
+ b0_a0_a0_p2_em2 = 0 
+ a0_a0_a0_p2_em2 = 0 
+ b0_b0_a1_p2_em2 = -11.8 
+ a0_b0_a1_p2_em2 = -0.00232 
+ b0_a0_a1_p2_em2 = 0 
+ a0_a0_a1_p2_em2 = 0 
+ b0_b0_a2_p2_em2 = -1.05 
+ a0_b0_a2_p2_em2 = -0.00022 
+ b0_a0_a2_p2_em2 = 0 
+ a0_a0_a2_p2_em2 = 0 
+ b0_b0_a3_p2_em2 = -0.205 
+ a0_b0_a3_p2_em2 = 0.000139 
+ b0_a0_a3_p2_em2 = 0 
+ a0_a0_a3_p2_em2 = 0 
+ b0_b0_a4_p2_em2 = 0 
+ a0_b0_a4_p2_em2 = 0 
+ b0_a0_a4_p2_em2 = 0 
+ a0_a0_a4_p2_em2 = 0 
+ b0_b0_p1_p2_em2 = 1.5 
+ a0_b0_p1_p2_em2 = 0 
+ b0_a0_p1_p2_em2 = 0 
+ a0_a0_p1_p2_em2 = 0 
+ b0_b0_p2_p2_em2 = 1.63 
+ a0_b0_p2_p2_em2 = 3.47E-06 
+ b0_a0_p2_p2_em2 = 0 
+ a0_a0_p2_p2_em2 = 0 
+ b0_b0_p3_p2_em2 = 2.46 
+ a0_b0_p3_p2_em2 = 0.000126 
+ b0_a0_p3_p2_em2 = 0 
+ a0_a0_p3_p2_em2 = 0 
+ b0_b0_p4_p2_em2 = 4.26 
+ a0_b0_p4_p2_em2 = 0.000219 
+ b0_a0_p4_p2_em2 = 0 
+ a0_a0_p4_p2_em2 = 0 
+ b0_b0_b0_p3_em2 = 20 
+ a0_b0_b0_p3_em2 = 0 
+ b0_a0_b0_p3_em2 = 0 
+ a0_a0_b0_p3_em2 = 0 
+ b0_b0_a0_p3_em2 = 0 
+ a0_b0_a0_p3_em2 = 0 
+ b0_a0_a0_p3_em2 = 0 
+ a0_a0_a0_p3_em2 = 0 
+ b0_b0_a1_p3_em2 = 0 
+ a0_b0_a1_p3_em2 = 0 
+ b0_a0_a1_p3_em2 = 0 
+ a0_a0_a1_p3_em2 = 0 
+ b0_b0_a2_p3_em2 = 0 
+ a0_b0_a2_p3_em2 = 0 
+ b0_a0_a2_p3_em2 = 0 
+ a0_a0_a2_p3_em2 = 0 
+ b0_b0_a3_p3_em2 = 0 
+ a0_b0_a3_p3_em2 = 0 
+ b0_a0_a3_p3_em2 = 0 
+ a0_a0_a3_p3_em2 = 0 
+ b0_b0_a4_p3_em2 = 0 
+ a0_b0_a4_p3_em2 = 0 
+ b0_a0_a4_p3_em2 = 0 
+ a0_a0_a4_p3_em2 = 0 
+ b0_b0_p1_p3_em2 = 0 
+ a0_b0_p1_p3_em2 = 0 
+ b0_a0_p1_p3_em2 = 0 
+ a0_a0_p1_p3_em2 = 0 
+ b0_b0_p2_p3_em2 = 1 
+ a0_b0_p2_p3_em2 = 0 
+ b0_a0_p2_p3_em2 = 0 
+ a0_a0_p2_p3_em2 = 0 
+ b0_b0_p3_p3_em2 = 2 
+ a0_b0_p3_p3_em2 = 0 
+ b0_a0_p3_p3_em2 = 0 
+ a0_a0_p3_p3_em2 = 0 
+ b0_b0_p4_p3_em2 = 3 
+ a0_b0_p4_p3_em2 = 0 
+ b0_a0_p4_p3_em2 = 0 
+ a0_a0_p4_p3_em2 = 0 
+ b0_b0_b0_p4_em2 = 33.3 
+ a0_b0_b0_p4_em2 = -0.0104 
+ b0_a0_b0_p4_em2 = -0.0173 
+ a0_a0_b0_p4_em2 = 5.15E-05 
+ b0_b0_a0_p4_em2 = 0 
+ a0_b0_a0_p4_em2 = 0 
+ b0_a0_a0_p4_em2 = 0 
+ a0_a0_a0_p4_em2 = 0 
+ b0_b0_a1_p4_em2 = -151 
+ a0_b0_a1_p4_em2 = 0.27 
+ b0_a0_a1_p4_em2 = 0.017 
+ a0_a0_a1_p4_em2 = -0.00026 
+ b0_b0_a2_p4_em2 = 1.56 
+ a0_b0_a2_p4_em2 = -0.0195 
+ b0_a0_a2_p4_em2 = -0.0325 
+ a0_a0_a2_p4_em2 = 0.000155 
+ b0_b0_a3_p4_em2 = 6.11 
+ a0_b0_a3_p4_em2 = -0.0128 
+ b0_a0_a3_p4_em2 = -0.017 
+ a0_a0_a3_p4_em2 = -3.61E-06 
+ b0_b0_a4_p4_em2 = 0 
+ a0_b0_a4_p4_em2 = 0 
+ b0_a0_a4_p4_em2 = 0 
+ a0_a0_a4_p4_em2 = 0 
+ b0_b0_p1_p4_em2 = 1.78 
+ a0_b0_p1_p4_em2 = 0.00199 
+ b0_a0_p1_p4_em2 = -0.000337 
+ a0_a0_p1_p4_em2 = 1.77E-06 
+ b0_b0_p2_p4_em2 = 1.87 
+ a0_b0_p2_p4_em2 = 0.00196 
+ b0_a0_p2_p4_em2 = -0.00114 
+ a0_a0_p2_p4_em2 = 4.71E-06 
+ b0_b0_p3_p4_em2 = 3 
+ a0_b0_p3_p4_em2 = -0.000192 
+ b0_a0_p3_p4_em2 = -0.00088 
+ a0_a0_p3_p4_em2 = 2.18E-06 
+ b0_b0_p4_p4_em2 = 0.522 
+ a0_b0_p4_p4_em2 = 0.0117 
+ b0_a0_p4_p4_em2 = 0.00798 
+ a0_a0_p4_p4_em2 = -2.34E-05 
}
endsection pmoshs45b_10hv_dfrt

section nmos90_10hv_dfrt
include "soachecks_top.scs" section=nmos90b_10hv_soa
if (enable_esdsoa == 1) {
anmos90_10hv_esdchk_1 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=1 enable=soa rule="esd_nmos90_Vt1=135p0_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_2 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=2 enable=soa rule="esd_nmos90_Vt1>135p0_Vgs0p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 135.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=135.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_3 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=3 enable=soa rule="esd_nmos90_=Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_4 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=4 enable=soa rule="esd_nmos90_>Vt1_Vgs_0p0_0p5_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(-0.0*(V(g)-V(s)-0.0))) > 135.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=135.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_5 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=5 enable=soa rule="esd_nmos90_Vt1=135p0_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_6 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=6 enable=soa rule="esd_nmos90_Vt1>135p0_Vgs0p5_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 135.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=135.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_7 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=7 enable=soa rule="esd_nmos90_=Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(0.6*(V(g)-V(s)-0.5))-135.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_8 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=8 enable=soa rule="esd_nmos90_>Vt1_Vgs_0p5_1p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(0.6*(V(g)-V(s)-0.5))) > 135.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=135.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_9 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=9 enable=soa rule="esd_nmos90_Vt1=134p7_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-134.7)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_10 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=10 enable=soa rule="esd_nmos90_Vt1>134p7_Vgs1p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 134.7 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=134.7 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_11 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=11 enable=soa rule="esd_nmos90_=Vt1_Vgs_1p0_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(0.9*(V(g)-V(s)-1.0))-134.7)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_12 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=12 enable=soa rule="esd_nmos90_>Vt1_Vgs_1p0_2p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(0.9*(V(g)-V(s)-1.0))) > 134.7 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=134.7 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_13 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=13 enable=soa rule="esd_nmos90_Vt1=133p8_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_14 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=14 enable=soa rule="esd_nmos90_Vt1>133p8_Vgs2p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_15 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=15 enable=soa rule="esd_nmos90_=Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(0.8*(V(g)-V(s)-2.0))-133.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_16 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=16 enable=soa rule="esd_nmos90_>Vt1_Vgs_2p0_3p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(0.8*(V(g)-V(s)-2.0))) > 133.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.8 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_17 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=17 enable=soa rule="esd_nmos90_Vt1=133p0_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_18 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=18 enable=soa rule="esd_nmos90_Vt1>133p0_Vgs3p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 133.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=133.0 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_19 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=19 enable=soa rule="esd_nmos90_=Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(2.7*(V(g)-V(s)-3.0))-133.0)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_20 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=20 enable=soa rule="esd_nmos90_>Vt1_Vgs_3p0_4p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(2.7*(V(g)-V(s)-3.0))) > 133.0 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=133.0 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_21 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=21 enable=soa rule="esd_nmos90_Vt1=130p3_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-130.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_22 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=22 enable=soa rule="esd_nmos90_Vt1>130p3_Vgs4p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 130.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=130.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_23 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=23 enable=soa rule="esd_nmos90_=Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(3.0*(V(g)-V(s)-4.0))-130.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_24 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=24 enable=soa rule="esd_nmos90_>Vt1_Vgs_4p0_5p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(3.0*(V(g)-V(s)-4.0))) > 130.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=130.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_25 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=25 enable=soa rule="esd_nmos90_Vt1=127p3_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-127.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_26 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=26 enable=soa rule="esd_nmos90_Vt1>127p3_Vgs5p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 127.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=127.3 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_27 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=27 enable=soa rule="esd_nmos90_=Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(3.5*(V(g)-V(s)-5.0))-127.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_28 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=28 enable=soa rule="esd_nmos90_>Vt1_Vgs_5p0_6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(3.5*(V(g)-V(s)-5.0))) > 127.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=127.3 formulae_cond4="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond4=5 realParameter_cond4=1 ruleType_cond4=4 targetV_cond4=0.3
anmos90_10hv_esdchk_29 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=29 enable=soa rule="esd_nmos90_Vt1=123p8_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_30 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=30 enable=soa rule="esd_nmos90_Vt1>123p8_Vgs6p0_1" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_31 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=31 enable=soa rule="esd_nmos90_=Vt1_Vgs>6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="(abs(V(d)-V(s)-123.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_32 (g s d s b s) monitor6t enable=soa rule="esd_nmos90_>Vt1_Vgs>6p0_1" targetT=0.0 formulae_cond1="V(g-to-s) > 6.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=6.0 formulae_cond2="V(d-to-s) > 123.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=123.8 formulae_cond3="absV(b-to-s) less and equal than 0.3 for duration > 0.0ns" monitorType_cond3=5 realParameter_cond3=1 ruleType_cond3=4 targetV_cond3=0.3
anmos90_10hv_esdchk_33 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=32 enable=soa rule="esd_nmos90_Vt1=107p9_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-107.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_34 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=33 enable=soa rule="esd_nmos90_Vt1>107p9_Vgs0p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 107.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=107.9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_35 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=34 enable=soa rule="esd_nmos90_=Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(abs(V(d)-V(s)+(16.2*(V(g)-V(s)-0.0))-107.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_36 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=35 enable=soa rule="esd_nmos90_>Vt1_Vgs_0p0_0p5_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.0 formulae_cond2="V(g-to-s) < 0.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=0.5 formulae_cond3="(V(d)-V(s)+(16.2*(V(g)-V(s)-0.0))) > 107.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=107.9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_37 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=36 enable=soa rule="esd_nmos90_Vt1=99p8_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-99.8)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_38 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=37 enable=soa rule="esd_nmos90_Vt1>99p8_Vgs0p5_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-0.5)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 99.8 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=99.8 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_39 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=38 enable=soa rule="esd_nmos90_=Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(abs(V(d)-V(s)+(5.8*(V(g)-V(s)-0.5))-99.8)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_40 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=39 enable=soa rule="esd_nmos90_>Vt1_Vgs_0p5_1p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 0.5 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=0.5 formulae_cond2="V(g-to-s) < 1.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1.0 formulae_cond3="(V(d)-V(s)+(5.8*(V(g)-V(s)-0.5))) > 99.8 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=99.8 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_41 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=40 enable=soa rule="esd_nmos90_Vt1=96p9_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-96.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_42 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=41 enable=soa rule="esd_nmos90_Vt1>96p9_Vgs1p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-1.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 96.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=96.9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_43 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=42 enable=soa rule="esd_nmos90_=Vt1_Vgs_1p0_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(abs(V(d)-V(s)+(8.0*(V(g)-V(s)-1.0))-96.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_44 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=43 enable=soa rule="esd_nmos90_>Vt1_Vgs_1p0_2p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 1.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=1.0 formulae_cond2="V(g-to-s) < 2.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=2.0 formulae_cond3="(V(d)-V(s)+(8.0*(V(g)-V(s)-1.0))) > 96.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=96.9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_45 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=44 enable=soa rule="esd_nmos90_Vt1=88p9_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-88.9)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_46 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=45 enable=soa rule="esd_nmos90_Vt1>88p9_Vgs2p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-2.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 88.9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=88.9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_47 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=46 enable=soa rule="esd_nmos90_=Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(abs(V(d)-V(s)+(7.4*(V(g)-V(s)-2.0))-88.9)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_48 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=47 enable=soa rule="esd_nmos90_>Vt1_Vgs_2p0_3p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 2.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=2.0 formulae_cond2="V(g-to-s) < 3.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=3.0 formulae_cond3="(V(d)-V(s)+(7.4*(V(g)-V(s)-2.0))) > 88.9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=88.9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_49 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=48 enable=soa rule="esd_nmos90_Vt1=81p5_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-81.5)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_50 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=49 enable=soa rule="esd_nmos90_Vt1>81p5_Vgs3p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-3.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 81.5 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=81.5 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_51 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=50 enable=soa rule="esd_nmos90_=Vt1_Vgs_3p0_4p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(abs(V(d)-V(s)+(11.2*(V(g)-V(s)-3.0))-81.5)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_52 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=51 enable=soa rule="esd_nmos90_>Vt1_Vgs_3p0_4p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 3.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=3.0 formulae_cond2="V(g-to-s) < 4.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=4.0 formulae_cond3="(V(d)-V(s)+(11.2*(V(g)-V(s)-3.0))) > 81.5 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=81.5 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_53 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=52 enable=soa rule="esd_nmos90_Vt1=70p3_Vgs4p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-70.3)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_54 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=53 enable=soa rule="esd_nmos90_Vt1>70p3_Vgs4p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-4.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 70.3 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=70.3 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_55 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=54 enable=soa rule="esd_nmos90_=Vt1_Vgs_4p0_5p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(abs(V(d)-V(s)+(7.9*(V(g)-V(s)-4.0))-70.3)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_56 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=55 enable=soa rule="esd_nmos90_>Vt1_Vgs_4p0_5p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 4.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=4.0 formulae_cond2="V(g-to-s) < 5.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=5.0 formulae_cond3="(V(d)-V(s)+(7.9*(V(g)-V(s)-4.0))) > 70.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=70.3 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_57 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=56 enable=soa rule="esd_nmos90_Vt1=62p4_Vgs5p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-62.4)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_58 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=57 enable=soa rule="esd_nmos90_Vt1>62p4_Vgs5p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-5.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="V(d-to-s) > 62.4 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=1 targetV_cond2=62.4 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
anmos90_10hv_esdchk_59 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=58 enable=soa rule="esd_nmos90_=Vt1_Vgs_5p0_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(abs(V(d)-V(s)+(-1.6*(V(g)-V(s)-5.0))-62.4)) < 1e-9 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=3 targetV_cond3=1e-9 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_60 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=59 enable=soa rule="esd_nmos90_>Vt1_Vgs_5p0_6p0_2" targetT=0.0 formulae_cond1="V(g-to-s) > 5.0 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=1 targetV_cond1=5.0 formulae_cond2="V(g-to-s) < 6.0 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=6.0 formulae_cond3="(V(d)-V(s)+(-1.6*(V(g)-V(s)-5.0))) > 62.4 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=62.4 formulae_cond4="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond4=1 realParameter_cond4=1 ruleType_cond4=1 targetV_cond4=0.3
anmos90_10hv_esdchk_61 (d g s b sub) monitor_esd_nmos90_10hv ruleNum=60 enable=soa rule="esd_nmos90_Vt1=64p0_Vgs6p0_2" targetT=0.0 formulae_cond1="(abs(V(g)-V(s)-6.0)) < 1e-9 for duration > 0.0ns" monitorType_cond1=1 realParameter_cond1=1 ruleType_cond1=3 targetV_cond1=1e-9 formulae_cond2="(abs(V(d)-V(s)-64.0)) < 1e-9 for duration > 0.0ns" monitorType_cond2=1 realParameter_cond2=1 ruleType_cond2=3 targetV_cond2=1e-9 formulae_cond3="V(b-to-s) > 0.3 for duration > 0.0ns" monitorType_cond3=1 realParameter_cond3=1 ruleType_cond3=1 targetV_cond3=0.3
